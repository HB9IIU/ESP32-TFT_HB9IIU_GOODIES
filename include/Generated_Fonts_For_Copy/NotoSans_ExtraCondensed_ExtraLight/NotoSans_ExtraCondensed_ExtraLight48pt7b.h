#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT48PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight48pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x00,
  0x17, 0xEC, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x30, 0x01, 0x03, 0x00, 0x20, 0x60, 0x0C, 0x08, 0x01,
  0x81, 0x00, 0x30, 0x20, 0x06, 0x04, 0x00, 0xC1, 0x80, 0x10, 0x30, 0x02,
  0x06, 0x00, 0x40, 0xC1, 0xFF, 0xFF, 0x83, 0x02, 0x00, 0x60, 0x40, 0x0C,
  0x08, 0x01, 0x81, 0x00, 0x30, 0x60, 0x04, 0x0C, 0x00, 0x81, 0x80, 0x10,
  0x30, 0x06, 0x06, 0x00, 0xC0, 0x81, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x60,
  0x40, 0x08, 0x18, 0x01, 0x03, 0x00, 0x20, 0x60, 0x04, 0x0C, 0x01, 0x81,
  0x80, 0x30, 0x20, 0x06, 0x04, 0x00, 0xC0, 0x80, 0x18, 0x30, 0x02, 0x06,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x80, 0x1F, 0xF8, 0x39, 0x1C, 0x61,
  0x04, 0xC1, 0x00, 0xC1, 0x00, 0xC1, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81,
  0x00, 0xC1, 0x00, 0xC1, 0x00, 0x61, 0x00, 0x71, 0x00, 0x39, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x01, 0x78, 0x01, 0x1C, 0x01, 0x0C, 0x01,
  0x06, 0x01, 0x02, 0x01, 0x03, 0x01, 0x03, 0x01, 0x03, 0x01, 0x02, 0x01,
  0x06, 0x01, 0x06, 0x81, 0x0C, 0xE1, 0x38, 0x7F, 0xF0, 0x07, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x3F, 0x00,
  0x40, 0x21, 0x00, 0xC0, 0x61, 0x80, 0xC0, 0x40, 0x80, 0x80, 0x40, 0x81,
  0x80, 0xC0, 0xC1, 0x80, 0xC0, 0xC1, 0x00, 0xC0, 0xC3, 0x00, 0xC0, 0xC3,
  0x00, 0xC0, 0xC2, 0x00, 0xC0, 0xC6, 0x00, 0xC0, 0xC6, 0x00, 0xC0, 0xC4,
  0x00, 0xC0, 0xCC, 0x78, 0xC0, 0xCC, 0xEC, 0x40, 0x88, 0xC6, 0x41, 0x99,
  0x82, 0x61, 0x99, 0x83, 0x23, 0x11, 0x83, 0x3F, 0x31, 0x03, 0x0C, 0x31,
  0x03, 0x00, 0x21, 0x01, 0x00, 0x61, 0x01, 0x00, 0x61, 0x01, 0x00, 0x41,
  0x01, 0x00, 0xC1, 0x01, 0x00, 0xC1, 0x03, 0x00, 0x81, 0x03, 0x00, 0x81,
  0x03, 0x01, 0x81, 0x83, 0x01, 0x01, 0x82, 0x01, 0x00, 0x86, 0x03, 0x00,
  0xC6, 0x02, 0x00, 0x7C, 0x03, 0x80, 0x01, 0xF8, 0x00, 0xC6, 0x00, 0x20,
  0xC0, 0x18, 0x30, 0x06, 0x04, 0x01, 0x81, 0x00, 0x60, 0x40, 0x18, 0x10,
  0x06, 0x04, 0x00, 0x83, 0x00, 0x30, 0xC0, 0x0C, 0x20, 0x01, 0x18, 0x00,
  0x6C, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x01, 0xD8, 0x00, 0x63,
  0x00, 0x30, 0xC0, 0x98, 0x18, 0x26, 0x06, 0x09, 0x80, 0xC6, 0x40, 0x11,
  0x90, 0x06, 0x6C, 0x00, 0x93, 0x00, 0x3C, 0x40, 0x06, 0x18, 0x01, 0x86,
  0x00, 0xF1, 0x80, 0x34, 0x30, 0x19, 0x87, 0x1C, 0x30, 0xFE, 0x0C, 0xFF,
  0xFF, 0xFF, 0x01, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30,
  0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x00, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06,
  0x06, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x0C,
  0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x0E, 0x23, 0x9F, 0xF0, 0x1C, 0x00, 0xA0, 0x0D, 0x80, 0xC6,
  0x0C, 0x10, 0xE0, 0xC2, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x33, 0x33, 0x66, 0x66, 0x4C, 0xC0, 0xFF,
  0xFF, 0xF0, 0x5F, 0xF0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x03, 0x80, 0x1F, 0xC0, 0x70, 0xC0, 0xC0, 0xC3,
  0x01, 0x86, 0x01, 0x98, 0x03, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x09, 0x00,
  0x1A, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x40, 0x06, 0xC0, 0x0D, 0x80, 0x13, 0x00, 0x66, 0x00, 0xC4, 0x01,
  0x8C, 0x02, 0x18, 0x0C, 0x18, 0x30, 0x1D, 0xE0, 0x1F, 0x80, 0x03, 0x07,
  0x1F, 0x3B, 0x73, 0xE3, 0xC3, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x80, 0x7F, 0xC3,
  0xC1, 0xC2, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0x80, 0x7F, 0xC3, 0xC1, 0xC6, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x1F, 0xC0, 0x3F, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x0E, 0x80, 0x39, 0xE1, 0xE1, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xB0, 0x00, 0x6C, 0x00, 0x13, 0x00, 0x0C, 0xC0,
  0x02, 0x30, 0x01, 0x8C, 0x00, 0x43, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x06,
  0x0C, 0x01, 0x83, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x03, 0x00, 0xC0, 0xC0, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x0C, 0x00, 0xC3,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x3F, 0xF8, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x40, 0x1F, 0xF8, 0x38, 0x3C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x40,
  0x1C, 0xF0, 0xF0, 0xFF, 0x80, 0x00, 0x60, 0x07, 0xF8, 0x1C, 0x10, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x11, 0xF8, 0x67, 0xF8, 0xD8,
  0x19, 0xA0, 0x1B, 0x80, 0x37, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x06, 0x80, 0x0D, 0x00, 0x1B, 0x00, 0x36, 0x00, 0x6C,
  0x00, 0xC8, 0x03, 0x18, 0x06, 0x38, 0x18, 0x38, 0x70, 0x3F, 0xC0, 0x1C,
  0x00, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x38, 0x38, 0x30,
  0x1C, 0x60, 0x0C, 0x60, 0x06, 0x40, 0x06, 0x40, 0x06, 0x40, 0x06, 0x40,
  0x06, 0x60, 0x06, 0x60, 0x0C, 0x30, 0x0C, 0x38, 0x18, 0x1C, 0x30, 0x0E,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0C, 0x60, 0x18, 0x30, 0x30, 0x18, 0x60,
  0x0C, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0,
  0x02, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0x60, 0x0C, 0x70, 0x1C, 0x3C,
  0x38, 0x0F, 0xF0, 0x03, 0x80, 0x3F, 0xC0, 0xE1, 0xC1, 0x80, 0xC6, 0x01,
  0x8C, 0x01, 0x30, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x0B, 0x00, 0x16,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0E, 0xC0,
  0x1D, 0x80, 0x59, 0x81, 0xB1, 0xFE, 0x61, 0xF0, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0xC3, 0x81, 0xFE, 0x00, 0x5F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x17, 0xFC, 0x27, 0x77, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x33, 0x36, 0x66, 0x64, 0xCC, 0x00,
  0x00, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x10, 0x00, 0x00, 0x1C, 0x1F, 0xF3, 0x07, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60,
  0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x18,
  0x07, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xC1,
  0xC0, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x60, 0x00, 0x06, 0x60, 0x0E,
  0x06, 0x40, 0x3F, 0x02, 0xC0, 0x61, 0x03, 0xC0, 0xC1, 0x03, 0xC0, 0x81,
  0x03, 0xC1, 0x81, 0x03, 0x81, 0x83, 0x03, 0x81, 0x03, 0x03, 0x81, 0x03,
  0x03, 0x81, 0x03, 0x03, 0x83, 0x03, 0x03, 0x83, 0x03, 0x03, 0x81, 0x03,
  0x03, 0x81, 0x03, 0x03, 0x81, 0x03, 0x02, 0x81, 0x87, 0x06, 0xC1, 0x85,
  0x06, 0xC0, 0xCD, 0x8C, 0xC0, 0xF8, 0xF8, 0xC0, 0x20, 0x20, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x80, 0x07, 0x87, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x02, 0x80, 0x00, 0xD8, 0x00, 0x1B,
  0x00, 0x02, 0x60, 0x00, 0x44, 0x00, 0x18, 0x80, 0x03, 0x18, 0x00, 0x63,
  0x00, 0x08, 0x60, 0x03, 0x04, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x03,
  0x00, 0x60, 0x20, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x30, 0x06, 0x06, 0x00, 0xC0, 0x80, 0x18, 0x30, 0x01,
  0x86, 0x00, 0x30, 0xC0, 0x06, 0x10, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x01,
  0x98, 0x00, 0x32, 0x00, 0x06, 0xC0, 0x00, 0x58, 0x00, 0x0C, 0xFF, 0xE1,
  0x83, 0xE3, 0x00, 0x66, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0, 0x01, 0x60,
  0x03, 0xC0, 0x07, 0x80, 0x0B, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xD8, 0x03,
  0x30, 0x0C, 0x7F, 0xF0, 0xFF, 0xE1, 0x80, 0x73, 0x00, 0x76, 0x00, 0x6C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xB0, 0x07, 0x60, 0x1C, 0xFF, 0xF1,
  0xFF, 0x80, 0x00, 0xF8, 0x03, 0xFF, 0x07, 0x03, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x01, 0x07, 0x87, 0x01, 0xFE,
  0xFF, 0xC0, 0x61, 0xF8, 0x30, 0x0E, 0x18, 0x03, 0x8C, 0x00, 0xC6, 0x00,
  0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8,
  0x00, 0x6C, 0x00, 0x36, 0x00, 0x0B, 0x00, 0x05, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x2C, 0x00, 0x36, 0x00, 0x1B, 0x00,
  0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x01, 0x98, 0x00, 0xCC,
  0x00, 0xC6, 0x00, 0x63, 0x00, 0x61, 0x80, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xFC,
  0x07, 0x80, 0xE0, 0xE0, 0x02, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x33, 0x00, 0x03, 0x38, 0x00,
  0x31, 0xC0, 0x03, 0x0E, 0x00, 0x30, 0x78, 0x1F, 0x01, 0xFF, 0xC0, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFE, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x11,
  0xFC, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x06, 0x06, 0x8E, 0xFC, 0x20, 0xC0, 0x0D, 0x80, 0x33,
  0x00, 0x66, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x30, 0x30, 0x60, 0x60, 0xC1,
  0x81, 0x83, 0x03, 0x0C, 0x06, 0x38, 0x0C, 0x60, 0x19, 0x80, 0x33, 0x00,
  0x6E, 0x00, 0xFC, 0x01, 0xEC, 0x03, 0x98, 0x06, 0x18, 0x0C, 0x30, 0x18,
  0x30, 0x30, 0x60, 0x60, 0x60, 0xC0, 0xC1, 0x80, 0xC3, 0x01, 0x86, 0x01,
  0x8C, 0x03, 0x18, 0x03, 0x30, 0x06, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x0C,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xA0, 0x00, 0x0D, 0xB0, 0x00, 0x0D, 0xB0, 0x00, 0x0F, 0x90, 0x00, 0x0B,
  0x98, 0x00, 0x1B, 0x98, 0x00, 0x1B, 0x88, 0x00, 0x13, 0x8C, 0x00, 0x33,
  0x8C, 0x00, 0x33, 0x8C, 0x00, 0x33, 0x84, 0x00, 0x63, 0x86, 0x00, 0x63,
  0x86, 0x00, 0x63, 0x82, 0x00, 0x43, 0x83, 0x00, 0xC3, 0x83, 0x00, 0xC3,
  0x83, 0x00, 0x83, 0x81, 0x81, 0x83, 0x81, 0x81, 0x83, 0x81, 0x81, 0x83,
  0x80, 0x83, 0x03, 0x80, 0xC3, 0x03, 0x80, 0xC3, 0x03, 0x80, 0x42, 0x03,
  0x80, 0x66, 0x03, 0x80, 0x66, 0x03, 0x80, 0x64, 0x03, 0x80, 0x3C, 0x03,
  0x80, 0x3C, 0x03, 0x80, 0x3C, 0x03, 0x80, 0x18, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x76, 0x00, 0x3B, 0x00, 0x1C, 0x80, 0x0E, 0x60, 0x07,
  0x30, 0x03, 0x8C, 0x01, 0xC6, 0x00, 0xE1, 0x80, 0x70, 0xC0, 0x38, 0x20,
  0x1C, 0x18, 0x0E, 0x04, 0x07, 0x03, 0x03, 0x81, 0x81, 0xC0, 0x60, 0xE0,
  0x30, 0x70, 0x0C, 0x38, 0x06, 0x1C, 0x01, 0x0E, 0x00, 0xC7, 0x00, 0x63,
  0x80, 0x19, 0xC0, 0x0C, 0xE0, 0x03, 0x70, 0x01, 0xB8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xC0, 0x01, 0xF0,
  0x00, 0xFF, 0x80, 0x38, 0x38, 0x0C, 0x01, 0x83, 0x00, 0x18, 0x60, 0x03,
  0x18, 0x00, 0x33, 0x00, 0x06, 0x40, 0x00, 0xD8, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xB0, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x61,
  0xC0, 0x1C, 0x1C, 0x07, 0x01, 0xE3, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x83,
  0x1F, 0x8C, 0x07, 0x30, 0x0E, 0xC0, 0x1B, 0x00, 0x6C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x6C, 0x01,
  0xB0, 0x06, 0xC0, 0x33, 0x03, 0x8F, 0xFC, 0x3F, 0x80, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0xFF, 0x80, 0x38, 0x38, 0x0C, 0x01, 0x83, 0x00, 0x18, 0x60, 0x03,
  0x18, 0x00, 0x33, 0x00, 0x06, 0x40, 0x00, 0xD8, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xB0, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x61,
  0xC0, 0x1C, 0x1C, 0x07, 0x01, 0xE3, 0xC0, 0x1F, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0xFF, 0x81, 0x8F, 0xC3, 0x01, 0xC6, 0x00,
  0xCC, 0x01, 0x98, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x1B,
  0x00, 0x36, 0x00, 0x6C, 0x00, 0xD8, 0x03, 0x30, 0x06, 0x60, 0x18, 0xC0,
  0xE1, 0xFF, 0x83, 0xFC, 0x06, 0x18, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x30,
  0x60, 0x60, 0xC0, 0x61, 0x80, 0xC3, 0x00, 0xC6, 0x01, 0x8C, 0x01, 0x98,
  0x03, 0x30, 0x06, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x0C, 0x03, 0xC0, 0x1F,
  0xFC, 0x70, 0x31, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x80, 0x39, 0xF1,
  0xE1, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xD0, 0x00, 0x6C, 0x00, 0x36, 0x00,
  0x1B, 0x00, 0x18, 0xC0, 0x0C, 0x70, 0x0C, 0x1E, 0x1E, 0x03, 0xFC, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0x34, 0x00, 0x0D, 0x80, 0x02, 0x60, 0x01, 0x98,
  0x00, 0x62, 0x00, 0x18, 0xC0, 0x04, 0x30, 0x03, 0x0C, 0x00, 0xC1, 0x00,
  0x30, 0x60, 0x0C, 0x18, 0x06, 0x06, 0x01, 0x81, 0x80, 0x60, 0x20, 0x18,
  0x0C, 0x04, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x10, 0x30, 0x06, 0x08, 0x01,
  0x86, 0x00, 0x61, 0x80, 0x08, 0x60, 0x03, 0x10, 0x00, 0xCC, 0x00, 0x33,
  0x00, 0x0C, 0xC0, 0x01, 0x20, 0x00, 0x68, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x40, 0x01, 0x80,
  0x06, 0x60, 0x03, 0x80, 0x06, 0x60, 0x03, 0x80, 0x06, 0x60, 0x03, 0xC0,
  0x06, 0x60, 0x02, 0xC0, 0x0C, 0x30, 0x02, 0xC0, 0x0C, 0x30, 0x06, 0xC0,
  0x0C, 0x30, 0x06, 0x40, 0x0C, 0x30, 0x06, 0x60, 0x08, 0x10, 0x06, 0x60,
  0x18, 0x18, 0x04, 0x60, 0x18, 0x18, 0x0C, 0x60, 0x18, 0x18, 0x0C, 0x20,
  0x18, 0x18, 0x0C, 0x30, 0x30, 0x08, 0x0C, 0x30, 0x30, 0x0C, 0x08, 0x30,
  0x30, 0x0C, 0x18, 0x30, 0x30, 0x0C, 0x18, 0x10, 0x20, 0x0C, 0x18, 0x18,
  0x60, 0x04, 0x18, 0x18, 0x60, 0x06, 0x10, 0x18, 0x60, 0x06, 0x30, 0x18,
  0x60, 0x06, 0x30, 0x08, 0x40, 0x06, 0x30, 0x0C, 0xC0, 0x03, 0x30, 0x0C,
  0xC0, 0x03, 0x20, 0x0C, 0xC0, 0x03, 0x60, 0x0C, 0xC0, 0x03, 0x60, 0x05,
  0x80, 0x01, 0x60, 0x05, 0x80, 0x01, 0x60, 0x07, 0x80, 0x01, 0xC0, 0x07,
  0x80, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x30, 0x03, 0x30,
  0x06, 0x10, 0x06, 0x18, 0x06, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x0C,
  0x18, 0x06, 0x18, 0x06, 0x30, 0x02, 0x30, 0x03, 0x30, 0x03, 0x60, 0x01,
  0x60, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x60, 0x03,
  0x60, 0x03, 0x20, 0x06, 0x30, 0x06, 0x30, 0x04, 0x10, 0x0C, 0x18, 0x0C,
  0x18, 0x18, 0x08, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x60,
  0x06, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0x40, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x20, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x10, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x08, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x04, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x02, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x7F, 0xFC, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0xFF,
  0xC0, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x30, 0xFF, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0C, 0x80, 0x03, 0x30,
  0x01, 0x84, 0x00, 0x61, 0x80, 0x30, 0x60, 0x0C, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x60, 0xC0, 0x18, 0x30, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x1B, 0x00,
  0x06, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC1, 0xC1, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x0F, 0x83, 0xFF, 0x08, 0x1C, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x01, 0xF0,
  0xFF, 0x9E, 0x0D, 0xC0, 0x6C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xEC, 0x0B, 0x70, 0xD9, 0xFC, 0xC0, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC3, 0xE0, 0xCF, 0xF0, 0xCC,
  0x18, 0xD0, 0x0C, 0xF0, 0x0C, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xC0,
  0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0xE0, 0x06, 0xE0,
  0x06, 0xE0, 0x0C, 0xD0, 0x0C, 0xD8, 0x18, 0xCC, 0x38, 0xC7, 0xF0, 0x03,
  0xE0, 0xFF, 0x1C, 0x13, 0x80, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x10, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x1F, 0x08, 0x7F,
  0x11, 0x83, 0x26, 0x03, 0x4C, 0x02, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x6C, 0x00, 0xD8, 0x01,
  0xB0, 0x07, 0x30, 0x0A, 0x60, 0x34, 0x71, 0xC8, 0x7F, 0x10, 0x03, 0xC0,
  0x3F, 0x81, 0x83, 0x0C, 0x06, 0x30, 0x09, 0x80, 0x36, 0x00, 0xD8, 0x03,
  0x40, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x01, 0x1E, 0x1C, 0x1F, 0xE0, 0x01, 0xE0, 0x7F, 0x06,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0xFF, 0x80, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x07, 0xC0, 0x1F, 0xE4, 0x60, 0xC9, 0x80, 0x53,
  0x00, 0xAC, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1B, 0x00, 0x36, 0x00, 0x6C, 0x01, 0x4C, 0x02, 0x98,
  0x0D, 0x1C, 0x72, 0x1F, 0xC4, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x19, 0x00, 0x73, 0x83, 0xC3,
  0xFF, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x3C, 0x33,
  0xFC, 0xDC, 0x3B, 0x40, 0x6F, 0x01, 0xB8, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x5F, 0xA0, 0x00, 0x01, 0x24,
  0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x00, 0x08, 0x71, 0xC2,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x3B, 0xCC, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x6C, 0x06, 0x60, 0x33, 0x03, 0x18, 0x30, 0xC1,
  0x86, 0x18, 0x30, 0xC1, 0x8C, 0x0C, 0xE0, 0x67, 0x03, 0x68, 0x1A, 0x60,
  0xF3, 0x07, 0x0C, 0x30, 0x61, 0x81, 0x8C, 0x0C, 0x60, 0x63, 0x01, 0x98,
  0x0C, 0xC0, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0xF0, 0xCF, 0xE1, 0xFC, 0xD8,
  0x73, 0x0C, 0xD0, 0x36, 0x06, 0xE0, 0x14, 0x06, 0xE0, 0x1C, 0x02, 0xE0,
  0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0,
  0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0,
  0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0,
  0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0,
  0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0x03,
  0xC3, 0x3F, 0xCD, 0x83, 0xB4, 0x06, 0xF0, 0x1B, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x30, 0x07, 0xC0, 0x0F,
  0xF0, 0x18, 0x18, 0x30, 0x0C, 0x20, 0x0C, 0x60, 0x06, 0x60, 0x06, 0x40,
  0x06, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0x40, 0x06, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x04, 0x30, 0x0C, 0x38, 0x1C, 0x1C, 0x38, 0x0F,
  0xF0, 0x03, 0xE0, 0xCF, 0xF0, 0xCC, 0x18, 0xD0, 0x0C, 0xD0, 0x0C, 0xE0,
  0x06, 0xE0, 0x06, 0xE0, 0x06, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0xC0,
  0x02, 0xC0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x0C, 0xD0, 0x0C, 0xD8,
  0x18, 0xCC, 0x38, 0xC7, 0xF0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x03, 0xC0, 0x1F, 0xE4, 0x60, 0xC9, 0x80, 0xD3, 0x00,
  0xAC, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x40, 0x07, 0x80, 0x0F, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1B, 0x00, 0x36, 0x00, 0x6C, 0x01, 0x4C, 0x02, 0x9C, 0x09,
  0x1C, 0x72, 0x1F, 0xC4, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x03, 0xF3, 0xEC, 0xC3, 0x60, 0xD0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x0F, 0x83,
  0xFE, 0x70, 0x2C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x68, 0x06, 0xF1, 0xC7,
  0xF8, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x83, 0xFE, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xC4, 0x3E,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x40,
  0x1D, 0x80, 0xF6, 0x06, 0xCE, 0x33, 0x1F, 0x8C, 0xC0, 0x0E, 0xC0, 0x19,
  0x80, 0x33, 0x00, 0x66, 0x00, 0x84, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30,
  0x10, 0x20, 0x60, 0x60, 0xC0, 0xC1, 0x81, 0x82, 0x01, 0x0C, 0x03, 0x18,
  0x06, 0x30, 0x0C, 0x40, 0x08, 0x80, 0x13, 0x00, 0x36, 0x00, 0x6C, 0x00,
  0xD0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0xC0, 0x0C, 0x01, 0xB0, 0x0E,
  0x00, 0xD8, 0x07, 0x00, 0x4C, 0x03, 0xC0, 0x62, 0x01, 0xE0, 0x31, 0x80,
  0xB0, 0x18, 0xC0, 0xC8, 0x0C, 0x60, 0x66, 0x04, 0x30, 0x33, 0x06, 0x08,
  0x11, 0x83, 0x06, 0x08, 0x41, 0x83, 0x0C, 0x20, 0x81, 0x86, 0x18, 0xC0,
  0x43, 0x0C, 0x60, 0x31, 0x06, 0x30, 0x19, 0x81, 0x18, 0x0C, 0xC0, 0x88,
  0x06, 0x60, 0x6C, 0x01, 0x30, 0x36, 0x00, 0xD0, 0x1B, 0x00, 0x78, 0x05,
  0x00, 0x3C, 0x02, 0x80, 0x0E, 0x01, 0xC0, 0x06, 0x00, 0xE0, 0x03, 0x00,
  0x70, 0x00, 0xE0, 0x1D, 0x80, 0x62, 0x03, 0x0C, 0x0C, 0x30, 0x20, 0x61,
  0x81, 0x86, 0x03, 0x30, 0x0C, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0xC0, 0x03,
  0x00, 0x1E, 0x00, 0x58, 0x03, 0x30, 0x0C, 0xC0, 0x61, 0x01, 0x86, 0x0C,
  0x18, 0x30, 0x31, 0x80, 0xC6, 0x01, 0xB0, 0x06, 0xC0, 0x0C, 0xC0, 0x0F,
  0x00, 0x34, 0x00, 0xD8, 0x02, 0x60, 0x19, 0x80, 0x62, 0x01, 0x8C, 0x04,
  0x30, 0x30, 0xC0, 0xC1, 0x03, 0x06, 0x08, 0x18, 0x60, 0x61, 0x80, 0x86,
  0x03, 0x10, 0x0C, 0xC0, 0x33, 0x00, 0x4C, 0x01, 0xA0, 0x07, 0x80, 0x1E,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x09, 0x80, 0x3C,
  0x00, 0xC0, 0x00, 0x7F, 0xE0, 0x08, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0xF0, 0x1C, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0xF0, 0x07, 0x80, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x03, 0xC0, 0x0E, 0x00, 0x60,
  0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x1F, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x06, 0x01, 0xC0, 0xF8, 0x0C, 0x00, 0x3F, 0x00, 0xBF,
  0xE0, 0x70, 0x3D, 0xF0, 0x07, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 34, 10, 3, -34 },
  { 14, 9, 12, 15, 3, -34 },
  { 28, 19, 34, 21, 1, -34 },
  { 109, 16, 39, 19, 2, -36 },
  { 187, 24, 35, 28, 2, -35 },
  { 292, 18, 35, 19, 1, -35 },
  { 371, 2, 12, 8, 3, -34 },
  { 374, 9, 42, 13, 2, -34 },
  { 422, 8, 42, 13, 2, -34 },
  { 464, 13, 13, 17, 2, -36 },
  { 486, 17, 22, 19, 1, -28 },
  { 533, 4, 11, 9, 2, -5 },
  { 539, 10, 2, 13, 1, -14 },
  { 542, 3, 4, 9, 3, -4 },
  { 544, 14, 34, 16, 1, -34 },
  { 604, 15, 35, 19, 2, -35 },
  { 670, 8, 34, 19, 4, -34 },
  { 704, 15, 35, 19, 2, -35 },
  { 770, 15, 35, 19, 2, -35 },
  { 836, 18, 34, 19, 1, -34 },
  { 913, 15, 34, 19, 2, -34 },
  { 977, 15, 36, 19, 2, -35 },
  { 1045, 15, 34, 19, 2, -34 },
  { 1109, 16, 35, 19, 2, -35 },
  { 1179, 15, 35, 19, 2, -35 },
  { 1245, 3, 26, 9, 3, -26 },
  { 1255, 4, 32, 9, 2, -26 },
  { 1271, 17, 20, 19, 1, -27 },
  { 1314, 17, 12, 19, 1, -23 },
  { 1340, 17, 20, 19, 1, -27 },
  { 1383, 11, 35, 13, 1, -35 },
  { 1432, 24, 39, 29, 3, -35 },
  { 1549, 19, 34, 19, 0, -34 },
  { 1630, 15, 34, 21, 4, -34 },
  { 1694, 16, 35, 20, 3, -35 },
  { 1764, 17, 34, 23, 4, -34 },
  { 1837, 12, 34, 18, 4, -34 },
  { 1888, 12, 34, 17, 4, -34 },
  { 1939, 20, 35, 25, 3, -35 },
  { 2027, 16, 34, 24, 4, -34 },
  { 2095, 7, 34, 11, 2, -34 },
  { 2125, 8, 43, 9, -2, -34 },
  { 2168, 15, 34, 19, 4, -34 },
  { 2232, 12, 34, 17, 4, -34 },
  { 2283, 24, 34, 32, 4, -34 },
  { 2385, 17, 34, 25, 4, -34 },
  { 2458, 19, 35, 25, 3, -35 },
  { 2542, 14, 34, 19, 4, -34 },
  { 2602, 19, 43, 25, 3, -35 },
  { 2705, 15, 34, 20, 4, -34 },
  { 2769, 15, 35, 19, 2, -35 },
  { 2835, 16, 34, 17, 0, -34 },
  { 2903, 17, 34, 24, 3, -34 },
  { 2976, 18, 34, 18, 0, -34 },
  { 3053, 32, 34, 32, 0, -34 },
  { 3189, 16, 34, 17, 0, -34 },
  { 3257, 16, 34, 16, 0, -34 },
  { 3325, 14, 34, 16, 1, -34 },
  { 3385, 9, 42, 15, 4, -34 },
  { 3433, 14, 34, 16, 1, -34 },
  { 3493, 9, 42, 15, 2, -34 },
  { 3541, 18, 17, 19, 1, -34 },
  { 3580, 19, 2, 19, 0, 4 },
  { 3585, 7, 8, 11, 2, -37 },
  { 3592, 13, 26, 18, 2, -26 },
  { 3635, 16, 36, 21, 3, -36 },
  { 3707, 12, 26, 15, 2, -26 },
  { 3746, 15, 36, 21, 2, -36 },
  { 3814, 14, 26, 19, 2, -26 },
  { 3860, 12, 37, 11, 0, -37 },
  { 3916, 15, 38, 21, 2, -26 },
  { 3988, 14, 36, 20, 3, -36 },
  { 4051, 3, 35, 9, 3, -35 },
  { 4065, 6, 47, 9, 0, -35 },
  { 4101, 13, 36, 16, 3, -36 },
  { 4160, 2, 36, 8, 3, -36 },
  { 4169, 24, 26, 30, 3, -26 },
  { 4247, 14, 26, 20, 3, -26 },
  { 4293, 16, 26, 20, 2, -26 },
  { 4345, 16, 37, 21, 3, -26 },
  { 4419, 15, 37, 21, 2, -26 },
  { 4489, 10, 26, 13, 3, -26 },
  { 4522, 12, 26, 15, 2, -26 },
  { 4561, 9, 31, 11, 1, -31 },
  { 4596, 14, 25, 20, 3, -25 },
  { 4640, 15, 25, 15, 0, -25 },
  { 4687, 25, 25, 25, 0, -25 },
  { 4766, 14, 25, 16, 1, -25 },
  { 4810, 14, 37, 16, 1, -25 },
  { 4875, 11, 25, 13, 1, -25 },
  { 4910, 12, 42, 17, 2, -34 },
  { 4973, 2, 49, 18, 8, -37 },
  { 4986, 12, 42, 17, 2, -34 },
  { 5049, 17, 4, 19, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight48pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT48PT7B_H_
