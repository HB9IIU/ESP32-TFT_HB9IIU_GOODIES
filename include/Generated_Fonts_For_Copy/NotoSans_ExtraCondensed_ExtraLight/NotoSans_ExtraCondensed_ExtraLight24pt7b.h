#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT24PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF9, 0x80, 0x99, 0x99, 0x99, 0x09, 0x02, 0x41, 0x10, 0x44,
  0x11, 0x1F, 0xF1, 0x10, 0x44, 0x11, 0x04, 0x81, 0x23, 0xBE, 0x22, 0x08,
  0x82, 0x20, 0x88, 0x22, 0x00, 0x10, 0x3C, 0x52, 0x90, 0x90, 0x90, 0x90,
  0xD0, 0x70, 0x18, 0x16, 0x12, 0x11, 0x11, 0x11, 0x12, 0xFC, 0x10, 0x10,
  0x70, 0x88, 0x88, 0x88, 0x88, 0x90, 0x89, 0x08, 0x90, 0x8A, 0x48, 0xAA,
  0x8A, 0x97, 0x51, 0x05, 0x10, 0x51, 0x09, 0x10, 0x91, 0x09, 0x11, 0x09,
  0x10, 0xE0, 0x38, 0x22, 0x11, 0x08, 0x84, 0x42, 0x40, 0xA0, 0x60, 0x70,
  0x28, 0x22, 0x50, 0xA8, 0x54, 0x12, 0x09, 0x0A, 0x79, 0x80, 0xFC, 0x19,
  0x08, 0x84, 0x21, 0x10, 0x84, 0x21, 0x08, 0x41, 0x08, 0x41, 0x08, 0x21,
  0x80, 0x84, 0x42, 0x21, 0x11, 0x11, 0x11, 0x11, 0x12, 0x22, 0x44, 0x80,
  0x10, 0x4F, 0xC4, 0x29, 0x30, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x55, 0xA0, 0xF8, 0xC0, 0x02, 0x08, 0x10, 0x40,
  0x81, 0x04, 0x08, 0x10, 0x40, 0x81, 0x04, 0x08, 0x20, 0x40, 0x80, 0x3C,
  0x44, 0x42, 0x82, 0x82, 0x82, 0x82, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82,
  0x42, 0x42, 0x44, 0x3C, 0x17, 0xD9, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x10, 0xFC, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08,
  0x10, 0x10, 0x20, 0x40, 0x80, 0xFF, 0x7D, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x04, 0x38, 0x0C, 0x08, 0x10, 0x20, 0x40, 0x83, 0xFC, 0x02, 0x03, 0x01,
  0x81, 0x40, 0xA0, 0x90, 0x48, 0x44, 0x22, 0x11, 0x10, 0x88, 0x4F, 0xF8,
  0x10, 0x08, 0x04, 0x02, 0x00, 0x7E, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80,
  0xFC, 0x02, 0x02, 0x01, 0x01, 0x01, 0x02, 0x02, 0x06, 0xFC, 0x1E, 0x20,
  0x40, 0x40, 0x40, 0x80, 0x98, 0xA4, 0xC2, 0x82, 0x81, 0x81, 0x81, 0x82,
  0x42, 0x42, 0x3C, 0xFE, 0x04, 0x08, 0x10, 0x40, 0x81, 0x04, 0x08, 0x10,
  0x40, 0x81, 0x04, 0x08, 0x10, 0x60, 0x7C, 0x42, 0x82, 0x82, 0x82, 0x42,
  0x64, 0x38, 0x38, 0x44, 0x82, 0x81, 0x81, 0x81, 0x81, 0x42, 0x7C, 0x7C,
  0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0xDC, 0x48, 0x10, 0x20, 0x41,
  0x02, 0x78, 0xC0, 0x18, 0x50, 0x00, 0x05, 0x5A, 0x03, 0x0C, 0x30, 0xC0,
  0x80, 0x60, 0x18, 0x04, 0x03, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x06, 0x18, 0x20, 0xC0, 0x80, 0xF8, 0x10,
  0x41, 0x04, 0x10, 0x82, 0x10, 0x82, 0x08, 0x20, 0x00, 0x08, 0x20, 0x0F,
  0x80, 0x82, 0x08, 0x08, 0x80, 0x24, 0x01, 0x23, 0xCA, 0x22, 0x51, 0x11,
  0x88, 0x8C, 0x44, 0x62, 0x23, 0x12, 0x28, 0x99, 0x47, 0x71, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x03, 0xE0, 0x08, 0x06, 0x05, 0x02, 0x81, 0x40,
  0x90, 0x88, 0x44, 0x22, 0x10, 0x8F, 0xC8, 0x24, 0x12, 0x05, 0x03, 0x01,
  0x80, 0x80, 0xFC, 0x82, 0x82, 0x82, 0x82, 0x82, 0x82, 0x8C, 0xFC, 0x82,
  0x82, 0x81, 0x81, 0x81, 0x82, 0x86, 0xFC, 0x1F, 0x90, 0x10, 0x08, 0x04,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x60, 0x1F, 0x00, 0xF8, 0x86, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x84, 0xF8, 0xFE, 0x08, 0x20, 0x82,
  0x08, 0x20, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFC, 0xFE, 0x08, 0x20,
  0x82, 0x08, 0x20, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x80, 0x1F, 0xCC,
  0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x83, 0xE0, 0x18, 0x06,
  0x01, 0x40, 0x50, 0x12, 0x04, 0xC1, 0x1F, 0xC0, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0xF4, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0xF0, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xE0, 0x83, 0x0A, 0x14,
  0x49, 0x92, 0x28, 0x50, 0xE1, 0x22, 0x44, 0x48, 0x90, 0xA1, 0x41, 0x82,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0xFC, 0x80, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xA0, 0x5A, 0x05, 0xA0, 0x59,
  0x09, 0x90, 0x99, 0x09, 0x90, 0x98, 0x91, 0x89, 0x18, 0x91, 0x86, 0x18,
  0x61, 0x86, 0x10, 0x80, 0xE0, 0x70, 0x34, 0x1A, 0x0D, 0x06, 0x43, 0x21,
  0x88, 0xC4, 0x61, 0x30, 0x98, 0x2C, 0x16, 0x0B, 0x03, 0x81, 0x80, 0x1F,
  0x08, 0x24, 0x09, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x40, 0x50, 0x14, 0x08, 0x86, 0x1F, 0x00, 0xF9, 0x0A, 0x0C,
  0x18, 0x30, 0x60, 0xC2, 0x8D, 0xE2, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80,
  0x1F, 0x08, 0x24, 0x09, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x40, 0x50, 0x14, 0x08, 0x86, 0x1F, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0xF8, 0x84, 0x82, 0x82, 0x82, 0x82, 0x82, 0x84, 0xF8,
  0x90, 0x88, 0x88, 0x88, 0x84, 0x84, 0x82, 0x83, 0x3E, 0x82, 0x04, 0x08,
  0x10, 0x10, 0x10, 0x18, 0x08, 0x08, 0x10, 0x20, 0x40, 0x83, 0xFC, 0xFF,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC2, 0x7C, 0x80, 0xC0, 0x50,
  0x28, 0x24, 0x12, 0x09, 0x04, 0x44, 0x22, 0x11, 0x08, 0x82, 0x81, 0x40,
  0xA0, 0x50, 0x10, 0x08, 0x00, 0x81, 0x01, 0x81, 0x82, 0x41, 0x82, 0x41,
  0x82, 0x42, 0x82, 0x42, 0x42, 0x42, 0x44, 0x22, 0x44, 0x22, 0x44, 0x24,
  0x44, 0x24, 0x28, 0x14, 0x28, 0x14, 0x28, 0x14, 0x28, 0x14, 0x28, 0x18,
  0x30, 0x08, 0x10, 0x41, 0x42, 0x22, 0x22, 0x24, 0x14, 0x14, 0x08, 0x08,
  0x18, 0x14, 0x24, 0x24, 0x22, 0x42, 0x41, 0x81, 0x81, 0x42, 0x42, 0x42,
  0x24, 0x24, 0x24, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0xFC, 0x10, 0x42, 0x08, 0x21, 0x04, 0x20, 0x82, 0x10, 0x41, 0x08,
  0x20, 0xFC, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x0F, 0x80, 0x81, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10,
  0x20, 0x40, 0x40, 0x81, 0x01, 0x02, 0x02, 0xF1, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x0C, 0x06, 0x04, 0x82, 0x42, 0x11,
  0x09, 0x05, 0x81, 0xFF, 0xC0, 0xC4, 0x30, 0x79, 0x10, 0x41, 0x04, 0x13,
  0xF1, 0x86, 0x18, 0x61, 0x7C, 0x81, 0x02, 0x04, 0x08, 0x17, 0x31, 0x41,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC5, 0x78, 0x1D, 0x84, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x04, 0x10, 0x3C, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x39, 0x45, 0x43, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0x43,
  0x3D, 0x38, 0x89, 0x0C, 0x18, 0x30, 0x7F, 0xC0, 0x81, 0x01, 0x02, 0x03,
  0xE0, 0x3C, 0x82, 0x08, 0x23, 0xE2, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x80, 0x39, 0x45, 0x43, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x83, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x02, 0x86, 0x78, 0x82, 0x08,
  0x20, 0x82, 0xEC, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x10,
  0x8F, 0xFF, 0x80, 0x20, 0x02, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0xB0,
  0x82, 0x08, 0x20, 0x82, 0x18, 0xA4, 0x92, 0x8A, 0x38, 0x92, 0x48, 0xA2,
  0x8A, 0x10, 0xFF, 0xFF, 0xC0, 0xB9, 0xD9, 0x46, 0x10, 0xC2, 0x18, 0x43,
  0x08, 0x61, 0x0C, 0x21, 0x84, 0x30, 0x86, 0x10, 0xC2, 0x18, 0x42, 0xBB,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x3C, 0x42, 0x42,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x42, 0x3C, 0xB9, 0x8A,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0x2B, 0xD0, 0x20, 0x40,
  0x81, 0x02, 0x00, 0x39, 0x45, 0x43, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x43, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xBC, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x80, 0x7A, 0x18, 0x20, 0x81, 0x03, 0x02, 0x04,
  0x10, 0x62, 0xF8, 0x21, 0x09, 0xF2, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x87, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x63, 0x74, 0x83,
  0x05, 0x0A, 0x14, 0x48, 0x89, 0x12, 0x28, 0x50, 0xA0, 0xC1, 0x00, 0x82,
  0x0C, 0x10, 0x91, 0x44, 0x8A, 0x24, 0x51, 0x22, 0x90, 0x94, 0x85, 0x14,
  0x28, 0xA1, 0x45, 0x0A, 0x30, 0x21, 0x81, 0x04, 0x00, 0x42, 0x84, 0x91,
  0x22, 0x83, 0x04, 0x0C, 0x28, 0x48, 0x92, 0x1C, 0x20, 0x81, 0x42, 0x42,
  0x42, 0x42, 0x24, 0x24, 0x24, 0x24, 0x18, 0x18, 0x18, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x20, 0xC0, 0xF8, 0x44, 0x21, 0x10, 0x88, 0x42, 0x21, 0x0F,
  0x80, 0x0C, 0x41, 0x04, 0x10, 0x41, 0x04, 0x20, 0x8C, 0x08, 0x20, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x0C, 0xFF, 0xFF, 0xFF, 0xE0, 0x81, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x40, 0xC4, 0x10, 0x41, 0x04, 0x10, 0x41, 0x08, 0xC0,
  0x20, 0x99, 0x86,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 17, 5, 2, -17 },
  { 4, 4, 6, 7, 2, -17 },
  { 7, 10, 17, 10, 0, -17 },
  { 29, 8, 19, 10, 1, -18 },
  { 48, 12, 17, 14, 1, -17 },
  { 74, 9, 17, 10, 1, -17 },
  { 94, 1, 6, 4, 2, -17 },
  { 95, 5, 21, 6, 1, -17 },
  { 109, 4, 21, 6, 1, -17 },
  { 120, 6, 6, 8, 1, -18 },
  { 125, 8, 11, 10, 1, -14 },
  { 136, 2, 6, 4, 1, -3 },
  { 138, 5, 1, 6, 1, -7 },
  { 139, 1, 2, 5, 2, -2 },
  { 140, 7, 17, 8, 1, -17 },
  { 155, 8, 17, 10, 1, -17 },
  { 172, 4, 17, 10, 2, -17 },
  { 181, 8, 17, 10, 1, -17 },
  { 198, 7, 17, 10, 1, -17 },
  { 213, 9, 17, 10, 0, -17 },
  { 233, 8, 17, 10, 1, -17 },
  { 250, 8, 17, 10, 1, -17 },
  { 267, 7, 17, 10, 1, -17 },
  { 282, 8, 17, 10, 1, -17 },
  { 299, 7, 17, 10, 1, -17 },
  { 314, 1, 13, 5, 2, -13 },
  { 316, 2, 16, 4, 1, -13 },
  { 320, 8, 10, 10, 1, -13 },
  { 330, 8, 6, 10, 1, -11 },
  { 336, 8, 10, 10, 1, -13 },
  { 346, 6, 17, 7, 0, -17 },
  { 359, 13, 19, 15, 1, -17 },
  { 390, 9, 17, 9, 0, -17 },
  { 410, 8, 17, 11, 2, -17 },
  { 427, 9, 17, 10, 1, -17 },
  { 447, 8, 17, 12, 2, -17 },
  { 464, 6, 17, 9, 2, -17 },
  { 477, 6, 17, 9, 2, -17 },
  { 490, 10, 17, 13, 1, -17 },
  { 512, 8, 17, 12, 2, -17 },
  { 529, 4, 17, 6, 1, -17 },
  { 538, 4, 21, 5, -1, -17 },
  { 549, 7, 17, 9, 2, -17 },
  { 564, 6, 17, 8, 2, -17 },
  { 577, 12, 17, 16, 2, -17 },
  { 603, 9, 17, 12, 2, -17 },
  { 623, 10, 17, 12, 1, -17 },
  { 645, 7, 17, 10, 2, -17 },
  { 660, 10, 21, 12, 1, -17 },
  { 687, 8, 17, 10, 2, -17 },
  { 704, 7, 17, 9, 1, -17 },
  { 719, 8, 17, 8, 0, -17 },
  { 736, 8, 17, 12, 2, -17 },
  { 753, 9, 17, 9, 0, -17 },
  { 773, 16, 17, 16, 0, -17 },
  { 807, 8, 17, 8, 0, -17 },
  { 824, 8, 17, 8, 0, -17 },
  { 841, 6, 17, 8, 1, -17 },
  { 854, 5, 21, 7, 2, -17 },
  { 868, 7, 17, 8, 1, -17 },
  { 883, 4, 21, 7, 1, -17 },
  { 894, 9, 8, 10, 0, -17 },
  { 903, 10, 1, 10, 0, 2 },
  { 905, 4, 3, 6, 1, -18 },
  { 907, 6, 13, 9, 1, -13 },
  { 917, 7, 18, 10, 2, -18 },
  { 933, 6, 13, 8, 1, -13 },
  { 943, 8, 18, 10, 1, -18 },
  { 961, 7, 13, 9, 1, -13 },
  { 973, 6, 18, 5, 0, -18 },
  { 987, 8, 19, 10, 1, -13 },
  { 1006, 6, 18, 10, 2, -18 },
  { 1020, 1, 17, 4, 2, -17 },
  { 1023, 3, 23, 4, 0, -17 },
  { 1032, 6, 18, 8, 2, -18 },
  { 1046, 1, 18, 4, 2, -18 },
  { 1049, 11, 13, 15, 2, -13 },
  { 1067, 6, 13, 10, 2, -13 },
  { 1077, 8, 13, 10, 1, -13 },
  { 1090, 7, 19, 10, 2, -13 },
  { 1107, 8, 19, 10, 1, -13 },
  { 1126, 4, 13, 7, 2, -13 },
  { 1133, 6, 13, 8, 1, -13 },
  { 1143, 5, 16, 5, 0, -16 },
  { 1153, 6, 13, 10, 2, -13 },
  { 1163, 7, 13, 7, 0, -13 },
  { 1175, 13, 13, 13, 0, -13 },
  { 1197, 7, 13, 8, 0, -13 },
  { 1209, 8, 19, 8, 0, -13 },
  { 1228, 5, 13, 6, 1, -13 },
  { 1237, 6, 21, 8, 1, -17 },
  { 1253, 1, 24, 9, 4, -18 },
  { 1256, 6, 21, 8, 1, -17 },
  { 1272, 8, 3, 10, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight24pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT24PT7B_H_
