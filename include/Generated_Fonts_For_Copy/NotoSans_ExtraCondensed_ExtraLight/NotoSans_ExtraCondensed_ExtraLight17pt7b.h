#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT17PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x90, 0xB6, 0xD0, 0x24, 0x48, 0x93, 0xF2, 0x44, 0x8A, 0x7F,
  0x28, 0x91, 0x22, 0x40, 0x23, 0xE9, 0x4A, 0x51, 0x86, 0x29, 0x4B, 0x76,
  0x10, 0xE4, 0xA4, 0xA4, 0xA8, 0xAA, 0xAD, 0xB5, 0x55, 0x15, 0x25, 0x25,
  0x27, 0x72, 0x49, 0x24, 0x61, 0x0A, 0x29, 0x9A, 0x28, 0xBD, 0xF0, 0x29,
  0x49, 0x24, 0x92, 0x44, 0x88, 0x89, 0x22, 0x49, 0x25, 0x25, 0x20, 0x22,
  0xF6, 0x90, 0x10, 0x41, 0x04, 0xFC, 0x41, 0x04, 0xF0, 0xF0, 0x80, 0x08,
  0x42, 0x21, 0x08, 0x84, 0x42, 0x11, 0x00, 0x74, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x62, 0xE0, 0x2E, 0x92, 0x49, 0x24, 0x90, 0xF0, 0x42, 0x10, 0x88,
  0x44, 0x22, 0x21, 0xF0, 0xF0, 0x42, 0x11, 0x30, 0x41, 0x08, 0x43, 0xE0,
  0x08, 0x30, 0x61, 0x42, 0x85, 0x12, 0x24, 0xFE, 0x10, 0x20, 0x40, 0xF4,
  0x21, 0x08, 0x78, 0x21, 0x08, 0x43, 0xE0, 0x7A, 0x21, 0x0A, 0x6E, 0x31,
  0x8C, 0x62, 0xE0, 0xF8, 0x42, 0x21, 0x08, 0x84, 0x22, 0x10, 0x80, 0x74,
  0x63, 0x15, 0x11, 0x51, 0x8C, 0x62, 0xE0, 0xF4, 0x63, 0x18, 0xC7, 0x65,
  0x08, 0x45, 0xC0, 0x80, 0x80, 0x81, 0xE0, 0x04, 0x33, 0x30, 0x60, 0x40,
  0xC1, 0xFC, 0x00, 0x3F, 0x81, 0x81, 0x81, 0x0C, 0x46, 0x20, 0xF1, 0x11,
  0x12, 0x24, 0x40, 0x04, 0x3E, 0x20, 0x90, 0x51, 0xA9, 0x4D, 0x26, 0x93,
  0x49, 0xA4, 0xCD, 0xA0, 0x08, 0x06, 0x40, 0xC0, 0x10, 0x60, 0xA1, 0x42,
  0x89, 0x11, 0x3E, 0x45, 0x0A, 0x14, 0x10, 0xFA, 0x18, 0x61, 0x8B, 0xC8,
  0xA1, 0x86, 0x18, 0x7E, 0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04,
  0x0F, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0xBC, 0xFC, 0x21,
  0x08, 0x7E, 0x10, 0x84, 0x21, 0xF0, 0xFC, 0x21, 0x08, 0x43, 0xF0, 0x84,
  0x21, 0x00, 0x3E, 0x82, 0x04, 0x08, 0x10, 0x23, 0xC1, 0x83, 0x05, 0x09,
  0xF0, 0x86, 0x18, 0x61, 0x87, 0xF8, 0x61, 0x86, 0x18, 0x61, 0xEA, 0xAA,
  0xAB, 0x24, 0x92, 0x49, 0x24, 0x92, 0x78, 0x8E, 0x29, 0x24, 0xA3, 0x8A,
  0x24, 0x92, 0x28, 0xA1, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0xF0,
  0x80, 0xE0, 0x70, 0x74, 0x3A, 0x2D, 0x16, 0x8B, 0x25, 0x94, 0xCA, 0x62,
  0x31, 0x10, 0x83, 0x87, 0x0D, 0x1A, 0x32, 0x64, 0xC5, 0x8B, 0x16, 0x1C,
  0x10, 0x78, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0x11, 0xC0,
  0xF4, 0x63, 0x18, 0xC7, 0xD0, 0x84, 0x21, 0x00, 0x78, 0x8A, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x05, 0x11, 0xC0, 0x81, 0x01, 0x00, 0xF2, 0x28,
  0xA2, 0x8A, 0x2F, 0x24, 0x92, 0x28, 0xA1, 0x7C, 0x21, 0x08, 0x30, 0x41,
  0x08, 0x43, 0xE0, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x5E, 0x86, 0x18, 0x51,
  0x45, 0x24, 0x8A, 0x28, 0xC3, 0x04, 0x84, 0x30, 0x86, 0x10, 0xA5, 0x14,
  0xA4, 0x94, 0x92, 0x91, 0x4A, 0x31, 0x86, 0x30, 0xC6, 0x08, 0x40, 0x45,
  0x24, 0x8C, 0x30, 0x43, 0x0C, 0x49, 0x24, 0xA1, 0x86, 0x24, 0x92, 0x50,
  0xC2, 0x08, 0x20, 0x82, 0x08, 0x78, 0x42, 0x21, 0x10, 0x84, 0x42, 0x11,
  0xF0, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x82, 0x10, 0x42,
  0x10, 0x42, 0x10, 0x42, 0x10, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x78, 0x10,
  0x50, 0xA2, 0x24, 0x50, 0x40, 0xFE, 0x94, 0xF1, 0x11, 0x79, 0x99, 0xF0,
  0x82, 0x08, 0x20, 0xFA, 0x28, 0x61, 0x86, 0x18, 0x62, 0xF8, 0x78, 0x88,
  0x88, 0x88, 0x70, 0x08, 0x42, 0x17, 0xC6, 0x31, 0x8C, 0x63, 0x17, 0x80,
  0x74, 0x63, 0x1F, 0x42, 0x10, 0x78, 0x34, 0x44, 0xE4, 0x44, 0x44, 0x44,
  0x40, 0x7C, 0x63, 0x18, 0xC6, 0x31, 0x78, 0x42, 0x1F, 0x00, 0x84, 0x21,
  0x0F, 0x46, 0x31, 0x8C, 0x63, 0x18, 0x80, 0x9F, 0xF0, 0x41, 0x55, 0x55,
  0x57, 0x84, 0x21, 0x09, 0x4A, 0x94, 0xE5, 0x25, 0x28, 0x80, 0xFF, 0xF8,
  0xF7, 0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0xF4, 0x63, 0x18,
  0xC6, 0x31, 0x88, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x70, 0xFA, 0x28, 0x61,
  0x86, 0x18, 0x62, 0xFA, 0x08, 0x20, 0x80, 0x7C, 0x63, 0x18, 0xC6, 0x31,
  0x78, 0x42, 0x10, 0x80, 0xF2, 0x49, 0x24, 0x80, 0xF8, 0x88, 0x61, 0x11,
  0xE0, 0x4B, 0xA4, 0x92, 0x49, 0x80, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x78,
  0x8C, 0x62, 0xA5, 0x29, 0x44, 0x20, 0x88, 0xC4, 0x55, 0x2A, 0xA5, 0x52,
  0xA9, 0x54, 0x44, 0x22, 0x00, 0xCA, 0x54, 0x62, 0x19, 0x49, 0x88, 0x8A,
  0x52, 0x95, 0x18, 0xC6, 0x21, 0x08, 0x4C, 0x00, 0x71, 0x12, 0x24, 0x44,
  0xF0, 0x34, 0x44, 0x44, 0x48, 0x44, 0x44, 0x42, 0x10, 0xFF, 0xFF, 0x80,
  0xC4, 0x22, 0x22, 0x23, 0x22, 0x22, 0x24, 0x80, 0xEC, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 12, 3, 1, -12 },
  { 3, 3, 4, 5, 1, -12 },
  { 5, 7, 12, 7, 0, -12 },
  { 16, 5, 14, 7, 1, -13 },
  { 25, 8, 12, 10, 1, -12 },
  { 37, 6, 12, 7, 1, -12 },
  { 46, 1, 4, 3, 1, -12 },
  { 47, 3, 15, 5, 1, -12 },
  { 53, 3, 15, 5, 1, -12 },
  { 59, 4, 5, 6, 1, -13 },
  { 62, 6, 8, 7, 0, -10 },
  { 68, 1, 4, 3, 1, -2 },
  { 69, 4, 1, 5, 0, -5 },
  { 70, 1, 1, 3, 1, -1 },
  { 71, 5, 12, 6, 0, -12 },
  { 79, 5, 12, 7, 1, -12 },
  { 87, 3, 12, 7, 1, -12 },
  { 92, 5, 12, 7, 1, -12 },
  { 100, 5, 12, 7, 1, -12 },
  { 108, 7, 12, 7, 0, -12 },
  { 119, 5, 12, 7, 1, -12 },
  { 127, 5, 12, 7, 1, -12 },
  { 135, 5, 12, 7, 1, -12 },
  { 143, 5, 12, 7, 1, -12 },
  { 151, 5, 12, 7, 1, -12 },
  { 159, 1, 9, 3, 1, -9 },
  { 161, 1, 11, 3, 1, -9 },
  { 163, 6, 8, 7, 0, -10 },
  { 169, 6, 4, 7, 0, -8 },
  { 172, 6, 8, 7, 0, -10 },
  { 178, 4, 12, 5, 0, -12 },
  { 184, 9, 14, 10, 1, -12 },
  { 200, 7, 12, 7, 0, -12 },
  { 211, 6, 12, 7, 1, -12 },
  { 220, 6, 12, 7, 1, -12 },
  { 229, 6, 12, 8, 1, -12 },
  { 238, 5, 12, 7, 1, -12 },
  { 246, 5, 12, 6, 1, -12 },
  { 254, 7, 12, 9, 1, -12 },
  { 265, 6, 12, 8, 1, -12 },
  { 274, 2, 12, 4, 1, -12 },
  { 277, 3, 15, 3, -1, -12 },
  { 283, 6, 12, 7, 1, -12 },
  { 292, 5, 12, 6, 1, -12 },
  { 300, 9, 12, 11, 1, -12 },
  { 314, 7, 12, 9, 1, -12 },
  { 325, 7, 12, 9, 1, -12 },
  { 336, 5, 12, 7, 1, -12 },
  { 344, 7, 15, 9, 1, -12 },
  { 358, 6, 12, 7, 1, -12 },
  { 367, 5, 12, 7, 1, -12 },
  { 375, 6, 12, 6, 0, -12 },
  { 384, 6, 12, 8, 1, -12 },
  { 393, 6, 12, 6, 0, -12 },
  { 402, 11, 12, 11, 0, -12 },
  { 419, 6, 12, 6, 0, -12 },
  { 428, 6, 12, 6, 0, -12 },
  { 437, 5, 12, 6, 0, -12 },
  { 445, 4, 15, 5, 1, -12 },
  { 453, 5, 12, 6, 0, -12 },
  { 461, 3, 15, 5, 1, -12 },
  { 467, 7, 6, 7, 0, -12 },
  { 473, 7, 1, 7, 0, 1 },
  { 474, 2, 3, 4, 1, -13 },
  { 475, 4, 9, 6, 1, -9 },
  { 480, 6, 13, 7, 1, -13 },
  { 490, 4, 9, 5, 1, -9 },
  { 495, 5, 13, 7, 1, -13 },
  { 504, 5, 9, 7, 1, -9 },
  { 510, 4, 13, 4, 0, -13 },
  { 517, 5, 13, 7, 1, -9 },
  { 526, 5, 13, 7, 1, -13 },
  { 535, 1, 12, 3, 1, -12 },
  { 537, 2, 16, 3, 0, -12 },
  { 541, 5, 13, 6, 1, -13 },
  { 550, 1, 13, 3, 1, -13 },
  { 552, 8, 9, 11, 1, -9 },
  { 561, 5, 9, 7, 1, -9 },
  { 567, 5, 9, 7, 1, -9 },
  { 573, 6, 13, 7, 1, -9 },
  { 583, 5, 13, 7, 1, -9 },
  { 592, 3, 9, 5, 1, -9 },
  { 596, 4, 9, 5, 1, -9 },
  { 601, 3, 11, 4, 0, -11 },
  { 606, 5, 9, 7, 1, -9 },
  { 612, 5, 9, 5, 0, -9 },
  { 618, 9, 9, 9, 0, -9 },
  { 629, 5, 9, 6, 0, -9 },
  { 635, 5, 13, 6, 0, -9 },
  { 644, 4, 9, 5, 0, -9 },
  { 649, 4, 15, 6, 1, -12 },
  { 657, 1, 17, 7, 3, -13 },
  { 660, 4, 15, 6, 1, -12 },
  { 668, 5, 2, 7, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight17pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT17PT7B_H_
