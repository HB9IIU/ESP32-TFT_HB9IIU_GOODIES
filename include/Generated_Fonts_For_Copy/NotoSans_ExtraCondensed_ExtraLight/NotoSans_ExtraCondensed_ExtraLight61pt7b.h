#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT61PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight61pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x06, 0xFF, 0xF7, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x00, 0x60, 0x30,
  0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30,
  0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x60,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x01, 0x80, 0x60, 0x01, 0x80, 0x40,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x80, 0xC0,
  0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x06, 0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x01, 0x80,
  0x06, 0x01, 0x80, 0x06, 0x03, 0x80, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00,
  0x06, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00,
  0x0C, 0x03, 0x00, 0x0C, 0x07, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x81, 0xFE, 0xFE,
  0x3C, 0x60, 0xC3, 0x06, 0x00, 0x70, 0x60, 0x06, 0x06, 0x00, 0xE0, 0x60,
  0x0C, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x06,
  0x00, 0xE0, 0x60, 0x06, 0x06, 0x00, 0x70, 0x60, 0x03, 0x86, 0x00, 0x1C,
  0x60, 0x00, 0xF6, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x67, 0x80, 0x06, 0x3C, 0x00, 0x60, 0xE0, 0x06, 0x06,
  0x00, 0x60, 0x70, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60,
  0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60, 0x70, 0x06,
  0x06, 0x80, 0x61, 0xCF, 0x06, 0x38, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x1F, 0x00, 0x06, 0x00, 0xFE, 0x00, 0x18, 0x03, 0x0C, 0x00,
  0x60, 0x18, 0x38, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x03, 0x81, 0x80, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x03,
  0x00, 0xC0, 0xC0, 0x0C, 0x03, 0x03, 0x00, 0x30, 0x0C, 0x0C, 0x00, 0xC0,
  0x30, 0x60, 0x03, 0x00, 0xC1, 0x80, 0x0C, 0x03, 0x06, 0x00, 0x30, 0x0C,
  0x30, 0x00, 0xC0, 0x30, 0xC0, 0x03, 0x00, 0xC3, 0x07, 0x0C, 0x03, 0x18,
  0x7E, 0x30, 0x0C, 0x63, 0x8C, 0xC0, 0x61, 0x8C, 0x19, 0x81, 0x8C, 0x60,
  0x66, 0x06, 0x31, 0x81, 0x98, 0x30, 0xC6, 0x03, 0x30, 0xC6, 0x18, 0x0C,
  0xFE, 0x18, 0xC0, 0x31, 0xF0, 0x63, 0x00, 0xC0, 0x03, 0x0C, 0x03, 0x00,
  0x0C, 0x30, 0x0C, 0x00, 0x30, 0xC0, 0x30, 0x01, 0x83, 0x00, 0xC0, 0x06,
  0x0C, 0x03, 0x00, 0x18, 0x30, 0x0C, 0x00, 0xC0, 0xC0, 0x30, 0x03, 0x03,
  0x00, 0xC0, 0x0C, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x0C, 0x01, 0x80, 0x60,
  0x30, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x06, 0x06, 0x00, 0xC0, 0x18, 0x18,
  0x03, 0x00, 0x30, 0xE0, 0x18, 0x00, 0x67, 0x00, 0x60, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x18, 0x70, 0x00,
  0x60, 0x60, 0x00, 0xC0, 0xE0, 0x03, 0x80, 0xC0, 0x06, 0x01, 0x80, 0x0C,
  0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xE0,
  0x30, 0x00, 0xC0, 0x60, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x03, 0x06,
  0x00, 0x06, 0x18, 0x00, 0x0E, 0x70, 0x00, 0x0D, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0x30, 0x00,
  0x18, 0x70, 0x00, 0x60, 0x60, 0x31, 0xC0, 0xE0, 0x63, 0x00, 0xC0, 0xC6,
  0x01, 0xC1, 0x9C, 0x01, 0x83, 0x30, 0x01, 0x86, 0x60, 0x03, 0x18, 0xC0,
  0x03, 0x31, 0x80, 0x07, 0x63, 0x00, 0x07, 0x86, 0x00, 0x0F, 0x0C, 0x00,
  0x0E, 0x1C, 0x00, 0x3C, 0x18, 0x00, 0x7C, 0x30, 0x01, 0xD8, 0x70, 0x07,
  0x38, 0x70, 0x1C, 0x30, 0x7F, 0xF0, 0x70, 0x7F, 0x80, 0x70, 0x18, 0x00,
  0x00, 0xFF, 0xFF, 0xB6, 0xDB, 0x6D, 0xB6, 0x00, 0x60, 0x18, 0x07, 0x00,
  0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x03,
  0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C,
  0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0xE0, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03,
  0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xC1,
  0x86, 0xF9, 0x9F, 0x3F, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x0C,
  0x60, 0x0C, 0x30, 0x18, 0x38, 0x30, 0x1C, 0x70, 0x08, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x71, 0xC6, 0x18, 0xE3, 0x8C, 0x31, 0xC6, 0x18, 0x63,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x6E, 0xFF, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x38,
  0x78, 0x0E, 0x03, 0x01, 0x80, 0x70, 0x70, 0x06, 0x0C, 0x00, 0xE3, 0x80,
  0x0C, 0x70, 0x01, 0x8C, 0x00, 0x39, 0x80, 0x07, 0x30, 0x00, 0x6E, 0x00,
  0x0D, 0xC0, 0x01, 0xB8, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB8, 0x00, 0x37, 0x00, 0x06, 0xE0, 0x00,
  0xCC, 0x00, 0x19, 0x80, 0x07, 0x30, 0x00, 0xC7, 0x00, 0x18, 0x60, 0x03,
  0x0E, 0x00, 0xE1, 0xC0, 0x18, 0x1C, 0x07, 0x01, 0xC1, 0xC0, 0x1F, 0xF0,
  0x01, 0xFC, 0x00, 0x00, 0xC0, 0x70, 0x3C, 0x1F, 0x0E, 0xC7, 0x33, 0x8D,
  0xC3, 0xE0, 0xF0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x07, 0xF8,
  0x01, 0xFF, 0xE0, 0x7C, 0x0F, 0x03, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xF8, 0x03, 0xFF, 0xC1, 0xF0, 0x3C, 0x78, 0x01, 0xC4, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x80,
  0x03, 0x9C, 0x00, 0xF3, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x08, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x19,
  0xC0, 0x00, 0x33, 0x80, 0x00, 0xC7, 0x00, 0x01, 0x8E, 0x00, 0x06, 0x1C,
  0x00, 0x0C, 0x38, 0x00, 0x30, 0x70, 0x00, 0x60, 0xE0, 0x01, 0x81, 0xC0,
  0x03, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x18, 0x0E, 0x00, 0x60, 0x1C, 0x00,
  0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x30,
  0x03, 0x80, 0xE0, 0x07, 0x01, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0C, 0x00,
  0x38, 0x38, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF,
  0xFE, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0xBF, 0xC0, 0x7F, 0xFE, 0x07, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x80, 0x07, 0x18, 0x03, 0xC3, 0xFF, 0xF0,
  0x3F, 0xF8, 0x00, 0x58, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0x06,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x1E, 0x03,
  0x0F, 0xF0, 0x67, 0xCF, 0x8C, 0xC0, 0x71, 0xB0, 0x07, 0x34, 0x00, 0x67,
  0x00, 0x0E, 0xE0, 0x00, 0xDC, 0x00, 0x1B, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1D, 0x80, 0x03, 0xB0, 0x00, 0x66, 0x00, 0x0C, 0xE0, 0x01, 0x8C,
  0x00, 0x71, 0xC0, 0x0C, 0x38, 0x03, 0x83, 0x80, 0xE0, 0x3E, 0x78, 0x03,
  0xFE, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0x07, 0x81, 0xC0, 0x1C, 0x38,
  0x00, 0xC3, 0x00, 0x0E, 0x30, 0x00, 0x67, 0x00, 0x06, 0x70, 0x00, 0x67,
  0x00, 0x06, 0x70, 0x00, 0x67, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0E,
  0x38, 0x00, 0xC1, 0x80, 0x1C, 0x1C, 0x03, 0x80, 0xE0, 0x70, 0x07, 0x0E,
  0x00, 0x3D, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0x9C, 0x00, 0x70,
  0xE0, 0x0E, 0x07, 0x01, 0xC0, 0x38, 0x38, 0x01, 0xC3, 0x00, 0x0E, 0x70,
  0x00, 0x66, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x36, 0x00, 0x07,
  0x70, 0x00, 0x63, 0x00, 0x0E, 0x38, 0x01, 0xC1, 0xC0, 0x3C, 0x0F, 0xDF,
  0x80, 0x7F, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x38,
  0x3C, 0x0E, 0x01, 0x83, 0x80, 0x38, 0x60, 0x03, 0x1C, 0x00, 0x73, 0x80,
  0x06, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x6C, 0x00,
  0x0D, 0x80, 0x01, 0xB0, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xCC, 0x00,
  0x79, 0xC0, 0x1B, 0x1C, 0x06, 0x61, 0xFF, 0x8C, 0x1F, 0xE1, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0xFF, 0xE0,
  0x1F, 0xF8, 0x00, 0x70, 0x00, 0x4F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xFF, 0xE0, 0x08, 0xF3,
  0xCF, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x1C, 0x71, 0x86, 0x38, 0xE3,
  0x0C, 0x71, 0x86, 0x18, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xC1, 0xFF,
  0x8E, 0x07, 0x10, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x18, 0x07, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x7F, 0x81, 0x8C, 0x01, 0xEF, 0x03,
  0xB8, 0x06, 0x0E, 0x03, 0x60, 0x18, 0x1C, 0x06, 0xC0, 0x30, 0x38, 0x0D,
  0x80, 0xC0, 0x70, 0x1B, 0x01, 0x80, 0xC0, 0x3E, 0x03, 0x01, 0x80, 0x7C,
  0x0E, 0x03, 0x00, 0xF0, 0x18, 0x06, 0x01, 0xE0, 0x30, 0x0C, 0x03, 0xC0,
  0x60, 0x18, 0x07, 0x80, 0xC0, 0x30, 0x0F, 0x01, 0x80, 0x60, 0x1E, 0x03,
  0x00, 0xC0, 0x3C, 0x06, 0x01, 0x80, 0x78, 0x0C, 0x07, 0x00, 0xF8, 0x18,
  0x0E, 0x03, 0xF0, 0x18, 0x14, 0x06, 0x60, 0x30, 0x28, 0x0C, 0xC0, 0x60,
  0xD8, 0x39, 0x80, 0x63, 0x38, 0xE3, 0x00, 0xFE, 0x3F, 0x87, 0x00, 0xF8,
  0x3E, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x03, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0xC3, 0x00, 0x01, 0x83, 0x80, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80,
  0x01, 0x81, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x07, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x0C, 0x00, 0x30, 0x1C, 0x00, 0x30, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x0E,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x60, 0x03, 0x8C, 0x00, 0x39,
  0x80, 0x03, 0xB0, 0x00, 0x76, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x36,
  0x00, 0x0E, 0xC0, 0x01, 0x98, 0x00, 0x73, 0x00, 0x1C, 0x60, 0x07, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x30, 0x07, 0xC6, 0x00, 0x1C, 0xC0, 0x01, 0xD8,
  0x00, 0x1B, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x76, 0x00, 0x0E, 0xC0,
  0x03, 0x98, 0x03, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x07, 0xFF, 0xC0, 0x78, 0x0E, 0x07, 0x00, 0x10, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0xC0,
  0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x81, 0x80, 0x1E, 0x0C, 0x00, 0x78, 0x60, 0x01, 0xC3,
  0x00, 0x07, 0x18, 0x00, 0x1C, 0xC0, 0x00, 0xE6, 0x00, 0x03, 0x30, 0x00,
  0x1D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00,
  0x03, 0xB0, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x0E, 0x60, 0x00, 0xE3,
  0x00, 0x07, 0x18, 0x00, 0x70, 0xC0, 0x0F, 0x06, 0x01, 0xF0, 0x3F, 0xFE,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0x00, 0xF8, 0x0F, 0x00,
  0x06, 0x07, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x07, 0x1C, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x03, 0x80,
  0x01, 0xC0, 0x78, 0x00, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x70, 0xFF,
  0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0xC7,
  0xBF, 0xC7, 0xC0, 0xC0, 0x00, 0xD8, 0x00, 0x3B, 0x00, 0x06, 0x60, 0x01,
  0xCC, 0x00, 0x71, 0x80, 0x0C, 0x30, 0x03, 0x86, 0x00, 0x60, 0xC0, 0x1C,
  0x18, 0x03, 0x03, 0x00, 0xE0, 0x60, 0x38, 0x0C, 0x06, 0x01, 0x81, 0xC0,
  0x30, 0x30, 0x06, 0x0E, 0x00, 0xC3, 0x80, 0x18, 0x60, 0x03, 0x1C, 0x00,
  0x63, 0x00, 0x0C, 0xF0, 0x01, 0xBE, 0x00, 0x36, 0xE0, 0x07, 0x8C, 0x00,
  0xF1, 0xC0, 0x1C, 0x38, 0x03, 0x03, 0x80, 0x60, 0x70, 0x0C, 0x06, 0x01,
  0x80, 0xE0, 0x30, 0x0C, 0x06, 0x01, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x83,
  0x00, 0x30, 0x60, 0x07, 0x0C, 0x00, 0x61, 0x80, 0x0E, 0x30, 0x00, 0xC6,
  0x00, 0x1C, 0xC0, 0x01, 0x98, 0x00, 0x3B, 0x00, 0x03, 0x60, 0x00, 0x70,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x06, 0xF6, 0x00,
  0x00, 0x0D, 0xEC, 0x00, 0x00, 0x3B, 0xD8, 0x00, 0x00, 0x67, 0x98, 0x00,
  0x00, 0xCF, 0x30, 0x00, 0x03, 0x9E, 0x60, 0x00, 0x06, 0x3C, 0xE0, 0x00,
  0x0C, 0x78, 0xC0, 0x00, 0x18, 0xF1, 0x80, 0x00, 0x71, 0xE3, 0x80, 0x00,
  0xC3, 0xC3, 0x00, 0x01, 0x87, 0x86, 0x00, 0x07, 0x0F, 0x0C, 0x00, 0x0C,
  0x1E, 0x0C, 0x00, 0x18, 0x3C, 0x18, 0x00, 0x70, 0x78, 0x30, 0x00, 0xC0,
  0xF0, 0x70, 0x01, 0x81, 0xE0, 0x60, 0x03, 0x03, 0xC0, 0xC0, 0x0E, 0x07,
  0x81, 0xC0, 0x18, 0x0F, 0x01, 0x80, 0x30, 0x1E, 0x03, 0x00, 0xE0, 0x3C,
  0x06, 0x01, 0x80, 0x78, 0x06, 0x03, 0x00, 0xF0, 0x0C, 0x0E, 0x01, 0xE0,
  0x18, 0x18, 0x03, 0xC0, 0x38, 0x30, 0x07, 0x80, 0x30, 0x60, 0x0F, 0x00,
  0x61, 0xC0, 0x1E, 0x00, 0xE3, 0x00, 0x3C, 0x00, 0xC6, 0x00, 0x78, 0x01,
  0x9C, 0x00, 0xF0, 0x03, 0x30, 0x01, 0xE0, 0x07, 0x60, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x30, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3D, 0x80, 0x00, 0xF7, 0x00, 0x03,
  0xCC, 0x00, 0x0F, 0x30, 0x00, 0x3C, 0x60, 0x00, 0xF1, 0x80, 0x03, 0xC7,
  0x00, 0x0F, 0x0C, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0x60, 0x03, 0xC1, 0x80,
  0x0F, 0x03, 0x00, 0x3C, 0x0C, 0x00, 0xF0, 0x38, 0x03, 0xC0, 0x60, 0x0F,
  0x01, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0E, 0x03, 0xC0, 0x18, 0x0F, 0x00,
  0x60, 0x3C, 0x00, 0xC0, 0xF0, 0x03, 0x03, 0xC0, 0x0E, 0x0F, 0x00, 0x18,
  0x3C, 0x00, 0x70, 0xF0, 0x00, 0xC3, 0xC0, 0x03, 0x8F, 0x00, 0x06, 0x3C,
  0x00, 0x18, 0xF0, 0x00, 0x33, 0xC0, 0x00, 0xCF, 0x00, 0x03, 0xBC, 0x00,
  0x06, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x3C,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x60, 0x00,
  0x38, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x18, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x66, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x70, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x38, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0x00, 0x78, 0xC0, 0x07, 0x30,
  0x00, 0xCC, 0x00, 0x3B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x3B, 0x00, 0x0E, 0xC0, 0x07, 0x30,
  0x01, 0xCC, 0x01, 0xE3, 0x07, 0xF0, 0xFF, 0xF0, 0x3F, 0xE0, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x3C,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x70, 0x00,
  0x38, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x18, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x66, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x70, 0x70, 0x00, 0x30, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x38, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0xFC, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x60,
  0x0F, 0x0C, 0x00, 0x71, 0x80, 0x06, 0x30, 0x00, 0xE6, 0x00, 0x0C, 0xC0,
  0x01, 0x98, 0x00, 0x3B, 0x00, 0x07, 0x60, 0x00, 0xEC, 0x00, 0x1D, 0x80,
  0x03, 0xB0, 0x00, 0x76, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00,
  0x0E, 0x60, 0x01, 0x8C, 0x00, 0x71, 0x80, 0x3C, 0x30, 0x7F, 0x07, 0xFF,
  0x80, 0xFF, 0xC0, 0x18, 0x1C, 0x03, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03,
  0x01, 0x80, 0x70, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x1C, 0x18, 0x01,
  0x83, 0x00, 0x38, 0x60, 0x03, 0x0C, 0x00, 0x71, 0x80, 0x06, 0x30, 0x00,
  0xE6, 0x00, 0x0C, 0xC0, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x03, 0xE0, 0x00,
  0x70, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x3C, 0x07, 0x8E, 0x00, 0x23, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x03, 0x9C, 0x00, 0xF3, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x76, 0x00, 0x01, 0xD8, 0x00, 0x06, 0x60,
  0x00, 0x19, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x8E, 0x00, 0x1C, 0x1C, 0x00,
  0x70, 0x78, 0x07, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x76,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0x9C, 0x00, 0x03, 0x18, 0x00, 0x0E, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x60, 0xC0, 0x01, 0xC1, 0x80,
  0x03, 0x03, 0x00, 0x06, 0x07, 0x00, 0x0C, 0x06, 0x00, 0x38, 0x0C, 0x00,
  0x60, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x70, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x80, 0x60, 0x03, 0x01, 0xC0,
  0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x18, 0x38, 0x00,
  0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0xC7, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x0D,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x60, 0x00, 0x18, 0x00, 0x07, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x60, 0x00,
  0x3C, 0x00, 0x06, 0x70, 0x00, 0x3C, 0x00, 0x06, 0x70, 0x00, 0x3C, 0x00,
  0x06, 0x30, 0x00, 0x3C, 0x00, 0x0E, 0x30, 0x00, 0x36, 0x00, 0x0E, 0x30,
  0x00, 0x76, 0x00, 0x0C, 0x38, 0x00, 0x66, 0x00, 0x0C, 0x38, 0x00, 0x66,
  0x00, 0x1C, 0x18, 0x00, 0x66, 0x00, 0x1C, 0x18, 0x00, 0x67, 0x00, 0x18,
  0x18, 0x00, 0xE3, 0x00, 0x18, 0x1C, 0x00, 0xC3, 0x00, 0x18, 0x1C, 0x00,
  0xC3, 0x00, 0x38, 0x0C, 0x00, 0xC3, 0x00, 0x38, 0x0C, 0x00, 0xC3, 0x80,
  0x30, 0x0C, 0x01, 0xC1, 0x80, 0x30, 0x0E, 0x01, 0x81, 0x80, 0x30, 0x06,
  0x01, 0x81, 0x80, 0x70, 0x06, 0x01, 0x81, 0x80, 0x70, 0x06, 0x01, 0x81,
  0xC0, 0x60, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x07, 0x03, 0x00, 0xC0, 0xE0,
  0x03, 0x03, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x03, 0x03,
  0x00, 0xE0, 0xC0, 0x03, 0x87, 0x00, 0x60, 0xC0, 0x03, 0x86, 0x00, 0x61,
  0xC0, 0x01, 0x86, 0x00, 0x61, 0xC0, 0x01, 0x86, 0x00, 0x61, 0x80, 0x01,
  0x86, 0x00, 0x71, 0x80, 0x01, 0xCE, 0x00, 0x31, 0x80, 0x00, 0xCC, 0x00,
  0x33, 0x80, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x33, 0x00,
  0x00, 0xCC, 0x00, 0x33, 0x00, 0x00, 0xEC, 0x00, 0x1B, 0x00, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x67, 0x00, 0x06, 0x30, 0x00, 0xE3, 0x00, 0x0C, 0x38, 0x01, 0xC1,
  0x80, 0x18, 0x1C, 0x01, 0x80, 0xC0, 0x38, 0x0C, 0x03, 0x00, 0xE0, 0x30,
  0x06, 0x07, 0x00, 0x60, 0x60, 0x07, 0x0E, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0x19, 0xC0, 0x01, 0x98, 0x00, 0x1D, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF8, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x31, 0xC0, 0x03, 0x0C, 0x00,
  0x70, 0xC0, 0x06, 0x0E, 0x00, 0x60, 0x60, 0x0E, 0x06, 0x00, 0xC0, 0x70,
  0x1C, 0x03, 0x01, 0x80, 0x30, 0x18, 0x03, 0x83, 0x80, 0x18, 0x30, 0x01,
  0xC7, 0x00, 0x1C, 0x60, 0x00, 0xC6, 0x00, 0x0E, 0xE0, 0x00, 0xEC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x06, 0x70,
  0x00, 0xE3, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x80, 0x1C, 0x18, 0x01, 0xC1,
  0x80, 0x18, 0x1C, 0x03, 0x80, 0xC0, 0x38, 0x0C, 0x03, 0x00, 0xE0, 0x30,
  0x06, 0x06, 0x00, 0x60, 0x60, 0x07, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0x38, 0xC0, 0x01, 0x98, 0x00, 0x19, 0x80, 0x01, 0xD8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x06, 0xE0,
  0x00, 0x1C, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xE1, 0x80, 0x01, 0x83, 0x00,
  0x07, 0x07, 0x00, 0x0C, 0x06, 0x00, 0x38, 0x0E, 0x00, 0x60, 0x0C, 0x01,
  0xC0, 0x1C, 0x03, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x18, 0x00, 0x30, 0x70,
  0x00, 0x70, 0xC0, 0x00, 0x63, 0x80, 0x00, 0xE6, 0x00, 0x00, 0xDC, 0x00,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0x87, 0x82, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x3E, 0x03, 0xFF, 0x07,
  0xC1, 0x8F, 0x00, 0xCE, 0x00, 0x6E, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xEC, 0x00,
  0xF6, 0x00, 0x5B, 0x80, 0x6C, 0xE0, 0x66, 0x7C, 0x73, 0x0F, 0xE1, 0x80,
  0xC0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x0F,
  0x80, 0xE3, 0xFE, 0x0E, 0x78, 0xF0, 0xEC, 0x03, 0x8F, 0x80, 0x18, 0xF0,
  0x01, 0xCD, 0x00, 0x0C, 0xF0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x6E,
  0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00,
  0x06, 0xE0, 0x00, 0xEF, 0x00, 0x0C, 0xD0, 0x00, 0xCD, 0x80, 0x1C, 0xC8,
  0x03, 0x8C, 0xE0, 0x70, 0xC7, 0xFF, 0x0C, 0x3F, 0xC0, 0x00, 0x20, 0x00,
  0x00, 0xF8, 0x07, 0xFC, 0x3E, 0x18, 0xF0, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x80, 0x87, 0xEF,
  0x07, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x03,
  0xE0, 0xC1, 0xFF, 0x18, 0x78, 0xF3, 0x1C, 0x07, 0x67, 0x00, 0x6C, 0xC0,
  0x07, 0xB8, 0x00, 0xF6, 0x00, 0x0E, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xD8, 0x00,
  0x3B, 0x00, 0x07, 0x70, 0x01, 0xE6, 0x00, 0x2C, 0xE0, 0x0D, 0x8E, 0x03,
  0x30, 0xFB, 0xC6, 0x0F, 0xF0, 0xC0, 0x78, 0x00, 0x01, 0xF0, 0x01, 0xFF,
  0x00, 0xE1, 0xE0, 0x70, 0x18, 0x38, 0x07, 0x0C, 0x00, 0xC7, 0x00, 0x19,
  0x80, 0x06, 0x60, 0x01, 0xB8, 0x00, 0x6E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x21, 0xE0, 0x18, 0x3F, 0x7E, 0x03, 0xFE, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x0F, 0xF0, 0x7D, 0x81, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0xFF, 0x8C, 0x7C, 0x79, 0x8E, 0x03, 0xB3, 0x80, 0x36,
  0x60, 0x03, 0xDC, 0x00, 0x3B, 0x00, 0x07, 0x60, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xEC,
  0x00, 0x1D, 0x80, 0x03, 0xB8, 0x00, 0xF3, 0x00, 0x16, 0x70, 0x06, 0xC7,
  0x01, 0x98, 0x7F, 0xE3, 0x07, 0xF8, 0x60, 0x38, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC6, 0x00, 0x70, 0xF8,
  0x7C, 0x0F, 0xFF, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x07, 0xC3,
  0x8F, 0xF1, 0xCE, 0x3C, 0xEC, 0x07, 0x7C, 0x01, 0xB6, 0x00, 0xFA, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0C, 0xEF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x0E, 0x0F, 0x0E, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0C, 0x0C, 0xBC, 0xF8, 0xE0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x06, 0xE0,
  0x0E, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x30, 0xE0, 0x60, 0xE0,
  0xE0, 0xE0, 0xC0, 0xE1, 0xC0, 0xE1, 0x80, 0xE3, 0x00, 0xE7, 0x00, 0xE7,
  0x80, 0xCD, 0x80, 0xDD, 0xC0, 0xD8, 0xC0, 0xF0, 0xC0, 0xF0, 0xE0, 0xE0,
  0x60, 0xE0, 0x70, 0xE0, 0x30, 0xE0, 0x30, 0xE0, 0x38, 0xE0, 0x18, 0xE0,
  0x1C, 0xE0, 0x0C, 0xE0, 0x0C, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x07, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x07, 0x83, 0x1F,
  0xE0, 0x7F, 0x8C, 0xE1, 0xC3, 0x8F, 0x33, 0x03, 0x98, 0x0E, 0xD8, 0x06,
  0x40, 0x3B, 0x40, 0x1B, 0x00, 0x6F, 0x00, 0x38, 0x01, 0xF8, 0x00, 0xE0,
  0x07, 0xE0, 0x03, 0x80, 0x1F, 0x80, 0x0C, 0x00, 0x3E, 0x00, 0x30, 0x00,
  0xF8, 0x00, 0xC0, 0x03, 0xE0, 0x03, 0x00, 0x0F, 0x80, 0x0C, 0x00, 0x3E,
  0x00, 0x30, 0x00, 0xF8, 0x00, 0xC0, 0x03, 0xE0, 0x03, 0x00, 0x0F, 0x80,
  0x0C, 0x00, 0x3E, 0x00, 0x30, 0x00, 0xF8, 0x00, 0xC0, 0x03, 0xE0, 0x03,
  0x00, 0x0F, 0x80, 0x0C, 0x00, 0x3E, 0x00, 0x30, 0x00, 0xF8, 0x00, 0xC0,
  0x03, 0xE0, 0x03, 0x00, 0x0F, 0x80, 0x0C, 0x00, 0x3E, 0x00, 0x30, 0x00,
  0xF8, 0x00, 0xC0, 0x03, 0xE0, 0x03, 0x00, 0x0F, 0x80, 0x0C, 0x00, 0x3E,
  0x00, 0x30, 0x00, 0xF8, 0x00, 0xC0, 0x03, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0xF8, 0x61, 0xFF, 0x31, 0xC3, 0x99, 0x80, 0xED, 0x80, 0x3E, 0x80, 0x1F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0x80, 0x01, 0xF0,
  0x00, 0xFF, 0x80, 0x38, 0x7C, 0x0E, 0x03, 0x83, 0x80, 0x38, 0x60, 0x03,
  0x9C, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xDC, 0x00, 0x1F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xEC, 0x00, 0x19,
  0x80, 0x03, 0x38, 0x00, 0xE3, 0x00, 0x18, 0x70, 0x07, 0x07, 0x01, 0xC0,
  0x7D, 0xF0, 0x07, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x0C, 0x3F, 0xE0,
  0xC7, 0x0F, 0x0C, 0xC0, 0x38, 0xC8, 0x01, 0x8D, 0x80, 0x1C, 0xD0, 0x00,
  0xCF, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00,
  0x06, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x6E,
  0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x0E,
  0xF0, 0x00, 0xCD, 0x00, 0x0C, 0xD8, 0x01, 0xCE, 0xC0, 0x38, 0xEE, 0x07,
  0x0E, 0x7F, 0xE0, 0xE3, 0xFC, 0x0E, 0x06, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x8C, 0x3C, 0x79,
  0x8E, 0x03, 0xB3, 0x80, 0x36, 0x60, 0x03, 0xDC, 0x00, 0x7B, 0x00, 0x07,
  0x60, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xEC, 0x00, 0x1D, 0x80, 0x03, 0xB8, 0x00, 0xF3,
  0x00, 0x16, 0x70, 0x06, 0xC7, 0x01, 0x98, 0x7F, 0xE3, 0x07, 0xF8, 0x60,
  0x1C, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xEC, 0x3F,
  0xC7, 0xFC, 0xE0, 0xCC, 0x0D, 0x80, 0xD0, 0x0D, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x03,
  0xF0, 0x3F, 0xFC, 0xF8, 0x79, 0xC0, 0x17, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xF0, 0x01, 0xB8, 0x07, 0x7F, 0xFC, 0x3F,
  0xF0, 0x0E, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0,
  0x0F, 0x60, 0x7E, 0x01, 0xC0, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xD8, 0x01, 0xEC, 0x00, 0xB7, 0x00, 0xD9, 0xC0, 0xCC, 0xFF, 0xE6, 0x3F,
  0xC3, 0x03, 0x00, 0x00, 0xE0, 0x00, 0xEC, 0x00, 0x19, 0x80, 0x03, 0x30,
  0x00, 0xE7, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x1C, 0x38,
  0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x03, 0x81, 0xC0, 0x60, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x70, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x18,
  0x30, 0x03, 0x06, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18,
  0xC0, 0x03, 0x38, 0x00, 0x76, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xC0, 0x03, 0x80, 0x0F,
  0x80, 0x07, 0x00, 0x1B, 0x00, 0x0E, 0x00, 0x37, 0x00, 0x3C, 0x00, 0x66,
  0x00, 0x6C, 0x00, 0xCC, 0x00, 0xD8, 0x03, 0x98, 0x01, 0xB0, 0x06, 0x38,
  0x07, 0x60, 0x0C, 0x30, 0x0C, 0xC0, 0x18, 0x60, 0x18, 0xC0, 0x70, 0xC0,
  0x31, 0x80, 0xC1, 0x80, 0x63, 0x01, 0x83, 0x81, 0xC6, 0x03, 0x03, 0x03,
  0x0E, 0x06, 0x06, 0x06, 0x0C, 0x1C, 0x0C, 0x0C, 0x18, 0x30, 0x1C, 0x38,
  0x30, 0x60, 0x18, 0x60, 0x60, 0xC0, 0x30, 0xC0, 0xE1, 0x80, 0x61, 0x80,
  0xC6, 0x00, 0xC3, 0x01, 0x8C, 0x01, 0xCE, 0x03, 0x18, 0x01, 0x98, 0x06,
  0x30, 0x03, 0x30, 0x0E, 0xE0, 0x06, 0x60, 0x0D, 0x80, 0x0C, 0xC0, 0x1B,
  0x00, 0x0F, 0x80, 0x36, 0x00, 0x1E, 0x00, 0x6C, 0x00, 0x3C, 0x00, 0x50,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0xC0, 0x03, 0x80,
  0x60, 0x01, 0xDC, 0x00, 0xE3, 0x00, 0x30, 0xE0, 0x1C, 0x18, 0x06, 0x07,
  0x01, 0x80, 0xC0, 0xE0, 0x30, 0x30, 0x06, 0x1C, 0x01, 0x86, 0x00, 0x33,
  0x80, 0x0C, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0C, 0xC0, 0x07, 0x38, 0x01,
  0x86, 0x00, 0xE1, 0xC0, 0x30, 0x30, 0x1C, 0x0E, 0x06, 0x01, 0x81, 0x80,
  0x60, 0xE0, 0x1C, 0x30, 0x03, 0x1C, 0x00, 0xE6, 0x00, 0x1B, 0x80, 0x07,
  0xE0, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x1D, 0x80, 0x06, 0x70, 0x01, 0x8C,
  0x00, 0x63, 0x00, 0x38, 0xC0, 0x0C, 0x38, 0x03, 0x06, 0x00, 0xC1, 0x80,
  0x70, 0x60, 0x18, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x30, 0x30,
  0x0E, 0x0C, 0x01, 0x83, 0x00, 0x61, 0xC0, 0x18, 0x60, 0x07, 0x18, 0x00,
  0xC6, 0x00, 0x33, 0x80, 0x0C, 0xC0, 0x03, 0xB0, 0x00, 0x6C, 0x00, 0x1B,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0xBC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x02, 0x00, 0x7C, 0x03, 0xF8, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x3C, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x01,
  0xF0, 0x0F, 0xC0, 0x18, 0x00, 0x00, 0x3F, 0x80, 0x0B, 0xFF, 0x00, 0x78,
  0x3E, 0x0F, 0x00, 0x7F, 0xE8, 0x00, 0xFC, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 44, 12, 4, -44 },
  { 23, 11, 16, 19, 4, -44 },
  { 45, 24, 44, 26, 1, -44 },
  { 177, 20, 50, 24, 2, -46 },
  { 302, 30, 45, 36, 3, -44 },
  { 471, 23, 45, 25, 2, -44 },
  { 601, 3, 16, 10, 4, -44 },
  { 607, 11, 54, 16, 3, -44 },
  { 682, 11, 54, 16, 2, -44 },
  { 757, 16, 16, 21, 3, -46 },
  { 789, 21, 29, 25, 2, -36 },
  { 866, 6, 14, 11, 2, -6 },
  { 877, 13, 3, 16, 2, -18 },
  { 882, 4, 5, 12, 4, -5 },
  { 885, 19, 44, 21, 1, -44 },
  { 990, 19, 44, 24, 3, -44 },
  { 1095, 10, 44, 24, 5, -44 },
  { 1150, 20, 44, 24, 2, -44 },
  { 1260, 19, 45, 24, 2, -44 },
  { 1367, 23, 44, 24, 1, -44 },
  { 1494, 19, 45, 24, 3, -44 },
  { 1601, 19, 45, 24, 3, -44 },
  { 1708, 19, 44, 24, 2, -44 },
  { 1813, 20, 45, 24, 2, -44 },
  { 1926, 19, 45, 24, 2, -44 },
  { 2033, 4, 33, 12, 4, -33 },
  { 2050, 6, 41, 11, 2, -33 },
  { 2081, 21, 25, 25, 2, -34 },
  { 2147, 21, 15, 25, 2, -29 },
  { 2187, 21, 25, 25, 2, -34 },
  { 2253, 14, 44, 17, 1, -44 },
  { 2330, 31, 49, 37, 3, -44 },
  { 2520, 24, 44, 24, 0, -44 },
  { 2652, 19, 44, 27, 5, -44 },
  { 2757, 21, 45, 26, 3, -44 },
  { 2876, 21, 44, 29, 5, -44 },
  { 2992, 16, 44, 23, 5, -44 },
  { 3080, 16, 44, 22, 5, -44 },
  { 3168, 26, 45, 32, 3, -44 },
  { 3315, 21, 44, 30, 5, -44 },
  { 3431, 10, 44, 14, 2, -44 },
  { 3486, 10, 55, 12, -3, -44 },
  { 3555, 19, 44, 24, 5, -44 },
  { 3660, 15, 44, 21, 5, -44 },
  { 3743, 31, 44, 41, 5, -44 },
  { 3914, 22, 44, 32, 5, -44 },
  { 4035, 25, 45, 32, 3, -44 },
  { 4176, 18, 44, 25, 5, -44 },
  { 4275, 25, 54, 32, 3, -44 },
  { 4444, 19, 44, 25, 5, -44 },
  { 4549, 19, 45, 24, 2, -44 },
  { 4656, 21, 44, 21, 0, -44 },
  { 4772, 22, 45, 30, 4, -44 },
  { 4896, 23, 44, 23, 0, -44 },
  { 5023, 40, 44, 40, 0, -44 },
  { 5243, 20, 44, 21, 1, -44 },
  { 5353, 20, 44, 20, 0, -44 },
  { 5463, 17, 44, 20, 2, -44 },
  { 5557, 12, 54, 19, 5, -44 },
  { 5638, 18, 44, 21, 1, -44 },
  { 5737, 12, 54, 19, 2, -44 },
  { 5818, 23, 22, 25, 1, -44 },
  { 5882, 25, 3, 24, 0, 5 },
  { 5892, 10, 10, 14, 2, -47 },
  { 5905, 17, 34, 23, 2, -33 },
  { 5978, 20, 47, 26, 4, -46 },
  { 6096, 15, 34, 20, 3, -33 },
  { 6160, 19, 47, 26, 3, -46 },
  { 6272, 18, 34, 24, 3, -33 },
  { 6349, 14, 47, 13, 1, -47 },
  { 6432, 19, 48, 26, 3, -33 },
  { 6546, 17, 46, 26, 4, -46 },
  { 6644, 4, 44, 11, 4, -44 },
  { 6666, 8, 59, 11, 0, -44 },
  { 6725, 16, 46, 21, 4, -46 },
  { 6817, 3, 46, 11, 4, -46 },
  { 6835, 30, 33, 38, 4, -33 },
  { 6959, 17, 33, 26, 4, -33 },
  { 7030, 19, 34, 25, 3, -33 },
  { 7111, 20, 47, 26, 4, -33 },
  { 7229, 19, 47, 26, 3, -33 },
  { 7341, 12, 33, 17, 4, -33 },
  { 7391, 15, 34, 19, 2, -33 },
  { 7455, 12, 41, 13, 1, -40 },
  { 7517, 17, 33, 26, 4, -32 },
  { 7588, 19, 32, 19, 0, -32 },
  { 7664, 31, 32, 32, 1, -32 },
  { 7788, 18, 32, 20, 1, -32 },
  { 7860, 18, 47, 20, 1, -32 },
  { 7966, 13, 32, 16, 2, -32 },
  { 8018, 15, 54, 21, 3, -44 },
  { 8120, 2, 61, 23, 11, -46 },
  { 8136, 15, 54, 21, 3, -44 },
  { 8238, 21, 5, 25, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight61pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT61PT7B_H_
