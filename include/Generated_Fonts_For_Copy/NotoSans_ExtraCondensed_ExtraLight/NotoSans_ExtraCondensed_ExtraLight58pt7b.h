#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT58PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight58pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x0E, 0xFF, 0xE0, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x20,
  0x10, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03,
  0x00, 0x0C, 0x06, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x60, 0x30,
  0x01, 0x80, 0x40, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x01,
  0x00, 0xC0, 0x06, 0x01, 0x00, 0x0C, 0x06, 0x03, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xC0, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01,
  0x80, 0x04, 0x03, 0x00, 0x18, 0x04, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x78,
  0x00, 0x7F, 0xF0, 0x3F, 0x9F, 0x8E, 0x30, 0x63, 0x86, 0x00, 0x60, 0xC0,
  0x1C, 0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80,
  0x30, 0x30, 0x06, 0x06, 0x00, 0xE0, 0xC0, 0x0C, 0x18, 0x01, 0xC3, 0x00,
  0x1C, 0x60, 0x01, 0xEC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x19, 0xE0, 0x03, 0x0E, 0x00, 0x60, 0xE0, 0x0C, 0x0C,
  0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C,
  0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x81, 0xA0, 0x30, 0x77,
  0x06, 0x3C, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x60, 0x1C, 0x60, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x06, 0x0C, 0x01,
  0x80, 0x60, 0x30, 0x18, 0x03, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x06, 0x00,
  0xC0, 0x60, 0x60, 0x06, 0x03, 0x03, 0x00, 0x30, 0x18, 0x18, 0x01, 0x80,
  0xC1, 0x80, 0x0C, 0x06, 0x0C, 0x00, 0x60, 0x30, 0x60, 0x03, 0x01, 0x86,
  0x00, 0x18, 0x0C, 0x30, 0x00, 0xC0, 0x61, 0x80, 0x06, 0x03, 0x18, 0x7E,
  0x30, 0x18, 0xC7, 0x31, 0x80, 0xC6, 0x30, 0xCC, 0x04, 0x63, 0x03, 0x30,
  0x63, 0x18, 0x19, 0x83, 0x18, 0xC0, 0xCE, 0x31, 0x8C, 0x06, 0x3F, 0x8C,
  0x60, 0x30, 0xF0, 0x63, 0x00, 0xC0, 0x06, 0x18, 0x06, 0x00, 0x30, 0xC0,
  0x30, 0x01, 0x86, 0x01, 0x80, 0x18, 0x30, 0x0C, 0x00, 0xC1, 0x80, 0x60,
  0x06, 0x0C, 0x03, 0x00, 0x60, 0x60, 0x18, 0x03, 0x03, 0x00, 0xC0, 0x18,
  0x18, 0x0C, 0x01, 0x80, 0xC0, 0x60, 0x0C, 0x03, 0x03, 0x00, 0x60, 0x18,
  0x18, 0x06, 0x00, 0xC0, 0xC0, 0x30, 0x03, 0x0C, 0x01, 0x80, 0x1C, 0xC0,
  0x18, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x80, 0x03, 0xE0, 0x00, 0x3F, 0x80,
  0x03, 0x8E, 0x00, 0x18, 0x30, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60,
  0x30, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00,
  0x30, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0xC3,
  0x00, 0x06, 0x30, 0x00, 0x3B, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xE0, 0x00, 0x73, 0x00, 0x07, 0x0C, 0x00, 0x30, 0x60,
  0x33, 0x01, 0x81, 0x98, 0x0E, 0x0D, 0xC0, 0x30, 0x6C, 0x01, 0xC3, 0x60,
  0x06, 0x3B, 0x00, 0x19, 0x98, 0x00, 0xCC, 0xC0, 0x03, 0xE6, 0x00, 0x1E,
  0x30, 0x00, 0x71, 0x80, 0x03, 0x8E, 0x00, 0x3C, 0x30, 0x03, 0xB1, 0xC0,
  0x39, 0x87, 0x03, 0x86, 0x1E, 0xF8, 0x38, 0x7F, 0x80, 0xC0, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x80,
  0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80,
  0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0E,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0xE0, 0x06, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x01, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01,
  0x80, 0x70, 0x1C, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x61, 0x83, 0xF8, 0x9F, 0x1F, 0xF8, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0x60, 0x06, 0x30, 0x0C, 0x30, 0x18, 0x18, 0x38, 0x0C, 0x10, 0x08,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x61, 0x86, 0x38,
  0xE3, 0x0C, 0x31, 0x86, 0x18, 0xC3, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x01,
  0xFE, 0x00, 0xE1, 0xC0, 0x70, 0x38, 0x38, 0x06, 0x0C, 0x01, 0x87, 0x00,
  0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xEE, 0x00, 0x1B, 0x80, 0x06,
  0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06,
  0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x80, 0x06, 0x60, 0x01, 0x98,
  0x00, 0xE6, 0x00, 0x31, 0xC0, 0x0C, 0x30, 0x07, 0x0E, 0x01, 0x81, 0x80,
  0xE0, 0x70, 0x70, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xE0, 0x3C, 0x1F,
  0x87, 0x71, 0xCE, 0x71, 0xDC, 0x3F, 0x07, 0x40, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0x81, 0xF0, 0x78,
  0x18, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x07,
  0xFF, 0x07, 0x81, 0xE3, 0x80, 0x1C, 0x40, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x33, 0x00, 0x3C, 0xFE, 0xFE, 0x0F, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0x60, 0x00, 0x0D, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x33, 0x80, 0x00,
  0xCE, 0x00, 0x06, 0x38, 0x00, 0x18, 0xE0, 0x00, 0xC3, 0x80, 0x03, 0x0E,
  0x00, 0x18, 0x38, 0x00, 0x60, 0xE0, 0x03, 0x83, 0x80, 0x0C, 0x0E, 0x00,
  0x70, 0x38, 0x01, 0x80, 0xE0, 0x06, 0x03, 0x80, 0x30, 0x0E, 0x00, 0xC0,
  0x38, 0x06, 0x00, 0xE0, 0x18, 0x03, 0x80, 0xC0, 0x0E, 0x03, 0x00, 0x38,
  0x18, 0x00, 0xE0, 0x60, 0x03, 0x83, 0x00, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xC6, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC7, 0xE0, 0x3F, 0xFE, 0x0F, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x8C, 0x01, 0xC3, 0xFF, 0xE0,
  0x7F, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x7C, 0x30,
  0x3C, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0xFE, 0x0C, 0xFF, 0xC3,
  0x70, 0x38, 0xD0, 0x07, 0x3C, 0x00, 0xCE, 0x00, 0x3B, 0x80, 0x06, 0xC0,
  0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x66, 0x00, 0x19,
  0x80, 0x06, 0x70, 0x03, 0x8C, 0x00, 0xC3, 0x80, 0x70, 0x70, 0x38, 0x0F,
  0x1C, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x38, 0x3C, 0x0C, 0x01,
  0xC3, 0x80, 0x18, 0x60, 0x03, 0x9C, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00,
  0xCC, 0x00, 0x19, 0x80, 0x03, 0x38, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x03,
  0x8E, 0x00, 0x60, 0xC0, 0x1C, 0x0C, 0x07, 0x00, 0xE1, 0xC0, 0x0E, 0xF0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0x70, 0x03, 0x87, 0x00, 0xE0, 0x38,
  0x18, 0x03, 0x06, 0x00, 0x31, 0xC0, 0x07, 0x30, 0x00, 0x66, 0x00, 0x0F,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x76, 0x00, 0x0C, 0xE0, 0x03, 0x8E, 0x00, 0x60,
  0xE0, 0x1C, 0x0F, 0x9F, 0x00, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x03, 0xF0,
  0x01, 0xFF, 0x01, 0xE1, 0xE0, 0x60, 0x18, 0x30, 0x03, 0x0C, 0x00, 0xC7,
  0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xD8, 0x00, 0x36, 0x00, 0x1D, 0x80, 0x07, 0x70, 0x01, 0xCC, 0x00, 0xF3,
  0x80, 0x6C, 0x70, 0x33, 0x0F, 0xFC, 0xC1, 0xFC, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x3D, 0xF0, 0x0F, 0xF8, 0x00, 0x60, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x38,
  0xE3, 0xCE, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x71, 0xC6, 0x18, 0xE3, 0x8C, 0x30,
  0xC6, 0x18, 0x63, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x1F, 0x81, 0xFF, 0x8E, 0x0F, 0x20, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C,
  0x30, 0x03, 0xE0, 0x19, 0xC0, 0x3F, 0xC0, 0x66, 0x01, 0xC3, 0x01, 0x98,
  0x06, 0x0C, 0x06, 0x60, 0x30, 0x30, 0x19, 0x80, 0xC0, 0xC0, 0x6E, 0x06,
  0x03, 0x00, 0xF0, 0x18, 0x0C, 0x03, 0xC0, 0x60, 0x30, 0x0F, 0x01, 0x80,
  0xC0, 0x3C, 0x06, 0x03, 0x00, 0xF0, 0x30, 0x0C, 0x03, 0xC0, 0xC0, 0x30,
  0x0F, 0x03, 0x00, 0xC0, 0x3C, 0x0C, 0x03, 0x01, 0xB0, 0x18, 0x0C, 0x06,
  0xC0, 0x60, 0x70, 0x1B, 0x01, 0x81, 0xC0, 0x6C, 0x06, 0x05, 0x01, 0xB8,
  0x18, 0x34, 0x0C, 0x60, 0x30, 0xD8, 0x71, 0x80, 0xEE, 0x3F, 0x86, 0x01,
  0xF0, 0xFC, 0x18, 0x01, 0x00, 0x40, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x18, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x63, 0x00, 0x00,
  0xC6, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x30, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x30, 0x0E, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x18, 0x00, 0xC0, 0x70, 0x01, 0x80, 0xE0, 0x03, 0x81, 0x80, 0x07, 0x03,
  0x00, 0x06, 0x06, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x30, 0x00, 0x38, 0x60,
  0x00, 0x30, 0xC0, 0x00, 0x63, 0x80, 0x00, 0xC6, 0x00, 0x01, 0xCC, 0x00,
  0x01, 0x98, 0x00, 0x03, 0x70, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC3, 0x80, 0x1C, 0x70, 0x01, 0xCE, 0x00, 0x1D, 0xC0, 0x01,
  0xB8, 0x00, 0x37, 0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x1B, 0x80, 0x03,
  0x70, 0x00, 0x6E, 0x00, 0x0D, 0xC0, 0x01, 0xB8, 0x00, 0x77, 0x00, 0x0C,
  0xE0, 0x03, 0x1C, 0x01, 0xE3, 0xFF, 0xF0, 0x7F, 0xFE, 0x0E, 0x01, 0xE1,
  0xC0, 0x07, 0x38, 0x00, 0x67, 0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x6E,
  0x00, 0x1D, 0xC0, 0x07, 0x38, 0x03, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x03, 0xE0, 0x70, 0x78, 0x01, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x01, 0x01, 0xF9, 0xF0, 0x07, 0xFE, 0x00, 0x04, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x38, 0x03, 0xC1, 0xC0, 0x07, 0x0E, 0x00,
  0x18, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0x67,
  0x00, 0x03, 0xB8, 0x00, 0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0x70, 0x00,
  0x1B, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0D, 0xC0,
  0x00, 0x6E, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x80, 0x01, 0xDC, 0x00, 0x0C,
  0xE0, 0x00, 0x67, 0x00, 0x07, 0x38, 0x00, 0x31, 0xC0, 0x03, 0x8E, 0x00,
  0x38, 0x70, 0x03, 0x83, 0x80, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xFC, 0x01, 0xF0, 0x1F, 0x03, 0x80, 0x06, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x70, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x38, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0E,
  0x00, 0x03, 0x07, 0x00, 0x03, 0x03, 0xC0, 0x07, 0x01, 0xFD, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x30,
  0xFF, 0x86, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0xFF, 0xFF, 0x80, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x03,
  0xBF, 0xCF, 0xE0, 0xE0, 0x01, 0xDC, 0x00, 0x33, 0x80, 0x0E, 0x70, 0x01,
  0x8E, 0x00, 0x61, 0xC0, 0x1C, 0x38, 0x03, 0x07, 0x00, 0xE0, 0xE0, 0x18,
  0x1C, 0x06, 0x03, 0x81, 0xC0, 0x70, 0x30, 0x0E, 0x0E, 0x01, 0xC1, 0x80,
  0x38, 0x70, 0x07, 0x1C, 0x00, 0xE3, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00,
  0x77, 0x80, 0x0F, 0xF8, 0x01, 0xF3, 0x00, 0x3C, 0x70, 0x07, 0x86, 0x00,
  0xE0, 0xE0, 0x1C, 0x0C, 0x03, 0x81, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x81,
  0xC0, 0x30, 0x38, 0x07, 0x07, 0x00, 0x60, 0xE0, 0x0E, 0x1C, 0x00, 0xC3,
  0x80, 0x1C, 0x70, 0x01, 0x8E, 0x00, 0x39, 0xC0, 0x03, 0x38, 0x00, 0x77,
  0x00, 0x06, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF6, 0x00, 0x00,
  0x0F, 0xD8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xBE, 0xC0, 0x00, 0x06,
  0xFB, 0x00, 0x00, 0x1B, 0xEC, 0x00, 0x00, 0xCF, 0x98, 0x00, 0x03, 0x3E,
  0x60, 0x00, 0x0C, 0xF9, 0x80, 0x00, 0x63, 0xE7, 0x00, 0x01, 0x8F, 0x8C,
  0x00, 0x06, 0x3E, 0x30, 0x00, 0x38, 0xF8, 0xC0, 0x00, 0xC3, 0xE1, 0x80,
  0x03, 0x0F, 0x86, 0x00, 0x0C, 0x3E, 0x18, 0x00, 0x60, 0xF8, 0x30, 0x01,
  0x83, 0xE0, 0xC0, 0x06, 0x0F, 0x83, 0x00, 0x30, 0x3E, 0x0E, 0x00, 0xC0,
  0xF8, 0x18, 0x03, 0x03, 0xE0, 0x60, 0x1C, 0x0F, 0x81, 0x80, 0x60, 0x3E,
  0x03, 0x01, 0x80, 0xF8, 0x0C, 0x06, 0x03, 0xE0, 0x30, 0x30, 0x0F, 0x80,
  0xE0, 0xC0, 0x3E, 0x01, 0x83, 0x00, 0xF8, 0x06, 0x18, 0x03, 0xE0, 0x1C,
  0x60, 0x0F, 0x80, 0x31, 0x80, 0x3E, 0x00, 0xCE, 0x00, 0xF8, 0x03, 0x30,
  0x03, 0xE0, 0x06, 0xC0, 0x0F, 0x80, 0x1B, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0x80, 0x0C, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x7E, 0xC0, 0x01, 0xFB, 0x80, 0x07, 0xE6, 0x00, 0x1F, 0x98, 0x00, 0x7E,
  0x30, 0x01, 0xF8, 0xC0, 0x07, 0xE1, 0x80, 0x1F, 0x86, 0x00, 0x7E, 0x1C,
  0x01, 0xF8, 0x30, 0x07, 0xE0, 0xC0, 0x1F, 0x81, 0x80, 0x7E, 0x06, 0x01,
  0xF8, 0x0C, 0x07, 0xE0, 0x30, 0x1F, 0x80, 0xE0, 0x7E, 0x01, 0x81, 0xF8,
  0x07, 0x07, 0xE0, 0x0C, 0x1F, 0x80, 0x30, 0x7E, 0x00, 0x61, 0xF8, 0x01,
  0x87, 0xE0, 0x03, 0x1F, 0x80, 0x0C, 0x7E, 0x00, 0x39, 0xF8, 0x00, 0x67,
  0xE0, 0x01, 0xDF, 0x80, 0x03, 0x7E, 0x00, 0x0C, 0xF8, 0x00, 0x1B, 0xE0,
  0x00, 0x6F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1C, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0x81, 0xE0, 0x0F, 0x00,
  0x70, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x1C, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x38, 0x00,
  0x1C, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xFF, 0xF0,
  0x3F, 0xFF, 0x0E, 0x01, 0xE3, 0x80, 0x1C, 0xE0, 0x03, 0x38, 0x00, 0xEE,
  0x00, 0x1B, 0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x6E, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x01,
  0xB8, 0x00, 0xEE, 0x00, 0x33, 0x80, 0x1C, 0xE0, 0x0E, 0x38, 0x7F, 0x0F,
  0xFF, 0x03, 0xFE, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0xC1, 0xE0, 0x0F, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x1C, 0x00,
  0x18, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x70, 0x00,
  0x0E, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x30, 0x00,
  0x0E, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x1C, 0x00,
  0x38, 0x0E, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x00, 0x3B, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0x80, 0x78, 0x70, 0x03, 0x8E, 0x00, 0x31, 0xC0, 0x07, 0x38, 0x00, 0x67,
  0x00, 0x0C, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE,
  0x00, 0x1D, 0xC0, 0x03, 0x38, 0x00, 0x67, 0x00, 0x0C, 0xE0, 0x03, 0x9C,
  0x00, 0x63, 0x80, 0x1C, 0x70, 0x07, 0x0E, 0x0F, 0xC1, 0xFF, 0xE0, 0x3F,
  0xF8, 0x07, 0x03, 0x00, 0xE0, 0x60, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70,
  0x1C, 0x0E, 0x01, 0x81, 0xC0, 0x38, 0x38, 0x03, 0x07, 0x00, 0x70, 0xE0,
  0x06, 0x1C, 0x00, 0xE3, 0x80, 0x0C, 0x70, 0x01, 0xCE, 0x00, 0x19, 0xC0,
  0x03, 0x38, 0x00, 0x77, 0x00, 0x06, 0xE0, 0x00, 0xE0, 0x01, 0xFE, 0x01,
  0xFF, 0xF0, 0xF0, 0x3C, 0x70, 0x02, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x3B, 0x80, 0x3C, 0xFF, 0xFE, 0x1F, 0xFE, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x77, 0x00, 0x06, 0x30,
  0x00, 0x63, 0x80, 0x0C, 0x1C, 0x03, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x76, 0x00, 0x01, 0x98, 0x00,
  0x06, 0x60, 0x00, 0x19, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x07, 0x06, 0x00, 0x18, 0x18,
  0x00, 0x60, 0x60, 0x01, 0x81, 0xC0, 0x0E, 0x03, 0x00, 0x30, 0x0C, 0x00,
  0xC0, 0x30, 0x03, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80,
  0x18, 0x06, 0x00, 0x60, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C,
  0x0C, 0x00, 0x30, 0x30, 0x00, 0xE1, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x18,
  0x00, 0x18, 0x60, 0x00, 0x73, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0D,
  0x80, 0x00, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x80, 0x01, 0x98, 0x00, 0x1E,
  0x00, 0x06, 0x70, 0x00, 0x78, 0x00, 0x18, 0xC0, 0x01, 0xE0, 0x00, 0x63,
  0x00, 0x06, 0xC0, 0x03, 0x8C, 0x00, 0x3B, 0x00, 0x0C, 0x30, 0x00, 0xCC,
  0x00, 0x30, 0xE0, 0x03, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0xC0, 0x07, 0x06,
  0x00, 0x33, 0x80, 0x1C, 0x18, 0x01, 0xC6, 0x00, 0x60, 0x60, 0x06, 0x18,
  0x01, 0x81, 0xC0, 0x18, 0x60, 0x06, 0x03, 0x00, 0x61, 0x80, 0x38, 0x0C,
  0x01, 0x87, 0x00, 0xC0, 0x30, 0x0E, 0x0C, 0x03, 0x00, 0xE0, 0x30, 0x30,
  0x0C, 0x03, 0x80, 0xC0, 0xC0, 0x30, 0x06, 0x03, 0x03, 0x01, 0xC0, 0x18,
  0x0C, 0x0E, 0x06, 0x00, 0x60, 0x30, 0x18, 0x18, 0x01, 0xC1, 0x80, 0x60,
  0x60, 0x03, 0x06, 0x01, 0x83, 0x80, 0x0C, 0x18, 0x06, 0x0C, 0x00, 0x30,
  0x60, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x30, 0xC0, 0x03, 0x8C, 0x00, 0xC3,
  0x00, 0x06, 0x30, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x0C, 0x60, 0x00, 0x63,
  0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x07, 0x60, 0x01, 0x98,
  0x00, 0x0D, 0x80, 0x06, 0xE0, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x00, 0xD8,
  0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0xB0, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xCC, 0x00, 0x73, 0x00, 0x18, 0xE0, 0x06, 0x18, 0x03, 0x86, 0x00, 0xC1,
  0xC0, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x83, 0x80, 0x60, 0xC0, 0x18,
  0x30, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x3B, 0x80, 0x06, 0xC0, 0x01, 0xB0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x7C, 0x00,
  0x1B, 0x00, 0x06, 0xC0, 0x03, 0x38, 0x00, 0xC6, 0x00, 0x71, 0x80, 0x18,
  0x70, 0x06, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xE0, 0x70, 0x18, 0x18, 0x06,
  0x06, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0E, 0x70, 0x01, 0x98, 0x00, 0x66,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x6C, 0x00, 0x1D,
  0x80, 0x03, 0x38, 0x00, 0x63, 0x00, 0x1C, 0x60, 0x03, 0x0E, 0x00, 0x60,
  0xC0, 0x1C, 0x18, 0x03, 0x03, 0x80, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x00,
  0xE0, 0x60, 0x0C, 0x1C, 0x01, 0x83, 0x00, 0x38, 0x60, 0x03, 0x1C, 0x00,
  0x63, 0x00, 0x0C, 0x60, 0x00, 0xDC, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0xFF, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x30,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00,
  0x06, 0x38, 0x00, 0x18, 0x60, 0x00, 0xC1, 0xC0, 0x03, 0x03, 0x00, 0x18,
  0x0E, 0x00, 0x60, 0x18, 0x03, 0x80, 0x70, 0x0C, 0x00, 0xC0, 0x70, 0x03,
  0x01, 0x80, 0x06, 0x0E, 0x00, 0x18, 0x30, 0x00, 0x31, 0xC0, 0x00, 0xC6,
  0x00, 0x03, 0xB8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0,
  0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x07, 0xF0,
  0x3F, 0xFC, 0x18, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x3F, 0x03, 0xFF, 0x0F, 0x83, 0x1C, 0x03, 0x30, 0x03, 0x70, 0x03,
  0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x07, 0x60, 0x0F, 0x60, 0x0B, 0x70, 0x1B, 0x3C, 0x73, 0x1F, 0xE3,
  0x03, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x87, 0xF0, 0x31,
  0xFF, 0x86, 0x60, 0x70, 0xD8, 0x03, 0x1A, 0x00, 0x73, 0xC0, 0x06, 0x70,
  0x00, 0xCE, 0x00, 0x1D, 0xC0, 0x01, 0xB8, 0x00, 0x36, 0x00, 0x06, 0xC0,
  0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0F, 0x80,
  0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00,
  0x03, 0x70, 0x00, 0x6E, 0x00, 0x1D, 0xC0, 0x03, 0x3C, 0x00, 0x66, 0x80,
  0x1C, 0xD8, 0x03, 0x19, 0x81, 0xE3, 0x1E, 0xF8, 0x61, 0xFE, 0x00, 0x04,
  0x00, 0x03, 0xFC, 0x1F, 0xF1, 0xE0, 0x46, 0x00, 0x38, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x04, 0x3E, 0x70, 0x7F, 0xC0, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC1, 0xFC, 0x30, 0xFF, 0x8C, 0x70, 0x33, 0x38, 0x06, 0xCC,
  0x00, 0xB7, 0x00, 0x3D, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01, 0xD8, 0x00, 0x76, 0x00,
  0x3D, 0xC0, 0x0B, 0x30, 0x06, 0xCE, 0x03, 0x31, 0xF3, 0xCC, 0x3F, 0xC3,
  0x00, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0x07, 0x07, 0x01, 0xC3,
  0x00, 0x63, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x21, 0xC0, 0x30, 0x7C, 0xF8, 0x1F, 0xF0, 0x00, 0xC0, 0x03,
  0xF8, 0x3F, 0xC1, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x1F, 0xE3, 0xFF, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x07,
  0xF0, 0xC3, 0xFF, 0x31, 0xC0, 0xCC, 0xE0, 0x1B, 0x30, 0x03, 0xD8, 0x00,
  0xF6, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x07, 0x60, 0x01, 0xD8, 0x00, 0xF7, 0x00, 0x2C,
  0xC0, 0x1B, 0x38, 0x0C, 0xC7, 0xDE, 0x30, 0xFF, 0x0C, 0x03, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x10, 0x01, 0xC7, 0x01, 0xE1,
  0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC3, 0xF8, 0xC7, 0xFC, 0xCE,
  0x0E, 0xD8, 0x06, 0xD0, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0E, 0x1C, 0x38, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC3,
  0xBE, 0x78, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x01, 0xF0, 0x03, 0x60, 0x0C, 0xC0, 0x39, 0x80, 0x63,
  0x01, 0x86, 0x07, 0x0C, 0x0C, 0x18, 0x38, 0x30, 0x60, 0x61, 0x80, 0xC7,
  0x01, 0x8E, 0x03, 0x3C, 0x06, 0x7C, 0x0D, 0x98, 0x1E, 0x30, 0x3C, 0x30,
  0x70, 0x60, 0xC0, 0xE1, 0x80, 0xC3, 0x01, 0x86, 0x01, 0x8C, 0x03, 0x18,
  0x07, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x3E, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xF0, 0x3F, 0x8C, 0xFF, 0x87, 0xFC, 0xCC, 0x1C, 0xE0, 0xED, 0x80,
  0xCC, 0x06, 0xD0, 0x0D, 0x80, 0x7E, 0x00, 0x70, 0x03, 0xE0, 0x07, 0x00,
  0x3E, 0x00, 0x70, 0x03, 0xE0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0,
  0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60,
  0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C,
  0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06,
  0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03,
  0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00,
  0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00,
  0x30, 0xC3, 0xF8, 0xC7, 0xFC, 0xCC, 0x0E, 0xD8, 0x06, 0xD0, 0x07, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xC0, 0xE0, 0xE0, 0x1C,
  0x70, 0x03, 0x18, 0x00, 0x66, 0x00, 0x1B, 0x80, 0x06, 0xC0, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x06, 0x60, 0x01, 0x98,
  0x00, 0x67, 0x00, 0x38, 0xC0, 0x1C, 0x18, 0x06, 0x03, 0xCF, 0x80, 0x7F,
  0x80, 0x03, 0x00, 0xC3, 0xF8, 0x31, 0xFF, 0x8C, 0xC0, 0xE3, 0x60, 0x0C,
  0xD8, 0x03, 0xBC, 0x00, 0x6E, 0x00, 0x1B, 0x80, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xBC,
  0x00, 0x6D, 0x00, 0x3B, 0x60, 0x0C, 0xCC, 0x0E, 0x31, 0xEF, 0x8C, 0x3F,
  0x83, 0x01, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0xC3,
  0xFE, 0x31, 0xC0, 0xCC, 0xE0, 0x1B, 0x30, 0x02, 0xDC, 0x00, 0xF6, 0x00,
  0x1D, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x80, 0x07, 0x60, 0x01, 0xD8, 0x00, 0xF7, 0x00, 0x2C, 0xE0, 0x1B,
  0x3C, 0x0C, 0xC7, 0xDE, 0x30, 0x7F, 0x0C, 0x02, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0xC3, 0xF8, 0xFF, 0x38, 0xE6, 0x0D, 0x81, 0xA0, 0x3C,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x0F, 0xF8,
  0x7F, 0xF3, 0x80, 0xDC, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x07, 0xC0,
  0x3B, 0xFF, 0xC7, 0xFE, 0x01, 0x80, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x01, 0xFF, 0xFF, 0xE3, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xF6, 0x0F, 0xC0, 0x40,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0x60, 0x0B, 0x70, 0x3B, 0x3F, 0xF3,
  0x1F, 0xE3, 0x06, 0x00, 0xE0, 0x01, 0xD8, 0x00, 0x66, 0x00, 0x19, 0x80,
  0x06, 0x60, 0x03, 0x8C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x07,
  0x0E, 0x01, 0x81, 0x80, 0x60, 0x60, 0x18, 0x18, 0x0E, 0x07, 0x03, 0x00,
  0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x06, 0x00, 0x61, 0x80, 0x18,
  0x60, 0x06, 0x18, 0x01, 0x8C, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30,
  0x00, 0xCC, 0x00, 0x16, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0C, 0x00, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x76, 0x00, 0xD8, 0x03, 0x30, 0x06, 0xC0, 0x19,
  0x80, 0x36, 0x00, 0xCC, 0x01, 0xB0, 0x06, 0x60, 0x0D, 0x80, 0x61, 0x80,
  0xC6, 0x03, 0x0C, 0x06, 0x30, 0x18, 0x60, 0x31, 0x80, 0xC3, 0x01, 0x8C,
  0x0E, 0x1C, 0x0C, 0x30, 0x60, 0x60, 0xC1, 0x83, 0x03, 0x06, 0x0C, 0x18,
  0x18, 0x30, 0x60, 0xC0, 0xC1, 0x83, 0x0C, 0x03, 0x1C, 0x0C, 0x60, 0x18,
  0xC0, 0x63, 0x00, 0xC6, 0x03, 0x18, 0x06, 0x30, 0x18, 0xC0, 0x39, 0x80,
  0xCC, 0x00, 0xD8, 0x03, 0x60, 0x06, 0xC0, 0x1B, 0x00, 0x36, 0x00, 0xD8,
  0x01, 0xB0, 0x06, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x03, 0xB0, 0x01, 0x8C,
  0x01, 0xC6, 0x00, 0xC3, 0x80, 0xE0, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x30,
  0x0C, 0x18, 0x03, 0x1C, 0x01, 0x8C, 0x00, 0x6E, 0x00, 0x36, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xB0, 0x00, 0xD8, 0x00,
  0xC6, 0x00, 0x63, 0x00, 0x71, 0xC0, 0x30, 0x60, 0x38, 0x38, 0x18, 0x0C,
  0x1C, 0x06, 0x0C, 0x01, 0x86, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x1B, 0x80,
  0x0E, 0xC0, 0x01, 0xF0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x76, 0x00, 0x33,
  0x80, 0x18, 0xC0, 0x0C, 0x60, 0x0E, 0x30, 0x06, 0x1C, 0x03, 0x06, 0x01,
  0x83, 0x01, 0xC1, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x30, 0x18, 0x38, 0x0C,
  0x18, 0x07, 0x0C, 0x01, 0x86, 0x00, 0xC7, 0x00, 0x63, 0x00, 0x39, 0x80,
  0x0C, 0xC0, 0x06, 0xE0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x27, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7C, 0x03, 0xF0, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xFC, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x03, 0xF0, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x7C, 0x01, 0xF0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x03, 0x80, 0xFC, 0x03, 0xC0, 0x00, 0x3F,
  0x00, 0x17, 0xFC, 0x01, 0xE0, 0xF0, 0x78, 0x03, 0xFE, 0x80, 0x0F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 41, 12, 4, -41 },
  { 22, 10, 15, 18, 4, -41 },
  { 41, 23, 41, 25, 1, -41 },
  { 159, 19, 47, 23, 2, -44 },
  { 271, 29, 43, 34, 3, -42 },
  { 427, 21, 43, 23, 2, -42 },
  { 540, 2, 15, 10, 4, -41 },
  { 544, 10, 50, 16, 3, -41 },
  { 607, 11, 50, 16, 2, -41 },
  { 676, 16, 16, 20, 2, -44 },
  { 708, 20, 27, 23, 2, -34 },
  { 776, 6, 14, 11, 2, -6 },
  { 787, 12, 2, 15, 2, -17 },
  { 790, 3, 4, 11, 4, -4 },
  { 792, 18, 41, 20, 1, -41 },
  { 885, 18, 42, 23, 3, -42 },
  { 980, 11, 41, 23, 4, -41 },
  { 1037, 19, 42, 23, 2, -42 },
  { 1137, 18, 43, 23, 2, -42 },
  { 1234, 22, 42, 23, 1, -42 },
  { 1350, 18, 42, 23, 3, -41 },
  { 1445, 18, 43, 23, 3, -42 },
  { 1542, 18, 41, 23, 2, -41 },
  { 1635, 19, 43, 23, 2, -42 },
  { 1738, 18, 43, 23, 2, -42 },
  { 1835, 3, 31, 11, 4, -31 },
  { 1847, 6, 39, 11, 2, -31 },
  { 1877, 20, 25, 23, 2, -33 },
  { 1940, 20, 15, 23, 2, -28 },
  { 1978, 20, 25, 23, 2, -33 },
  { 2041, 14, 42, 16, 1, -42 },
  { 2115, 30, 47, 36, 3, -42 },
  { 2292, 23, 41, 23, 0, -41 },
  { 2410, 19, 41, 26, 4, -41 },
  { 2508, 20, 43, 24, 3, -42 },
  { 2616, 21, 41, 28, 4, -41 },
  { 2724, 16, 41, 22, 4, -41 },
  { 2806, 16, 41, 21, 4, -41 },
  { 2888, 24, 43, 30, 3, -42 },
  { 3017, 20, 41, 29, 4, -41 },
  { 3120, 9, 41, 13, 2, -41 },
  { 3167, 10, 51, 11, -3, -41 },
  { 3231, 19, 41, 23, 4, -41 },
  { 3329, 15, 41, 20, 4, -41 },
  { 3406, 30, 41, 39, 4, -41 },
  { 3560, 22, 41, 30, 4, -41 },
  { 3673, 24, 43, 30, 3, -42 },
  { 3802, 18, 41, 23, 4, -41 },
  { 3895, 24, 52, 30, 3, -42 },
  { 4051, 19, 41, 24, 4, -41 },
  { 4149, 18, 43, 23, 2, -42 },
  { 4246, 20, 41, 20, 0, -41 },
  { 4349, 20, 42, 29, 4, -41 },
  { 4454, 22, 41, 22, 0, -41 },
  { 4567, 38, 41, 38, 0, -41 },
  { 4762, 18, 41, 20, 1, -41 },
  { 4855, 19, 41, 19, 0, -41 },
  { 4953, 16, 41, 19, 2, -41 },
  { 5035, 11, 50, 18, 5, -41 },
  { 5104, 18, 41, 19, 1, -41 },
  { 5197, 11, 50, 18, 2, -41 },
  { 5266, 22, 20, 23, 1, -41 },
  { 5321, 23, 2, 23, 0, 5 },
  { 5327, 9, 9, 14, 2, -44 },
  { 5338, 16, 32, 22, 2, -31 },
  { 5402, 19, 45, 25, 4, -44 },
  { 5509, 14, 32, 19, 3, -31 },
  { 5565, 18, 45, 25, 3, -44 },
  { 5667, 17, 32, 23, 3, -31 },
  { 5735, 13, 44, 13, 1, -44 },
  { 5807, 18, 45, 25, 3, -31 },
  { 5909, 16, 44, 24, 4, -44 },
  { 5997, 3, 42, 11, 4, -42 },
  { 6013, 7, 56, 11, 0, -42 },
  { 6062, 15, 44, 20, 4, -44 },
  { 6145, 2, 44, 10, 4, -44 },
  { 6156, 28, 31, 36, 4, -31 },
  { 6265, 16, 31, 24, 4, -31 },
  { 6327, 18, 32, 24, 3, -31 },
  { 6399, 18, 45, 25, 4, -31 },
  { 6501, 18, 45, 25, 3, -31 },
  { 6603, 11, 31, 16, 4, -31 },
  { 6646, 14, 32, 18, 2, -31 },
  { 6702, 11, 39, 13, 1, -38 },
  { 6756, 16, 32, 24, 4, -31 },
  { 6820, 18, 31, 18, 0, -31 },
  { 6890, 29, 31, 31, 1, -31 },
  { 7003, 17, 31, 19, 1, -31 },
  { 7069, 17, 45, 19, 1, -31 },
  { 7165, 12, 31, 15, 2, -31 },
  { 7212, 14, 50, 20, 3, -41 },
  { 7300, 2, 58, 22, 10, -44 },
  { 7315, 14, 50, 20, 3, -41 },
  { 7403, 20, 5, 23, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight58pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT58PT7B_H_
