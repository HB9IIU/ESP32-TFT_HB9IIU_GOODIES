#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT9PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xC0, 0x6F, 0x6E, 0x6A, 0x7B, 0x26, 0xFA, 0x46, 0xA9, 0xB6,
  0x95, 0x60, 0x4A, 0x44, 0xAA, 0xF0, 0xC0, 0x6A, 0xA4, 0xD5, 0x5C, 0x5E,
  0x80, 0x5D, 0x20, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x56, 0xDB, 0x58,
  0xFC, 0xC4, 0x92, 0xB8, 0x54, 0xA2, 0x78, 0x26, 0x6A, 0x72, 0xF3, 0x93,
  0xC0, 0x73, 0xDA, 0xC0, 0xE4, 0xA4, 0x80, 0x56, 0xAB, 0x78, 0x56, 0xD6,
  0x58, 0x88, 0x8C, 0x39, 0x10, 0xFC, 0xC5, 0x40, 0xD5, 0x88, 0x7D, 0xEF,
  0xBB, 0xA0, 0xC0, 0x44, 0xA6, 0xA9, 0xF7, 0x5B, 0x80, 0x34, 0x88, 0x88,
  0x70, 0xF6, 0xDB, 0x80, 0xEE, 0xB0, 0xEE, 0xA0, 0x34, 0x88, 0x99, 0x70,
  0xB7, 0xDB, 0x40, 0xD5, 0x70, 0xFF, 0xD2, 0x4D, 0x40, 0xAA, 0xB0, 0x99,
  0x9B, 0xFD, 0xB6, 0xFB, 0x40, 0x25, 0x99, 0x99, 0x70, 0xFE, 0xA0, 0x25,
  0x99, 0x99, 0x52, 0x10, 0xF7, 0x4D, 0x40, 0x72, 0x22, 0x78, 0xE9, 0x24,
  0x80, 0xB6, 0xDB, 0xC0, 0xB6, 0xA4, 0x80, 0xA6, 0xDB, 0x56, 0x59, 0x20,
  0xA9, 0x2B, 0x40, 0xB5, 0x24, 0x80, 0xE9, 0x29, 0xC0, 0xFE, 0x89, 0x22,
  0x40, 0xD5, 0x5C, 0x56, 0x80, 0xF0, 0x90, 0xE5, 0xDE, 0xAF, 0xFC, 0x72,
  0x46, 0x25, 0xDB, 0x78, 0x77, 0xC6, 0x6E, 0xA8, 0x76, 0xDE, 0x58, 0xAF,
  0xFC, 0xBE, 0xBF, 0x80, 0xAE, 0xAC, 0xFE, 0xFD, 0xDD, 0xD0, 0xFF, 0xC0,
  0x76, 0xDE, 0xFF, 0xE8, 0x76, 0xDE, 0x48, 0xF8, 0xF1, 0x1E, 0xBA, 0xB0,
  0xFF, 0xC0, 0xB6, 0xE4, 0xAD, 0x7B, 0xA5, 0x00, 0xB9, 0x2A, 0xB6, 0xA4,
  0xB0, 0xD6, 0xC0, 0x69, 0x44, 0x98, 0xFF, 0x80, 0xC9, 0x14, 0xB0, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 1, 2, 3, 1, -6 },
  { 3, 4, 6, 4, 0, -6 },
  { 6, 3, 8, 4, 0, -7 },
  { 9, 5, 7, 5, 0, -7 },
  { 14, 4, 7, 4, 0, -7 },
  { 18, 1, 2, 2, 0, -6 },
  { 19, 2, 7, 2, 0, -6 },
  { 21, 2, 7, 2, 0, -6 },
  { 23, 3, 3, 3, 0, -7 },
  { 25, 3, 4, 4, 0, -5 },
  { 27, 1, 2, 2, 0, -1 },
  { 28, 2, 1, 2, 0, -3 },
  { 29, 1, 1, 2, 0, -1 },
  { 30, 3, 6, 3, 0, -6 },
  { 33, 3, 7, 4, 0, -7 },
  { 36, 1, 6, 4, 1, -6 },
  { 37, 3, 7, 4, 0, -7 },
  { 40, 3, 7, 4, 0, -7 },
  { 43, 4, 6, 4, 0, -6 },
  { 46, 3, 6, 4, 0, -6 },
  { 49, 3, 6, 4, 0, -6 },
  { 52, 3, 6, 4, 0, -6 },
  { 55, 3, 7, 4, 0, -7 },
  { 58, 3, 7, 4, 0, -7 },
  { 61, 1, 5, 2, 0, -5 },
  { 62, 1, 6, 2, 0, -5 },
  { 63, 3, 4, 4, 0, -5 },
  { 65, 3, 2, 4, 0, -4 },
  { 66, 3, 4, 4, 0, -5 },
  { 68, 2, 7, 2, 0, -7 },
  { 70, 5, 7, 6, 0, -6 },
  { 75, 4, 6, 4, 0, -6 },
  { 78, 3, 6, 4, 1, -6 },
  { 81, 4, 7, 4, 0, -7 },
  { 85, 3, 6, 4, 1, -6 },
  { 88, 2, 6, 3, 1, -6 },
  { 90, 2, 6, 3, 1, -6 },
  { 92, 4, 7, 5, 0, -7 },
  { 96, 3, 6, 4, 1, -6 },
  { 99, 2, 6, 2, 0, -6 },
  { 101, 1, 8, 2, 0, -6 },
  { 102, 3, 6, 4, 1, -6 },
  { 105, 2, 6, 3, 1, -6 },
  { 107, 4, 6, 6, 1, -6 },
  { 110, 3, 6, 5, 1, -6 },
  { 113, 4, 7, 5, 0, -7 },
  { 117, 2, 6, 4, 1, -6 },
  { 119, 4, 9, 5, 0, -7 },
  { 124, 3, 6, 4, 1, -6 },
  { 127, 3, 7, 4, 0, -7 },
  { 130, 3, 6, 3, 0, -6 },
  { 133, 3, 6, 4, 1, -6 },
  { 136, 3, 6, 3, 0, -6 },
  { 139, 6, 6, 6, 0, -6 },
  { 144, 3, 6, 3, 0, -6 },
  { 147, 3, 6, 3, 0, -6 },
  { 150, 3, 6, 3, 0, -6 },
  { 153, 1, 7, 3, 1, -6 },
  { 154, 3, 6, 3, 0, -6 },
  { 157, 2, 7, 3, 0, -6 },
  { 159, 3, 3, 4, 0, -6 },
  { 161, 4, 1, 4, 0, 0 },
  { 162, 2, 2, 2, 0, -7 },
  { 163, 3, 5, 3, 0, -5 },
  { 165, 2, 7, 4, 1, -7 },
  { 167, 3, 5, 3, 0, -5 },
  { 169, 3, 7, 4, 0, -7 },
  { 172, 3, 5, 3, 0, -5 },
  { 174, 2, 7, 2, 0, -7 },
  { 176, 3, 7, 4, 0, -5 },
  { 179, 2, 7, 4, 1, -7 },
  { 181, 1, 7, 2, 0, -7 },
  { 182, 1, 9, 2, 0, -7 },
  { 184, 2, 7, 3, 1, -7 },
  { 186, 1, 7, 2, 0, -7 },
  { 187, 4, 5, 6, 1, -5 },
  { 190, 2, 5, 4, 1, -5 },
  { 192, 3, 5, 4, 0, -5 },
  { 194, 2, 7, 4, 1, -5 },
  { 196, 3, 7, 4, 0, -5 },
  { 199, 1, 5, 2, 1, -5 },
  { 200, 3, 5, 3, 0, -5 },
  { 202, 2, 6, 2, 0, -6 },
  { 204, 2, 5, 4, 1, -5 },
  { 206, 3, 5, 3, 0, -5 },
  { 208, 5, 5, 5, 0, -5 },
  { 212, 3, 5, 3, 0, -5 },
  { 214, 3, 7, 3, 0, -5 },
  { 217, 2, 5, 2, 0, -5 },
  { 219, 3, 7, 3, 0, -6 },
  { 222, 1, 9, 3, 1, -7 },
  { 224, 3, 7, 3, 0, -6 },
  { 227, 3, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight9pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT9PT7B_H_
