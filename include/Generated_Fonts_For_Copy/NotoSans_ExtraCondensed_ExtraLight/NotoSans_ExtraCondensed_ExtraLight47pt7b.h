#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT47PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight47pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x00,
  0x17, 0xFC, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0B, 0x05, 0x82, 0xC1,
  0x60, 0xB0, 0x58, 0x2C, 0x10, 0x01, 0x02, 0x00, 0xC0, 0x80, 0x30, 0x20,
  0x0C, 0x08, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x20, 0x60, 0x08, 0x18, 0x02,
  0x04, 0x00, 0x81, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0x06, 0x04, 0x01, 0x83,
  0x00, 0x60, 0xC0, 0x10, 0x30, 0x04, 0x0C, 0x01, 0x03, 0x00, 0xC0, 0x80,
  0x30, 0x20, 0x0C, 0x08, 0x03, 0x02, 0x0F, 0xFF, 0xF8, 0x20, 0x60, 0x08,
  0x18, 0x02, 0x06, 0x00, 0x81, 0x80, 0x60, 0x40, 0x18, 0x10, 0x06, 0x04,
  0x01, 0x83, 0x00, 0x60, 0xC0, 0x10, 0x30, 0x04, 0x0C, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x7F, 0x01, 0xFF, 0xCE, 0x61, 0x98, 0xC0, 0x61,
  0x80, 0xC3, 0x01, 0x06, 0x02, 0x0C, 0x04, 0x18, 0x08, 0x30, 0x18, 0x60,
  0x30, 0xC0, 0x31, 0x80, 0x33, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x3F, 0x00, 0x67, 0x00, 0xC3, 0x01, 0x83, 0x03, 0x06, 0x06, 0x04, 0x0C,
  0x08, 0x18, 0x10, 0x30, 0x60, 0x60, 0xC0, 0xC1, 0x41, 0x86, 0xE3, 0x39,
  0xFF, 0xE0, 0x3E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x1E, 0x00, 0x40, 0x33, 0x00, 0xC0, 0x61, 0x00, 0xC0, 0x61, 0x80, 0x80,
  0x41, 0x81, 0x80, 0xC0, 0x81, 0x80, 0xC0, 0x81, 0x00, 0xC0, 0x83, 0x00,
  0xC0, 0x83, 0x00, 0xC0, 0xC2, 0x00, 0xC0, 0xC6, 0x00, 0xC0, 0xC6, 0x00,
  0xC0, 0xC4, 0x00, 0xC0, 0x8C, 0x30, 0xC0, 0x8C, 0xFC, 0xC0, 0x88, 0x8C,
  0x41, 0x99, 0x86, 0x61, 0x99, 0x06, 0x61, 0x11, 0x02, 0x3F, 0x31, 0x02,
  0x1E, 0x33, 0x03, 0x00, 0x23, 0x03, 0x00, 0x63, 0x03, 0x00, 0x63, 0x03,
  0x00, 0x43, 0x03, 0x00, 0xC3, 0x03, 0x00, 0xC3, 0x03, 0x00, 0x83, 0x03,
  0x01, 0x81, 0x02, 0x01, 0x81, 0x02, 0x01, 0x01, 0x86, 0x03, 0x01, 0x86,
  0x03, 0x00, 0xCC, 0x02, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xF8, 0x00, 0xC2,
  0x00, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x81, 0x00, 0x60, 0xC0,
  0x18, 0x30, 0x06, 0x0C, 0x00, 0x83, 0x00, 0x30, 0x80, 0x0C, 0x60, 0x01,
  0x30, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x60, 0x01, 0x98,
  0x00, 0xC3, 0x06, 0x20, 0xC1, 0x98, 0x18, 0x66, 0x02, 0x19, 0x00, 0xC6,
  0xC0, 0x19, 0x30, 0x06, 0xCC, 0x00, 0xF1, 0x00, 0x38, 0x40, 0x06, 0x18,
  0x03, 0x86, 0x01, 0xB0, 0xC0, 0xE6, 0x3C, 0x71, 0x83, 0xF0, 0x30, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0x81, 0x80, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30,
  0x10, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0x80, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06,
  0x03, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x04,
  0x06, 0x06, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0xC0, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x82, 0x1F, 0x27, 0x1F, 0xC0, 0x60, 0x0D, 0x00, 0x98, 0x10, 0xC3,
  0x06, 0x60, 0x60, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x3F, 0xFF, 0xE0, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x33, 0x33, 0x66, 0x66, 0xCC, 0x80, 0xFF, 0xFF, 0xF0, 0x5F, 0xF0, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x00, 0x07,
  0xC0, 0x1F, 0xC0, 0x60, 0xC1, 0x80, 0xC3, 0x01, 0x84, 0x01, 0x18, 0x03,
  0x30, 0x06, 0x60, 0x0C, 0x80, 0x1B, 0x00, 0x16, 0x00, 0x2C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0x60, 0x02, 0x40, 0x0C, 0xC0, 0x19,
  0x80, 0x33, 0x00, 0x66, 0x00, 0x86, 0x03, 0x0C, 0x06, 0x0C, 0x18, 0x0E,
  0xF0, 0x0F, 0x80, 0x01, 0x81, 0xC1, 0xE1, 0xB1, 0x99, 0x8F, 0x86, 0x83,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x0F, 0xC0, 0xFF, 0xC3, 0x80, 0xC2,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0,
  0xFF, 0xC3, 0x80, 0xC4, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0xE0, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x40, 0x1C, 0xF0, 0xF0,
  0xFF, 0x80, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x05, 0x00, 0x07,
  0x80, 0x02, 0xC0, 0x03, 0x60, 0x01, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00,
  0xC6, 0x00, 0x63, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x30, 0x60, 0x18, 0x30,
  0x18, 0x18, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x03, 0x02, 0x01, 0x83, 0x00,
  0xC1, 0x00, 0x61, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x17, 0xF0, 0x3F, 0xF8, 0x40, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x40, 0x18, 0xF0, 0xE0, 0xFF, 0x80, 0x00, 0xF8, 0x0F, 0xF0, 0x38,
  0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x30, 0x33, 0xFC, 0x6E,
  0x1C, 0xD0, 0x19, 0xC0, 0x1B, 0x80, 0x37, 0x00, 0x2C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x06, 0x80, 0x0D, 0x00, 0x1B, 0x00, 0x36,
  0x00, 0xCC, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x1C, 0x30, 0x1F, 0xC0, 0x04,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xC0, 0xE3, 0x00,
  0xE6, 0x00, 0xCC, 0x01, 0x90, 0x03, 0x60, 0x02, 0x40, 0x04, 0x80, 0x19,
  0x80, 0x33, 0x00, 0x63, 0x01, 0x83, 0x06, 0x03, 0x18, 0x03, 0xE0, 0x07,
  0x80, 0x1D, 0x80, 0x61, 0xC1, 0x81, 0xC6, 0x01, 0x8C, 0x01, 0xB0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xD8, 0x03, 0x38, 0x0C, 0x3C, 0x38, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F,
  0x83, 0x03, 0x18, 0x04, 0x60, 0x19, 0x00, 0x2C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x60, 0x0D, 0x80, 0x53, 0x03, 0x4F, 0x79, 0x0F, 0xCC, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x07, 0x00, 0x38, 0x41, 0xC1, 0xFE, 0x00, 0xFF, 0xA0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xBF, 0xE0, 0x77, 0x72, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0x33, 0x66, 0x64, 0xCC, 0x80, 0x00,
  0x01, 0x80, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x30, 0x00, 0x00, 0x3E, 0x1F, 0xF2,
  0x07, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0xC0, 0x38, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x60, 0x38, 0x00, 0x60, 0x06, 0x00, 0x60, 0x01, 0x80,
  0x60, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x08, 0x07, 0xE0, 0xCC, 0x06, 0x30, 0x66, 0x06, 0x18,
  0x33, 0x06, 0x0C, 0x09, 0x83, 0x06, 0x04, 0x81, 0x03, 0x02, 0x40, 0x81,
  0x81, 0x20, 0xC0, 0xC0, 0xF0, 0x60, 0x60, 0x78, 0x30, 0x30, 0x2C, 0x18,
  0x18, 0x16, 0x0C, 0x0C, 0x09, 0x06, 0x06, 0x0C, 0x83, 0x07, 0x06, 0x40,
  0x82, 0x83, 0x20, 0x61, 0x41, 0x18, 0x31, 0xB1, 0x8C, 0x0F, 0x8F, 0x86,
  0x03, 0x83, 0x81, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x08,
  0x00, 0x3C, 0x78, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x06, 0x80, 0x01, 0xA0, 0x00, 0x4C, 0x00, 0x13, 0x00, 0x0C,
  0xC0, 0x03, 0x10, 0x00, 0xC6, 0x00, 0x21, 0x80, 0x18, 0x60, 0x06, 0x08,
  0x01, 0x83, 0x00, 0x40, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x01, 0x00,
  0xC0, 0x60, 0x60, 0x18, 0x1F, 0xFE, 0x06, 0x00, 0x81, 0x80, 0x30, 0x40,
  0x0C, 0x30, 0x03, 0x0C, 0x00, 0x43, 0x00, 0x18, 0x80, 0x06, 0x60, 0x01,
  0x98, 0x00, 0x26, 0x00, 0x0D, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x30,
  0xFE, 0x01, 0xFF, 0xC2, 0x01, 0xC4, 0x00, 0xC8, 0x01, 0xD0, 0x01, 0xA0,
  0x03, 0x40, 0x06, 0x80, 0x0D, 0x00, 0x1A, 0x00, 0x34, 0x00, 0x68, 0x00,
  0x90, 0x03, 0x20, 0x0C, 0x40, 0xF0, 0xFF, 0xC1, 0x00, 0xE2, 0x00, 0x64,
  0x00, 0x68, 0x00, 0xD0, 0x00, 0xA0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xD0, 0x01, 0xA0, 0x06, 0x40, 0x1C,
  0xFF, 0xF1, 0xFF, 0x80, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xC0, 0x41, 0xC0,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0xC3, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0xC0, 0x80, 0xF0, 0x80,
  0x38, 0x80, 0x18, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x06, 0x80,
  0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x06, 0x80, 0x06, 0x80,
  0x06, 0x80, 0x0C, 0x80, 0x1C, 0x80, 0x38, 0x80, 0x70, 0xFF, 0xE0, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0xFF, 0xE8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFE, 0xFF, 0xE8, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFE,
  0x03, 0x80, 0x70, 0x60, 0x02, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0xFF, 0xC0, 0x0F, 0xF4, 0x00, 0x03, 0x40, 0x00, 0x36,
  0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x32, 0x00, 0x03,
  0x30, 0x00, 0x33, 0x00, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x0C, 0x00,
  0x30, 0x70, 0x03, 0x03, 0xC0, 0xF0, 0x0F, 0xFC, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0xFF, 0xFC, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x11, 0xFC, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02,
  0x06, 0x06, 0x8E, 0xFC, 0x80, 0x0D, 0x00, 0x32, 0x00, 0x64, 0x01, 0x88,
  0x03, 0x10, 0x0C, 0x20, 0x38, 0x40, 0x60, 0x81, 0x81, 0x03, 0x02, 0x0C,
  0x04, 0x18, 0x08, 0x60, 0x11, 0x80, 0x23, 0x00, 0x4E, 0x00, 0x9C, 0x01,
  0x68, 0x03, 0x98, 0x06, 0x10, 0x0C, 0x30, 0x10, 0x60, 0x20, 0x60, 0x40,
  0xC0, 0x80, 0xC1, 0x01, 0x82, 0x01, 0x84, 0x03, 0x08, 0x03, 0x10, 0x06,
  0x20, 0x06, 0x40, 0x0C, 0x80, 0x0D, 0x00, 0x1C, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xA0, 0x00, 0x0F, 0xB0, 0x00,
  0x0B, 0xB0, 0x00, 0x1B, 0x90, 0x00, 0x1B, 0x98, 0x00, 0x13, 0x98, 0x00,
  0x33, 0x88, 0x00, 0x33, 0x8C, 0x00, 0x23, 0x8C, 0x00, 0x63, 0x8C, 0x00,
  0x63, 0x84, 0x00, 0x63, 0x86, 0x00, 0x43, 0x86, 0x00, 0xC3, 0x82, 0x00,
  0xC3, 0x83, 0x00, 0x83, 0x83, 0x01, 0x83, 0x83, 0x01, 0x83, 0x81, 0x81,
  0x03, 0x81, 0x83, 0x03, 0x81, 0x83, 0x03, 0x80, 0x83, 0x03, 0x80, 0xC2,
  0x03, 0x80, 0xC6, 0x03, 0x80, 0x46, 0x03, 0x80, 0x64, 0x03, 0x80, 0x6C,
  0x03, 0x80, 0x6C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3B, 0x00, 0x1D,
  0x80, 0x0E, 0x40, 0x07, 0x30, 0x03, 0x98, 0x01, 0xC6, 0x00, 0xE3, 0x00,
  0x70, 0xC0, 0x38, 0x60, 0x1C, 0x10, 0x0E, 0x0C, 0x07, 0x02, 0x03, 0x81,
  0x81, 0xC0, 0xC0, 0xE0, 0x30, 0x70, 0x18, 0x38, 0x06, 0x1C, 0x03, 0x0E,
  0x00, 0x87, 0x00, 0x63, 0x80, 0x31, 0xC0, 0x0C, 0xE0, 0x06, 0x70, 0x01,
  0xB8, 0x00, 0xDC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0E, 0x07, 0x01, 0xC0, 0x18,
  0x18, 0x01, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x06, 0x60, 0x00,
  0x66, 0x00, 0x06, 0x60, 0x00, 0x26, 0x00, 0x03, 0x60, 0x00, 0x34, 0x00,
  0x03, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36,
  0x00, 0x02, 0x60, 0x00, 0x66, 0x00, 0x06, 0x20, 0x00, 0x63, 0x00, 0x06,
  0x30, 0x00, 0xC1, 0x80, 0x0C, 0x1C, 0x01, 0x80, 0xE0, 0x38, 0x07, 0x8F,
  0x00, 0x3F, 0xC0, 0xF8, 0x07, 0xFE, 0x20, 0x79, 0x00, 0xE8, 0x03, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x34, 0x07, 0x3F, 0xF1, 0xFE, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x7F, 0xE0, 0x0E, 0x03, 0x01, 0xC0, 0x18, 0x18, 0x01, 0xC3,
  0x00, 0x0C, 0x30, 0x00, 0x43, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0x26, 0x00, 0x03, 0x60, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00,
  0x03, 0x40, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x02, 0x60,
  0x00, 0x66, 0x00, 0x06, 0x20, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0xC1,
  0x80, 0x0C, 0x18, 0x01, 0x80, 0xC0, 0x38, 0x07, 0x8F, 0x00, 0x3F, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0xF8, 0x01, 0xFF, 0x82,
  0x03, 0x84, 0x01, 0x88, 0x01, 0x90, 0x03, 0x20, 0x06, 0x40, 0x04, 0x80,
  0x09, 0x00, 0x1A, 0x00, 0x34, 0x00, 0x48, 0x01, 0x90, 0x03, 0x20, 0x06,
  0x40, 0x18, 0x80, 0x61, 0xFF, 0x83, 0xFC, 0x04, 0x18, 0x08, 0x10, 0x10,
  0x30, 0x20, 0x60, 0x40, 0x60, 0x80, 0xC1, 0x00, 0xC2, 0x01, 0x84, 0x01,
  0x88, 0x03, 0x10, 0x03, 0x20, 0x06, 0x40, 0x06, 0x80, 0x0D, 0x00, 0x1C,
  0x07, 0xF0, 0x3F, 0xF8, 0xE0, 0x13, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x40, 0x1C,
  0xF0, 0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x68, 0x00, 0x36,
  0x00, 0x33, 0x00, 0x18, 0xC0, 0x0C, 0x70, 0x0C, 0x1E, 0x1C, 0x07, 0xFC,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x09, 0x00, 0x06, 0x60, 0x01,
  0x98, 0x00, 0x66, 0x00, 0x10, 0x80, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3,
  0x00, 0x30, 0x40, 0x08, 0x18, 0x06, 0x06, 0x01, 0x81, 0x80, 0x60, 0x20,
  0x10, 0x08, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x20, 0x04, 0x18,
  0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0x40, 0x02, 0x10, 0x00, 0xCC, 0x00,
  0x33, 0x00, 0x0C, 0xC0, 0x01, 0x20, 0x00, 0x58, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x07, 0x80, 0x07,
  0x00, 0x0D, 0x00, 0x0E, 0x00, 0x13, 0x00, 0x1C, 0x00, 0x66, 0x00, 0x28,
  0x00, 0xCC, 0x00, 0x50, 0x01, 0x88, 0x01, 0xB0, 0x03, 0x18, 0x03, 0x60,
  0x0C, 0x30, 0x06, 0xC0, 0x18, 0x60, 0x0D, 0x80, 0x30, 0xC0, 0x11, 0x00,
  0x60, 0x80, 0x63, 0x00, 0x81, 0x80, 0xC6, 0x03, 0x03, 0x01, 0x8C, 0x06,
  0x06, 0x03, 0x18, 0x0C, 0x0C, 0x04, 0x10, 0x18, 0x08, 0x18, 0x30, 0x20,
  0x18, 0x30, 0x60, 0xC0, 0x30, 0x60, 0xC1, 0x80, 0x60, 0xC1, 0x83, 0x00,
  0xC1, 0x01, 0x06, 0x00, 0x86, 0x03, 0x18, 0x01, 0x8C, 0x06, 0x30, 0x03,
  0x18, 0x0C, 0x60, 0x06, 0x30, 0x18, 0xC0, 0x04, 0x40, 0x11, 0x00, 0x0D,
  0x80, 0x36, 0x00, 0x1B, 0x00, 0x6C, 0x00, 0x36, 0x00, 0xD8, 0x00, 0x6C,
  0x01, 0xB0, 0x00, 0x50, 0x01, 0x40, 0x00, 0xA0, 0x02, 0x80, 0x01, 0xC0,
  0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x60, 0x03, 0x30, 0x06, 0x30, 0x06,
  0x10, 0x06, 0x18, 0x0C, 0x18, 0x0C, 0x0C, 0x08, 0x0C, 0x18, 0x0C, 0x18,
  0x06, 0x30, 0x06, 0x30, 0x02, 0x20, 0x03, 0x60, 0x03, 0x60, 0x01, 0x40,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x03, 0x60, 0x03, 0x60,
  0x06, 0x20, 0x06, 0x30, 0x04, 0x30, 0x0C, 0x10, 0x0C, 0x18, 0x18, 0x18,
  0x18, 0x08, 0x10, 0x0C, 0x30, 0x0C, 0x30, 0x06, 0x60, 0x06, 0x60, 0x06,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0C,
  0x20, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x10, 0x18, 0x18, 0x18, 0x18, 0x30,
  0x08, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x04, 0x60, 0x06, 0x60, 0x06, 0xC0,
  0x02, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x7F, 0xF9,
  0xFF, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0x80, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0xFF, 0xFF, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x2C, 0x00, 0x32, 0x00, 0x11, 0x80, 0x18, 0xC0, 0x08,
  0x30, 0x0C, 0x18, 0x04, 0x06, 0x06, 0x03, 0x02, 0x00, 0xC3, 0x00, 0x61,
  0x00, 0x19, 0x80, 0x0D, 0x80, 0x03, 0xC0, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xC0, 0xC1, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x1F, 0xC7, 0x8E,
  0x20, 0x30, 0x03, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x7F, 0x1C, 0x17, 0x01, 0x60, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x57, 0x0D, 0x3F, 0x90, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x3F, 0x0C, 0xE7, 0x1B,
  0x03, 0x3C, 0x03, 0x70, 0x06, 0xE0, 0x05, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0x70, 0x06, 0xF0,
  0x0D, 0xA0, 0x33, 0x31, 0xC6, 0x3F, 0x00, 0x07, 0xF0, 0xE3, 0x18, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC1, 0x0F, 0xF0, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x7E, 0x31, 0xC7, 0x67, 0x02, 0xCC,
  0x03, 0xB0, 0x07, 0x60, 0x06, 0xC0, 0x0D, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x68, 0x00, 0xD8, 0x01, 0xB0, 0x07, 0x20, 0x0E, 0x60,
  0x24, 0x71, 0xC8, 0x7F, 0x10, 0x0F, 0xC0, 0x71, 0xC3, 0x03, 0x0C, 0x06,
  0x60, 0x19, 0x80, 0x26, 0x00, 0xD0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x47, 0x06, 0x0F,
  0xF0, 0x03, 0xE0, 0xFC, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x3F, 0xCF, 0xF8, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x0F, 0xE2, 0x3C, 0xE4, 0xC0, 0x59, 0x80, 0x76, 0x00,
  0xEC, 0x00, 0xD8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0D, 0x00, 0x1B, 0x00, 0x76, 0x00, 0xE4, 0x01, 0xCC, 0x05, 0x8E, 0x3B,
  0x0F, 0xC6, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x80, 0x31, 0xE3, 0xC1, 0xFF, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x8F, 0xCC, 0xEF, 0x6C, 0x1B, 0xC0, 0x7C,
  0x03, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x10, 0xFF, 0x80,
  0x00, 0x09, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x48, 0x1C,
  0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0xAC, 0xF0, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x6C, 0x06, 0x60, 0x33, 0x03, 0x18, 0x10, 0xC1,
  0x86, 0x18, 0x30, 0xC1, 0x8C, 0x0C, 0xC0, 0x67, 0x03, 0x78, 0x1A, 0x60,
  0xF3, 0x07, 0x08, 0x30, 0x61, 0x83, 0x0C, 0x0C, 0x60, 0x63, 0x01, 0x18,
  0x0C, 0xC0, 0x66, 0x01, 0xB0, 0x0D, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xC1, 0xF9, 0xB9, 0xC6, 0x7B, 0x40,
  0xD8, 0x37, 0x01, 0xA0, 0x3E, 0x03, 0x80, 0x7C, 0x03, 0x00, 0xF0, 0x06,
  0x01, 0xE0, 0x0C, 0x03, 0xC0, 0x18, 0x07, 0x80, 0x30, 0x0F, 0x00, 0x60,
  0x1E, 0x00, 0xC0, 0x3C, 0x01, 0x80, 0x78, 0x03, 0x00, 0xF0, 0x06, 0x01,
  0xE0, 0x0C, 0x03, 0xC0, 0x18, 0x07, 0x80, 0x30, 0x0F, 0x00, 0x60, 0x1E,
  0x00, 0xC0, 0x3C, 0x01, 0x80, 0x78, 0x03, 0x00, 0xF0, 0x06, 0x01, 0xE0,
  0x0C, 0x03, 0xC0, 0x18, 0x06, 0xC7, 0xE6, 0x63, 0xB6, 0x0F, 0xE0, 0x3E,
  0x01, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x08, 0x0F, 0xE0,
  0x38, 0xE0, 0xC0, 0x61, 0x80, 0x66, 0x00, 0xCC, 0x00, 0x90, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0D, 0x00, 0x1B, 0x00, 0x26,
  0x00, 0xC6, 0x01, 0x8C, 0x06, 0x0E, 0x1C, 0x0F, 0xE0, 0xC7, 0xE1, 0x9C,
  0xE3, 0x60, 0x66, 0x80, 0x6E, 0x00, 0xDC, 0x00, 0xB8, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x2E, 0x00,
  0xDA, 0x01, 0xB6, 0x06, 0x66, 0x38, 0xC7, 0xE1, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xE2, 0x38, 0xE4, 0xE0, 0x59, 0x80,
  0x76, 0x00, 0xEC, 0x00, 0xD8, 0x01, 0xA0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0D, 0x00, 0x1B, 0x00, 0x76, 0x00, 0xE6, 0x01, 0xCC, 0x05,
  0x8E, 0x3B, 0x0F, 0xC6, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0xC7, 0xE7, 0xF6, 0x1A, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x1F, 0xCF, 0x1D, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x06, 0x00,
  0xE0, 0x3F, 0x0E, 0x7F, 0x80, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x83,
  0xFF, 0xFF, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x01, 0x00, 0xC4, 0x7E, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xB0, 0x15, 0x81, 0xA7, 0x19, 0x1F, 0x88, 0xC0, 0x0D, 0x00,
  0x36, 0x00, 0xD8, 0x02, 0x60, 0x18, 0x80, 0x62, 0x01, 0x8C, 0x04, 0x30,
  0x30, 0xC0, 0xC1, 0x03, 0x06, 0x0C, 0x18, 0x20, 0x61, 0x80, 0x86, 0x03,
  0x18, 0x0C, 0x40, 0x33, 0x00, 0x4C, 0x01, 0x30, 0x06, 0x80, 0x1E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x0C, 0x01, 0x40, 0x1C, 0x03, 0x60,
  0x1C, 0x03, 0x60, 0x14, 0x03, 0x60, 0x16, 0x03, 0x20, 0x36, 0x02, 0x30,
  0x36, 0x06, 0x30, 0x32, 0x06, 0x30, 0x32, 0x06, 0x10, 0x23, 0x04, 0x10,
  0x63, 0x04, 0x18, 0x63, 0x0C, 0x18, 0x61, 0x0C, 0x18, 0x41, 0x0C, 0x08,
  0x41, 0x88, 0x0C, 0xC1, 0x98, 0x0C, 0xC1, 0x98, 0x0C, 0xC0, 0x98, 0x04,
  0x80, 0x90, 0x04, 0x80, 0xD0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x07,
  0x00, 0x70, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0xC0, 0x19, 0x80, 0x66,
  0x03, 0x0C, 0x0C, 0x30, 0x60, 0x41, 0x81, 0x84, 0x02, 0x30, 0x0C, 0xC0,
  0x36, 0x00, 0x78, 0x01, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x58, 0x03, 0x60,
  0x08, 0xC0, 0x63, 0x01, 0x86, 0x0C, 0x18, 0x30, 0x31, 0x80, 0xC6, 0x01,
  0x30, 0x06, 0xC0, 0x1C, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x98, 0x06, 0x60,
  0x19, 0x80, 0x66, 0x01, 0x08, 0x0C, 0x30, 0x30, 0xC0, 0xC3, 0x02, 0x04,
  0x18, 0x18, 0x60, 0x61, 0x81, 0x84, 0x02, 0x30, 0x0C, 0xC0, 0x33, 0x00,
  0xC8, 0x01, 0x60, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x0B, 0x80, 0x3C, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0xC0, 0x18, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x10, 0x1F, 0x03, 0x80, 0x30,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0xF8, 0x0F, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x38, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x0F, 0x80, 0x1C,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x00, 0xF0, 0x0F, 0x03, 0x80, 0x30, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x01, 0xC0, 0xF8, 0x00, 0x1C, 0x00,
  0x3F, 0xC0, 0x70, 0x78, 0xF0, 0x0F, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 34, 10, 3, -34 },
  { 14, 9, 13, 15, 3, -34 },
  { 29, 18, 34, 20, 1, -34 },
  { 106, 15, 39, 19, 2, -36 },
  { 180, 24, 34, 28, 2, -34 },
  { 282, 18, 34, 19, 1, -34 },
  { 359, 2, 13, 8, 3, -34 },
  { 363, 9, 41, 13, 2, -34 },
  { 410, 8, 41, 13, 2, -34 },
  { 451, 12, 13, 17, 2, -36 },
  { 471, 17, 21, 19, 1, -27 },
  { 516, 4, 11, 9, 2, -5 },
  { 522, 10, 2, 12, 1, -14 },
  { 525, 3, 4, 9, 3, -4 },
  { 527, 14, 34, 16, 1, -34 },
  { 587, 15, 34, 19, 2, -34 },
  { 651, 9, 34, 19, 3, -34 },
  { 690, 15, 34, 19, 2, -34 },
  { 754, 15, 34, 19, 2, -34 },
  { 818, 17, 34, 19, 1, -34 },
  { 891, 15, 34, 19, 2, -34 },
  { 955, 15, 35, 19, 2, -34 },
  { 1021, 15, 34, 19, 2, -34 },
  { 1085, 15, 34, 19, 2, -34 },
  { 1149, 14, 34, 19, 2, -34 },
  { 1209, 3, 25, 9, 3, -25 },
  { 1219, 4, 31, 9, 2, -25 },
  { 1235, 17, 19, 19, 1, -26 },
  { 1276, 17, 11, 19, 1, -22 },
  { 1300, 17, 19, 19, 1, -26 },
  { 1341, 11, 34, 13, 1, -34 },
  { 1388, 25, 38, 29, 2, -34 },
  { 1507, 18, 34, 18, 0, -34 },
  { 1584, 15, 34, 21, 4, -34 },
  { 1648, 17, 34, 20, 2, -34 },
  { 1721, 16, 34, 23, 4, -34 },
  { 1789, 12, 34, 18, 4, -34 },
  { 1840, 12, 34, 17, 4, -34 },
  { 1891, 20, 34, 25, 2, -34 },
  { 1976, 16, 34, 23, 4, -34 },
  { 2044, 7, 34, 11, 2, -34 },
  { 2074, 8, 42, 9, -2, -34 },
  { 2116, 15, 34, 18, 4, -34 },
  { 2180, 11, 34, 16, 4, -34 },
  { 2227, 24, 34, 31, 4, -34 },
  { 2329, 17, 34, 24, 4, -34 },
  { 2402, 20, 34, 24, 2, -34 },
  { 2487, 13, 34, 19, 4, -34 },
  { 2543, 20, 42, 24, 2, -34 },
  { 2648, 15, 34, 20, 4, -34 },
  { 2712, 15, 34, 19, 2, -34 },
  { 2776, 16, 34, 16, 0, -34 },
  { 2844, 17, 34, 23, 3, -34 },
  { 2917, 18, 34, 18, 0, -34 },
  { 2994, 31, 34, 31, 0, -34 },
  { 3126, 16, 34, 16, 0, -34 },
  { 3194, 16, 34, 16, 0, -34 },
  { 3262, 14, 34, 16, 1, -34 },
  { 3322, 9, 41, 14, 4, -34 },
  { 3369, 14, 34, 16, 1, -34 },
  { 3429, 9, 41, 14, 2, -34 },
  { 3476, 17, 17, 19, 1, -34 },
  { 3513, 19, 2, 19, 0, 4 },
  { 3518, 7, 8, 11, 2, -36 },
  { 3525, 12, 25, 18, 2, -25 },
  { 3563, 15, 36, 20, 3, -36 },
  { 3631, 12, 25, 15, 2, -25 },
  { 3669, 15, 36, 20, 2, -36 },
  { 3737, 14, 25, 18, 2, -25 },
  { 3781, 11, 36, 10, 0, -36 },
  { 3831, 15, 36, 20, 2, -25 },
  { 3899, 13, 36, 20, 3, -36 },
  { 3958, 3, 34, 9, 3, -34 },
  { 3971, 6, 45, 9, 0, -34 },
  { 4005, 13, 36, 16, 3, -36 },
  { 4064, 2, 36, 8, 3, -36 },
  { 4073, 23, 25, 29, 3, -25 },
  { 4145, 13, 25, 20, 3, -25 },
  { 4186, 15, 25, 19, 2, -25 },
  { 4233, 15, 36, 20, 3, -25 },
  { 4301, 15, 36, 20, 2, -25 },
  { 4369, 9, 25, 13, 3, -25 },
  { 4398, 11, 25, 15, 2, -25 },
  { 4433, 9, 31, 10, 1, -31 },
  { 4468, 13, 25, 20, 3, -25 },
  { 4509, 14, 25, 15, 0, -25 },
  { 4553, 24, 25, 25, 0, -25 },
  { 4628, 14, 25, 15, 1, -25 },
  { 4672, 14, 36, 15, 1, -25 },
  { 4735, 11, 25, 13, 1, -25 },
  { 4770, 12, 41, 16, 2, -34 },
  { 4832, 2, 47, 18, 8, -36 },
  { 4844, 12, 41, 16, 2, -34 },
  { 4906, 17, 4, 19, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight47pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT47PT7B_H_
