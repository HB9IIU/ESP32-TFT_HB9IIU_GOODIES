#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT62PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight62pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x76, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x06, 0x7F, 0xF7, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x00, 0x60, 0x18,
  0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x03,
  0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0,
  0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C,
  0x06, 0x01, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80,
  0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18,
  0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x18, 0x06, 0x00, 0x0C, 0x03,
  0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0,
  0x30, 0x00, 0x60, 0x38, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x18,
  0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x79, 0x87, 0x87, 0x0C, 0x04,
  0x70, 0x60, 0x03, 0x03, 0x00, 0x38, 0x18, 0x01, 0xC0, 0xC0, 0x0C, 0x06,
  0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xE0, 0x60, 0x03,
  0x03, 0x00, 0x18, 0x18, 0x00, 0xE0, 0xC0, 0x03, 0x86, 0x00, 0x0F, 0x30,
  0x00, 0x3D, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1B, 0xC0, 0x00, 0xC7, 0x00, 0x06, 0x1C, 0x00, 0x30, 0x70, 0x01, 0x81,
  0xC0, 0x0C, 0x06, 0x00, 0x60, 0x38, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x1C, 0x01, 0x80, 0xC0, 0x0C, 0x0E,
  0x00, 0x60, 0x66, 0x03, 0x07, 0x3E, 0x18, 0xF0, 0xFF, 0xFE, 0x00, 0xFF,
  0xC0, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x01, 0x00, 0x3F, 0x00, 0x0C,
  0x00, 0xC3, 0x00, 0x18, 0x03, 0x87, 0x00, 0x30, 0x06, 0x06, 0x00, 0xC0,
  0x0C, 0x0C, 0x01, 0x80, 0x30, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x0C, 0x00,
  0xC0, 0x30, 0x18, 0x01, 0x80, 0x60, 0x30, 0x03, 0x00, 0xC0, 0xC0, 0x06,
  0x01, 0x81, 0x80, 0x0C, 0x03, 0x03, 0x00, 0x18, 0x06, 0x0C, 0x00, 0x30,
  0x0C, 0x18, 0x00, 0x60, 0x18, 0x30, 0x00, 0xC0, 0x30, 0xC0, 0x01, 0x80,
  0x61, 0x80, 0x03, 0x00, 0xC3, 0x0F, 0x86, 0x01, 0x8C, 0x3F, 0x8C, 0x03,
  0x18, 0xE1, 0x9C, 0x0E, 0x31, 0x83, 0x18, 0x18, 0xC3, 0x03, 0x30, 0x31,
  0x8C, 0x06, 0x70, 0xE3, 0x18, 0x0C, 0x73, 0x8C, 0x30, 0x1C, 0x7E, 0x18,
  0x60, 0x18, 0x78, 0x30, 0xC0, 0x30, 0x00, 0xE1, 0x80, 0x60, 0x01, 0x87,
  0x00, 0xC0, 0x03, 0x0E, 0x01, 0x80, 0x0E, 0x1C, 0x03, 0x00, 0x18, 0x38,
  0x06, 0x00, 0x30, 0x70, 0x0C, 0x00, 0xE0, 0x60, 0x18, 0x01, 0x80, 0xC0,
  0x30, 0x03, 0x01, 0x80, 0x60, 0x0E, 0x03, 0x01, 0xC0, 0x18, 0x06, 0x03,
  0x00, 0x30, 0x0C, 0x06, 0x00, 0xE0, 0x18, 0x0C, 0x01, 0x80, 0x18, 0x38,
  0x03, 0x00, 0x30, 0x60, 0x0E, 0x00, 0x3B, 0x80, 0x18, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x70,
  0x00, 0x70, 0x60, 0x00, 0xC0, 0xE0, 0x01, 0x80, 0xC0, 0x07, 0x01, 0x80,
  0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x18, 0x00,
  0xE0, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x80, 0x07,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x70,
  0x00, 0x1C, 0x60, 0x00, 0x70, 0x60, 0x00, 0xC0, 0xC0, 0x33, 0x80, 0xC0,
  0x66, 0x01, 0xC1, 0xDC, 0x01, 0x83, 0x38, 0x03, 0x86, 0x60, 0x03, 0x0C,
  0xC0, 0x07, 0x19, 0x80, 0x06, 0x63, 0x00, 0x06, 0xC6, 0x00, 0x0F, 0x8C,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x30, 0x00, 0xD8, 0x70,
  0x03, 0xB8, 0x60, 0x0E, 0x30, 0xE0, 0x38, 0x70, 0xFF, 0xE0, 0x60, 0xFF,
  0x80, 0xE0, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0x6D, 0xB6, 0x00,
  0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03,
  0x80, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0xE0, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01,
  0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x81, 0x83, 0xF1,
  0x8F, 0x7F, 0xFC, 0x0F, 0xE0, 0x03, 0x80, 0x03, 0xC0, 0x06, 0x60, 0x0C,
  0x30, 0x18, 0x38, 0x38, 0x18, 0x30, 0x0C, 0x10, 0x08, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x71, 0xC6, 0x18, 0xE3, 0x8C, 0x30, 0xC7, 0x18, 0x63, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x6F, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x3C, 0x78, 0x06, 0x03, 0x81,
  0xC0, 0x70, 0x70, 0x07, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x70, 0x01, 0xCC,
  0x00, 0x39, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0D, 0xC0, 0x01, 0xB8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xCC, 0x00, 0x19, 0x80,
  0x03, 0x30, 0x00, 0x67, 0x00, 0x1C, 0xE0, 0x03, 0x0C, 0x00, 0x61, 0xC0,
  0x1C, 0x18, 0x03, 0x03, 0x80, 0xE0, 0x38, 0x38, 0x03, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0xE0, 0x3C, 0x1F, 0x87, 0x71, 0xCE, 0x71, 0xDC, 0x3F, 0x07,
  0xC0, 0xE8, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x3E, 0x1F, 0x07, 0x80, 0x78,
  0x20, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xE0,
  0x3E, 0x1F, 0x0F, 0x00, 0x78, 0x60, 0x01, 0xC4, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC8, 0x00, 0x3C, 0xE0, 0x07, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x70, 0x00, 0x06,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x33, 0x80, 0x00, 0xE7, 0x00, 0x01, 0x8E,
  0x00, 0x07, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x70, 0x00, 0x60, 0xE0,
  0x00, 0xC1, 0xC0, 0x03, 0x03, 0x80, 0x06, 0x07, 0x00, 0x18, 0x0E, 0x00,
  0x30, 0x1C, 0x00, 0xC0, 0x38, 0x01, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x30, 0x03, 0x80, 0x60, 0x07, 0x01, 0x80, 0x0E, 0x03, 0x00,
  0x1C, 0x0E, 0x00, 0x38, 0x18, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x10, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x06,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x80,
  0x07, 0x18, 0x03, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x30, 0x00, 0x00,
  0x1E, 0x00, 0x1F, 0xF0, 0x0F, 0xFE, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x87, 0xF0, 0x63, 0xFF, 0x0C, 0xE0,
  0x71, 0xB8, 0x07, 0x36, 0x00, 0x77, 0x80, 0x0E, 0xE0, 0x00, 0xDC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xB0, 0x00,
  0x36, 0x00, 0x0E, 0xC0, 0x01, 0xDC, 0x00, 0x31, 0x80, 0x0E, 0x38, 0x01,
  0xC3, 0x00, 0x70, 0x70, 0x1C, 0x07, 0xCF, 0x80, 0x7F, 0xC0, 0x03, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0xF8, 0x03, 0xE3, 0xE0, 0x38, 0x03, 0x81, 0x80, 0x0C, 0x1C,
  0x00, 0x70, 0xC0, 0x01, 0x8E, 0x00, 0x0C, 0x70, 0x00, 0x73, 0x80, 0x03,
  0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x18, 0x00, 0x30, 0xE0,
  0x03, 0x83, 0x00, 0x1C, 0x1C, 0x01, 0xC0, 0x70, 0x1C, 0x01, 0xC1, 0xC0,
  0x07, 0x1C, 0x00, 0x1F, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x73,
  0xC0, 0x07, 0x07, 0x00, 0x60, 0x1C, 0x07, 0x00, 0x70, 0x70, 0x01, 0xC7,
  0x00, 0x06, 0x38, 0x00, 0x39, 0x80, 0x00, 0xDC, 0x00, 0x06, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0x30,
  0x00, 0x19, 0x80, 0x00, 0xCE, 0x00, 0x0E, 0x30, 0x00, 0xE1, 0xC0, 0x07,
  0x07, 0x80, 0xF0, 0x1F, 0xBF, 0x00, 0x7F, 0xE0, 0x00, 0x30, 0x00, 0x01,
  0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0x1F, 0x01, 0xC0, 0x70, 0x18, 0x03, 0x83,
  0x80, 0x18, 0x30, 0x00, 0xC7, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0E,
  0x60, 0x00, 0x66, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00,
  0x6E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00,
  0x07, 0x70, 0x00, 0xF7, 0x00, 0x0F, 0x30, 0x00, 0xF3, 0x80, 0x1F, 0x1C,
  0x03, 0x71, 0xE0, 0xE6, 0x0F, 0xFC, 0x60, 0x3F, 0x86, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x70, 0x00, 0xEF, 0xFF, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xFF, 0xF0, 0x1C,
  0xF3, 0xCF, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x1C, 0x71, 0xC6, 0x38,
  0xE3, 0x0C, 0x31, 0xC6, 0x18, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0xC3, 0xE7, 0xC2,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x0C, 0x30,
  0x01, 0xF8, 0x06, 0x30, 0x07, 0xFC, 0x06, 0x30, 0x0E, 0x0C, 0x06, 0x70,
  0x0C, 0x0C, 0x06, 0x60, 0x18, 0x0C, 0x07, 0x60, 0x18, 0x0C, 0x03, 0x60,
  0x30, 0x0C, 0x03, 0x60, 0x30, 0x0C, 0x03, 0xE0, 0x30, 0x0C, 0x03, 0xE0,
  0x30, 0x0C, 0x03, 0xE0, 0x70, 0x1C, 0x03, 0xE0, 0x60, 0x1C, 0x03, 0xC0,
  0x60, 0x1C, 0x03, 0xC0, 0x60, 0x1C, 0x03, 0xC0, 0x60, 0x1C, 0x03, 0xC0,
  0x60, 0x1C, 0x07, 0xC0, 0x60, 0x18, 0x07, 0xE0, 0x70, 0x18, 0x06, 0xE0,
  0x30, 0x1C, 0x06, 0x60, 0x30, 0x3C, 0x06, 0x60, 0x30, 0x3C, 0x0E, 0x60,
  0x38, 0x64, 0x0C, 0x60, 0x1C, 0xE6, 0x18, 0x60, 0x0F, 0xC7, 0xF8, 0x70,
  0x07, 0x81, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x06, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x76, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x67, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x80, 0x00, 0xC1, 0x80, 0x01, 0xC1,
  0x80, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0x81, 0xC0, 0x03, 0x80,
  0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xE0, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x38, 0x1C, 0x00,
  0x38, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x1C, 0x18, 0x00,
  0x1C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x30, 0x00,
  0x0E, 0x70, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xC0, 0x0F, 0x8C, 0x00, 0x38, 0xC0, 0x01, 0xCC, 0x00, 0x0C, 0xC0, 0x00,
  0xEC, 0x00, 0x0E, 0xC0, 0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x00, 0xEC, 0x00,
  0x0E, 0xC0, 0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0,
  0x01, 0xCC, 0x00, 0x38, 0xC0, 0x07, 0x0C, 0x03, 0xE0, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xC0, 0x0F, 0x0C, 0x00, 0x38, 0xC0, 0x01, 0xCC, 0x00, 0x0E,
  0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x00, 0xEC, 0x00, 0x1C, 0xC0,
  0x03, 0x8C, 0x01, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xF0, 0x1F, 0x8F, 0x80, 0xF0, 0x02, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x80, 0x3F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x1C, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0C, 0x01, 0xF0,
  0x30, 0x01, 0xE0, 0xC0, 0x03, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x30,
  0x00, 0x18, 0xC0, 0x00, 0x73, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x30, 0x00,
  0x0E, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xB0, 0x00, 0x06,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x06, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x6C, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x33, 0x00,
  0x00, 0xCC, 0x00, 0x07, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xE3, 0x00, 0x03,
  0x0C, 0x00, 0x1C, 0x30, 0x00, 0xE0, 0xC0, 0x07, 0x03, 0x00, 0xF8, 0x0F,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xC1, 0xFC, 0x07,
  0x80, 0x0E, 0x03, 0x80, 0x00, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x18, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x07,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x1E, 0x00, 0x3C, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x30, 0xFF, 0xCF, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x1C, 0x06, 0x87, 0xBF, 0xCF, 0xE0, 0xC0, 0x00, 0xF8, 0x00, 0x3B,
  0x00, 0x06, 0x60, 0x01, 0xCC, 0x00, 0x71, 0x80, 0x0C, 0x30, 0x03, 0x86,
  0x00, 0x60, 0xC0, 0x1C, 0x18, 0x07, 0x03, 0x00, 0xC0, 0x60, 0x38, 0x0C,
  0x06, 0x01, 0x81, 0xC0, 0x30, 0x70, 0x06, 0x0E, 0x00, 0xC3, 0x80, 0x18,
  0x60, 0x03, 0x1C, 0x00, 0x67, 0x00, 0x0C, 0xF0, 0x01, 0xBE, 0x00, 0x36,
  0xE0, 0x07, 0x8C, 0x00, 0xF1, 0xC0, 0x1C, 0x18, 0x03, 0x03, 0x80, 0x60,
  0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x30, 0x0E, 0x06, 0x00, 0xC0, 0xC0,
  0x1C, 0x18, 0x01, 0x83, 0x00, 0x38, 0x60, 0x03, 0x0C, 0x00, 0x71, 0x80,
  0x06, 0x30, 0x00, 0xE6, 0x00, 0x0C, 0xC0, 0x01, 0xD8, 0x00, 0x1B, 0x00,
  0x03, 0xE0, 0x00, 0x30, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xD8,
  0x00, 0x00, 0x3F, 0xD8, 0x00, 0x00, 0x37, 0xD8, 0x00, 0x00, 0x37, 0xCC,
  0x00, 0x00, 0x77, 0xCC, 0x00, 0x00, 0x67, 0xCC, 0x00, 0x00, 0x67, 0xCE,
  0x00, 0x00, 0xE7, 0xC6, 0x00, 0x00, 0xC7, 0xC6, 0x00, 0x00, 0xC7, 0xC7,
  0x00, 0x00, 0xC7, 0xC3, 0x00, 0x01, 0xC7, 0xC3, 0x00, 0x01, 0x87, 0xC3,
  0x00, 0x01, 0x87, 0xC1, 0x80, 0x03, 0x87, 0xC1, 0x80, 0x03, 0x07, 0xC1,
  0x80, 0x03, 0x07, 0xC1, 0xC0, 0x07, 0x07, 0xC0, 0xC0, 0x06, 0x07, 0xC0,
  0xC0, 0x06, 0x07, 0xC0, 0xE0, 0x06, 0x07, 0xC0, 0x60, 0x0E, 0x07, 0xC0,
  0x60, 0x0C, 0x07, 0xC0, 0x70, 0x0C, 0x07, 0xC0, 0x30, 0x1C, 0x07, 0xC0,
  0x30, 0x18, 0x07, 0xC0, 0x30, 0x18, 0x07, 0xC0, 0x38, 0x38, 0x07, 0xC0,
  0x18, 0x30, 0x07, 0xC0, 0x18, 0x30, 0x07, 0xC0, 0x1C, 0x30, 0x07, 0xC0,
  0x0C, 0x70, 0x07, 0xC0, 0x0C, 0x60, 0x07, 0xC0, 0x0E, 0x60, 0x07, 0xC0,
  0x06, 0xE0, 0x07, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0x60, 0x00, 0x3D, 0xC0, 0x00, 0xF3, 0x00, 0x03, 0xCC, 0x00, 0x0F,
  0x18, 0x00, 0x3C, 0x60, 0x00, 0xF1, 0xC0, 0x03, 0xC3, 0x00, 0x0F, 0x0E,
  0x00, 0x3C, 0x18, 0x00, 0xF0, 0x60, 0x03, 0xC0, 0xC0, 0x0F, 0x03, 0x00,
  0x3C, 0x0E, 0x00, 0xF0, 0x18, 0x03, 0xC0, 0x70, 0x0F, 0x00, 0xC0, 0x3C,
  0x03, 0x80, 0xF0, 0x06, 0x03, 0xC0, 0x18, 0x0F, 0x00, 0x30, 0x3C, 0x00,
  0xC0, 0xF0, 0x03, 0x83, 0xC0, 0x06, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x30,
  0xF0, 0x00, 0xE3, 0xC0, 0x01, 0x8F, 0x00, 0x06, 0x3C, 0x00, 0x1C, 0xF0,
  0x00, 0x33, 0xC0, 0x00, 0xEF, 0x00, 0x01, 0xBC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x00,
  0xE0, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x00, 0xE0, 0x60,
  0x00, 0x18, 0x38, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x70, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x03,
  0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x38, 0x0E, 0x00,
  0x1C, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x07, 0x80, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0C, 0x03,
  0xE3, 0x00, 0x3C, 0xC0, 0x03, 0xB0, 0x00, 0xEC, 0x00, 0x1B, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x6C, 0x00,
  0x1B, 0x00, 0x0E, 0xC0, 0x07, 0x30, 0x03, 0xCC, 0x01, 0xE3, 0xFF, 0xF0,
  0xFF, 0xF0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0x1C, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x18, 0x38,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E,
  0x70, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x06, 0x60, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x06, 0x70, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x06, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x07, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0xC0, 0x3E, 0x0C, 0x00, 0x70, 0xC0, 0x03, 0x8C,
  0x00, 0x38, 0xC0, 0x01, 0x8C, 0x00, 0x1C, 0xC0, 0x00, 0xCC, 0x00, 0x0C,
  0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00,
  0xCC, 0x00, 0x1C, 0xC0, 0x01, 0xCC, 0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00,
  0x30, 0xC0, 0x0F, 0x0C, 0x01, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xC0,
  0xE0, 0x0C, 0x06, 0x00, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0C,
  0x03, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xE0,
  0xC0, 0x06, 0x0C, 0x00, 0x70, 0xC0, 0x03, 0x0C, 0x00, 0x38, 0xC0, 0x03,
  0x8C, 0x00, 0x1C, 0xC0, 0x01, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xEC, 0x00,
  0x07, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x7E, 0x3F, 0x1E, 0x00, 0x63, 0x80,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x03, 0x90, 0x00, 0xF3, 0x00, 0x3C, 0x7F, 0xFF, 0x07, 0xFF, 0x80,
  0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8,
  0x00, 0x07, 0x60, 0x00, 0x1D, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x8E, 0x00,
  0x0C, 0x1C, 0x00, 0x70, 0x78, 0x07, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x38, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x1C, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x0C, 0x00, 0x60, 0x0E, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x06, 0x00, 0xC0, 0x07, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x81, 0x80,
  0x03, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0x83, 0x80, 0x01, 0x83, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC7, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0x00,
  0x01, 0x98, 0x00, 0x07, 0x00, 0x00, 0xCE, 0x00, 0x03, 0x80, 0x00, 0xE7,
  0x00, 0x03, 0x60, 0x00, 0x71, 0x80, 0x01, 0xB0, 0x00, 0x30, 0xC0, 0x00,
  0xD8, 0x00, 0x18, 0x60, 0x00, 0x6C, 0x00, 0x0C, 0x38, 0x00, 0x36, 0x00,
  0x0E, 0x1C, 0x00, 0x3B, 0x80, 0x07, 0x06, 0x00, 0x19, 0xC0, 0x03, 0x03,
  0x00, 0x0C, 0x60, 0x01, 0x81, 0x80, 0x06, 0x30, 0x00, 0xC0, 0xE0, 0x03,
  0x18, 0x00, 0xE0, 0x70, 0x03, 0x8C, 0x00, 0x70, 0x18, 0x01, 0x87, 0x00,
  0x30, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x06, 0x00, 0x60, 0xC0, 0x1C, 0x03,
  0x80, 0x30, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x30, 0x06, 0x00, 0x60, 0x18,
  0x1C, 0x03, 0x00, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x1C, 0x06, 0x03, 0x01,
  0xC0, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x03, 0x03, 0x80, 0xC0, 0x60, 0x01,
  0x81, 0x80, 0x70, 0x30, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x00, 0x70, 0x60,
  0x0C, 0x1C, 0x00, 0x38, 0x30, 0x06, 0x0C, 0x00, 0x0C, 0x38, 0x03, 0x06,
  0x00, 0x06, 0x18, 0x01, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x63, 0x80, 0x01,
  0xC6, 0x00, 0x31, 0xC0, 0x00, 0xE3, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x80,
  0x0C, 0x60, 0x00, 0x19, 0x80, 0x07, 0x30, 0x00, 0x0C, 0xC0, 0x01, 0xB8,
  0x00, 0x07, 0x60, 0x00, 0xDC, 0x00, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x00,
  0xD8, 0x00, 0x36, 0x00, 0x00, 0x78, 0x00, 0x1B, 0x00, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x73, 0x00, 0x06, 0x30, 0x00, 0xE3, 0x80, 0x0C, 0x18,
  0x01, 0xC1, 0xC0, 0x1C, 0x0C, 0x01, 0x80, 0xC0, 0x38, 0x0E, 0x03, 0x00,
  0x60, 0x30, 0x06, 0x07, 0x00, 0x70, 0x60, 0x03, 0x0E, 0x00, 0x30, 0xC0,
  0x03, 0x8C, 0x00, 0x19, 0xC0, 0x01, 0x98, 0x00, 0x0D, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x01, 0xD8, 0x00, 0x19, 0x80, 0x01, 0x9C, 0x00, 0x38, 0xC0, 0x03,
  0x0C, 0x00, 0x70, 0xE0, 0x06, 0x06, 0x00, 0x60, 0x60, 0x0E, 0x07, 0x00,
  0xC0, 0x30, 0x1C, 0x03, 0x01, 0x80, 0x38, 0x18, 0x01, 0x83, 0x80, 0x1C,
  0x30, 0x01, 0xC7, 0x00, 0x0C, 0x60, 0x00, 0xE6, 0x00, 0x0E, 0xE0, 0x00,
  0x6C, 0x00, 0x07, 0xE0, 0x00, 0x3B, 0x00, 0x03, 0x98, 0x00, 0x1C, 0xE0,
  0x00, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x70, 0xE0, 0x03, 0x03, 0x00, 0x18,
  0x18, 0x01, 0xC0, 0xE0, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x07, 0x00, 0xE0,
  0x30, 0x03, 0x01, 0x80, 0x18, 0x1C, 0x00, 0xE0, 0xC0, 0x03, 0x06, 0x00,
  0x18, 0x70, 0x00, 0xE3, 0x00, 0x03, 0x18, 0x00, 0x19, 0xC0, 0x00, 0xEC,
  0x00, 0x03, 0x60, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x18, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x70, 0x00,
  0x06, 0x60, 0x00, 0x18, 0xE0, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x01,
  0x81, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x07, 0x00, 0x38, 0x06, 0x00, 0x60,
  0x0E, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x1C, 0x0E, 0x00, 0x18, 0x18, 0x00,
  0x38, 0x70, 0x00, 0x30, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x6E, 0x00, 0x00,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x07, 0xF8, 0x1F, 0xFF,
  0x06, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0xFE, 0x07, 0xFF, 0x0F, 0x81, 0x8E, 0x00, 0xCE, 0x00,
  0x6E, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xEC, 0x00, 0x76, 0x00, 0x7B, 0x80, 0x2C,
  0xE0, 0x36, 0x7C, 0x73, 0x0F, 0xF1, 0x80, 0xC0, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE1, 0xFC, 0x0E, 0x7F,
  0xF0, 0xE6, 0x07, 0x8E, 0xC0, 0x1C, 0xF8, 0x01, 0xCF, 0x00, 0x0C, 0xF0,
  0x00, 0xEF, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0x6F, 0x00,
  0x06, 0xF0, 0x00, 0xEF, 0x00, 0x0C, 0xF8, 0x01, 0xCC, 0xC0, 0x18, 0xCE,
  0x07, 0x8C, 0x7F, 0xF0, 0xC3, 0xFE, 0x00, 0x03, 0x00, 0x01, 0xFF, 0x07,
  0xFE, 0x0F, 0x02, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x01, 0x0F,
  0xDE, 0x03, 0xFE, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x03, 0xF8, 0x70, 0xFF, 0xC7, 0x1E, 0x06, 0x71,
  0xC0, 0x37, 0x38, 0x01, 0xF3, 0x00, 0x1F, 0x70, 0x00, 0xF6, 0x00, 0x0F,
  0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x0F, 0x60, 0x00, 0xF7,
  0x00, 0x0F, 0x30, 0x01, 0xF3, 0x80, 0x37, 0x1C, 0x06, 0x30, 0xFB, 0xE3,
  0x07, 0xF8, 0x30, 0x0C, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xC0, 0xE0,
  0x60, 0x1C, 0x38, 0x03, 0x0C, 0x00, 0x67, 0x00, 0x19, 0x80, 0x06, 0x60,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x11, 0xE0, 0x18, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x1C, 0x00, 0x01, 0xFC,
  0x0F, 0xF0, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x07, 0xFE,
  0x3F, 0xF8, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0xF8, 0x21,
  0xFF, 0xCC, 0x78, 0x1D, 0x9C, 0x01, 0xB3, 0x80, 0x1E, 0xE0, 0x01, 0xDC,
  0x00, 0x3B, 0x00, 0x07, 0x60, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xEC, 0x00, 0x1D, 0x80,
  0x03, 0xB8, 0x00, 0xF3, 0x00, 0x16, 0x70, 0x06, 0xC7, 0x01, 0x98, 0x7D,
  0xE3, 0x07, 0xF8, 0x60, 0x1C, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xE4, 0x00, 0x78, 0xF0, 0x3E, 0x0F, 0xFF,
  0x80, 0x7F, 0x80, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x1F,
  0xC3, 0x9F, 0xF8, 0xEE, 0x07, 0x3B, 0x00, 0xEF, 0x80, 0x3B, 0xC0, 0x06,
  0xF0, 0x01, 0xBC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1C, 0x6F, 0xFE, 0x60, 0x00, 0x00, 0x00, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60,
  0x0E, 0x0F, 0x0F, 0x0E, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x9C, 0xF8, 0xF0,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x1D, 0xC0, 0x0C, 0xE0, 0x0E,
  0x70, 0x0E, 0x38, 0x06, 0x1C, 0x07, 0x0E, 0x03, 0x07, 0x03, 0x03, 0x83,
  0x81, 0xC1, 0x80, 0xE1, 0xC0, 0x71, 0xC0, 0x38, 0xC0, 0x1C, 0xF0, 0x0E,
  0x78, 0x07, 0x6E, 0x03, 0xF3, 0x01, 0xF1, 0x80, 0xF0, 0xE0, 0x78, 0x30,
  0x38, 0x1C, 0x1C, 0x06, 0x0E, 0x03, 0x07, 0x01, 0xC3, 0x80, 0x61, 0xC0,
  0x38, 0xE0, 0x0C, 0x70, 0x06, 0x38, 0x03, 0x9C, 0x00, 0xCE, 0x00, 0x77,
  0x00, 0x1B, 0x80, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC3, 0xF8,
  0x0F, 0xE3, 0x1F, 0xF0, 0x7F, 0xCC, 0xC0, 0xE3, 0x03, 0xB2, 0x01, 0x98,
  0x06, 0xD8, 0x07, 0x40, 0x1F, 0x40, 0x0F, 0x00, 0x3F, 0x00, 0x38, 0x00,
  0xF8, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x0E, 0x00, 0x3E,
  0x00, 0x38, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0x80, 0x0F, 0x80,
  0x0E, 0x00, 0x3E, 0x00, 0x38, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0xE0, 0x03,
  0x80, 0x0F, 0x80, 0x0E, 0x00, 0x3E, 0x00, 0x38, 0x00, 0xF8, 0x00, 0xE0,
  0x03, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x0E, 0x00, 0x3E, 0x00, 0x38, 0x00,
  0xF8, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x0E, 0x00, 0x3E,
  0x00, 0x38, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0x80, 0x0F, 0x80,
  0x0E, 0x00, 0x3E, 0x00, 0x38, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0xE0, 0x03,
  0x80, 0x0C, 0xC1, 0xFC, 0x31, 0xFF, 0x8C, 0xE0, 0x73, 0x30, 0x0E, 0xD8,
  0x03, 0xB4, 0x00, 0x6F, 0x00, 0x1B, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1E, 0x07,
  0x03, 0x80, 0x38, 0x38, 0x01, 0xC7, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00,
  0x0E, 0x60, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x06,
  0xE0, 0x00, 0x6E, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0E, 0x60, 0x00,
  0xC7, 0x00, 0x0C, 0x30, 0x01, 0xC3, 0x80, 0x38, 0x1C, 0x07, 0x80, 0xFF,
  0xF0, 0x07, 0xFC, 0x00, 0x07, 0x00, 0xC1, 0xFC, 0x0C, 0x7F, 0xF0, 0xC6,
  0x07, 0x8C, 0xC0, 0x18, 0xD8, 0x01, 0xCD, 0x80, 0x0C, 0xD0, 0x00, 0xEF,
  0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0x6F, 0x00, 0x06, 0xF0,
  0x00, 0xEF, 0x00, 0x0C, 0xF8, 0x01, 0xCE, 0xC0, 0x18, 0xEE, 0x07, 0x8E,
  0x7F, 0xF0, 0xE3, 0xFC, 0x0E, 0x06, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF8, 0x21, 0xFF, 0xC4, 0x78,
  0x19, 0x8E, 0x01, 0xB3, 0x80, 0x1E, 0x60, 0x03, 0xDC, 0x00, 0x3B, 0x00,
  0x07, 0x60, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xEC, 0x00, 0x1D, 0x80, 0x03, 0xB8, 0x00,
  0xF3, 0x80, 0x16, 0x70, 0x06, 0xC7, 0x01, 0x98, 0x7D, 0xE3, 0x07, 0xF8,
  0x60, 0x1C, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0xC1, 0xFC, 0x7F, 0xC6, 0x1C, 0xC0, 0xC8, 0x0D, 0x80, 0xD0, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x00, 0x0F, 0xFC, 0x1F, 0xFE, 0x38, 0x06, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x80, 0x0E, 0xE0, 0x1C, 0xFF, 0xF8, 0x3F, 0xF0, 0x07, 0x00, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3F, 0xFF,
  0xFF, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0x07, 0xF0,
  0x18, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3D, 0x80, 0x0B, 0x60, 0x06, 0xDC, 0x03, 0x33, 0x81, 0xCC, 0xFF,
  0xE3, 0x1F, 0xF0, 0xC0, 0x60, 0x00, 0xE0, 0x00, 0xEC, 0x00, 0x1D, 0x80,
  0x03, 0x30, 0x00, 0x67, 0x00, 0x1C, 0x60, 0x03, 0x8C, 0x00, 0x61, 0x80,
  0x0C, 0x38, 0x03, 0x83, 0x00, 0x70, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0xC0,
  0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0xC1,
  0xC0, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0E, 0x38, 0x00, 0xC6,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x73, 0x00, 0x06, 0xC0, 0x00, 0xD8,
  0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x76, 0x00, 0x6C, 0x00, 0xCC, 0x00, 0xD8, 0x01,
  0x98, 0x01, 0xB0, 0x03, 0x30, 0x03, 0x60, 0x0E, 0x70, 0x06, 0x60, 0x18,
  0x60, 0x1C, 0xC0, 0x30, 0xC0, 0x31, 0x80, 0x61, 0x80, 0x63, 0x00, 0xC3,
  0x80, 0xC7, 0x03, 0x83, 0x03, 0x86, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x38, 0x30, 0x70, 0xE0, 0x30,
  0xE0, 0x61, 0x80, 0x61, 0x80, 0xC3, 0x00, 0xC3, 0x01, 0x86, 0x01, 0xC6,
  0x03, 0x1C, 0x01, 0x8C, 0x07, 0x30, 0x03, 0x38, 0x06, 0x60, 0x06, 0x60,
  0x0C, 0xC0, 0x0C, 0xC0, 0x19, 0x80, 0x1D, 0x80, 0x37, 0x00, 0x1B, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x00, 0x60, 0x01, 0xDC,
  0x00, 0x63, 0x00, 0x38, 0xE0, 0x0C, 0x18, 0x03, 0x06, 0x01, 0xC1, 0xC0,
  0x60, 0x30, 0x38, 0x0E, 0x0C, 0x01, 0x87, 0x00, 0x71, 0x80, 0x0C, 0xE0,
  0x03, 0xB0, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x0E, 0xC0, 0x03, 0x38, 0x01, 0xC6, 0x00, 0x61,
  0x80, 0x38, 0x70, 0x0C, 0x0C, 0x07, 0x03, 0x81, 0x80, 0x60, 0x60, 0x1C,
  0x38, 0x03, 0x0C, 0x00, 0xE7, 0x00, 0x19, 0x80, 0x07, 0xE0, 0x01, 0xC0,
  0xE0, 0x00, 0xFC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x67, 0x00, 0x1C,
  0xE0, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x38, 0x03, 0x83, 0x00, 0x60,
  0x60, 0x0C, 0x0C, 0x01, 0x81, 0xC0, 0x70, 0x18, 0x0C, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x0E, 0x0E, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00,
  0x71, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x38, 0x00,
  0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x01, 0x3C,
  0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0x00, 0x7F, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x01, 0xFE, 0x00, 0x7E, 0x7C, 0x07, 0x80, 0xF8, 0xF8, 0x01, 0xFF, 0x40,
  0x03, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 44, 13, 4, -44 },
  { 23, 11, 16, 19, 4, -44 },
  { 45, 25, 44, 27, 1, -44 },
  { 183, 21, 51, 25, 2, -47 },
  { 317, 31, 46, 37, 3, -45 },
  { 496, 23, 46, 25, 2, -45 },
  { 629, 3, 16, 11, 4, -44 },
  { 635, 11, 54, 17, 3, -44 },
  { 710, 12, 54, 17, 2, -44 },
  { 791, 16, 17, 22, 3, -47 },
  { 825, 21, 28, 25, 2, -36 },
  { 899, 6, 14, 12, 2, -6 },
  { 910, 13, 2, 16, 2, -18 },
  { 914, 4, 5, 12, 4, -5 },
  { 917, 19, 44, 21, 1, -44 },
  { 1022, 19, 45, 25, 3, -45 },
  { 1129, 11, 44, 25, 5, -44 },
  { 1190, 20, 45, 25, 2, -45 },
  { 1303, 20, 46, 25, 2, -45 },
  { 1418, 23, 45, 25, 1, -45 },
  { 1548, 19, 45, 25, 3, -44 },
  { 1655, 19, 46, 25, 3, -45 },
  { 1765, 19, 44, 25, 3, -44 },
  { 1870, 21, 46, 25, 2, -45 },
  { 1991, 20, 46, 25, 2, -45 },
  { 2106, 4, 33, 12, 4, -33 },
  { 2123, 6, 41, 12, 2, -33 },
  { 2154, 21, 26, 25, 2, -35 },
  { 2223, 21, 16, 25, 2, -30 },
  { 2265, 21, 26, 25, 2, -35 },
  { 2334, 15, 45, 17, 1, -45 },
  { 2419, 32, 51, 38, 3, -45 },
  { 2623, 24, 44, 24, 0, -44 },
  { 2755, 20, 44, 27, 5, -44 },
  { 2865, 22, 46, 26, 3, -45 },
  { 2992, 22, 44, 30, 5, -44 },
  { 3113, 16, 44, 24, 5, -44 },
  { 3201, 16, 44, 22, 5, -44 },
  { 3289, 26, 46, 33, 3, -45 },
  { 3439, 21, 44, 31, 5, -44 },
  { 3555, 10, 44, 14, 2, -44 },
  { 3610, 10, 55, 12, -3, -44 },
  { 3679, 19, 44, 24, 5, -44 },
  { 3784, 15, 44, 22, 5, -44 },
  { 3867, 32, 44, 41, 5, -44 },
  { 4043, 22, 44, 32, 5, -44 },
  { 4164, 26, 46, 32, 3, -45 },
  { 4314, 18, 44, 25, 5, -44 },
  { 4413, 26, 56, 32, 3, -45 },
  { 4595, 20, 44, 26, 5, -44 },
  { 4705, 19, 46, 24, 3, -45 },
  { 4815, 21, 44, 21, 0, -44 },
  { 4931, 22, 45, 31, 4, -44 },
  { 5055, 24, 44, 24, 0, -44 },
  { 5187, 41, 44, 41, 0, -44 },
  { 5413, 20, 44, 21, 1, -44 },
  { 5523, 21, 44, 21, 0, -44 },
  { 5639, 17, 44, 21, 2, -44 },
  { 5733, 12, 54, 19, 5, -44 },
  { 5814, 19, 44, 21, 1, -44 },
  { 5919, 12, 54, 19, 2, -44 },
  { 6000, 23, 21, 25, 1, -44 },
  { 6061, 25, 2, 25, 0, 6 },
  { 6068, 10, 9, 14, 2, -47 },
  { 6080, 17, 34, 23, 2, -33 },
  { 6153, 20, 48, 27, 4, -47 },
  { 6273, 16, 34, 20, 3, -33 },
  { 6341, 20, 48, 27, 3, -47 },
  { 6461, 18, 34, 24, 3, -33 },
  { 6538, 14, 47, 14, 1, -47 },
  { 6621, 19, 48, 27, 3, -33 },
  { 6735, 18, 47, 26, 4, -47 },
  { 6841, 4, 45, 11, 4, -45 },
  { 6864, 8, 60, 11, 0, -45 },
  { 6924, 17, 47, 21, 4, -47 },
  { 7024, 3, 47, 11, 4, -47 },
  { 7042, 30, 33, 39, 4, -33 },
  { 7166, 18, 33, 26, 4, -33 },
  { 7241, 20, 34, 26, 3, -33 },
  { 7326, 20, 48, 27, 4, -33 },
  { 7446, 19, 48, 27, 3, -33 },
  { 7560, 12, 33, 17, 4, -33 },
  { 7610, 16, 34, 20, 2, -33 },
  { 7678, 12, 42, 14, 1, -41 },
  { 7741, 18, 34, 26, 4, -33 },
  { 7818, 19, 33, 19, 0, -33 },
  { 7897, 31, 33, 33, 1, -33 },
  { 8025, 18, 33, 20, 1, -33 },
  { 8100, 19, 48, 20, 1, -33 },
  { 8214, 13, 33, 17, 2, -33 },
  { 8268, 16, 54, 22, 3, -44 },
  { 8376, 2, 62, 24, 11, -47 },
  { 8392, 15, 54, 22, 3, -44 },
  { 8494, 21, 6, 25, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight62pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT62PT7B_H_
