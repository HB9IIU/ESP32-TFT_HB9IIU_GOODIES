#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT40PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x06, 0x08, 0x06, 0x08, 0x06,
  0x18, 0x04, 0x18, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x04,
  0x10, 0x7F, 0xFF, 0x0C, 0x10, 0x08, 0x30, 0x08, 0x30, 0x08, 0x30, 0x08,
  0x20, 0x08, 0x20, 0x08, 0x20, 0x18, 0x20, 0xFF, 0xFC, 0xFF, 0xFC, 0x10,
  0x60, 0x10, 0x60, 0x10, 0x60, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x30,
  0x40, 0x30, 0x40, 0x30, 0xC0, 0x02, 0x00, 0x08, 0x00, 0xFE, 0x0F, 0xBE,
  0x32, 0x11, 0x88, 0x04, 0x20, 0x30, 0x80, 0xC2, 0x03, 0x08, 0x04, 0x20,
  0x10, 0x80, 0x62, 0x00, 0xE8, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x09,
  0xC0, 0x21, 0x80, 0x82, 0x02, 0x0C, 0x08, 0x30, 0x20, 0xC0, 0x83, 0x02,
  0x08, 0x08, 0x68, 0x23, 0x3F, 0xF8, 0x1F, 0x80, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x38, 0x02, 0x06, 0x40, 0x20, 0x46, 0x06, 0x0C, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x30, 0xC0, 0x83, 0x08, 0x08, 0x30, 0x80, 0x83, 0x18, 0x08,
  0x31, 0x00, 0x83, 0x10, 0x08, 0x33, 0x10, 0x83, 0x23, 0xC8, 0x22, 0x46,
  0xC2, 0x64, 0x24, 0x64, 0xC2, 0x6C, 0x48, 0x33, 0x8C, 0x83, 0x00, 0x88,
  0x30, 0x08, 0x83, 0x01, 0x88, 0x30, 0x10, 0x83, 0x01, 0x08, 0x30, 0x30,
  0x83, 0x02, 0x08, 0x30, 0x20, 0xC2, 0x06, 0x04, 0x20, 0x40, 0x66, 0x0C,
  0x03, 0xC0, 0x07, 0x00, 0x3B, 0x00, 0x43, 0x00, 0x82, 0x03, 0x04, 0x06,
  0x08, 0x0C, 0x10, 0x08, 0x20, 0x10, 0xC0, 0x21, 0x80, 0x62, 0x00, 0x4C,
  0x00, 0xF0, 0x00, 0xC0, 0x07, 0x80, 0x09, 0x00, 0x23, 0x00, 0xC3, 0x09,
  0x02, 0x16, 0x06, 0x2C, 0x04, 0xD8, 0x0D, 0xB0, 0x0A, 0x60, 0x1C, 0xC0,
  0x18, 0x80, 0x71, 0x81, 0xB1, 0x86, 0x21, 0xF8, 0x60, 0xFF, 0xE0, 0x02,
  0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x40, 0xC1, 0x83, 0x02,
  0x06, 0x04, 0x0C, 0x08, 0x18, 0x18, 0x81, 0x81, 0x83, 0x03, 0x06, 0x06,
  0x0C, 0x08, 0x18, 0x30, 0x20, 0x40, 0x81, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0x81, 0x02, 0x0C, 0x18, 0x20, 0x41, 0x82, 0x0C, 0x18, 0x60, 0x83,
  0x00, 0x0C, 0x03, 0x00, 0x42, 0x11, 0x77, 0x83, 0x00, 0xE0, 0x48, 0x21,
  0x18, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x6D, 0xB5,
  0xB4, 0x80, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x00, 0x0F, 0x01, 0xF8, 0x30, 0xC6, 0x06, 0x60, 0x64, 0x02, 0x40,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x34, 0x02, 0x60, 0x26, 0x06, 0x30, 0x43, 0x9C, 0x0F, 0x80, 0x02, 0x0C,
  0x79, 0xB6, 0x78, 0xE1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0x1F, 0x07, 0xB8, 0xC0, 0xC0, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x08, 0x00, 0xFF, 0xF0, 0x0F, 0x81, 0xEF, 0x38,
  0x18, 0x80, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x04, 0x03, 0xC0, 0x3E, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0xC1, 0xC7, 0xFC, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x05, 0x00, 0x1A, 0x00, 0x24, 0x00, 0xC8, 0x01, 0x10, 0x02,
  0x20, 0x08, 0x40, 0x10, 0x80, 0x61, 0x00, 0x82, 0x03, 0x04, 0x04, 0x08,
  0x18, 0x10, 0x20, 0x20, 0xC0, 0x41, 0x00, 0x86, 0x01, 0x08, 0x02, 0x1F,
  0xFF, 0xC0, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x7F, 0xE7, 0xFE, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0x8E, 0x1C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x6C, 0x1C, 0xFF, 0x00, 0x03,
  0xC0, 0xFE, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x30, 0xDF, 0xCB, 0x06, 0xA0, 0x2C, 0x03, 0xC0,
  0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x40,
  0x36, 0x02, 0x60, 0x63, 0x0C, 0x1F, 0x80, 0x20, 0xFF, 0xFF, 0xFF, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x30, 0x00, 0x07, 0x80, 0x7F, 0x83, 0x03, 0x08, 0x04, 0x60,
  0x19, 0x80, 0x66, 0x01, 0x98, 0x06, 0x60, 0x18, 0x80, 0x43, 0x03, 0x06,
  0x18, 0x0C, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0x30, 0x30, 0x60, 0x80, 0xC6,
  0x01, 0x90, 0x02, 0x40, 0x0B, 0x00, 0x3C, 0x00, 0xD0, 0x02, 0x40, 0x09,
  0x80, 0x62, 0x01, 0x0E, 0x1C, 0x0F, 0xC0, 0x1F, 0x03, 0xB8, 0x60, 0xC4,
  0x06, 0xC0, 0x6C, 0x02, 0x80, 0x28, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x3C, 0x03, 0xC0, 0x76, 0x07, 0x31, 0xB1, 0xF3, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x88,
  0x30, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x6D, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0D, 0xB6, 0xB6, 0x90, 0x00, 0x0C, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x1C,
  0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x7C, 0x77, 0xA0,
  0xC0, 0x30, 0x18, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x20,
  0x30, 0x30, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x06, 0x03, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xF0, 0x01,
  0x80, 0xC0, 0x18, 0x01, 0x01, 0x80, 0x0C, 0x08, 0x00, 0x30, 0xC0, 0x00,
  0x84, 0x00, 0x04, 0x60, 0x10, 0x32, 0x07, 0xE0, 0x90, 0x61, 0x04, 0x82,
  0x08, 0x2C, 0x10, 0x41, 0x61, 0x82, 0x0F, 0x08, 0x10, 0x78, 0x41, 0x83,
  0xC2, 0x0C, 0x1E, 0x10, 0x60, 0xB0, 0x83, 0x05, 0x84, 0x18, 0x2C, 0x30,
  0xC1, 0x61, 0x86, 0x19, 0x04, 0x58, 0x88, 0x3E, 0x78, 0x40, 0x40, 0x83,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x08, 0x00, 0x7F, 0x80, 0x00, 0x60, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0x40, 0x06, 0x40, 0x06,
  0x60, 0x04, 0x60, 0x04, 0x20, 0x0C, 0x20, 0x0C, 0x20, 0x08, 0x30, 0x08,
  0x30, 0x18, 0x10, 0x18, 0x10, 0x18, 0x18, 0x1F, 0xF8, 0x10, 0x08, 0x30,
  0x08, 0x30, 0x0C, 0x20, 0x0C, 0x20, 0x04, 0x60, 0x04, 0x60, 0x06, 0x40,
  0x06, 0x40, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xFC, 0x07, 0xFE, 0x30, 0x19,
  0x80, 0x6C, 0x03, 0x60, 0x0B, 0x00, 0x58, 0x02, 0xC0, 0x16, 0x00, 0xB0,
  0x0D, 0x80, 0x4C, 0x06, 0x7F, 0xE3, 0xFF, 0x18, 0x0C, 0xC0, 0x36, 0x00,
  0xB0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x01, 0xB0, 0x1D, 0x87, 0xCF, 0xF8, 0x00, 0x01, 0xF0, 0x1E, 0xF0, 0xC0,
  0x46, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x83, 0x03, 0xF8, 0xF8, 0x03,
  0xFE, 0x0C, 0x0E, 0x30, 0x1C, 0xC0, 0x33, 0x00, 0x6C, 0x01, 0xB0, 0x02,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x2C, 0x01, 0xB0, 0x06, 0xC0, 0x13, 0x00, 0xCC, 0x06, 0x30, 0xF0, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF, 0xBF, 0xF6, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x07, 0xFE, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x01, 0xFC, 0x03,
  0xEF, 0x83, 0x00, 0x43, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x7F, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x34, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0x40, 0x03,
  0x30, 0x01, 0x8C, 0x00, 0xC7, 0x00, 0x61, 0xC0, 0x70, 0x3F, 0xF0, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0C, 0xFE, 0xF8, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x8F, 0xE0, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0A, 0x37, 0xC0,
  0xC0, 0x16, 0x01, 0xB0, 0x19, 0x80, 0xCC, 0x0C, 0x60, 0x43, 0x06, 0x18,
  0x60, 0xC3, 0x06, 0x30, 0x31, 0x01, 0x98, 0x0C, 0x80, 0x6C, 0x03, 0xF0,
  0x1C, 0x80, 0xC6, 0x06, 0x10, 0x30, 0xC1, 0x86, 0x0C, 0x18, 0x60, 0xC3,
  0x03, 0x18, 0x18, 0xC0, 0x66, 0x03, 0x30, 0x0D, 0x80, 0x6C, 0x01, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF,
  0xC0, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x40, 0x00, 0xFA,
  0x00, 0x07, 0xF8, 0x00, 0x2F, 0x40, 0x03, 0x7A, 0x00, 0x1B, 0xD8, 0x00,
  0x9E, 0x40, 0x04, 0xF2, 0x00, 0x67, 0x98, 0x02, 0x3C, 0xC0, 0x11, 0xE2,
  0x01, 0x8F, 0x10, 0x0C, 0x78, 0xC0, 0x43, 0xC2, 0x06, 0x1E, 0x10, 0x30,
  0xF0, 0xC1, 0x07, 0x82, 0x08, 0x3C, 0x10, 0xC1, 0xE0, 0xC4, 0x0F, 0x06,
  0x20, 0x78, 0x13, 0x03, 0xC0, 0x98, 0x1E, 0x06, 0x80, 0xF0, 0x1C, 0x07,
  0x80, 0xE0, 0x3C, 0x06, 0x01, 0x80, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1D,
  0x00, 0x3F, 0x00, 0x7A, 0x00, 0xF6, 0x01, 0xEC, 0x03, 0xC8, 0x07, 0x98,
  0x0F, 0x10, 0x1E, 0x30, 0x3C, 0x20, 0x78, 0x60, 0xF0, 0x41, 0xE0, 0x83,
  0xC1, 0x87, 0x81, 0x0F, 0x03, 0x1E, 0x02, 0x3C, 0x06, 0x78, 0x04, 0xF0,
  0x0D, 0xE0, 0x1B, 0xC0, 0x17, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x60, 0x03, 0xE0, 0x07, 0xBC, 0x06, 0x03, 0x06, 0x00, 0x83, 0x00, 0x63,
  0x00, 0x11, 0x80, 0x0C, 0x80, 0x06, 0x40, 0x01, 0x60, 0x00, 0xB0, 0x00,
  0x58, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x58, 0x00, 0x24, 0x00, 0x12, 0x00, 0x19,
  0x80, 0x0C, 0xC0, 0x06, 0x20, 0x06, 0x18, 0x03, 0x06, 0x03, 0x01, 0x83,
  0x00, 0x7F, 0x00, 0xFC, 0x0F, 0xF8, 0xC1, 0xCC, 0x06, 0xC0, 0x2C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x2C, 0x06,
  0xC0, 0xCC, 0x78, 0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x03,
  0xE0, 0x07, 0xBC, 0x06, 0x03, 0x06, 0x00, 0x83, 0x00, 0x63, 0x00, 0x11,
  0x80, 0x0C, 0x80, 0x06, 0x40, 0x01, 0x60, 0x00, 0xB0, 0x00, 0x58, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x58, 0x00, 0x24, 0x00, 0x12, 0x00, 0x19, 0x80, 0x0C,
  0xC0, 0x06, 0x20, 0x06, 0x18, 0x03, 0x06, 0x03, 0x01, 0x83, 0x00, 0x7F,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0xFC, 0x07, 0xFC, 0x30, 0x31, 0x80, 0xCC, 0x02,
  0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0x4C,
  0x06, 0x60, 0x33, 0x07, 0x1F, 0xE0, 0xC2, 0x06, 0x18, 0x30, 0xC1, 0x83,
  0x0C, 0x18, 0x60, 0x43, 0x03, 0x18, 0x08, 0xC0, 0x66, 0x01, 0x30, 0x0D,
  0x80, 0x6C, 0x01, 0x80, 0x0F, 0xC3, 0xFF, 0x60, 0x14, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x6C, 0x1C, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x09, 0x00, 0x66, 0x01, 0x8E,
  0x1C, 0x1F, 0xE0, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1A, 0x00, 0x34, 0x00,
  0x4C, 0x00, 0x98, 0x03, 0x10, 0x06, 0x20, 0x08, 0x60, 0x10, 0xC0, 0x60,
  0x80, 0xC1, 0x01, 0x03, 0x02, 0x06, 0x0C, 0x0C, 0x18, 0x08, 0x20, 0x10,
  0x40, 0x31, 0x80, 0x63, 0x00, 0x46, 0x00, 0x88, 0x01, 0x90, 0x03, 0x60,
  0x02, 0xC0, 0x05, 0x00, 0x0A, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x70, 0x03, 0x00, 0x34, 0x00, 0xC0, 0x0D, 0x00, 0x38, 0x03, 0x60,
  0x0E, 0x00, 0x98, 0x06, 0x80, 0x26, 0x01, 0xA0, 0x18, 0x80, 0x68, 0x06,
  0x20, 0x13, 0x01, 0x8C, 0x04, 0xC0, 0x43, 0x03, 0x30, 0x10, 0x40, 0xC4,
  0x0C, 0x10, 0x31, 0x03, 0x06, 0x08, 0x40, 0x81, 0x82, 0x18, 0x20, 0x61,
  0x86, 0x18, 0x08, 0x60, 0x86, 0x02, 0x18, 0x21, 0x80, 0xC4, 0x08, 0x40,
  0x31, 0x03, 0x10, 0x0C, 0xC0, 0xCC, 0x01, 0x30, 0x13, 0x00, 0x4C, 0x04,
  0xC0, 0x1A, 0x01, 0x20, 0x06, 0x80, 0x68, 0x01, 0xA0, 0x1E, 0x00, 0x38,
  0x03, 0x80, 0x0E, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x60, 0x09, 0x00,
  0xCC, 0x06, 0x60, 0x21, 0x03, 0x0C, 0x10, 0x21, 0x81, 0x0C, 0x0C, 0x40,
  0x26, 0x01, 0x30, 0x0D, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x07,
  0x80, 0x24, 0x01, 0x30, 0x18, 0x80, 0x84, 0x0C, 0x30, 0x60, 0x82, 0x04,
  0x30, 0x31, 0x00, 0x98, 0x06, 0xC0, 0x3C, 0x00, 0x80, 0xC0, 0x0E, 0x00,
  0xD0, 0x06, 0xC0, 0x26, 0x03, 0x10, 0x18, 0xC0, 0x86, 0x0C, 0x10, 0x60,
  0xC2, 0x06, 0x30, 0x11, 0x80, 0xC8, 0x06, 0xC0, 0x16, 0x00, 0xE0, 0x07,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x7F, 0xEF, 0xFC,
  0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0F,
  0xFE, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0xFF, 0xFF, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0x01, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x34, 0x00, 0x4C, 0x01, 0x88, 0x02, 0x18, 0x0C, 0x10, 0x10, 0x30,
  0x60, 0x20, 0x80, 0x63, 0x00, 0x44, 0x00, 0xD8, 0x01, 0xC0, 0xFF, 0xFF,
  0x83, 0x06, 0x08, 0x10, 0x20, 0x40, 0x02, 0x07, 0xF8, 0x83, 0x00, 0x30,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x1F, 0x8E, 0x13, 0x02,
  0xC0, 0x50, 0x0A, 0x01, 0xC0, 0x28, 0x0D, 0x01, 0xB0, 0x36, 0x0A, 0x7E,
  0x40, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x82, 0x04, 0xFE, 0x2C, 0x39, 0x40, 0xCC, 0x03, 0x60, 0x1B,
  0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x05, 0x00, 0x38, 0x01, 0xC0,
  0x0A, 0x00, 0x50, 0x02, 0xC0, 0x36, 0x01, 0xB0, 0x09, 0x40, 0xCB, 0x0C,
  0x4F, 0xC0, 0x02, 0x07, 0xF3, 0x80, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x10,
  0x06, 0x01, 0x80, 0x38, 0x47, 0xF0, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x06, 0x18, 0xFC, 0xCC, 0x36,
  0xC0, 0xF6, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xD0, 0x0E, 0xC0, 0xB3, 0x0D, 0x8F, 0xCC, 0x04, 0x01, 0xF8, 0x30, 0xC6,
  0x04, 0x40, 0x64, 0x02, 0xC0, 0x2C, 0x03, 0x80, 0x38, 0x03, 0xFF, 0xF8,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x38, 0x61, 0xFC, 0x01, 0x03, 0xF0, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x0F, 0xF0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x02, 0x01, 0xF9, 0x30, 0x56,
  0x03, 0x40, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0x80, 0x1C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x40, 0x36,
  0x05, 0x30, 0xD1, 0xF9, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x24, 0x0E, 0x7F, 0xC0, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x86, 0x13, 0xF2, 0xC3, 0x50, 0x2C,
  0x07, 0x80, 0xF0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0xFC, 0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x80, 0x18, 0xC6, 0x00,
  0x00, 0x00, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x23, 0x7B, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x38, 0x1A,
  0x04, 0x83, 0x21, 0x88, 0x42, 0x30, 0x88, 0x26, 0x0B, 0xC2, 0xB0, 0xC4,
  0x31, 0x88, 0x22, 0x0C, 0x81, 0x20, 0x48, 0x1A, 0x02, 0x80, 0xE0, 0x10,
  0xFF, 0xFF, 0xFF, 0xFC, 0x04, 0x02, 0x13, 0xF1, 0xFA, 0x86, 0x43, 0x50,
  0x78, 0x3C, 0x0E, 0x07, 0x80, 0xC0, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80,
  0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00,
  0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01,
  0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x40, 0x02, 0x13, 0xF2,
  0xC3, 0x50, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x06, 0x00, 0xFE, 0x0C, 0x18, 0xC0, 0x44, 0x03,
  0x60, 0x1B, 0x00, 0x58, 0x02, 0x80, 0x14, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x58, 0x02, 0xC0, 0x12, 0x01, 0x90, 0x0C, 0xC0,
  0xC3, 0x0E, 0x0F, 0xC0, 0x02, 0x09, 0xFC, 0xB0, 0xEA, 0x06, 0xC0, 0x3C,
  0x03, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x2A, 0x06, 0x90, 0xC8,
  0xF8, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x00, 0x02, 0x01, 0xF9, 0x30, 0xD6, 0x07, 0x60, 0x34, 0x03,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x40, 0x36, 0x05, 0x30, 0xD1, 0xF9,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x9F, 0x62, 0x85, 0x0C, 0x18, 0x30, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x00, 0x02, 0x0F, 0xF7,
  0x05, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x06, 0x03, 0xC1, 0x9F,
  0xC0, 0x20, 0x40, 0x81, 0x02, 0x1F, 0xC8, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x3C,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78,
  0x17, 0x02, 0xB0, 0x93, 0xE2, 0xC0, 0x34, 0x03, 0x40, 0x36, 0x02, 0x60,
  0x62, 0x06, 0x20, 0x62, 0x04, 0x30, 0x41, 0x0C, 0x10, 0xC1, 0x08, 0x18,
  0x81, 0x98, 0x09, 0x80, 0x90, 0x0D, 0x00, 0xF0, 0x07, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x30, 0x1A, 0x01, 0x80, 0x90, 0x1C, 0x04, 0xC0, 0xA0, 0x26,
  0x05, 0x83, 0x10, 0x2C, 0x18, 0x83, 0x20, 0x86, 0x19, 0x04, 0x30, 0x88,
  0x20, 0x84, 0x63, 0x04, 0x23, 0x18, 0x23, 0x08, 0x81, 0x98, 0x44, 0x0C,
  0x82, 0x60, 0x24, 0x1B, 0x01, 0x20, 0xD0, 0x0B, 0x02, 0x80, 0x78, 0x14,
  0x01, 0x80, 0xE0, 0x0C, 0x07, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x68, 0x09,
  0x83, 0x10, 0x63, 0x08, 0x23, 0x06, 0x40, 0x58, 0x0A, 0x01, 0xC0, 0x18,
  0x07, 0x00, 0xB0, 0x36, 0x04, 0x41, 0x8C, 0x20, 0x8C, 0x19, 0x01, 0x60,
  0x3C, 0x02, 0x40, 0x1B, 0x00, 0x98, 0x04, 0x40, 0x62, 0x03, 0x18, 0x10,
  0xC0, 0x82, 0x0C, 0x10, 0x60, 0xC2, 0x06, 0x10, 0x11, 0x80, 0x8C, 0x06,
  0x40, 0x32, 0x00, 0xB0, 0x05, 0x80, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x7C, 0x01, 0x80, 0x00, 0x7F, 0x80, 0x80, 0x40, 0x60, 0x20, 0x30,
  0x18, 0x08, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x60,
  0x30, 0x10, 0x18, 0x0F, 0xF8, 0x00, 0x40, 0xF0, 0x60, 0x30, 0x0C, 0x03,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x18, 0x3C, 0x0F, 0x00, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x01, 0x80, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x40, 0x10, 0x06, 0x00, 0xF0, 0x3C, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06,
  0x0F, 0x00, 0x3C, 0x05, 0xBC, 0x18, 0x1F, 0xA0, 0x08,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 29, 8, 3, -29 },
  { 9, 7, 11, 12, 3, -29 },
  { 19, 16, 29, 17, 1, -29 },
  { 77, 14, 32, 16, 1, -30 },
  { 133, 20, 29, 24, 2, -29 },
  { 206, 15, 29, 16, 1, -29 },
  { 261, 1, 11, 7, 3, -29 },
  { 263, 7, 35, 11, 2, -29 },
  { 294, 7, 35, 11, 2, -29 },
  { 325, 10, 10, 14, 2, -30 },
  { 338, 14, 18, 16, 1, -23 },
  { 370, 3, 9, 7, 2, -4 },
  { 374, 9, 2, 11, 1, -12 },
  { 377, 2, 3, 8, 3, -3 },
  { 378, 12, 29, 13, 1, -29 },
  { 422, 12, 29, 16, 2, -29 },
  { 466, 7, 29, 16, 3, -29 },
  { 492, 12, 29, 16, 2, -29 },
  { 536, 13, 29, 16, 1, -29 },
  { 584, 15, 29, 16, 1, -29 },
  { 639, 12, 29, 16, 2, -29 },
  { 683, 12, 30, 16, 2, -29 },
  { 728, 12, 29, 16, 2, -29 },
  { 772, 14, 29, 16, 1, -29 },
  { 823, 12, 29, 16, 2, -29 },
  { 867, 2, 21, 8, 3, -21 },
  { 873, 3, 26, 7, 2, -21 },
  { 883, 14, 16, 16, 1, -22 },
  { 911, 14, 10, 16, 1, -19 },
  { 929, 14, 16, 16, 1, -22 },
  { 957, 9, 29, 11, 1, -29 },
  { 990, 21, 33, 25, 2, -29 },
  { 1077, 16, 29, 16, 0, -29 },
  { 1135, 13, 29, 18, 3, -29 },
  { 1183, 14, 29, 17, 2, -29 },
  { 1234, 14, 29, 19, 3, -29 },
  { 1285, 11, 29, 15, 3, -29 },
  { 1325, 11, 29, 14, 3, -29 },
  { 1365, 17, 29, 21, 2, -29 },
  { 1427, 14, 29, 20, 3, -29 },
  { 1478, 7, 29, 9, 1, -29 },
  { 1504, 7, 36, 8, -2, -29 },
  { 1536, 13, 29, 16, 3, -29 },
  { 1584, 10, 29, 14, 3, -29 },
  { 1621, 21, 29, 27, 3, -29 },
  { 1698, 15, 29, 21, 3, -29 },
  { 1753, 17, 29, 21, 2, -29 },
  { 1815, 12, 29, 16, 3, -29 },
  { 1859, 17, 36, 21, 2, -29 },
  { 1936, 13, 29, 17, 3, -29 },
  { 1984, 12, 29, 16, 2, -29 },
  { 2028, 13, 29, 14, 0, -29 },
  { 2076, 14, 29, 20, 3, -29 },
  { 2127, 15, 29, 15, 0, -29 },
  { 2182, 26, 29, 26, 0, -29 },
  { 2277, 13, 29, 14, 0, -29 },
  { 2325, 13, 29, 13, 0, -29 },
  { 2373, 11, 29, 13, 1, -29 },
  { 2413, 8, 35, 12, 3, -29 },
  { 2448, 12, 29, 13, 1, -29 },
  { 2492, 8, 35, 12, 1, -29 },
  { 2527, 15, 14, 16, 1, -29 },
  { 2554, 16, 1, 16, 0, 4 },
  { 2556, 6, 7, 9, 2, -31 },
  { 2562, 11, 22, 15, 1, -22 },
  { 2593, 13, 30, 17, 3, -30 },
  { 2642, 10, 22, 13, 2, -22 },
  { 2670, 13, 30, 17, 2, -30 },
  { 2719, 12, 22, 16, 2, -22 },
  { 2752, 10, 31, 9, 0, -31 },
  { 2791, 12, 32, 17, 2, -22 },
  { 2839, 11, 30, 17, 3, -30 },
  { 2881, 2, 29, 7, 3, -29 },
  { 2889, 5, 39, 7, 0, -29 },
  { 2914, 10, 30, 14, 3, -30 },
  { 2952, 1, 30, 7, 3, -30 },
  { 2956, 19, 22, 25, 3, -22 },
  { 3009, 11, 22, 17, 3, -22 },
  { 3040, 13, 22, 16, 2, -22 },
  { 3076, 12, 31, 17, 3, -22 },
  { 3123, 12, 31, 17, 2, -22 },
  { 3170, 7, 21, 11, 3, -21 },
  { 3189, 10, 22, 13, 1, -22 },
  { 3217, 7, 26, 9, 1, -26 },
  { 3240, 11, 21, 17, 3, -21 },
  { 3269, 12, 21, 12, 0, -21 },
  { 3301, 21, 21, 21, 0, -21 },
  { 3357, 11, 21, 13, 1, -21 },
  { 3386, 13, 31, 13, 0, -21 },
  { 3437, 9, 21, 11, 1, -21 },
  { 3461, 10, 35, 14, 2, -29 },
  { 3505, 1, 40, 15, 7, -30 },
  { 3510, 10, 35, 14, 2, -29 },
  { 3554, 14, 4, 16, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight40pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT40PT7B_H_
