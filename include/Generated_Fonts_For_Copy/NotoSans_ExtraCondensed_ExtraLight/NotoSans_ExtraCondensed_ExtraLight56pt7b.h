#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT56PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight56pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xC0, 0x00, 0x0F, 0xFF, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x20, 0x00, 0xC0,
  0x40, 0x03, 0x01, 0x00, 0x0C, 0x0C, 0x00, 0x20, 0x30, 0x01, 0x80, 0xC0,
  0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x06,
  0x02, 0x00, 0x18, 0x08, 0x00, 0x60, 0x60, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF0, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00,
  0x30, 0x10, 0x00, 0xC0, 0x40, 0x03, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x60,
  0x30, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x81, 0x80, 0xC0, 0x06, 0x02, 0x00, 0x10, 0x18, 0x00, 0x40, 0x60, 0x03,
  0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x01,
  0x80, 0x0C, 0x04, 0x00, 0x30, 0x30, 0x00, 0x80, 0xC0, 0x06, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xC0,
  0x3F, 0xFF, 0x0F, 0x30, 0xE3, 0x86, 0x04, 0x60, 0xC0, 0x1C, 0x18, 0x03,
  0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06,
  0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x18, 0x01, 0xC3, 0x00, 0x1C, 0x60, 0x01,
  0xEC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x19, 0xE0, 0x03, 0x0E, 0x00, 0x60, 0xC0, 0x0C, 0x0C, 0x01, 0x81, 0x80,
  0x30, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x03, 0x00,
  0x60, 0x60, 0x0C, 0x1D, 0x01, 0x83, 0x38, 0x31, 0xC7, 0xFF, 0xF0, 0x3F,
  0xF8, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x01, 0x80, 0x73, 0x80, 0x18,
  0x06, 0x18, 0x03, 0x00, 0x40, 0xC0, 0x30, 0x0C, 0x0C, 0x03, 0x00, 0xC0,
  0xC0, 0x60, 0x0C, 0x04, 0x06, 0x00, 0xC0, 0x60, 0x60, 0x08, 0x06, 0x0C,
  0x00, 0x80, 0x60, 0xC0, 0x08, 0x06, 0x0C, 0x00, 0x80, 0x61, 0x80, 0x08,
  0x06, 0x18, 0x00, 0x80, 0x61, 0x80, 0x08, 0x06, 0x30, 0x00, 0x80, 0x63,
  0x06, 0x0C, 0x06, 0x31, 0xF8, 0xC0, 0xC6, 0x39, 0xCC, 0x0C, 0x63, 0x0C,
  0xC0, 0xC6, 0x60, 0x64, 0x0C, 0xC6, 0x06, 0x61, 0x8C, 0x60, 0x63, 0x38,
  0xC6, 0x06, 0x3F, 0x18, 0x40, 0x60, 0x41, 0x8C, 0x02, 0x00, 0x18, 0xC0,
  0x30, 0x03, 0x0C, 0x03, 0x00, 0x30, 0xC0, 0x30, 0x03, 0x0C, 0x03, 0x00,
  0x60, 0xC0, 0x30, 0x06, 0x0C, 0x03, 0x00, 0x60, 0xC0, 0x20, 0x0C, 0x04,
  0x06, 0x00, 0xC0, 0x60, 0x60, 0x0C, 0x06, 0x06, 0x01, 0x80, 0x60, 0x60,
  0x18, 0x06, 0x06, 0x01, 0x80, 0x30, 0xC0, 0x30, 0x03, 0x98, 0x03, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0x3F, 0x00, 0x03, 0x9C,
  0x00, 0x18, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x30, 0x03,
  0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x30, 0x30,
  0x01, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x86, 0x00, 0x06,
  0x70, 0x00, 0x37, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00,
  0x0E, 0xC0, 0x00, 0x63, 0x00, 0x06, 0x1C, 0x00, 0x70, 0x60, 0x63, 0x01,
  0x83, 0x38, 0x0C, 0x19, 0x80, 0x30, 0xCC, 0x01, 0x86, 0x60, 0x06, 0x33,
  0x00, 0x3B, 0x18, 0x00, 0xD8, 0xC0, 0x03, 0xC6, 0x00, 0x1C, 0x30, 0x00,
  0xE1, 0x80, 0x07, 0x86, 0x00, 0x6C, 0x30, 0x07, 0x70, 0xC0, 0x71, 0x87,
  0xDF, 0x06, 0x0F, 0xE0, 0x38, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x0E,
  0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03,
  0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x08, 0x30, 0x7C, 0x67, 0x9F, 0xFC, 0x03, 0xC0, 0x07, 0x00, 0x19,
  0x00, 0x33, 0x00, 0xC3, 0x03, 0x03, 0x0C, 0x07, 0x08, 0x04, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x18, 0xC6, 0x73, 0x98, 0xC6, 0x73, 0x18, 0x8C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0x00, 0x80, 0x03, 0xF8, 0x03, 0xDE, 0x03, 0x83, 0x83,
  0x80, 0xC1, 0x80, 0x31, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x03, 0x30, 0x01,
  0xB8, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1B, 0x00, 0x0D, 0xC0, 0x06, 0x60,
  0x03, 0x30, 0x01, 0x98, 0x01, 0x8E, 0x00, 0xC3, 0x00, 0x61, 0xC0, 0x60,
  0x70, 0x70, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xC0, 0x70, 0x7C, 0x3B,
  0x1C, 0xCE, 0x37, 0x0F, 0x83, 0x40, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x03,
  0xFE, 0x03, 0xE7, 0xC1, 0xC0, 0x38, 0x20, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x80, 0x07, 0xFE, 0x03, 0xE7,
  0xC3, 0xC0, 0x38, 0x40, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xCC, 0x00, 0xE3, 0xF1, 0xF0,
  0x3F, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0xCC, 0x00,
  0x06, 0x60, 0x00, 0x23, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x01, 0x86,
  0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x60, 0x60, 0x03,
  0x03, 0x00, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x03, 0x00,
  0x18, 0x18, 0x00, 0xC1, 0x80, 0x06, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x7F, 0xFE, 0x3F, 0xFF, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xCF, 0xE0, 0x7F, 0xFC, 0x38, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE4, 0x01, 0xE3, 0xF7,
  0xE0, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xC0,
  0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x81, 0x00, 0xC7, 0xF8, 0x67, 0x9E, 0x36, 0x03, 0x9E, 0x00,
  0xCE, 0x00, 0x37, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0x60, 0x03, 0xB0, 0x01, 0x98, 0x00, 0xCE, 0x00, 0xE3, 0x00,
  0x61, 0xC0, 0x70, 0x78, 0xF0, 0x1F, 0xF0, 0x01, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x07, 0xF8, 0x03, 0xEF, 0x81, 0xC0, 0x70, 0xE0,
  0x0C, 0x30, 0x01, 0x9C, 0x00, 0x66, 0x00, 0x19, 0x80, 0x07, 0x60, 0x01,
  0xD8, 0x00, 0x76, 0x00, 0x19, 0xC0, 0x06, 0x30, 0x01, 0x8E, 0x00, 0xC1,
  0x80, 0x70, 0x30, 0x38, 0x06, 0x1C, 0x00, 0xEE, 0x00, 0x1E, 0x00, 0x0F,
  0xC0, 0x07, 0x38, 0x03, 0x87, 0x01, 0xC0, 0x60, 0xE0, 0x0C, 0x70, 0x03,
  0x98, 0x00, 0x66, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x36, 0x00, 0x1D, 0x80,
  0x06, 0x30, 0x03, 0x8E, 0x01, 0xC1, 0xF1, 0xE0, 0x1F, 0xF0, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x01, 0xFE, 0x00, 0xF7, 0xC0, 0x70, 0x38, 0x38, 0x06,
  0x0C, 0x01, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x01, 0xB8, 0x00, 0x6E,
  0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x06, 0xE0, 0x01, 0xF8, 0x00, 0x76, 0x00, 0x1D, 0x80, 0x0F, 0x70, 0x03,
  0xCC, 0x01, 0xE3, 0x80, 0xD8, 0x78, 0x76, 0x0F, 0xF9, 0x80, 0x78, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0xE7, 0xC0, 0x3F, 0xC0, 0x01, 0x80, 0x00,
  0xDF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x39, 0xCE, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0xC6, 0x73, 0x98, 0xC6, 0x63, 0x18, 0x8C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x03, 0xFE, 0x3E, 0xF8, 0x80, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x78, 0x07, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x30, 0x07, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x07, 0x03, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60,
  0x0F, 0x80, 0xC6, 0x00, 0xFF, 0x03, 0x30, 0x0C, 0x18, 0x19, 0x80, 0xC0,
  0xC0, 0xCC, 0x06, 0x06, 0x06, 0xC0, 0x60, 0x70, 0x36, 0x03, 0x03, 0x00,
  0xB0, 0x18, 0x18, 0x07, 0x81, 0x80, 0xC0, 0x3C, 0x0C, 0x06, 0x01, 0xE0,
  0x60, 0x30, 0x0F, 0x03, 0x01, 0x80, 0x78, 0x18, 0x0C, 0x02, 0xC0, 0xC0,
  0x60, 0x36, 0x06, 0x03, 0x01, 0xB0, 0x30, 0x18, 0x0D, 0x81, 0x80, 0xC0,
  0x6C, 0x0C, 0x0E, 0x03, 0x60, 0x30, 0x58, 0x33, 0x01, 0x86, 0xC1, 0x8C,
  0x06, 0x73, 0x18, 0x60, 0x3F, 0x1F, 0x83, 0x00, 0x70, 0x38, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x40, 0x00, 0xF0, 0x0C, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33,
  0x00, 0x00, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80,
  0x01, 0x86, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03,
  0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x06, 0x01,
  0x80, 0x38, 0x07, 0x00, 0xC0, 0x0C, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x70, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60,
  0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0xC7, 0x00, 0x03, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x6E,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x0C, 0x01, 0xE3,
  0x00, 0x1C, 0xC0, 0x03, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00,
  0x6C, 0x00, 0x3B, 0x00, 0x0C, 0xC0, 0x07, 0x30, 0x07, 0x8F, 0xFF, 0x83,
  0xFF, 0xF0, 0xC0, 0x0E, 0x30, 0x01, 0xCC, 0x00, 0x3B, 0x00, 0x06, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1B,
  0x00, 0x0E, 0xC0, 0x07, 0x30, 0x03, 0xCF, 0xFF, 0xC3, 0xFF, 0xC0, 0x00,
  0x08, 0x00, 0x1F, 0xF8, 0x0F, 0xCF, 0x83, 0xC0, 0x10, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x08, 0x0F, 0x8F, 0x00, 0xFF,
  0xC0, 0x01, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xC0, 0x3E, 0x0C, 0x00,
  0xF0, 0xC0, 0x03, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0xCC, 0x00, 0x0C, 0xC0,
  0x00, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0,
  0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x03, 0x8C, 0x00, 0x30, 0xC0, 0x0F, 0x0C,
  0x03, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0xFF, 0xF7, 0xFF, 0xEC, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0F,
  0xFF, 0xDF, 0xFF, 0xB0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xF3, 0xF0, 0x1E, 0x00,
  0x70, 0x70, 0x00, 0x41, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x30, 0x00, 0x06,
  0x70, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x60,
  0xE0, 0x00, 0xC0, 0xE0, 0x01, 0x80, 0xFC, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xFF, 0xBF, 0x87, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE1, 0xFD, 0xFF, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x1A, 0x0E, 0xFF, 0x1F,
  0x80, 0xC0, 0x01, 0xF0, 0x00, 0xEC, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x0E,
  0x30, 0x03, 0x0C, 0x01, 0xC3, 0x00, 0x60, 0xC0, 0x38, 0x30, 0x0C, 0x0C,
  0x06, 0x03, 0x03, 0x80, 0xC0, 0xC0, 0x30, 0x70, 0x0C, 0x18, 0x03, 0x0C,
  0x00, 0xC7, 0x00, 0x31, 0x80, 0x0C, 0xF0, 0x03, 0x3C, 0x00, 0xDB, 0x80,
  0x34, 0x60, 0x0F, 0x1C, 0x03, 0x83, 0x00, 0xC0, 0xE0, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00,
  0x30, 0xC0, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x03,
  0x30, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x03, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFD, 0x80, 0x00, 0x0F, 0xEC,
  0x00, 0x00, 0x6F, 0x60, 0x00, 0x03, 0x79, 0x80, 0x00, 0x1B, 0xCC, 0x00,
  0x01, 0x9E, 0x60, 0x00, 0x0C, 0xF1, 0x80, 0x00, 0x67, 0x8C, 0x00, 0x06,
  0x3C, 0x60, 0x00, 0x31, 0xE3, 0x00, 0x01, 0x8F, 0x0C, 0x00, 0x1C, 0x78,
  0x60, 0x00, 0xC3, 0xC3, 0x00, 0x06, 0x1E, 0x0C, 0x00, 0x30, 0xF0, 0x60,
  0x03, 0x07, 0x83, 0x00, 0x18, 0x3C, 0x1C, 0x00, 0xC1, 0xE0, 0x60, 0x0C,
  0x0F, 0x03, 0x00, 0x60, 0x78, 0x18, 0x03, 0x03, 0xC0, 0x60, 0x38, 0x1E,
  0x03, 0x01, 0x80, 0xF0, 0x18, 0x0C, 0x07, 0x80, 0x60, 0x60, 0x3C, 0x03,
  0x06, 0x01, 0xE0, 0x18, 0x30, 0x0F, 0x00, 0xE1, 0x80, 0x78, 0x03, 0x18,
  0x03, 0xC0, 0x18, 0xC0, 0x1E, 0x00, 0xC6, 0x00, 0xF0, 0x03, 0x70, 0x07,
  0x80, 0x1B, 0x00, 0x3C, 0x00, 0xD8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3D, 0x80, 0x01, 0xEC, 0x00, 0x0F, 0x30, 0x00,
  0x79, 0x80, 0x03, 0xCE, 0x00, 0x1E, 0x30, 0x00, 0xF1, 0x80, 0x07, 0x86,
  0x00, 0x3C, 0x30, 0x01, 0xE0, 0xC0, 0x0F, 0x06, 0x00, 0x78, 0x18, 0x03,
  0xC0, 0xC0, 0x1E, 0x07, 0x00, 0xF0, 0x18, 0x07, 0x80, 0xC0, 0x3C, 0x03,
  0x01, 0xE0, 0x18, 0x0F, 0x00, 0x60, 0x78, 0x03, 0x03, 0xC0, 0x1C, 0x1E,
  0x00, 0x60, 0xF0, 0x03, 0x07, 0x80, 0x0C, 0x3C, 0x00, 0x61, 0xE0, 0x01,
  0x8F, 0x00, 0x0C, 0x78, 0x00, 0x33, 0xC0, 0x01, 0x9E, 0x00, 0x0E, 0xF0,
  0x00, 0x37, 0x80, 0x01, 0xBC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xBF, 0x00,
  0x78, 0x0F, 0x00, 0xC0, 0x06, 0x03, 0x80, 0x06, 0x0E, 0x00, 0x0E, 0x18,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x39, 0x80, 0x00, 0x33, 0x00,
  0x00, 0x66, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x36,
  0x00, 0x00, 0xEC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0x70,
  0x00, 0x1C, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x60, 0xC0, 0x01, 0xC1, 0xC0,
  0x03, 0x01, 0xC0, 0x0C, 0x03, 0xC0, 0x78, 0x03, 0xF7, 0xE0, 0x01, 0xFF,
  0x00, 0x00, 0x20, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x30, 0x0F, 0x18, 0x01,
  0xCC, 0x00, 0x76, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x06, 0xC0, 0x03, 0x60, 0x03, 0xB0, 0x01, 0x98, 0x01, 0xCC, 0x03,
  0xC7, 0xFF, 0xC3, 0xFF, 0x81, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xBF, 0x00, 0x78, 0x07, 0x00, 0xC0, 0x06, 0x03, 0x80, 0x06, 0x0E, 0x00,
  0x0E, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x39, 0x80, 0x00,
  0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x36, 0x00, 0x00, 0xEC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00,
  0x06, 0x70, 0x00, 0x1C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x01,
  0xC1, 0xC0, 0x03, 0x01, 0xC0, 0x0C, 0x03, 0xC0, 0x78, 0x01, 0xF7, 0xE0,
  0x01, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0xFF, 0xC0, 0x3F, 0xFE,
  0x0C, 0x03, 0xC3, 0x00, 0x38, 0xC0, 0x07, 0x30, 0x00, 0xCC, 0x00, 0x33,
  0x00, 0x0E, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0,
  0x01, 0xB0, 0x00, 0x6C, 0x00, 0x3B, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x01,
  0x8C, 0x00, 0xE3, 0x00, 0x70, 0xFF, 0xF8, 0x3F, 0xF8, 0x0C, 0x0C, 0x03,
  0x03, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0C, 0x03, 0x03, 0x00, 0xE0, 0xC0,
  0x18, 0x30, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0E, 0x30, 0x01,
  0x8C, 0x00, 0x73, 0x00, 0x0C, 0xC0, 0x03, 0xB0, 0x00, 0x6C, 0x00, 0x1F,
  0x00, 0x03, 0x00, 0x60, 0x01, 0xFF, 0xC0, 0xFD, 0xF8, 0x70, 0x06, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x01, 0xCC, 0x00, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x40,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xE0, 0x00, 0x66, 0x00,
  0x06, 0x60, 0x00, 0xE7, 0x00, 0x0C, 0x38, 0x01, 0xC1, 0xC0, 0x38, 0x1F,
  0xBF, 0x00, 0x7F, 0xE0, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xD8, 0x00, 0x06, 0xC0, 0x00, 0x76, 0x00, 0x03, 0x30, 0x00, 0x18, 0xC0,
  0x00, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0E, 0x00, 0x18,
  0x30, 0x00, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x01, 0x80,
  0x18, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x38, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xE0, 0x60, 0x03, 0x07,
  0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x00, 0xCC, 0x00, 0x06, 0xC0,
  0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3B, 0x00, 0x03, 0x80,
  0x01, 0x98, 0x00, 0x1C, 0x00, 0x0C, 0xC0, 0x00, 0xE0, 0x00, 0x66, 0x00,
  0x05, 0x00, 0x03, 0x38, 0x00, 0x6C, 0x00, 0x38, 0xC0, 0x03, 0x60, 0x01,
  0x86, 0x00, 0x1B, 0x00, 0x0C, 0x30, 0x00, 0xD8, 0x00, 0x61, 0x80, 0x06,
  0xC0, 0x03, 0x0E, 0x00, 0x63, 0x00, 0x38, 0x30, 0x03, 0x18, 0x01, 0x81,
  0x80, 0x18, 0xC0, 0x0C, 0x0C, 0x00, 0xC6, 0x00, 0x60, 0x70, 0x06, 0x30,
  0x07, 0x01, 0x80, 0x60, 0xC0, 0x30, 0x0C, 0x03, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x30, 0x0C, 0x03, 0x00, 0xC1, 0x80, 0x60, 0x1C, 0x06, 0x0C, 0x07,
  0x00, 0x60, 0x60, 0x70, 0x30, 0x03, 0x03, 0x01, 0x81, 0x80, 0x18, 0x18,
  0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x60, 0x60, 0x07, 0x06, 0x03, 0x06, 0x00,
  0x18, 0x60, 0x1C, 0x30, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x06, 0x18, 0x03,
  0x0C, 0x00, 0x30, 0xC0, 0x18, 0xE0, 0x00, 0xC6, 0x00, 0xC6, 0x00, 0x06,
  0x60, 0x06, 0x30, 0x00, 0x33, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0xCC,
  0x00, 0x0C, 0xC0, 0x06, 0xE0, 0x00, 0x36, 0x00, 0x36, 0x00, 0x01, 0xE0,
  0x01, 0xB0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xE7,
  0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0xC1, 0xC0, 0x18, 0x18, 0x07, 0x03,
  0x00, 0xC0, 0x30, 0x18, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x18, 0x01,
  0x86, 0x00, 0x38, 0xC0, 0x03, 0x38, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x61, 0x80, 0x0C,
  0x30, 0x01, 0x86, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x18, 0x0C, 0x03, 0x03, 0x00, 0x60, 0x60, 0x06, 0x1C, 0x00, 0xC3, 0x00,
  0x1C, 0xE0, 0x01, 0x98, 0x00, 0x37, 0x00, 0x07, 0xC0, 0x00, 0xEC, 0x00,
  0x19, 0x80, 0x07, 0x30, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00,
  0xC0, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0xC0, 0x03, 0x18,
  0x00, 0x63, 0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xC0,
  0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0xC0, 0x00, 0xC6,
  0x00, 0x06, 0x38, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x30, 0x18, 0x01,
  0x80, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x03,
  0x06, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x03, 0x98, 0x00, 0x0D, 0x80,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x38, 0x0C, 0x07,
  0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x0F, 0xF0, 0x7F, 0xF0, 0xC0,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x3F, 0xC1, 0xFF, 0x8F,
  0x03, 0x38, 0x06, 0xE0, 0x0D, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0xC0, 0x1D, 0x80, 0x6B, 0x80, 0x93,
  0x87, 0x23, 0xF8, 0x40, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0xFC, 0x0C, 0x7F, 0xC3, 0x30, 0x38, 0xD8, 0x07, 0x34, 0x00, 0xCE, 0x00,
  0x33, 0x80, 0x06, 0xE0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00,
  0x1B, 0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0xCF, 0x00, 0x33, 0x40, 0x1C,
  0xDC, 0x0E, 0x33, 0xCF, 0x0C, 0x7F, 0x80, 0x01, 0x00, 0x03, 0xF8, 0x3F,
  0xF1, 0xE0, 0x8E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1F, 0x3C,
  0x1F, 0xF0, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x3F, 0x0C, 0x3F, 0xE6,
  0x38, 0x3B, 0x38, 0x0D, 0xB8, 0x03, 0xD8, 0x00, 0xEC, 0x00, 0x7E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x3B, 0x00,
  0x1D, 0x80, 0x1E, 0x60, 0x0B, 0x38, 0x0C, 0x8F, 0x1C, 0x43, 0xFC, 0x20,
  0x30, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x18, 0x1C, 0x30, 0x0C, 0x70, 0x06,
  0x60, 0x06, 0x60, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x1C, 0x02, 0x0F, 0x1E,
  0x07, 0xFC, 0x00, 0x60, 0x01, 0xF0, 0x3F, 0xC1, 0x84, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1F, 0xE3, 0xFF, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x07, 0xF0, 0x8F, 0xFC, 0x47, 0x07, 0x66, 0x00, 0xB7, 0x00,
  0x7B, 0x00, 0x1D, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0xC0, 0x07, 0x60, 0x03, 0xB0, 0x03, 0xCC, 0x01, 0x67,
  0x01, 0xB1, 0xE7, 0x98, 0x7F, 0x8C, 0x04, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x40, 0x0E, 0x3E, 0x7E, 0x0F, 0xFC, 0x00, 0x20, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC3, 0xF0, 0xC7, 0xF8, 0xCC, 0x1C, 0xD8, 0x0E, 0xF0, 0x06,
  0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xDF, 0xF4, 0x00, 0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xC0, 0x0C, 0x1C, 0x38, 0x70, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0xEB, 0x9E, 0x10, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x01, 0xB0, 0x06, 0x60,
  0x1C, 0xC0, 0x31, 0x80, 0xC3, 0x01, 0x86, 0x06, 0x0C, 0x1C, 0x18, 0x30,
  0x30, 0xC0, 0x61, 0x80, 0xC6, 0x01, 0x9E, 0x03, 0x3C, 0x06, 0xD8, 0x0D,
  0x18, 0x1E, 0x30, 0x38, 0x70, 0x60, 0x60, 0xC0, 0xC1, 0x80, 0xC3, 0x01,
  0x86, 0x03, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x1D,
  0x80, 0x1B, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x87, 0xE0, 0x3F, 0x19, 0xFE, 0x1F, 0xF3, 0x60, 0xE3,
  0x07, 0x68, 0x0C, 0xC0, 0x6F, 0x00, 0xD0, 0x0F, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x18, 0x01, 0xE0, 0x03, 0x00, 0x3C, 0x00, 0x60, 0x07, 0x80,
  0x0C, 0x00, 0xF0, 0x01, 0x80, 0x1E, 0x00, 0x30, 0x03, 0xC0, 0x06, 0x00,
  0x78, 0x00, 0xC0, 0x0F, 0x00, 0x18, 0x01, 0xE0, 0x03, 0x00, 0x3C, 0x00,
  0x60, 0x07, 0x80, 0x0C, 0x00, 0xF0, 0x01, 0x80, 0x1E, 0x00, 0x30, 0x03,
  0xC0, 0x06, 0x00, 0x78, 0x00, 0xC0, 0x0F, 0x00, 0x18, 0x01, 0xE0, 0x03,
  0x00, 0x3C, 0x00, 0x60, 0x07, 0x80, 0x0C, 0x00, 0xC0, 0xC3, 0xF0, 0xCF,
  0xF8, 0xCC, 0x1C, 0xD8, 0x0E, 0xF0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x07, 0xF0, 0x03,
  0xFF, 0x01, 0xC0, 0xE0, 0xC0, 0x18, 0x70, 0x07, 0x18, 0x00, 0xC6, 0x00,
  0x33, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06,
  0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x07, 0xC0, 0x01, 0xB0,
  0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00,
  0x19, 0x80, 0x0E, 0x60, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x60, 0xE0, 0x38,
  0x1F, 0x3C, 0x01, 0xFE, 0x00, 0x08, 0x00, 0x83, 0xF0, 0x31, 0xFF, 0x0C,
  0xC0, 0xE3, 0x60, 0x18, 0xD0, 0x03, 0x3C, 0x00, 0xCE, 0x00, 0x1B, 0x80,
  0x06, 0xE0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6E, 0x00, 0x1B, 0x80,
  0x06, 0xE0, 0x03, 0x3C, 0x00, 0xCD, 0x80, 0x63, 0x70, 0x38, 0xCF, 0x3C,
  0x31, 0xFE, 0x0C, 0x04, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xE0, 0x87, 0xFC,
  0x47, 0x07, 0x67, 0x00, 0xB7, 0x00, 0x7B, 0x00, 0x1D, 0x80, 0x0F, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x07, 0x60,
  0x03, 0xB8, 0x03, 0xCC, 0x01, 0x67, 0x01, 0xB1, 0xE7, 0x98, 0x7F, 0x8C,
  0x02, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0xC3, 0xF8, 0xFB, 0x30, 0xEC, 0x0D, 0x01, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x0F, 0xF0,
  0xFF, 0xF3, 0x80, 0x98, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x78, 0x01, 0xB0, 0x0E, 0xFD,
  0xF1, 0xFF, 0x80, 0x60, 0x00, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xFF, 0xFF, 0xC6, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0xC0, 0x39, 0x0F, 0xC0, 0xC0, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0B, 0xC0, 0x15, 0x80, 0x6B, 0x81, 0x93, 0xDE, 0x23,
  0xF8, 0x40, 0xC0, 0x00, 0xC0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xEC, 0x00,
  0x66, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x1C, 0x60, 0x0C, 0x30, 0x06, 0x1C,
  0x03, 0x06, 0x03, 0x83, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x30,
  0x18, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x01, 0x86, 0x00, 0xC6, 0x00, 0x63,
  0x00, 0x31, 0x80, 0x0C, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00,
  0x58, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0xC0, 0x06, 0x00, 0x3C,
  0x00, 0x60, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x06, 0xC0, 0x0F,
  0x00, 0x66, 0x00, 0xF0, 0x06, 0x60, 0x0D, 0x00, 0x66, 0x01, 0x98, 0x06,
  0x60, 0x19, 0x80, 0xC3, 0x01, 0x98, 0x0C, 0x30, 0x19, 0x80, 0xC3, 0x03,
  0x0C, 0x0C, 0x30, 0x30, 0xC0, 0xC3, 0x03, 0x0C, 0x18, 0x18, 0x30, 0xC1,
  0x81, 0x83, 0x0C, 0x18, 0x18, 0x60, 0x61, 0x81, 0x86, 0x06, 0x30, 0x0C,
  0x60, 0x63, 0x00, 0xC6, 0x06, 0x30, 0x0C, 0x60, 0x63, 0x00, 0xCC, 0x03,
  0x30, 0x0C, 0xC0, 0x36, 0x00, 0x6C, 0x03, 0x60, 0x06, 0xC0, 0x36, 0x00,
  0x68, 0x01, 0x60, 0x07, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80,
  0x1C, 0x00, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x60, 0x07, 0x70, 0x06, 0x30,
  0x0E, 0x38, 0x0C, 0x18, 0x0C, 0x18, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x06,
  0x30, 0x06, 0x60, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x70, 0x0C, 0x30, 0x0C,
  0x38, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x0C, 0x30, 0x0C, 0x30, 0x06, 0x60,
  0x06, 0x60, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xD8, 0x00, 0xCC,
  0x00, 0x66, 0x00, 0x33, 0x00, 0x38, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x06,
  0x18, 0x07, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0xE0, 0x30,
  0x60, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x1C, 0x01, 0x8C, 0x00, 0xC6, 0x00,
  0x63, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xA0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x5E, 0x00, 0x3E, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3C, 0x03, 0xF0, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x3E, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F,
  0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x03, 0xF0, 0x01, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x3E, 0x00,
  0x3C, 0x03, 0xC0, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x01, 0xE0, 0x3F, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x07,
  0x03, 0xC3, 0xC0, 0x1F, 0xE8, 0x00, 0x70,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 40, 11, 4, -40 },
  { 16, 10, 14, 17, 4, -40 },
  { 34, 22, 40, 24, 1, -40 },
  { 144, 19, 46, 22, 2, -43 },
  { 254, 28, 42, 33, 3, -41 },
  { 401, 21, 42, 23, 2, -41 },
  { 512, 2, 14, 10, 4, -40 },
  { 516, 10, 49, 15, 3, -40 },
  { 578, 10, 49, 15, 2, -40 },
  { 640, 15, 16, 20, 2, -43 },
  { 670, 19, 26, 23, 2, -33 },
  { 732, 5, 13, 10, 2, -6 },
  { 741, 12, 2, 15, 1, -16 },
  { 744, 3, 4, 11, 4, -4 },
  { 746, 17, 40, 19, 1, -40 },
  { 831, 17, 41, 22, 3, -41 },
  { 919, 10, 40, 22, 4, -40 },
  { 969, 18, 41, 22, 2, -41 },
  { 1062, 18, 42, 22, 2, -41 },
  { 1157, 21, 40, 22, 1, -40 },
  { 1262, 17, 41, 22, 3, -40 },
  { 1350, 17, 41, 22, 3, -40 },
  { 1438, 18, 40, 22, 2, -40 },
  { 1528, 18, 41, 22, 2, -40 },
  { 1621, 18, 42, 22, 2, -41 },
  { 1716, 3, 30, 11, 4, -30 },
  { 1728, 5, 37, 10, 2, -30 },
  { 1752, 19, 23, 23, 2, -31 },
  { 1807, 19, 14, 23, 2, -27 },
  { 1841, 19, 23, 23, 2, -31 },
  { 1896, 13, 41, 15, 1, -41 },
  { 1963, 29, 45, 34, 3, -40 },
  { 2127, 22, 40, 22, 0, -40 },
  { 2237, 18, 40, 25, 4, -40 },
  { 2327, 19, 42, 24, 3, -41 },
  { 2427, 20, 40, 27, 4, -40 },
  { 2527, 15, 40, 22, 4, -40 },
  { 2602, 15, 40, 20, 4, -40 },
  { 2677, 23, 42, 29, 3, -41 },
  { 2798, 19, 40, 28, 4, -40 },
  { 2893, 9, 40, 13, 2, -40 },
  { 2938, 10, 50, 11, -3, -40 },
  { 3001, 18, 40, 22, 4, -40 },
  { 3091, 14, 40, 19, 4, -40 },
  { 3161, 29, 40, 37, 4, -40 },
  { 3306, 21, 40, 29, 4, -40 },
  { 3411, 23, 42, 29, 3, -41 },
  { 3532, 17, 40, 23, 4, -40 },
  { 3617, 23, 51, 29, 3, -41 },
  { 3764, 18, 40, 23, 4, -40 },
  { 3854, 18, 42, 22, 2, -41 },
  { 3949, 19, 40, 19, 0, -40 },
  { 4044, 20, 41, 28, 4, -40 },
  { 4147, 21, 40, 21, 0, -40 },
  { 4252, 37, 40, 37, 0, -40 },
  { 4437, 19, 40, 19, 0, -40 },
  { 4532, 19, 40, 19, 0, -40 },
  { 4627, 15, 40, 19, 2, -40 },
  { 4702, 10, 49, 17, 5, -40 },
  { 4764, 17, 40, 19, 1, -40 },
  { 4849, 11, 49, 17, 2, -40 },
  { 4917, 21, 20, 23, 1, -40 },
  { 4970, 23, 2, 22, 0, 5 },
  { 4976, 9, 9, 13, 2, -43 },
  { 4987, 15, 31, 21, 2, -30 },
  { 5046, 18, 44, 24, 4, -43 },
  { 5145, 14, 31, 18, 3, -30 },
  { 5200, 17, 44, 24, 3, -43 },
  { 5294, 16, 31, 22, 3, -30 },
  { 5356, 13, 43, 12, 1, -43 },
  { 5426, 17, 44, 24, 3, -30 },
  { 5520, 16, 43, 23, 4, -43 },
  { 5606, 3, 41, 10, 4, -41 },
  { 5622, 7, 55, 10, 0, -41 },
  { 5671, 15, 43, 19, 4, -43 },
  { 5752, 2, 43, 10, 4, -43 },
  { 5763, 27, 30, 35, 4, -30 },
  { 5865, 16, 30, 23, 4, -30 },
  { 5925, 18, 31, 23, 3, -30 },
  { 5995, 18, 43, 24, 4, -30 },
  { 6092, 17, 43, 24, 3, -30 },
  { 6184, 11, 30, 15, 4, -30 },
  { 6226, 14, 31, 18, 2, -30 },
  { 6281, 10, 38, 12, 1, -37 },
  { 6329, 15, 31, 23, 4, -30 },
  { 6388, 17, 30, 17, 0, -30 },
  { 6452, 28, 30, 30, 1, -30 },
  { 6557, 16, 30, 18, 1, -30 },
  { 6617, 17, 44, 18, 1, -30 },
  { 6711, 12, 30, 15, 2, -30 },
  { 6756, 14, 49, 20, 3, -40 },
  { 6842, 2, 57, 21, 10, -43 },
  { 6857, 14, 49, 20, 3, -40 },
  { 6943, 19, 5, 23, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight56pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT56PT7B_H_
