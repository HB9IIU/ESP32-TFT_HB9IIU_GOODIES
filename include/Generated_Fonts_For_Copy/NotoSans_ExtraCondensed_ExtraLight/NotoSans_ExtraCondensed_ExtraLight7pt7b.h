#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT7PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xF0, 0x5E, 0xEC, 0xF1, 0x3C, 0xEE, 0xD3, 0x50, 0xDB, 0x5E,
  0xC0, 0x6A, 0x90, 0x95, 0x60, 0xF0, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x56,
  0x80, 0xFF, 0xC0, 0xF8, 0xD5, 0xC0, 0xD5, 0xC0, 0x4B, 0x74, 0xD1, 0x9E,
  0xD3, 0xDE, 0xD5, 0x80, 0xF5, 0x5E, 0xFD, 0xC0, 0x90, 0x98, 0x71, 0x80,
  0xE0, 0xC7, 0x00, 0xD6, 0x80, 0x7B, 0xFF, 0x86, 0x5B, 0xDA, 0xFB, 0xC0,
  0x72, 0x46, 0xFF, 0x80, 0xF8, 0xF8, 0x72, 0x56, 0xFF, 0xC0, 0xF8, 0xFC,
  0xEA, 0xC0, 0xF8, 0xB6, 0xFE, 0xFF, 0xC0, 0xF6, 0xDE, 0xBA, 0x80, 0xF6,
  0xDE, 0x40, 0xBA, 0xC0, 0xE5, 0xC0, 0xD5, 0x40, 0xB6, 0xDE, 0xB7, 0x64,
  0xAD, 0x7C, 0xE5, 0x00, 0xD7, 0xC0, 0xF9, 0x40, 0xD6, 0xC0, 0xFC, 0xA5,
  0x40, 0xD5, 0x70, 0x54, 0xE0, 0x80, 0xDF, 0x9E, 0xDE, 0x6B, 0x3E, 0xDE,
  0xFB, 0xEA, 0x80, 0x76, 0xF3, 0x80, 0xBF, 0xC0, 0xF8, 0xFE, 0xBF, 0xC0,
  0xF8, 0xDB, 0xBB, 0xFF, 0xD6, 0xF0, 0xF6, 0xF9, 0x00, 0xF6, 0xF2, 0x40,
  0xEA, 0x67, 0xF8, 0xFF, 0xF6, 0xDD, 0x5A, 0xDB, 0xF5, 0x60, 0xDB, 0x57,
  0x50, 0xFE, 0xD5, 0x70, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 5, 1, 0, -5 },
  { 2, 2, 2, 2, 0, -5 },
  { 3, 3, 5, 3, 0, -5 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 5, 4, 0, -5 },
  { 10, 3, 5, 3, 0, -5 },
  { 12, 1, 2, 1, 0, -5 },
  { 13, 2, 6, 2, 0, -5 },
  { 15, 2, 6, 2, 0, -5 },
  { 17, 2, 2, 2, 0, -5 },
  { 18, 3, 3, 3, 0, -4 },
  { 20, 1, 2, 1, 0, -1 },
  { 21, 2, 1, 2, 0, -2 },
  { 22, 1, 1, 1, 0, -1 },
  { 23, 2, 5, 2, 0, -5 },
  { 25, 2, 5, 3, 0, -5 },
  { 27, 1, 5, 3, 1, -5 },
  { 28, 2, 5, 3, 0, -5 },
  { 30, 2, 5, 3, 0, -5 },
  { 32, 3, 5, 3, 0, -5 },
  { 34, 3, 5, 3, 0, -5 },
  { 36, 3, 5, 3, 0, -5 },
  { 38, 2, 5, 3, 0, -5 },
  { 40, 3, 5, 3, 0, -5 },
  { 42, 2, 5, 3, 0, -5 },
  { 44, 1, 4, 1, 0, -4 },
  { 45, 1, 5, 1, 0, -4 },
  { 46, 3, 3, 3, 0, -4 },
  { 48, 3, 1, 3, 0, -3 },
  { 49, 3, 3, 3, 0, -4 },
  { 51, 2, 5, 2, 0, -5 },
  { 53, 4, 6, 4, 0, -5 },
  { 56, 3, 5, 3, 0, -5 },
  { 58, 2, 5, 3, 1, -5 },
  { 60, 3, 5, 3, 0, -5 },
  { 62, 2, 5, 3, 1, -5 },
  { 64, 1, 5, 3, 1, -5 },
  { 65, 1, 5, 3, 1, -5 },
  { 66, 3, 5, 4, 0, -5 },
  { 68, 2, 5, 3, 1, -5 },
  { 70, 1, 5, 2, 0, -5 },
  { 71, 1, 6, 1, 0, -5 },
  { 72, 2, 5, 3, 1, -5 },
  { 74, 1, 5, 2, 1, -5 },
  { 75, 3, 5, 5, 1, -5 },
  { 77, 2, 5, 4, 1, -5 },
  { 79, 3, 5, 4, 0, -5 },
  { 81, 2, 5, 3, 1, -5 },
  { 83, 3, 6, 4, 0, -5 },
  { 86, 2, 5, 3, 1, -5 },
  { 88, 2, 5, 3, 0, -5 },
  { 90, 2, 5, 2, 0, -5 },
  { 92, 3, 5, 3, 0, -5 },
  { 94, 3, 5, 3, 0, -5 },
  { 96, 5, 5, 5, 0, -5 },
  { 100, 2, 5, 2, 0, -5 },
  { 102, 2, 5, 2, 0, -5 },
  { 104, 2, 5, 2, 0, -5 },
  { 106, 1, 6, 2, 1, -5 },
  { 107, 2, 5, 2, 0, -5 },
  { 109, 2, 6, 2, 0, -5 },
  { 111, 3, 2, 3, 0, -5 },
  { 112, 3, 1, 3, 0, 0 },
  { 113, 1, 1, 2, 0, -5 },
  { 114, 2, 4, 3, 0, -4 },
  { 115, 3, 5, 3, 0, -5 },
  { 117, 2, 4, 2, 0, -4 },
  { 118, 3, 5, 3, 0, -5 },
  { 120, 2, 4, 3, 0, -4 },
  { 121, 2, 5, 2, 0, -5 },
  { 123, 3, 6, 3, 0, -4 },
  { 126, 2, 5, 3, 0, -5 },
  { 128, 1, 5, 1, 0, -5 },
  { 129, 1, 7, 1, 0, -5 },
  { 130, 2, 5, 2, 0, -5 },
  { 132, 1, 5, 1, 0, -5 },
  { 133, 4, 4, 4, 0, -4 },
  { 135, 2, 4, 3, 0, -4 },
  { 136, 3, 4, 3, 0, -4 },
  { 138, 3, 6, 3, 0, -4 },
  { 141, 3, 6, 3, 0, -4 },
  { 144, 2, 4, 2, 0, -4 },
  { 145, 2, 4, 2, 0, -4 },
  { 146, 1, 5, 2, 0, -5 },
  { 147, 2, 4, 3, 0, -4 },
  { 148, 2, 4, 2, 0, -4 },
  { 149, 4, 4, 4, 0, -4 },
  { 151, 2, 4, 2, 0, -4 },
  { 152, 2, 6, 2, 0, -4 },
  { 154, 2, 4, 2, 0, -4 },
  { 155, 2, 6, 2, 0, -5 },
  { 157, 1, 7, 3, 1, -5 },
  { 158, 2, 6, 2, 0, -5 },
  { 160, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight7pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT7PT7B_H_
