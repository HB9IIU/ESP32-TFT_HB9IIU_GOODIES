#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT11PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFC, 0x52, 0xBE, 0xA5, 0x79, 0x8C, 0x7A, 0xA4, 0x23, 0x3E,
  0x20, 0x4A, 0xAB, 0x2F, 0x54, 0xD2, 0xCB, 0x66, 0x64, 0x4B, 0x9F, 0xE0,
  0x6A, 0xAA, 0x90, 0x95, 0x55, 0x60, 0xCD, 0x80, 0x22, 0xF2, 0x20, 0xC0,
  0xE0, 0x80, 0x12, 0x22, 0x44, 0x48, 0x69, 0x99, 0x99, 0x97, 0x75, 0x55,
  0x61, 0x11, 0x22, 0x4F, 0xE1, 0x16, 0x11, 0x1F, 0x12, 0x55, 0x9F, 0x11,
  0xF2, 0x62, 0x4E, 0x72, 0x6B, 0x6F, 0xF1, 0x12, 0x22, 0x44, 0x79, 0x96,
  0x59, 0x97, 0x69, 0x99, 0x71, 0x16, 0x84, 0x86, 0x34, 0xC3, 0xFF, 0xC3,
  0x3C, 0xE4, 0x94, 0x82, 0x74, 0x6B, 0xBD, 0xEE, 0xF0, 0x70, 0x22, 0x65,
  0x79, 0x99, 0xF6, 0xFB, 0x6F, 0x72, 0x49, 0x23, 0xE9, 0x99, 0x99, 0x9E,
  0xF2, 0x79, 0x27, 0xF2, 0x4F, 0x24, 0x78, 0x88, 0xB9, 0x97, 0x99, 0x9F,
  0x99, 0x99, 0xD5, 0x57, 0x55, 0x55, 0x70, 0xB7, 0x4D, 0xAD, 0x92, 0x49,
  0x27, 0x8C, 0x63, 0x1D, 0xEE, 0xB5, 0x99, 0x9D, 0xBB, 0x99, 0xE9, 0x99,
  0x99, 0x9E, 0xD6, 0xDD, 0x24, 0xE9, 0x99, 0x99, 0x9E, 0x21, 0xD6, 0xDD,
  0xAD, 0x78, 0x84, 0x21, 0x1F, 0xF4, 0x44, 0x44, 0x44, 0x99, 0x99, 0x99,
  0x9E, 0x99, 0x99, 0x66, 0x64, 0x93, 0x26, 0x4D, 0x56, 0xAD, 0x99, 0x22,
  0x96, 0x64, 0x46, 0xA9, 0x9A, 0xA6, 0x44, 0x44, 0xE4, 0x94, 0xA7, 0xEA,
  0xAA, 0xB0, 0x88, 0x44, 0x22, 0x21, 0xD5, 0x55, 0x70, 0x26, 0x59, 0xF0,
  0xC0, 0x64, 0xFB, 0xC0, 0x93, 0xDB, 0x6F, 0x72, 0x48, 0xC0, 0x11, 0x79,
  0x99, 0x97, 0x69, 0xF8, 0x87, 0x6B, 0x24, 0x92, 0x79, 0x99, 0x97, 0x11,
  0x60, 0x93, 0xDB, 0x6D, 0xBF, 0xBF, 0xE0, 0x92, 0xE9, 0xB5, 0xFF, 0xDD,
  0x6B, 0x5A, 0xD4, 0xF6, 0xDB, 0x40, 0x69, 0x99, 0x97, 0xF6, 0xDB, 0xE4,
  0x80, 0x79, 0x99, 0x97, 0x11, 0x10, 0xEA, 0xA0, 0x71, 0x13, 0xC0, 0xBA,
  0xA4, 0xB6, 0xDB, 0xC0, 0xB6, 0xB4, 0x80, 0xA6, 0x9B, 0x56, 0x49, 0x20,
  0xAD, 0x27, 0x40, 0x9A, 0xA6, 0x44, 0x44, 0x80, 0xE5, 0x29, 0xC0, 0x6A,
  0xAA, 0x90, 0xFF, 0xE0, 0xAA, 0x5A, 0xA0, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 8, 2, 1, -8 },
  { 2, 2, 3, 3, 1, -8 },
  { 3, 5, 8, 5, 0, -8 },
  { 8, 4, 9, 4, 0, -8 },
  { 13, 6, 8, 7, 0, -8 },
  { 19, 4, 8, 4, 0, -8 },
  { 23, 1, 3, 2, 0, -8 },
  { 24, 2, 10, 3, 1, -8 },
  { 27, 2, 10, 3, 0, -8 },
  { 30, 3, 3, 4, 0, -8 },
  { 32, 4, 5, 4, 0, -6 },
  { 35, 1, 2, 2, 0, -1 },
  { 36, 3, 1, 3, 0, -3 },
  { 37, 1, 1, 2, 1, -1 },
  { 38, 4, 8, 4, 0, -8 },
  { 42, 4, 8, 4, 0, -8 },
  { 46, 2, 8, 4, 1, -8 },
  { 48, 4, 8, 4, 0, -8 },
  { 52, 4, 8, 4, 0, -8 },
  { 56, 4, 8, 4, 0, -8 },
  { 60, 3, 8, 4, 1, -8 },
  { 63, 3, 8, 4, 1, -8 },
  { 66, 4, 8, 4, 0, -8 },
  { 70, 4, 8, 4, 0, -8 },
  { 74, 4, 8, 4, 0, -8 },
  { 78, 1, 6, 2, 1, -6 },
  { 79, 1, 7, 2, 0, -6 },
  { 80, 4, 4, 4, 0, -6 },
  { 82, 4, 2, 4, 0, -5 },
  { 83, 4, 4, 4, 0, -6 },
  { 85, 3, 8, 3, 0, -8 },
  { 88, 5, 9, 7, 1, -8 },
  { 94, 4, 8, 4, 0, -8 },
  { 98, 3, 8, 5, 1, -8 },
  { 101, 3, 8, 5, 1, -8 },
  { 104, 4, 8, 5, 1, -8 },
  { 108, 3, 8, 4, 1, -8 },
  { 111, 3, 8, 4, 1, -8 },
  { 114, 4, 8, 6, 1, -8 },
  { 118, 4, 8, 5, 1, -8 },
  { 122, 2, 8, 3, 0, -8 },
  { 124, 2, 10, 2, -1, -8 },
  { 127, 3, 8, 4, 1, -8 },
  { 130, 3, 8, 4, 1, -8 },
  { 133, 5, 8, 7, 1, -8 },
  { 138, 4, 8, 6, 1, -8 },
  { 142, 4, 8, 6, 1, -8 },
  { 146, 3, 8, 4, 1, -8 },
  { 149, 4, 10, 6, 1, -8 },
  { 154, 3, 8, 5, 1, -8 },
  { 157, 4, 8, 4, 0, -8 },
  { 161, 4, 8, 4, 0, -8 },
  { 165, 4, 8, 5, 1, -8 },
  { 169, 4, 8, 4, 0, -8 },
  { 173, 7, 8, 7, 0, -8 },
  { 180, 4, 8, 4, 0, -8 },
  { 184, 4, 8, 4, 0, -8 },
  { 188, 3, 8, 4, 0, -8 },
  { 191, 2, 10, 3, 1, -8 },
  { 194, 4, 8, 4, 0, -8 },
  { 198, 2, 10, 3, 0, -8 },
  { 201, 4, 4, 4, 0, -8 },
  { 203, 4, 1, 4, 0, 1 },
  { 204, 2, 1, 3, 0, -8 },
  { 205, 3, 6, 4, 0, -6 },
  { 208, 3, 8, 5, 1, -8 },
  { 211, 3, 6, 4, 0, -6 },
  { 214, 4, 8, 5, 0, -8 },
  { 218, 4, 6, 4, 0, -6 },
  { 221, 3, 8, 2, 0, -8 },
  { 224, 4, 9, 5, 0, -6 },
  { 229, 3, 8, 5, 1, -8 },
  { 232, 1, 8, 2, 1, -8 },
  { 233, 1, 11, 2, 0, -8 },
  { 235, 3, 8, 4, 1, -8 },
  { 238, 1, 8, 2, 0, -8 },
  { 239, 5, 6, 7, 1, -6 },
  { 243, 3, 6, 5, 1, -6 },
  { 246, 4, 6, 5, 0, -6 },
  { 249, 3, 9, 5, 1, -6 },
  { 253, 4, 9, 5, 0, -6 },
  { 258, 2, 6, 3, 1, -6 },
  { 260, 3, 6, 3, 0, -6 },
  { 263, 2, 7, 2, 0, -7 },
  { 265, 3, 6, 5, 1, -6 },
  { 268, 3, 6, 3, 0, -6 },
  { 271, 6, 6, 6, 0, -6 },
  { 276, 3, 6, 4, 0, -6 },
  { 279, 4, 9, 4, 0, -6 },
  { 284, 3, 6, 3, 0, -6 },
  { 287, 2, 10, 4, 1, -8 },
  { 290, 1, 11, 4, 2, -8 },
  { 292, 2, 10, 4, 1, -8 },
  { 295, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight11pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT11PT7B_H_
