#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT70PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight70pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3B, 0x81, 0xDC, 0x0E, 0xC0, 0x76, 0x03, 0xB0, 0x1D,
  0x80, 0xEC, 0x07, 0x60, 0x3B, 0x01, 0xD8, 0x0E, 0xC0, 0x36, 0x01, 0xB0,
  0x0D, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xC0, 0x00, 0x38, 0x06, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30,
  0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x70, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C,
  0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0x80, 0x00,
  0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x01, 0xC0, 0x38, 0x00,
  0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x03, 0x00,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x70, 0x00, 0x30,
  0x07, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x0E, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x60, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xDB, 0xFC,
  0x1E, 0x18, 0x38, 0x3C, 0x18, 0x08, 0x38, 0x18, 0x00, 0x70, 0x18, 0x00,
  0x70, 0x18, 0x00, 0x60, 0x18, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x18, 0x00,
  0xE0, 0x18, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x18, 0x00, 0x60, 0x18, 0x00,
  0x60, 0x18, 0x00, 0x70, 0x18, 0x00, 0x38, 0x18, 0x00, 0x3C, 0x18, 0x00,
  0x1E, 0x18, 0x00, 0x0F, 0x18, 0x00, 0x07, 0xD8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x19, 0xE0,
  0x00, 0x18, 0xF0, 0x00, 0x18, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x0E,
  0x00, 0x18, 0x0E, 0x00, 0x18, 0x06, 0x00, 0x18, 0x07, 0x00, 0x18, 0x07,
  0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x06,
  0x00, 0x18, 0x06, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x1C, 0x80, 0x18, 0x3C,
  0xF0, 0x18, 0x78, 0xFF, 0x9F, 0xF0, 0x3F, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x0C, 0x00, 0x73, 0x80, 0x03, 0x80, 0x1C, 0x38, 0x00, 0x60, 0x03,
  0x03, 0x80, 0x0C, 0x00, 0xE0, 0x30, 0x03, 0x80, 0x18, 0x06, 0x00, 0x60,
  0x03, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x0C, 0x03, 0x80,
  0x60, 0x03, 0x80, 0x30, 0x0C, 0x00, 0x70, 0x06, 0x03, 0x80, 0x0E, 0x00,
  0xC0, 0x60, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x30, 0x03, 0x03, 0x80, 0x06,
  0x00, 0x60, 0x60, 0x00, 0xC0, 0x0C, 0x0C, 0x00, 0x18, 0x01, 0x83, 0x80,
  0x03, 0x00, 0x30, 0x60, 0x00, 0x70, 0x06, 0x0C, 0x00, 0x0E, 0x00, 0xC3,
  0x81, 0xC1, 0xC0, 0x18, 0x60, 0xFE, 0x18, 0x07, 0x0C, 0x39, 0xE3, 0x00,
  0xE3, 0x8E, 0x0C, 0x60, 0x18, 0x61, 0x81, 0xCC, 0x03, 0x0C, 0x70, 0x19,
  0xC0, 0xE3, 0x8C, 0x03, 0x18, 0x18, 0x61, 0x80, 0x73, 0x87, 0x0C, 0x30,
  0x0E, 0x3F, 0xC3, 0x86, 0x00, 0xC3, 0xF0, 0x61, 0xC0, 0x18, 0x18, 0x0C,
  0x38, 0x03, 0x00, 0x03, 0x87, 0x00, 0x60, 0x00, 0x60, 0xE0, 0x0C, 0x00,
  0x0C, 0x1C, 0x01, 0x80, 0x03, 0x83, 0x80, 0x30, 0x00, 0x60, 0x70, 0x06,
  0x00, 0x0C, 0x0E, 0x00, 0xC0, 0x03, 0x81, 0xC0, 0x18, 0x00, 0x60, 0x38,
  0x03, 0x00, 0x0C, 0x07, 0x00, 0x60, 0x03, 0x80, 0xE0, 0x0C, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x70, 0x03, 0x80, 0x30, 0x0E, 0x00,
  0x60, 0x07, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x80, 0x0C, 0x0E,
  0x00, 0x60, 0x01, 0xC3, 0x80, 0x0C, 0x00, 0x1F, 0xE0, 0x03, 0x80, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0x80,
  0xE0, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03,
  0x00, 0x70, 0x00, 0xC0, 0x1C, 0x00, 0x30, 0x07, 0x00, 0x0E, 0x01, 0x80,
  0x03, 0x80, 0x60, 0x00, 0xE0, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03,
  0x80, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x0E, 0x18, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x1C, 0x18, 0x00, 0x06, 0x07, 0x00, 0xE3, 0x80, 0xE0, 0x38, 0xC0,
  0x38, 0x0E, 0x70, 0x07, 0x03, 0x98, 0x00, 0xC0, 0xC6, 0x00, 0x38, 0x33,
  0x80, 0x06, 0x0C, 0xE0, 0x01, 0xC7, 0x38, 0x00, 0x31, 0xCE, 0x00, 0x0E,
  0x63, 0x80, 0x01, 0xF8, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x0E, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x7E, 0x1C, 0x00, 0x1F, 0x83,
  0x80, 0x0E, 0x70, 0xF0, 0x07, 0x0C, 0x1E, 0x07, 0x83, 0x83, 0xFF, 0xC0,
  0x60, 0x7F, 0xC0, 0x1C, 0x03, 0xC0, 0x00, 0x77, 0x76, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0E, 0x0C, 0x0F,
  0xE1, 0x1F, 0x3F, 0x5F, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0x06, 0xC0, 0x03,
  0xB0, 0x01, 0xC6, 0x00, 0x60, 0xC0, 0x30, 0x38, 0x1C, 0x07, 0x0E, 0x00,
  0xC1, 0x00, 0x20, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x1C, 0x71, 0xC7, 0x38, 0xE3, 0x8E, 0x31, 0xC7, 0x18,
  0x63, 0x8C, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0x73, 0xFE, 0xF7, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF8,
  0x01, 0xE0, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x81, 0xC0, 0x0E, 0x06,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x00, 0x03, 0x1C, 0x00,
  0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x06,
  0x60, 0x00, 0x19, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x76, 0x00, 0x01, 0x98, 0x00, 0x06, 0x70, 0x00, 0x19, 0xC0, 0x00,
  0x67, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xC3,
  0x80, 0x07, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x60, 0x70, 0x03, 0x80, 0xE0,
  0x0E, 0x03, 0xC0, 0x70, 0x07, 0x87, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x38, 0x03, 0xC0, 0x3E, 0x07, 0xF0, 0x7B, 0x87, 0x9C, 0x78,
  0xE7, 0x87, 0x78, 0x3F, 0x81, 0xD0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF8, 0x1F, 0x01, 0xF0, 0x70, 0x01,
  0xC0, 0x80, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xF8, 0x1E, 0x01, 0xF0, 0xE0, 0x01, 0xE3, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x20, 0x00, 0x78, 0xF0, 0x07, 0xC3, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0x30,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x1C,
  0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x70, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x00, 0xC0,
  0x01, 0xC0, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x03, 0x00, 0x38,
  0x00, 0xC0, 0x1C, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00,
  0xE0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x03,
  0x03, 0x80, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x73, 0xFC, 0x01,
  0xFF, 0xFC, 0x07, 0xF9, 0xFC, 0x08, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x8C, 0x00, 0x3C, 0x3C,
  0x01, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0x03, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x0F, 0x00, 0x61, 0xFF, 0x81, 0x8F, 0xFF, 0x0E,
  0x70, 0x1E, 0x3B, 0x80, 0x3C, 0xEC, 0x00, 0x73, 0xE0, 0x00, 0xEF, 0x00,
  0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x1B, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x76, 0x00, 0x01, 0xD8,
  0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00,
  0x07, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0x63, 0x80, 0x03, 0x8E, 0x00, 0x0E,
  0x18, 0x00, 0x30, 0x70, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0xC0, 0x78, 0x07,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x78,
  0x0F, 0x01, 0xC0, 0x0F, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00,
  0xE6, 0x00, 0x01, 0x8E, 0x00, 0x03, 0x1C, 0x00, 0x06, 0x38, 0x00, 0x1C,
  0x30, 0x00, 0x38, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x07, 0x00,
  0xE0, 0x1C, 0x00, 0xF0, 0xF0, 0x00, 0xF3, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00,
  0x39, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0D,
  0x80, 0x00, 0x1B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xCE,
  0x00, 0x07, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x1F,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0xC0, 0x3C, 0x07, 0x01, 0xC0, 0x1C, 0x1C, 0x00, 0x70,
  0xC0, 0x03, 0x8E, 0x00, 0x0C, 0x70, 0x00, 0x77, 0x00, 0x01, 0xB8, 0x00,
  0x0D, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x70,
  0x00, 0x7B, 0x80, 0x03, 0xCC, 0x00, 0x36, 0x70, 0x03, 0xB1, 0xC0, 0x39,
  0x87, 0xFF, 0x8C, 0x1F, 0xF8, 0x60, 0x3F, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x20, 0x1E, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0x73, 0xFE, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x73, 0xFE, 0xF7,
  0x00, 0x3C, 0xF3, 0xCF, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC7, 0x1C, 0x73, 0x8E, 0x38, 0xE3, 0x1C, 0x71, 0x86, 0x38, 0xC3, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x1F,
  0xF8, 0x3F, 0xFF, 0x0E, 0x07, 0x84, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x03, 0x8C,
  0x00, 0x3F, 0x80, 0x33, 0x80, 0x0F, 0xF8, 0x06, 0x70, 0x07, 0x83, 0x00,
  0xEC, 0x00, 0xE0, 0x60, 0x1D, 0x80, 0x38, 0x0C, 0x03, 0xF0, 0x06, 0x01,
  0x80, 0x3E, 0x01, 0xC0, 0x30, 0x07, 0xC0, 0x30, 0x06, 0x00, 0xF8, 0x06,
  0x00, 0xC0, 0x1E, 0x01, 0xC0, 0x38, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x78,
  0x06, 0x00, 0xE0, 0x0F, 0x00, 0xC0, 0x1C, 0x01, 0xE0, 0x18, 0x03, 0x80,
  0x3C, 0x03, 0x00, 0x70, 0x07, 0x80, 0x60, 0x0E, 0x00, 0xF0, 0x0C, 0x01,
  0xC0, 0x1E, 0x01, 0x80, 0x38, 0x03, 0xC0, 0x30, 0x07, 0x00, 0x78, 0x06,
  0x00, 0xE0, 0x1F, 0x00, 0xE0, 0x3C, 0x03, 0xE0, 0x1C, 0x07, 0x80, 0x6E,
  0x01, 0x80, 0xF0, 0x1D, 0xC0, 0x38, 0x36, 0x03, 0xB8, 0x07, 0x06, 0x60,
  0xE3, 0x00, 0x71, 0x8E, 0x3C, 0x60, 0x07, 0xF0, 0xFF, 0x0E, 0x00, 0x7C,
  0x0F, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x08, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x38,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x38, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x03, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x18, 0x0E, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x1C,
  0x03, 0x00, 0x03, 0x00, 0x70, 0x00, 0x60, 0x0E, 0x00, 0x1C, 0x00, 0xC0,
  0x03, 0x80, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x00, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x70, 0x00, 0x70, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0, 0x30, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x06, 0x07,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0C, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0x80, 0xFF,
  0x87, 0x00, 0x0F, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77,
  0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70,
  0x00, 0x0E, 0xE0, 0x00, 0x19, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00,
  0x03, 0x8E, 0x00, 0x0F, 0x1C, 0x00, 0x3C, 0x38, 0x07, 0xF0, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x81, 0xC0, 0x07, 0xC3, 0x80, 0x03, 0xC7, 0x00, 0x01,
  0xCE, 0x00, 0x03, 0x9C, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00,
  0x03, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x7C, 0x70, 0x0F, 0xF0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xFF, 0x01, 0xF0, 0x0E, 0x03, 0xC0, 0x02, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x01, 0x01, 0xF0, 0x07, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xE0, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x38, 0x1F,
  0xF0, 0x1C, 0x00, 0x7C, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x38,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x70,
  0x00, 0x01, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x07, 0x00, 0x07, 0x83, 0x80, 0x0F, 0x81, 0xC0, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0xFF, 0xFE, 0xFF, 0xFF, 0xDC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x1E, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x08, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x7C, 0x00, 0x07, 0x00, 0xF8, 0x01,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x41, 0xEF, 0xF9, 0xFE, 0x04, 0x00, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x73,
  0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0x70, 0x00, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0x80,
  0x1C, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x0E,
  0x00, 0x70, 0x1C, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80,
  0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00,
  0x73, 0xE0, 0x00, 0xEF, 0xC0, 0x01, 0xD9, 0xC0, 0x03, 0xF3, 0x80, 0x07,
  0xC3, 0x80, 0x0F, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x38, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x60, 0x38, 0x00, 0xE0, 0x70, 0x00,
  0xC0, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x87, 0x00, 0x03,
  0x0E, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1B, 0xEC, 0x00, 0x00, 0x03, 0xBE, 0xC0, 0x00, 0x00, 0x3B, 0xEE,
  0x00, 0x00, 0x03, 0x3E, 0x60, 0x00, 0x00, 0x73, 0xE6, 0x00, 0x00, 0x07,
  0x3E, 0x70, 0x00, 0x00, 0x63, 0xE7, 0x00, 0x00, 0x06, 0x3E, 0x30, 0x00,
  0x00, 0xE3, 0xE3, 0x80, 0x00, 0x0E, 0x3E, 0x38, 0x00, 0x00, 0xC3, 0xE1,
  0x80, 0x00, 0x1C, 0x3E, 0x18, 0x00, 0x01, 0xC3, 0xE1, 0xC0, 0x00, 0x18,
  0x3E, 0x0C, 0x00, 0x03, 0x83, 0xE0, 0xC0, 0x00, 0x38, 0x3E, 0x0E, 0x00,
  0x03, 0x03, 0xE0, 0xE0, 0x00, 0x30, 0x3E, 0x06, 0x00, 0x07, 0x03, 0xE0,
  0x70, 0x00, 0x70, 0x3E, 0x07, 0x00, 0x06, 0x03, 0xE0, 0x30, 0x00, 0xE0,
  0x3E, 0x03, 0x00, 0x0E, 0x03, 0xE0, 0x38, 0x00, 0xC0, 0x3E, 0x01, 0x80,
  0x1C, 0x03, 0xE0, 0x18, 0x01, 0xC0, 0x3E, 0x01, 0xC0, 0x18, 0x03, 0xE0,
  0x1C, 0x01, 0x80, 0x3E, 0x00, 0xC0, 0x38, 0x03, 0xE0, 0x0E, 0x03, 0x80,
  0x3E, 0x00, 0xE0, 0x30, 0x03, 0xE0, 0x06, 0x07, 0x00, 0x3E, 0x00, 0x60,
  0x70, 0x03, 0xE0, 0x07, 0x06, 0x00, 0x3E, 0x00, 0x70, 0xE0, 0x03, 0xE0,
  0x03, 0x0E, 0x00, 0x3E, 0x00, 0x38, 0xC0, 0x03, 0xE0, 0x03, 0x8C, 0x00,
  0x3E, 0x00, 0x19, 0xC0, 0x03, 0xE0, 0x01, 0xDC, 0x00, 0x3E, 0x00, 0x1D,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7E, 0xC0, 0x00, 0x1F, 0xB8, 0x00, 0x07, 0xE6, 0x00,
  0x01, 0xF9, 0xC0, 0x00, 0x7E, 0x30, 0x00, 0x1F, 0x8E, 0x00, 0x07, 0xE3,
  0x80, 0x01, 0xF8, 0x60, 0x00, 0x7E, 0x1C, 0x00, 0x1F, 0x83, 0x00, 0x07,
  0xE0, 0xE0, 0x01, 0xF8, 0x18, 0x00, 0x7E, 0x07, 0x00, 0x1F, 0x81, 0xC0,
  0x07, 0xE0, 0x38, 0x01, 0xF8, 0x0E, 0x00, 0x7E, 0x01, 0x80, 0x1F, 0x80,
  0x70, 0x07, 0xE0, 0x0C, 0x01, 0xF8, 0x03, 0x80, 0x7E, 0x00, 0x60, 0x1F,
  0x80, 0x1C, 0x07, 0xE0, 0x07, 0x01, 0xF8, 0x00, 0xE0, 0x7E, 0x00, 0x38,
  0x1F, 0x80, 0x06, 0x07, 0xE0, 0x01, 0xC1, 0xF8, 0x00, 0x30, 0x7E, 0x00,
  0x0E, 0x1F, 0x80, 0x03, 0x87, 0xE0, 0x00, 0x71, 0xF8, 0x00, 0x1C, 0x7E,
  0x00, 0x03, 0x1F, 0x80, 0x00, 0xE7, 0xE0, 0x00, 0x19, 0xF8, 0x00, 0x07,
  0x7E, 0x00, 0x00, 0xDF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x03,
  0x80, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x18, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x07, 0x00,
  0x01, 0xC0, 0x3C, 0x00, 0x1C, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0xE0, 0x3E,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x38, 0x3F, 0xE1, 0xC0, 0x0F, 0x8E, 0x00,
  0x1E, 0x70, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x37,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01,
  0xDC, 0x00, 0x1C, 0xE0, 0x01, 0xC7, 0x00, 0x3E, 0x38, 0x3F, 0xE1, 0xFF,
  0xFC, 0x0F, 0xFF, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x03, 0x80, 0x38, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x1C, 0x30, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x3C,
  0x00, 0x1C, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0x83, 0xFE, 0x07, 0x00, 0x3E,
  0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38,
  0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE,
  0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0,
  0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0x8E, 0x00,
  0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x38, 0x70, 0x00, 0xE0, 0xE0, 0x07,
  0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0E, 0x03, 0x80,
  0x1C, 0x03, 0x00, 0x38, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x1C,
  0x00, 0x70, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x00, 0xC1, 0xC0,
  0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x83, 0xE0, 0x1E,
  0x1E, 0x00, 0x10, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x20, 0x00,
  0x78, 0xF0, 0x07, 0xC3, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x0D, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0x30, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xCE, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0xE0,
  0x78, 0x00, 0xF0, 0x1E, 0x01, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x07, 0x30, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70,
  0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0x80, 0x60, 0x00, 0x70, 0x0C, 0x00,
  0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x30, 0x03, 0x00, 0x0E, 0x00,
  0x60, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x38, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xC0, 0x01,
  0xC0, 0x18, 0x00, 0x18, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x70, 0x18,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x1C, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x06,
  0x70, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x77, 0x00, 0x00, 0x78, 0x00, 0x01, 0x9C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xFC, 0x00, 0x03, 0x8E, 0x00, 0x03,
  0xF0, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x33,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0xCC, 0x00, 0x07, 0x06, 0x00, 0x07, 0x38,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x73, 0x80,
  0x03, 0x81, 0xC0, 0x01, 0x86, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x18, 0x00,
  0x38, 0x0E, 0x00, 0x38, 0x70, 0x00, 0xC0, 0x38, 0x00, 0xE1, 0xC0, 0x07,
  0x00, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x03, 0x80, 0x0C, 0x0C, 0x00, 0x70,
  0x06, 0x00, 0x30, 0x30, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0xE0, 0x06, 0x00,
  0x70, 0x07, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x00, 0x38,
  0x06, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x03, 0x80,
  0xE0, 0x1C, 0x07, 0x00, 0x06, 0x03, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x0C,
  0x00, 0xC0, 0x60, 0x00, 0x70, 0x30, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0,
  0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x1C, 0x00,
  0x60, 0xE0, 0x00, 0x38, 0x60, 0x01, 0x83, 0x00, 0x00, 0xE1, 0x80, 0x07,
  0x1C, 0x00, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x71,
  0xC0, 0x00, 0x18, 0xE0, 0x00, 0xC6, 0x00, 0x00, 0x73, 0x00, 0x03, 0x18,
  0x00, 0x01, 0xCC, 0x00, 0x0C, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80,
  0x00, 0x0D, 0xC0, 0x00, 0xEE, 0x00, 0x00, 0x37, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0,
  0x00, 0x60, 0xC0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x06, 0x03, 0x00,
  0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x03,
  0x00, 0x18, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x30, 0x00, 0x60, 0xE0,
  0x00, 0xE1, 0x80, 0x01, 0xC7, 0x00, 0x01, 0x8E, 0x00, 0x03, 0x98, 0x00,
  0x07, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0x60, 0x00, 0x0E, 0xE0, 0x00, 0x18, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0xE3,
  0x80, 0x01, 0x83, 0x00, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x0C,
  0x00, 0x70, 0x1C, 0x00, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70,
  0x1C, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0x60, 0x01, 0xC1, 0xC0, 0x03, 0x83,
  0x80, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0xE0,
  0x00, 0x1D, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x1D, 0xC0,
  0x00, 0x33, 0x80, 0x00, 0xE3, 0x00, 0x01, 0xC7, 0x00, 0x03, 0x0E, 0x00,
  0x0E, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x30, 0x38, 0x00, 0xE0, 0x30, 0x01,
  0xC0, 0x70, 0x03, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x30,
  0x03, 0x80, 0xE0, 0x03, 0x01, 0xC0, 0x06, 0x03, 0x00, 0x0E, 0x0E, 0x00,
  0x0C, 0x1C, 0x00, 0x18, 0x30, 0x00, 0x38, 0xE0, 0x00, 0x31, 0xC0, 0x00,
  0x63, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xB0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0C,
  0xE0, 0x00, 0x07, 0x1C, 0x00, 0x01, 0x87, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x30, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x06, 0x01, 0xC0, 0x03, 0x80, 0x30,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x1C, 0x00, 0x70, 0x0E, 0x00,
  0x0C, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x00, 0xF0, 0x01, 0xFF, 0xC0,
  0xFF, 0xFC, 0x1C, 0x03, 0xC1, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x87, 0xC0, 0x71, 0xC0, 0x0E, 0x70, 0x01, 0xDC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7D, 0xC0, 0x1B, 0xBC, 0x06, 0x73, 0xF7, 0xCE, 0x3F,
  0xE0, 0xC0, 0xF0, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x1E, 0x00,
  0xC1, 0xFF, 0x03, 0x0F, 0xFF, 0x0C, 0x70, 0x3C, 0x33, 0x00, 0x38, 0xD8,
  0x00, 0x73, 0x60, 0x01, 0xCD, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00,
  0x03, 0x36, 0x00, 0x1C, 0xD8, 0x00, 0xE3, 0x30, 0x03, 0x8C, 0x70, 0x3C,
  0x30, 0xFF, 0xE0, 0xC1, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x7F, 0xF0, 0x3F, 0xFC, 0x1E, 0x02, 0x0F, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x3E, 0x01, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x1E, 0x03, 0x03, 0xFE, 0x0C,
  0x1F, 0xFE, 0x30, 0xF0, 0x1C, 0xC7, 0x80, 0x33, 0x1C, 0x00, 0x6C, 0xE0,
  0x00, 0xF3, 0x80, 0x03, 0xCC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00,
  0x77, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x76, 0x00, 0x01, 0xDC,
  0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0xF3, 0x80, 0x03, 0xCE, 0x00,
  0x0B, 0x1C, 0x00, 0x6C, 0x70, 0x03, 0x30, 0xF0, 0x3C, 0xC1, 0xFF, 0xE3,
  0x03, 0xFE, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xE0, 0x1E, 0x07, 0x81, 0xE0, 0x1C, 0x0E, 0x00, 0x70, 0xE0, 0x01,
  0x87, 0x00, 0x0E, 0x30, 0x00, 0x73, 0x80, 0x01, 0x9C, 0x00, 0x0C, 0xE0,
  0x00, 0x76, 0x00, 0x03, 0xB0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x04, 0x0F, 0x00, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x18, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0x81, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0xFF,
  0xF8, 0xFF, 0xF8, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x30, 0x7F, 0xF8, 0xC3, 0xC0, 0x73,
  0x1E, 0x00, 0xEC, 0x70, 0x01, 0xB3, 0x80, 0x03, 0xCE, 0x00, 0x0F, 0x30,
  0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x60, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x76, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77,
  0x00, 0x03, 0xCE, 0x00, 0x0B, 0x38, 0x00, 0x6C, 0x70, 0x01, 0xB1, 0xC0,
  0x0C, 0xC3, 0xC0, 0xE3, 0x07, 0xFF, 0x0C, 0x0F, 0xF8, 0x30, 0x07, 0x80,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC4, 0x00, 0x0F, 0x1C, 0x00, 0x78,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x07,
  0x80, 0xC1, 0xFF, 0x0C, 0x3F, 0xF8, 0xC7, 0x03, 0x8C, 0xC0, 0x1C, 0xD8,
  0x00, 0xCD, 0x80, 0x0E, 0xD0, 0x00, 0xEF, 0x00, 0x06, 0xE0, 0x00, 0x6E,
  0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x73, 0xBE,
  0xF7, 0x10, 0x00, 0x00, 0x00, 0x00, 0x01, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x07, 0x03, 0x83, 0xE1, 0xF0, 0x70,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x7E, 0x3F, 0x1E, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x03, 0xB0, 0x00, 0xEC, 0x00, 0x73, 0x00, 0x38, 0xC0, 0x0E, 0x30, 0x07,
  0x0C, 0x01, 0x83, 0x00, 0xE0, 0xC0, 0x70, 0x30, 0x1C, 0x0C, 0x0E, 0x03,
  0x03, 0x00, 0xC1, 0xC0, 0x30, 0xE0, 0x0C, 0x38, 0x03, 0x1F, 0x00, 0xCF,
  0xC0, 0x33, 0x30, 0x0D, 0xCE, 0x03, 0x63, 0x80, 0xF0, 0x70, 0x3C, 0x1C,
  0x0E, 0x03, 0x03, 0x00, 0xE0, 0xC0, 0x18, 0x30, 0x07, 0x0C, 0x01, 0xC3,
  0x00, 0x30, 0xC0, 0x0E, 0x30, 0x01, 0x8C, 0x00, 0x73, 0x00, 0x1C, 0xC0,
  0x03, 0x30, 0x00, 0xEC, 0x00, 0x1B, 0x00, 0x07, 0xC0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x30, 0xFF, 0x80, 0xFF, 0x0C, 0x7F, 0xF0,
  0xFF, 0xE3, 0x38, 0x1C, 0x38, 0x3C, 0xCC, 0x03, 0x98, 0x07, 0xB6, 0x00,
  0xE4, 0x00, 0xED, 0x00, 0x1B, 0x00, 0x3B, 0xC0, 0x07, 0x80, 0x06, 0xE0,
  0x01, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x1F,
  0x80, 0x03, 0x00, 0x07, 0xE0, 0x00, 0xC0, 0x01, 0xF8, 0x00, 0x30, 0x00,
  0x7C, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x03, 0x00, 0x07, 0xC0, 0x00, 0xC0,
  0x01, 0xF0, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x03,
  0x00, 0x07, 0xC0, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x7C, 0x00,
  0x0C, 0x00, 0x1F, 0x00, 0x03, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0x01, 0xF0,
  0x00, 0x30, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x03, 0x00, 0x07,
  0xC0, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x0C, 0x00,
  0x1F, 0x00, 0x03, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x30,
  0x00, 0x7C, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x03, 0x00, 0x07, 0xC0, 0x00,
  0xC0, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x70, 0x00, 0x78, 0x0C, 0x1F, 0xF0,
  0xC7, 0xFF, 0x8C, 0x70, 0x3C, 0xCC, 0x01, 0xCD, 0x80, 0x0E, 0xD8, 0x00,
  0xEF, 0x00, 0x0E, 0xF0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00,
  0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x0F, 0x03, 0x80, 0x0E, 0x0E,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x39, 0xC0,
  0x00, 0x73, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xB8, 0x00,
  0x03, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x06, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33,
  0x00, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x8C, 0x00, 0x06, 0x1C,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x78, 0x03, 0xC0, 0x78,
  0x0F, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x03, 0x07, 0xFC, 0x0C, 0x3F, 0xF8, 0x31, 0xC0, 0xF0, 0xCE, 0x00,
  0xE3, 0x30, 0x01, 0xCD, 0x80, 0x07, 0x34, 0x00, 0x0E, 0xF0, 0x00, 0x3B,
  0xC0, 0x00, 0xEE, 0x00, 0x01, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x06, 0xE0, 0x00, 0x1B, 0xC0, 0x00, 0xEF, 0x00, 0x03,
  0xB4, 0x00, 0x1C, 0xD8, 0x00, 0x73, 0x30, 0x03, 0x8C, 0xE0, 0x1E, 0x31,
  0xC0, 0xF0, 0xC3, 0xFF, 0x83, 0x07, 0xFC, 0x0C, 0x03, 0x80, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFC, 0x30, 0x7F, 0xF8,
  0xC3, 0xC0, 0x73, 0x0E, 0x00, 0xCC, 0x70, 0x01, 0xB3, 0x80, 0x02, 0xCE,
  0x00, 0x0F, 0x30, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00,
  0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x36, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x70, 0x00, 0x1D,
  0xC0, 0x00, 0x77, 0x00, 0x03, 0xCE, 0x00, 0x0B, 0x38, 0x00, 0x6C, 0x70,
  0x01, 0xB1, 0xE0, 0x0C, 0xC3, 0xC0, 0xE3, 0x07, 0xFF, 0x0C, 0x0F, 0xF8,
  0x30, 0x07, 0x80, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x26, 0x0F,
  0xF0, 0xFF, 0x8E, 0x1C, 0xE0, 0x66, 0x03, 0x60, 0x1B, 0x00, 0xD0, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x00,
  0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xFC, 0x70, 0x06, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xEC, 0x00, 0x7B, 0xC0, 0x3C, 0xFF, 0xFE, 0x0F, 0xFF,
  0x00, 0x3C, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x03, 0xFF, 0xFF, 0xFE, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x7F, 0x81, 0xFC, 0x03, 0x80, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0B,
  0x70, 0x03, 0x6E, 0x00, 0xCC, 0xF0, 0x39, 0x9F, 0xFE, 0x30, 0xFF, 0x86,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3B, 0x00, 0x01, 0xDC, 0x00, 0x0E, 0xE0,
  0x00, 0x67, 0x00, 0x07, 0x18, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0C,
  0x38, 0x00, 0x60, 0xC0, 0x07, 0x06, 0x00, 0x38, 0x38, 0x01, 0x81, 0xC0,
  0x0C, 0x06, 0x00, 0xE0, 0x30, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0x80,
  0x30, 0x1C, 0x01, 0x80, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x30, 0x01, 0x81,
  0x80, 0x0C, 0x1C, 0x00, 0x60, 0xE0, 0x03, 0x86, 0x00, 0x1C, 0x30, 0x00,
  0x63, 0x80, 0x03, 0x1C, 0x00, 0x1C, 0xC0, 0x00, 0xE6, 0x00, 0x03, 0x70,
  0x00, 0x1B, 0x80, 0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x76, 0x00,
  0x1F, 0x00, 0x0C, 0xC0, 0x03, 0x60, 0x01, 0x9C, 0x00, 0x6E, 0x00, 0x33,
  0x80, 0x0D, 0xC0, 0x0E, 0x30, 0x03, 0x98, 0x01, 0xC6, 0x00, 0x73, 0x00,
  0x30, 0xE0, 0x0E, 0x60, 0x06, 0x1C, 0x01, 0x8E, 0x01, 0xC3, 0x80, 0x31,
  0xC0, 0x38, 0x30, 0x0E, 0x18, 0x07, 0x06, 0x01, 0xC3, 0x00, 0xC0, 0xE0,
  0x30, 0x70, 0x18, 0x1C, 0x06, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0xC0, 0xE0,
  0x30, 0x38, 0x18, 0x18, 0x07, 0x07, 0x03, 0x03, 0x00, 0xE0, 0xC0, 0x70,
  0x60, 0x1C, 0x18, 0x0E, 0x1C, 0x01, 0x87, 0x00, 0xC3, 0x80, 0x30, 0xE0,
  0x18, 0x60, 0x07, 0x1C, 0x03, 0x0C, 0x00, 0xE3, 0x00, 0x73, 0x80, 0x0C,
  0x60, 0x0E, 0x70, 0x01, 0x9C, 0x00, 0xCC, 0x00, 0x33, 0x80, 0x19, 0x80,
  0x07, 0x60, 0x03, 0x30, 0x00, 0xEC, 0x00, 0x7E, 0x00, 0x0D, 0x80, 0x0F,
  0xC0, 0x01, 0xB0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x71, 0x80, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x01, 0xC1, 0xC0, 0x0C,
  0x0E, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x06, 0x03, 0x00, 0x38,
  0x38, 0x00, 0xC1, 0xC0, 0x07, 0x1C, 0x00, 0x18, 0xE0, 0x00, 0xE6, 0x00,
  0x07, 0x70, 0x00, 0x1B, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0xEE, 0x00, 0x06, 0x70, 0x00,
  0x71, 0xC0, 0x03, 0x8E, 0x00, 0x38, 0x30, 0x01, 0xC1, 0xC0, 0x0C, 0x06,
  0x00, 0xE0, 0x38, 0x06, 0x00, 0xC0, 0x70, 0x07, 0x03, 0x00, 0x38, 0x38,
  0x00, 0xE1, 0xC0, 0x07, 0x1C, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x1B, 0x00, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x67,
  0x00, 0x03, 0x18, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0C, 0x38, 0x00,
  0x60, 0xC0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0x81, 0xC0, 0x0C, 0x06,
  0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x1C,
  0x01, 0xC0, 0xE0, 0x0E, 0x06, 0x00, 0x70, 0x30, 0x01, 0x83, 0x80, 0x0E,
  0x1C, 0x00, 0x70, 0xC0, 0x03, 0x86, 0x00, 0x0C, 0x70, 0x00, 0x73, 0x80,
  0x03, 0x98, 0x00, 0x1C, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0x70, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0xFE, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xC0,
  0x07, 0xF0, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x01, 0x3F, 0xF0, 0x01, 0x7D, 0xF8, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0x0F, 0xFE, 0x80, 0x03, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 50, 14, 5, -50 },
  { 26, 13, 18, 22, 4, -50 },
  { 56, 28, 50, 30, 1, -50 },
  { 231, 24, 57, 28, 2, -53 },
  { 402, 35, 52, 41, 3, -51 },
  { 630, 26, 52, 28, 2, -51 },
  { 799, 4, 18, 12, 4, -50 },
  { 808, 12, 61, 19, 4, -50 },
  { 900, 12, 61, 19, 3, -50 },
  { 992, 18, 19, 25, 3, -53 },
  { 1035, 24, 32, 28, 2, -41 },
  { 1131, 6, 16, 13, 3, -7 },
  { 1143, 15, 2, 19, 2, -20 },
  { 1147, 5, 5, 13, 4, -5 },
  { 1151, 20, 50, 24, 2, -50 },
  { 1276, 22, 51, 28, 3, -51 },
  { 1417, 13, 50, 28, 5, -50 },
  { 1499, 22, 51, 28, 3, -51 },
  { 1640, 22, 52, 28, 3, -51 },
  { 1783, 26, 50, 28, 1, -50 },
  { 1946, 22, 51, 28, 3, -50 },
  { 2087, 22, 51, 28, 3, -50 },
  { 2228, 22, 50, 28, 3, -50 },
  { 2366, 23, 52, 28, 3, -51 },
  { 2516, 21, 52, 28, 3, -51 },
  { 2653, 5, 37, 13, 4, -37 },
  { 2677, 6, 46, 13, 3, -37 },
  { 2712, 24, 29, 28, 2, -39 },
  { 2799, 24, 17, 28, 2, -33 },
  { 2850, 24, 29, 28, 2, -39 },
  { 2937, 17, 51, 19, 1, -51 },
  { 3046, 35, 56, 43, 4, -50 },
  { 3291, 27, 50, 27, 0, -50 },
  { 3460, 23, 50, 31, 5, -50 },
  { 3604, 24, 52, 29, 4, -51 },
  { 3760, 25, 50, 34, 5, -50 },
  { 3917, 19, 50, 27, 5, -50 },
  { 4036, 19, 50, 25, 5, -50 },
  { 4155, 29, 52, 37, 4, -51 },
  { 4344, 24, 50, 35, 5, -50 },
  { 4494, 11, 50, 16, 3, -50 },
  { 4563, 11, 63, 14, -3, -50 },
  { 4650, 23, 50, 28, 5, -50 },
  { 4794, 18, 50, 24, 5, -50 },
  { 4907, 36, 50, 47, 5, -50 },
  { 5132, 26, 50, 36, 5, -50 },
  { 5295, 29, 52, 36, 4, -51 },
  { 5484, 21, 50, 28, 5, -50 },
  { 5616, 29, 63, 36, 4, -51 },
  { 5845, 23, 50, 29, 5, -50 },
  { 5989, 22, 52, 28, 3, -51 },
  { 6132, 23, 50, 24, 1, -50 },
  { 6276, 25, 51, 35, 5, -50 },
  { 6436, 27, 50, 27, 0, -50 },
  { 6605, 46, 50, 46, 0, -50 },
  { 6893, 23, 50, 24, 1, -50 },
  { 7037, 23, 50, 23, 0, -50 },
  { 7181, 20, 50, 23, 2, -50 },
  { 7306, 13, 61, 21, 6, -50 },
  { 7406, 20, 50, 24, 2, -50 },
  { 7531, 14, 61, 21, 2, -50 },
  { 7638, 26, 25, 28, 1, -50 },
  { 7720, 28, 3, 28, 0, 6 },
  { 7731, 11, 11, 16, 3, -53 },
  { 7747, 19, 39, 26, 3, -38 },
  { 7840, 22, 54, 30, 5, -53 },
  { 7989, 18, 39, 22, 3, -38 },
  { 8077, 22, 54, 30, 3, -53 },
  { 8226, 21, 39, 27, 3, -38 },
  { 8329, 16, 54, 15, 1, -54 },
  { 8437, 22, 55, 30, 3, -38 },
  { 8589, 20, 53, 29, 5, -53 },
  { 8722, 5, 51, 13, 4, -51 },
  { 8754, 9, 68, 13, 0, -51 },
  { 8831, 18, 53, 24, 5, -53 },
  { 8951, 2, 53, 12, 5, -53 },
  { 8965, 34, 38, 44, 5, -38 },
  { 9127, 20, 38, 29, 5, -38 },
  { 9222, 23, 39, 29, 3, -38 },
  { 9335, 22, 54, 30, 5, -38 },
  { 9484, 22, 54, 30, 3, -38 },
  { 9633, 13, 38, 19, 5, -38 },
  { 9695, 18, 39, 22, 2, -38 },
  { 9783, 13, 47, 15, 1, -46 },
  { 9860, 19, 38, 29, 5, -37 },
  { 9951, 21, 37, 22, 0, -37 },
  { 10049, 35, 37, 37, 1, -37 },
  { 10211, 21, 37, 23, 1, -37 },
  { 10309, 21, 54, 23, 1, -37 },
  { 10451, 15, 37, 19, 2, -37 },
  { 10521, 18, 61, 24, 3, -50 },
  { 10659, 3, 70, 27, 12, -53 },
  { 10686, 18, 61, 24, 3, -50 },
  { 10824, 24, 6, 28, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight70pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT70PT7B_H_
