#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT22PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0x99, 0x99, 0x99, 0x11, 0x08, 0x84, 0x42, 0x41, 0x23,
  0xFC, 0x48, 0x24, 0x22, 0x11, 0x3F, 0xE4, 0x42, 0x41, 0x20, 0x90, 0x48,
  0x10, 0x21, 0xFC, 0x89, 0x12, 0x24, 0x48, 0x70, 0x30, 0x50, 0x91, 0x22,
  0x44, 0xEE, 0x30, 0x20, 0x60, 0x92, 0x22, 0x44, 0x48, 0x88, 0xA1, 0x14,
  0x24, 0xB4, 0xA9, 0x95, 0x2C, 0xA4, 0x28, 0x85, 0x10, 0x92, 0x22, 0x44,
  0x48, 0x86, 0x30, 0x48, 0x48, 0x48, 0x48, 0x48, 0x30, 0x20, 0x50, 0x91,
  0x8A, 0x8A, 0x86, 0x84, 0x86, 0x79, 0xFC, 0x12, 0x24, 0x44, 0x88, 0x88,
  0x88, 0x88, 0x44, 0x42, 0x30, 0x84, 0x42, 0x22, 0x11, 0x11, 0x11, 0x12,
  0x22, 0x24, 0x80, 0x20, 0x8E, 0xCC, 0x31, 0x20, 0x10, 0x20, 0x40, 0x81,
  0x1F, 0xC4, 0x08, 0x10, 0x20, 0x5A, 0x80, 0xF0, 0x70, 0x04, 0x10, 0x82,
  0x08, 0x41, 0x04, 0x20, 0x84, 0x10, 0x42, 0x08, 0x20, 0x38, 0x89, 0x14,
  0x28, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x28, 0x91, 0x1C, 0x17,
  0xD9, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x79, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x08, 0x10, 0x41, 0x02, 0x08, 0x20, 0x7F, 0x79, 0x08, 0x10,
  0x10, 0x20, 0x81, 0x3C, 0x08, 0x08, 0x08, 0x10, 0x20, 0x41, 0x7C, 0x02,
  0x03, 0x01, 0x81, 0x40, 0xA0, 0x90, 0x48, 0x44, 0x22, 0x21, 0x10, 0x9F,
  0xF0, 0x20, 0x10, 0x08, 0x04, 0x7C, 0x82, 0x04, 0x08, 0x10, 0x2C, 0x66,
  0x04, 0x04, 0x08, 0x10, 0x20, 0x41, 0x7C, 0x1C, 0x41, 0x02, 0x08, 0x10,
  0x2E, 0x62, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x51, 0x1E, 0xFE, 0x04, 0x10,
  0x20, 0x41, 0x02, 0x04, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x20, 0x38,
  0x8A, 0x0C, 0x18, 0x28, 0x93, 0x18, 0x28, 0x8A, 0x0C, 0x18, 0x30, 0x61,
  0x3E, 0x38, 0x8A, 0x14, 0x28, 0x30, 0x60, 0xC1, 0x46, 0xF4, 0x08, 0x20,
  0x40, 0x82, 0x38, 0x70, 0x00, 0x07, 0x70, 0x00, 0x05, 0xA8, 0x06, 0x10,
  0xC6, 0x0C, 0x04, 0x06, 0x02, 0x02, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x80, 0xC0, 0x60, 0x30, 0x61, 0x0C, 0x60, 0x80, 0xF0, 0x20, 0x41, 0x04,
  0x20, 0x84, 0x10, 0x82, 0x08, 0x00, 0x02, 0x08, 0x0F, 0x02, 0x10, 0x81,
  0x20, 0x14, 0x02, 0x9E, 0x62, 0x4C, 0x89, 0x91, 0x32, 0x26, 0x44, 0xC8,
  0x98, 0xB2, 0x89, 0x90, 0x02, 0x00, 0x20, 0x03, 0xE0, 0x08, 0x0C, 0x05,
  0x02, 0x81, 0x41, 0x20, 0x90, 0x44, 0x22, 0x1F, 0x10, 0x88, 0x24, 0x12,
  0x0A, 0x05, 0x01, 0xF9, 0x0A, 0x14, 0x18, 0x30, 0xA1, 0x7C, 0x8D, 0x0A,
  0x0C, 0x18, 0x30, 0x61, 0x7C, 0x1F, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x1F, 0xF1, 0x1A, 0x14,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xA1, 0x7C, 0xFC,
  0x21, 0x08, 0x42, 0x1F, 0x84, 0x21, 0x08, 0x42, 0x1F, 0xFC, 0x21, 0x08,
  0x42, 0x10, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x0F, 0x18, 0x50, 0x08, 0x04,
  0x04, 0x02, 0x01, 0x00, 0x83, 0xC0, 0x60, 0x30, 0x14, 0x0A, 0x04, 0x82,
  0x3F, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0xE9, 0x24, 0x92, 0x49, 0x24, 0x97, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x2E, 0x85, 0x0A, 0x24, 0x49, 0x14,
  0x28, 0x70, 0xA1, 0x22, 0x44, 0x48, 0x91, 0x21, 0x43, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x80, 0x30, 0x0F, 0x01, 0xE0,
  0x3C, 0x0B, 0x41, 0x68, 0x2D, 0x09, 0xA1, 0x32, 0x26, 0x44, 0xC9, 0x18,
  0xA3, 0x14, 0x63, 0x0C, 0x21, 0x81, 0x81, 0xC1, 0xC1, 0xA1, 0xA1, 0xA1,
  0x91, 0x91, 0x89, 0x89, 0x85, 0x85, 0x83, 0x83, 0x81, 0x1E, 0x10, 0x90,
  0x48, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x14, 0x0A,
  0x08, 0x84, 0x7C, 0xF2, 0x28, 0x61, 0x86, 0x18, 0x61, 0x9B, 0x88, 0x20,
  0x82, 0x08, 0x20, 0x1E, 0x10, 0x90, 0x48, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x14, 0x0A, 0x08, 0x84, 0x7C, 0x04, 0x01, 0x00,
  0x80, 0x20, 0xF1, 0x12, 0x14, 0x28, 0x50, 0xA1, 0x44, 0xF1, 0x22, 0x44,
  0x48, 0x90, 0xA1, 0x41, 0x3E, 0x82, 0x04, 0x08, 0x10, 0x10, 0x10, 0x18,
  0x08, 0x08, 0x10, 0x20, 0x41, 0x7C, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xBE, 0x81, 0x81,
  0x81, 0x41, 0x42, 0x42, 0x42, 0x22, 0x22, 0x24, 0x24, 0x14, 0x14, 0x18,
  0x18, 0x08, 0x81, 0x06, 0x04, 0x18, 0x30, 0x50, 0xC1, 0x42, 0x85, 0x0A,
  0x24, 0x28, 0x89, 0x22, 0x24, 0x88, 0x91, 0x22, 0x45, 0x09, 0x14, 0x18,
  0x50, 0x61, 0x41, 0x82, 0x06, 0x08, 0x42, 0x85, 0x09, 0x22, 0x43, 0x06,
  0x0C, 0x18, 0x30, 0x91, 0x22, 0x48, 0x50, 0xC1, 0x83, 0x05, 0x0A, 0x24,
  0x44, 0x8A, 0x14, 0x18, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0xFC, 0x10,
  0x82, 0x10, 0x41, 0x08, 0x20, 0x84, 0x10, 0x42, 0x08, 0x3F, 0xF8, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x82, 0x08, 0x10, 0x41,
  0x02, 0x08, 0x20, 0x41, 0x04, 0x08, 0x20, 0x41, 0xF1, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x08, 0x04, 0x05, 0x02, 0x82, 0x21,
  0x11, 0x05, 0x83, 0xFF, 0x80, 0x88, 0x90, 0x7A, 0x20, 0x41, 0x04, 0xF4,
  0x61, 0x86, 0x18, 0xDD, 0x81, 0x02, 0x04, 0x08, 0x17, 0x31, 0x42, 0x85,
  0x06, 0x0C, 0x18, 0x30, 0xA1, 0x42, 0xF8, 0x3D, 0x04, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x04, 0x0F, 0x02, 0x04, 0x08, 0x10, 0x27, 0x51, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xA3, 0x7A, 0x38, 0x8A, 0x14, 0x18, 0x3F,
  0xE0, 0x40, 0x81, 0x01, 0x01, 0xE0, 0x19, 0x08, 0x42, 0x78, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x20, 0x3A, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x05, 0x1B, 0xD0, 0x20, 0x40, 0x82, 0xFC, 0x82, 0x08, 0x20, 0x82,
  0xCC, 0xA1, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0xD0, 0x55, 0x55,
  0x55, 0x64, 0x04, 0x92, 0x49, 0x24, 0x92, 0x49, 0x2C, 0x84, 0x21, 0x08,
  0x46, 0x52, 0xA5, 0x39, 0x49, 0x4A, 0x51, 0x88, 0xFF, 0xFF, 0x80, 0xF3,
  0xA3, 0x18, 0xC6, 0x21, 0x88, 0x62, 0x18, 0x86, 0x21, 0x88, 0x62, 0x18,
  0x86, 0x21, 0xB3, 0x28, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x38,
  0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0x11, 0xE0, 0xB9, 0x8A,
  0x14, 0x28, 0x30, 0x60, 0xC1, 0x85, 0x0A, 0x17, 0xC8, 0x10, 0x20, 0x40,
  0x80, 0x3A, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0x1B, 0xD0,
  0x20, 0x40, 0x81, 0x02, 0xBC, 0x88, 0x88, 0x88, 0x88, 0x88, 0x7C, 0x21,
  0x08, 0x20, 0xC1, 0x08, 0x43, 0xE0, 0x22, 0x3E, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x82, 0x18, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05,
  0x1B, 0xD0, 0x83, 0x09, 0x12, 0x24, 0x48, 0x92, 0x14, 0x28, 0x50, 0x40,
  0x80, 0x84, 0x30, 0xC5, 0x18, 0xA3, 0x14, 0xA2, 0x92, 0x92, 0x51, 0x4A,
  0x29, 0x46, 0x28, 0xC2, 0x08, 0x40, 0x42, 0x89, 0x11, 0x42, 0x82, 0x04,
  0x14, 0x28, 0x89, 0x16, 0x10, 0x82, 0x85, 0x0A, 0x24, 0x44, 0x89, 0x14,
  0x28, 0x30, 0x40, 0x81, 0x02, 0x04, 0x10, 0xE0, 0xF1, 0x12, 0x22, 0x44,
  0x48, 0x8F, 0x0C, 0x42, 0x08, 0x20, 0x82, 0x08, 0x23, 0x06, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x81, 0x03, 0xFF, 0xFF, 0xFC, 0xC0, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x10, 0x71, 0x04, 0x20, 0x82, 0x08, 0x20, 0x86, 0x20, 0x63,
  0x3C,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 16, 4, 2, -16 },
  { 3, 4, 6, 7, 1, -16 },
  { 6, 9, 16, 9, 0, -16 },
  { 24, 7, 18, 9, 1, -17 },
  { 40, 11, 16, 13, 1, -16 },
  { 62, 8, 16, 9, 1, -16 },
  { 78, 1, 6, 4, 1, -16 },
  { 79, 4, 19, 6, 1, -16 },
  { 89, 4, 19, 6, 1, -16 },
  { 99, 6, 6, 8, 1, -17 },
  { 104, 7, 10, 9, 1, -13 },
  { 113, 2, 5, 4, 1, -2 },
  { 115, 4, 1, 6, 1, -6 },
  { 116, 2, 2, 4, 1, -2 },
  { 117, 6, 16, 7, 1, -16 },
  { 129, 7, 16, 9, 1, -16 },
  { 143, 4, 16, 9, 2, -16 },
  { 151, 7, 16, 9, 1, -16 },
  { 165, 7, 16, 9, 1, -16 },
  { 179, 9, 16, 9, 0, -16 },
  { 197, 7, 16, 9, 1, -16 },
  { 211, 7, 16, 9, 1, -16 },
  { 225, 7, 16, 9, 1, -16 },
  { 239, 7, 16, 9, 1, -16 },
  { 253, 7, 16, 9, 1, -16 },
  { 267, 2, 12, 4, 1, -12 },
  { 270, 2, 15, 4, 1, -12 },
  { 274, 7, 9, 9, 1, -12 },
  { 282, 7, 6, 9, 1, -11 },
  { 288, 7, 9, 9, 1, -12 },
  { 296, 6, 16, 6, 0, -16 },
  { 308, 11, 18, 13, 1, -16 },
  { 333, 9, 16, 9, 0, -16 },
  { 351, 7, 16, 10, 2, -16 },
  { 365, 8, 16, 9, 1, -16 },
  { 381, 7, 16, 11, 2, -16 },
  { 395, 5, 16, 8, 2, -16 },
  { 405, 5, 16, 8, 2, -16 },
  { 415, 9, 16, 12, 1, -16 },
  { 433, 7, 16, 11, 2, -16 },
  { 447, 3, 16, 5, 1, -16 },
  { 453, 4, 20, 4, -1, -16 },
  { 463, 7, 16, 9, 2, -16 },
  { 477, 5, 16, 8, 2, -16 },
  { 487, 11, 16, 15, 2, -16 },
  { 509, 8, 16, 11, 2, -16 },
  { 525, 9, 16, 11, 1, -16 },
  { 543, 6, 16, 9, 2, -16 },
  { 555, 9, 20, 11, 1, -16 },
  { 578, 7, 16, 9, 2, -16 },
  { 592, 7, 16, 9, 1, -16 },
  { 606, 7, 16, 8, 0, -16 },
  { 620, 7, 16, 11, 2, -16 },
  { 634, 8, 16, 8, 0, -16 },
  { 650, 14, 16, 15, 0, -16 },
  { 678, 7, 16, 8, 0, -16 },
  { 692, 7, 16, 7, 0, -16 },
  { 706, 6, 16, 7, 1, -16 },
  { 718, 4, 20, 7, 2, -16 },
  { 728, 6, 16, 7, 1, -16 },
  { 740, 4, 20, 7, 1, -16 },
  { 750, 9, 8, 9, 0, -16 },
  { 759, 9, 1, 9, 0, 2 },
  { 761, 3, 4, 5, 1, -17 },
  { 763, 6, 12, 8, 1, -12 },
  { 772, 7, 17, 10, 2, -17 },
  { 787, 6, 12, 7, 1, -12 },
  { 796, 7, 17, 10, 1, -17 },
  { 811, 7, 12, 9, 1, -12 },
  { 822, 5, 17, 5, 0, -17 },
  { 833, 7, 17, 9, 1, -12 },
  { 848, 6, 17, 9, 2, -17 },
  { 861, 2, 16, 4, 1, -16 },
  { 865, 3, 21, 4, 0, -16 },
  { 873, 5, 17, 7, 2, -17 },
  { 884, 1, 17, 4, 1, -17 },
  { 887, 10, 12, 14, 2, -12 },
  { 902, 6, 12, 9, 2, -12 },
  { 911, 7, 12, 9, 1, -12 },
  { 922, 7, 17, 9, 2, -12 },
  { 937, 7, 17, 9, 1, -12 },
  { 952, 4, 12, 6, 2, -12 },
  { 958, 5, 12, 7, 1, -12 },
  { 966, 5, 14, 5, 0, -14 },
  { 975, 7, 12, 9, 1, -12 },
  { 986, 7, 12, 7, 0, -12 },
  { 997, 11, 12, 12, 0, -12 },
  { 1014, 7, 12, 7, 0, -12 },
  { 1025, 7, 17, 7, 0, -12 },
  { 1040, 4, 12, 6, 1, -12 },
  { 1046, 6, 20, 8, 1, -16 },
  { 1061, 1, 22, 8, 4, -17 },
  { 1064, 6, 20, 8, 1, -16 },
  { 1079, 7, 2, 9, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight22pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT22PT7B_H_
