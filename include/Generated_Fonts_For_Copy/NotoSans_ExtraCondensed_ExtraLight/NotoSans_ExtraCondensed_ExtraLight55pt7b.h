#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT55PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x24,
  0x00, 0x00, 0x7F, 0xF8, 0xC1, 0xF0, 0x7C, 0x1F, 0x06, 0xC1, 0xB0, 0x6C,
  0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x1B, 0x06, 0xC0, 0xB0, 0x20, 0x00, 0xC0,
  0xC0, 0x02, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0,
  0x06, 0x03, 0x00, 0x18, 0x08, 0x00, 0x60, 0x20, 0x01, 0x81, 0x80, 0x06,
  0x06, 0x00, 0x10, 0x18, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x0C, 0x06,
  0x00, 0x30, 0x18, 0x00, 0xC0, 0x40, 0x03, 0x01, 0x00, 0x0C, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60,
  0x30, 0x01, 0x80, 0xC0, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x60, 0x60,
  0x01, 0x01, 0x80, 0x04, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x03,
  0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x10, 0x00, 0xC0, 0xC0, 0x03, 0x03,
  0x00, 0x08, 0x0C, 0x00, 0x20, 0x30, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x0F, 0xFE, 0x07, 0xF7, 0xE3,
  0x8C, 0x11, 0xC3, 0x00, 0x60, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03,
  0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xE0, 0xC0,
  0x18, 0x30, 0x03, 0x0C, 0x00, 0x73, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0xDE, 0x00, 0x31, 0xC0, 0x0C, 0x38, 0x03,
  0x06, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0,
  0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x06, 0x00, 0xC3, 0xB0, 0x31, 0xCF,
  0xEF, 0xE0, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x04, 0x01, 0xF8, 0x00, 0x80, 0x30,
  0xC0, 0x18, 0x03, 0x0C, 0x01, 0x80, 0x60, 0x60, 0x10, 0x06, 0x06, 0x03,
  0x00, 0x60, 0x60, 0x30, 0x06, 0x06, 0x02, 0x00, 0x40, 0x60, 0x60, 0x04,
  0x02, 0x06, 0x00, 0xC0, 0x20, 0x40, 0x0C, 0x03, 0x0C, 0x00, 0xC0, 0x30,
  0xC0, 0x0C, 0x03, 0x08, 0x00, 0xC0, 0x21, 0x80, 0x04, 0x02, 0x18, 0x00,
  0x40, 0x61, 0x0F, 0x86, 0x06, 0x31, 0xDC, 0x60, 0x63, 0x18, 0xC6, 0x06,
  0x23, 0x06, 0x60, 0x66, 0x30, 0x63, 0x0C, 0x62, 0x02, 0x39, 0xC4, 0x60,
  0x31, 0xF8, 0xC6, 0x03, 0x0E, 0x0C, 0x60, 0x30, 0x00, 0x86, 0x03, 0x00,
  0x18, 0x60, 0x30, 0x01, 0x86, 0x03, 0x00, 0x10, 0x60, 0x30, 0x03, 0x06,
  0x03, 0x00, 0x30, 0x60, 0x30, 0x03, 0x06, 0x03, 0x00, 0x60, 0x60, 0x30,
  0x06, 0x06, 0x03, 0x00, 0x60, 0x20, 0x30, 0x0C, 0x03, 0x06, 0x00, 0xC0,
  0x30, 0x60, 0x0C, 0x01, 0x06, 0x01, 0x80, 0x18, 0xC0, 0x18, 0x00, 0xF8,
  0x00, 0x00, 0x02, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0C, 0x30, 0x01,
  0xC1, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80,
  0x18, 0x18, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x18, 0x18,
  0x00, 0xC1, 0x00, 0x0C, 0x30, 0x00, 0xC7, 0x00, 0x06, 0x60, 0x00, 0x6C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0D, 0x80, 0x01, 0x8C, 0x00, 0x30,
  0xC0, 0x07, 0x06, 0x06, 0x60, 0x60, 0x6E, 0x03, 0x06, 0xC0, 0x30, 0x6C,
  0x01, 0x86, 0xC0, 0x1C, 0xCC, 0x00, 0xCC, 0xC0, 0x06, 0xCC, 0x00, 0x78,
  0xC0, 0x03, 0x8C, 0x00, 0x38, 0xC0, 0x07, 0x86, 0x00, 0x6C, 0x60, 0x0C,
  0xC3, 0x01, 0x86, 0x3C, 0xF0, 0x61, 0xFE, 0x03, 0x01, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0xC0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0xC0,
  0x60, 0x18, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0,
  0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0xC0, 0x18, 0x07, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C,
  0x03, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x0C,
  0x06, 0x03, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x0C, 0x20, 0xFE, 0x4F, 0x8F, 0xF8, 0x01, 0x80, 0x07, 0x80, 0x19, 0x00,
  0x63, 0x01, 0x83, 0x03, 0x03, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0xC6, 0x73, 0x18,
  0xC6, 0x63, 0x18, 0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x07,
  0xF8, 0x07, 0x8E, 0x03, 0x03, 0x83, 0x00, 0xC1, 0x80, 0x71, 0x80, 0x18,
  0xC0, 0x0C, 0x60, 0x06, 0x70, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00,
  0x36, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x06,
  0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00,
  0x1B, 0x00, 0x0D, 0xC0, 0x06, 0x60, 0x06, 0x30, 0x03, 0x1C, 0x01, 0x86,
  0x01, 0x83, 0x80, 0xC0, 0xE0, 0xC0, 0x3F, 0xE0, 0x0F, 0xC0, 0x01, 0xC0,
  0xF0, 0x7C, 0x3B, 0x1C, 0xCE, 0x36, 0x0F, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0xE0, 0x0F, 0xFC, 0x1F, 0x0F, 0x0C, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xC0, 0x0F, 0xFC, 0x1E, 0x0F, 0x1C, 0x01, 0xC4, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x3C, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x76, 0x00, 0x73, 0xF1, 0xF0, 0x7F,
  0xE0, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xB0, 0x00, 0x1B, 0x00, 0x01, 0x30, 0x00, 0x33, 0x00, 0x03, 0x30,
  0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01, 0x83,
  0x00, 0x18, 0x30, 0x03, 0x03, 0x00, 0x30, 0x30, 0x06, 0x03, 0x00, 0x60,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x03, 0x01, 0x80, 0x30, 0x30,
  0x03, 0x03, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x86, 0x00, 0xFF, 0xF0, 0x7C, 0x3C, 0x10, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x88, 0x03,
  0xC7, 0xDF, 0x81, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x78, 0x01, 0xFF, 0x01,
  0xE1, 0x81, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC3, 0xF0, 0x67, 0xFC, 0x36, 0x07, 0x1A,
  0x00, 0xCE, 0x00, 0x67, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03,
  0x60, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x06, 0xE0, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCE, 0x00, 0xC3,
  0x00, 0x61, 0xC0, 0x60, 0x78, 0xF0, 0x1F, 0xE0, 0x01, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x01, 0xE0,
  0x01, 0xFF, 0x01, 0xE1, 0xE0, 0xE0, 0x1C, 0x30, 0x03, 0x1C, 0x00, 0xE6,
  0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80,
  0x06, 0x70, 0x01, 0x8C, 0x00, 0xC3, 0x80, 0x70, 0x70, 0x18, 0x0E, 0x1C,
  0x01, 0xCE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x07, 0x70, 0x03, 0x87, 0x01,
  0xC0, 0xE0, 0xE0, 0x1C, 0x30, 0x03, 0x18, 0x00, 0x66, 0x00, 0x1B, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x36, 0x00, 0x19, 0x80, 0x06, 0x70, 0x03, 0x8E, 0x01, 0xC1,
  0xE1, 0xE0, 0x1F, 0xE0, 0x00, 0x40, 0x00, 0x01, 0xE0, 0x07, 0xFC, 0x07,
  0x87, 0x07, 0x01, 0xC3, 0x00, 0x63, 0x80, 0x39, 0x80, 0x0C, 0xC0, 0x06,
  0xE0, 0x03, 0x60, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xEC,
  0x00, 0x77, 0x00, 0x79, 0x80, 0x2C, 0x70, 0x76, 0x1F, 0xF3, 0x07, 0xE1,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0xE7, 0xC0, 0x7F, 0x80, 0x04, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x39, 0xCE,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x18, 0xCE, 0x73, 0x18, 0xCC, 0x63, 0x11, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x80,
  0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x00, 0x1F, 0x03, 0xFE, 0x38, 0x39, 0x00,
  0xE0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x1C, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x06, 0x60, 0x0F, 0xE0, 0x66, 0x01, 0xC6, 0x06,
  0x60, 0x30, 0x60, 0x26, 0x07, 0x06, 0x03, 0xC0, 0x60, 0x60, 0x3C, 0x06,
  0x06, 0x03, 0xC0, 0xC0, 0x60, 0x3C, 0x0C, 0x06, 0x03, 0xC0, 0xC0, 0x60,
  0x3C, 0x0C, 0x06, 0x03, 0xC0, 0xC0, 0x60, 0x3C, 0x0C, 0x06, 0x03, 0xC0,
  0xC0, 0x60, 0x3C, 0x0C, 0x06, 0x03, 0xC0, 0xC0, 0xE0, 0x3C, 0x0C, 0x0E,
  0x06, 0xC0, 0xC0, 0xA0, 0x6C, 0x0C, 0x0A, 0x06, 0xC0, 0x61, 0xA0, 0xC4,
  0x07, 0x33, 0x1C, 0x60, 0x3F, 0x1F, 0x86, 0x01, 0xC0, 0xF0, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x01, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x36, 0x00,
  0x00, 0xD8, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x23, 0x00, 0x01,
  0x8C, 0x00, 0x06, 0x10, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x03, 0x06,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x06, 0x03, 0x00,
  0x18, 0x0C, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1C, 0x00, 0xC0, 0x60, 0x03,
  0x01, 0x80, 0x0E, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x83,
  0x00, 0x07, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00,
  0x03, 0x18, 0x00, 0x06, 0x60, 0x00, 0x1B, 0x80, 0x00, 0x6C, 0x00, 0x01,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0C, 0x00, 0xE3, 0x00, 0x1C, 0xC0, 0x03,
  0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C,
  0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0xEC, 0x00, 0x33, 0x00,
  0x1C, 0xC0, 0x0E, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0x00, 0xF0, 0xC0, 0x07,
  0x30, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x3B, 0x00, 0x1C, 0xC0, 0x1E,
  0x3F, 0xFF, 0x0F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x0F, 0x07,
  0x83, 0x80, 0x20, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x40,
  0xFC, 0x78, 0x07, 0xFE, 0x00, 0x18, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0xC0, 0x1E, 0x0C, 0x00, 0x70, 0xC0, 0x03, 0x0C, 0x00, 0x38, 0xC0, 0x01,
  0x8C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x00,
  0xCC, 0x00, 0x1C, 0xC0, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x07, 0x0C, 0x00,
  0xE0, 0xC0, 0x3C, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF, 0xFB, 0xFF, 0xF6, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0xFF,
  0xEF, 0xFF, 0xD8, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0x81, 0xF0, 0x3C, 0x00,
  0x60, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xDC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x06,
  0x70, 0x00, 0x0C, 0x70, 0x00, 0x18, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x60,
  0xF0, 0x01, 0xC0, 0x7C, 0x7F, 0x80, 0x7F, 0xFC, 0x00, 0x05, 0x00, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x18, 0xFF, 0x8C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x83, 0xF3, 0xFE, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01,
  0x80, 0xE8, 0x73, 0xFC, 0x7C, 0x00, 0xC0, 0x03, 0xB0, 0x00, 0xCC, 0x00,
  0x73, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x07, 0x0C, 0x01, 0x83, 0x00, 0xE0,
  0xC0, 0x30, 0x30, 0x18, 0x0C, 0x0E, 0x03, 0x03, 0x00, 0xC1, 0xC0, 0x30,
  0x60, 0x0C, 0x30, 0x03, 0x1C, 0x00, 0xC6, 0x00, 0x33, 0x80, 0x0C, 0xF0,
  0x03, 0x6C, 0x00, 0xD3, 0x80, 0x3C, 0x60, 0x0E, 0x1C, 0x03, 0x03, 0x00,
  0xC0, 0xE0, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x00, 0xC0, 0xC0, 0x38, 0x30,
  0x06, 0x0C, 0x01, 0xC3, 0x00, 0x30, 0xC0, 0x0E, 0x30, 0x01, 0x8C, 0x00,
  0x63, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x1C, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xD8, 0x00, 0x00,
  0xFD, 0x80, 0x00, 0x0F, 0xD8, 0x00, 0x01, 0xBC, 0xC0, 0x00, 0x1B, 0xCC,
  0x00, 0x01, 0xBC, 0xC0, 0x00, 0x33, 0xCC, 0x00, 0x03, 0x3C, 0x60, 0x00,
  0x33, 0xC6, 0x00, 0x07, 0x3C, 0x60, 0x00, 0x63, 0xC3, 0x00, 0x06, 0x3C,
  0x30, 0x00, 0x63, 0xC3, 0x00, 0x0C, 0x3C, 0x18, 0x00, 0xC3, 0xC1, 0x80,
  0x0C, 0x3C, 0x18, 0x01, 0x83, 0xC1, 0x80, 0x18, 0x3C, 0x0C, 0x01, 0x83,
  0xC0, 0xC0, 0x38, 0x3C, 0x0C, 0x03, 0x03, 0xC0, 0x60, 0x30, 0x3C, 0x06,
  0x03, 0x03, 0xC0, 0x60, 0x60, 0x3C, 0x03, 0x06, 0x03, 0xC0, 0x30, 0x60,
  0x3C, 0x03, 0x0C, 0x03, 0xC0, 0x38, 0xC0, 0x3C, 0x01, 0x8C, 0x03, 0xC0,
  0x19, 0x80, 0x3C, 0x01, 0x98, 0x03, 0xC0, 0x0D, 0x80, 0x3C, 0x00, 0xD8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x00, 0x30,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xD8, 0x00,
  0x3D, 0x80, 0x03, 0xCC, 0x00, 0x3C, 0xC0, 0x03, 0xCE, 0x00, 0x3C, 0x60,
  0x03, 0xC6, 0x00, 0x3C, 0x30, 0x03, 0xC3, 0x00, 0x3C, 0x18, 0x03, 0xC1,
  0x80, 0x3C, 0x0C, 0x03, 0xC0, 0xC0, 0x3C, 0x0E, 0x03, 0xC0, 0x60, 0x3C,
  0x06, 0x03, 0xC0, 0x30, 0x3C, 0x03, 0x03, 0xC0, 0x18, 0x3C, 0x01, 0x83,
  0xC0, 0x1C, 0x3C, 0x00, 0xC3, 0xC0, 0x0C, 0x3C, 0x00, 0x63, 0xC0, 0x06,
  0x3C, 0x00, 0x33, 0xC0, 0x03, 0x3C, 0x00, 0x1B, 0xC0, 0x01, 0xBC, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x30, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x1E, 0x0F, 0x00, 0x70,
  0x07, 0x01, 0xC0, 0x06, 0x03, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x0C, 0x70, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x73, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06,
  0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x37, 0x00, 0x00, 0x66, 0x00,
  0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x07, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x70, 0xE0, 0x00, 0xC0, 0xC0, 0x03, 0x80, 0xC0, 0x0E,
  0x01, 0xE0, 0x38, 0x01, 0xFB, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x18, 0x00,
  0xFF, 0xE0, 0xFF, 0xF8, 0xC0, 0x3C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06,
  0xC0, 0x0E, 0xC0, 0x1C, 0xC1, 0xF8, 0xFF, 0xE0, 0xFC, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00,
  0x1E, 0x0F, 0x00, 0x70, 0x07, 0x01, 0xC0, 0x06, 0x03, 0x00, 0x0E, 0x0E,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x70, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0x73, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x07, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x70, 0xE0, 0x00, 0xC0, 0xC0,
  0x03, 0x80, 0xC0, 0x0E, 0x01, 0xE0, 0x38, 0x01, 0xFB, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0x16, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0xFF, 0xE0, 0x3F, 0xFE, 0x0C, 0x01, 0xC3, 0x00, 0x38,
  0xC0, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30,
  0x00, 0xCC, 0x00, 0x3B, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00,
  0x33, 0x00, 0x0C, 0xC0, 0x06, 0x30, 0x03, 0x8C, 0x01, 0xC3, 0x03, 0xE0,
  0xFF, 0xE0, 0x3F, 0xF0, 0x0C, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x1C, 0x0C, 0x03, 0x03, 0x00, 0xE0, 0xC0, 0x18, 0x30, 0x07, 0x0C, 0x00,
  0xC3, 0x00, 0x30, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x73, 0x00, 0x0C,
  0xC0, 0x03, 0xB0, 0x00, 0x6C, 0x00, 0x1C, 0x01, 0xF8, 0x03, 0xFF, 0x87,
  0xC1, 0xE3, 0x00, 0x23, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x76, 0x00, 0x73, 0xFB, 0xF0, 0xFF, 0xE0, 0x01, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0xEC, 0x00, 0x19, 0xC0, 0x03, 0x18, 0x00, 0xC3, 0xC0, 0x38,
  0x3F, 0x7E, 0x01, 0xFF, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x01,
  0xD8, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x18, 0xC0,
  0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0E, 0x00, 0x30,
  0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x01, 0x80,
  0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x0C, 0x06, 0x00,
  0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x06,
  0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0xC6, 0x00, 0x06, 0x30, 0x00, 0x33, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0,
  0x00, 0x36, 0x00, 0x01, 0xA0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x36, 0x00, 0x06, 0x00, 0x03, 0x60,
  0x00, 0x70, 0x00, 0x76, 0x00, 0x0F, 0x00, 0x06, 0x60, 0x00, 0xF0, 0x00,
  0x67, 0x00, 0x0F, 0x00, 0x06, 0x30, 0x00, 0xD0, 0x00, 0xE3, 0x00, 0x0D,
  0x80, 0x0C, 0x30, 0x01, 0x98, 0x00, 0xC3, 0x00, 0x19, 0x80, 0x0C, 0x18,
  0x01, 0x98, 0x00, 0xC1, 0x80, 0x19, 0x80, 0x1C, 0x18, 0x01, 0x8C, 0x01,
  0x81, 0x80, 0x30, 0xC0, 0x18, 0x1C, 0x03, 0x0C, 0x01, 0x80, 0xC0, 0x30,
  0xC0, 0x18, 0x0C, 0x03, 0x0C, 0x03, 0x80, 0xC0, 0x30, 0x60, 0x30, 0x0C,
  0x06, 0x06, 0x03, 0x00, 0xE0, 0x60, 0x60, 0x30, 0x06, 0x06, 0x06, 0x07,
  0x00, 0x60, 0x60, 0x60, 0x60, 0x06, 0x06, 0x03, 0x06, 0x00, 0x60, 0xC0,
  0x30, 0x60, 0x03, 0x0C, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x30, 0xE0, 0x03,
  0x0C, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x18, 0xC0, 0x03, 0x18, 0x01, 0x8C,
  0x00, 0x19, 0x80, 0x18, 0xC0, 0x01, 0x98, 0x01, 0x98, 0x00, 0x19, 0x80,
  0x19, 0x80, 0x01, 0x98, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x00,
  0xF0, 0x00, 0xD8, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0xCE, 0x00, 0x31, 0x80, 0x18, 0x60, 0x06, 0x0C, 0x03, 0x83, 0x00, 0xC0,
  0xC0, 0x30, 0x18, 0x18, 0x06, 0x06, 0x01, 0x81, 0x80, 0x30, 0xC0, 0x0C,
  0x30, 0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x19, 0x80, 0x06, 0x60, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x18,
  0x30, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x18, 0x03,
  0x06, 0x00, 0xE3, 0x00, 0x18, 0xC0, 0x06, 0x70, 0x01, 0xD8, 0x00, 0x3E,
  0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x76, 0x00, 0x19, 0x80, 0x06, 0x30,
  0x03, 0x8C, 0x00, 0xC3, 0x00, 0x30, 0x60, 0x1C, 0x18, 0x06, 0x06, 0x01,
  0x80, 0xC0, 0xE0, 0x30, 0x30, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x61, 0x80,
  0x18, 0x60, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0xFF, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF8, 0x00, 0x0D, 0x80, 0x01, 0x9C, 0x00, 0x18, 0xC0, 0x03, 0x0C,
  0x00, 0x30, 0x60, 0x06, 0x06, 0x00, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x18, 0x18, 0x01, 0x81, 0x80, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0E, 0x60,
  0x00, 0x66, 0x00, 0x07, 0xC0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80,
  0x01, 0xC0, 0x3F, 0xE0, 0xF0, 0xE1, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x0F, 0xC1, 0xFF, 0x8F, 0x03, 0x38, 0x06, 0xE0, 0x0D, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1D, 0x80, 0x7B, 0x81, 0xB3, 0x86, 0x63, 0xF8, 0xC0, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x0E, 0x06, 0x3F, 0xC3, 0x38, 0xF1, 0xB0, 0x1C, 0xD0, 0x06, 0x78,
  0x01, 0xB8, 0x00, 0xDC, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x6E, 0x00, 0x37, 0x80, 0x3B, 0x40, 0x19, 0xB0, 0x1C,
  0xCF, 0x3C, 0x63, 0xFC, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x1F, 0xF0, 0xF1,
  0x86, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1F, 0x38, 0x1F, 0xE0,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x01, 0xC0, 0xC1, 0xFE, 0x30, 0xF1, 0xCC,
  0x70, 0x1B, 0x18, 0x02, 0xCC, 0x00, 0xF3, 0x00, 0x1D, 0xC0, 0x07, 0x60,
  0x01, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x36, 0x00, 0x0D,
  0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x1D, 0x80, 0x07, 0x30,
  0x01, 0xCC, 0x00, 0xF3, 0x80, 0x2C, 0x70, 0x1B, 0x0F, 0x1C, 0xC1, 0xFE,
  0x30, 0x08, 0x00, 0x01, 0x80, 0x0F, 0xF0, 0x1C, 0x38, 0x38, 0x1C, 0x30,
  0x0C, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x02, 0x1F,
  0x1E, 0x07, 0xFC, 0x00, 0x80, 0x03, 0xF0, 0x7F, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x0F, 0xFC, 0xFF, 0xC1, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x01, 0xFE,
  0x30, 0xF1, 0xCC, 0x70, 0x1B, 0x38, 0x02, 0xCC, 0x00, 0xF3, 0x00, 0x1D,
  0x80, 0x07, 0x60, 0x01, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xD8, 0x00,
  0x36, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x76, 0x00, 0x1D,
  0x80, 0x07, 0x30, 0x01, 0xCC, 0x00, 0xB3, 0x80, 0x6C, 0x70, 0x33, 0x0F,
  0x3C, 0xC1, 0xFC, 0x30, 0x08, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x1C, 0x60, 0x0E, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x0C, 0x18, 0xFE, 0x33,
  0x9E, 0x6C, 0x0E, 0xD0, 0x0D, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0C, 0xDF, 0xE0, 0x00, 0x00, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0x0C, 0x1C, 0x78, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x67, 0xCF, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x7C, 0x03, 0xB0, 0x0C, 0xC0, 0x63,
  0x01, 0x8C, 0x0C, 0x30, 0x70, 0xC1, 0x83, 0x0C, 0x0C, 0x30, 0x31, 0x80,
  0xCE, 0x03, 0x3C, 0x0D, 0xB0, 0x34, 0xC0, 0xF1, 0x83, 0x86, 0x0C, 0x1C,
  0x30, 0x30, 0xC0, 0xC3, 0x01, 0x8C, 0x06, 0x30, 0x0C, 0xC0, 0x33, 0x00,
  0xCC, 0x01, 0xB0, 0x06, 0xC0, 0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x1C, 0x10, 0xFE,
  0x0F, 0xE2, 0x31, 0xC3, 0x1E, 0x6C, 0x0C, 0xC0, 0xCF, 0x01, 0xB0, 0x0D,
  0xC0, 0x1C, 0x01, 0xB8, 0x03, 0x80, 0x36, 0x00, 0x70, 0x06, 0xC0, 0x0E,
  0x00, 0xF8, 0x01, 0x80, 0x1F, 0x00, 0x30, 0x03, 0xE0, 0x06, 0x00, 0x7C,
  0x00, 0xC0, 0x0F, 0x80, 0x18, 0x01, 0xF0, 0x03, 0x00, 0x3E, 0x00, 0x60,
  0x07, 0xC0, 0x0C, 0x00, 0xF8, 0x01, 0x80, 0x1F, 0x00, 0x30, 0x03, 0xE0,
  0x06, 0x00, 0x7C, 0x00, 0xC0, 0x0F, 0x80, 0x18, 0x01, 0xF0, 0x03, 0x00,
  0x3E, 0x00, 0x60, 0x07, 0xC0, 0x0C, 0x00, 0xF8, 0x01, 0x80, 0x1F, 0x00,
  0x30, 0x03, 0xE0, 0x06, 0x00, 0x7C, 0x00, 0xC0, 0x0F, 0x80, 0x18, 0x01,
  0xC0, 0x00, 0xC1, 0x0F, 0xF2, 0x38, 0xF6, 0xC0, 0x6D, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0xFF, 0x00, 0xE1, 0xE0, 0x70, 0x1C, 0x38, 0x03, 0x0C, 0x00, 0xE3,
  0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80,
  0x03, 0x60, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x36,
  0x00, 0x19, 0x80, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xE1, 0x80, 0x30, 0x70,
  0x1C, 0x0F, 0x3E, 0x01, 0xFE, 0x00, 0x04, 0x00, 0x01, 0xC0, 0x43, 0xFC,
  0x23, 0x8F, 0x13, 0x01, 0xC9, 0x00, 0x67, 0x80, 0x1B, 0x80, 0x0D, 0xC0,
  0x06, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x06, 0xE0,
  0x03, 0x78, 0x03, 0xB4, 0x01, 0x9B, 0x01, 0xCC, 0xF3, 0xC6, 0x3F, 0x83,
  0x02, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xFE, 0x30, 0xF1, 0xCC, 0x70,
  0x1B, 0x18, 0x02, 0xCC, 0x00, 0xF3, 0x00, 0x1D, 0xC0, 0x07, 0x60, 0x01,
  0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80,
  0x03, 0x60, 0x00, 0xD8, 0x00, 0x76, 0x00, 0x1D, 0xC0, 0x07, 0x30, 0x01,
  0xCC, 0x00, 0xB1, 0x80, 0x6C, 0x70, 0x33, 0x0F, 0x3C, 0xC1, 0xFC, 0x30,
  0x08, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x01, 0xA1, 0xFC, 0xFF, 0x60, 0xD8, 0x3C,
  0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x03, 0xC0, 0x7F, 0xE3, 0xC3,
  0x9C, 0x02, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xB0, 0x0C, 0xF9, 0xF1, 0xFF, 0x00,
  0x60, 0x00, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x83, 0xFF,
  0xFF, 0xC6, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0xE4, 0x3F, 0x03,
  0x00, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x2D, 0xC0, 0xD9, 0xCF, 0x11, 0xFC, 0x20, 0x40, 0x00, 0xE0, 0x03,
  0xB0, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x71, 0x80, 0x30, 0xC0,
  0x18, 0x60, 0x0C, 0x30, 0x06, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x81,
  0x80, 0xC0, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x18,
  0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x00, 0x0D, 0x80, 0x06,
  0xC0, 0x03, 0x60, 0x01, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x06, 0xC0, 0x0E, 0x00, 0x6C, 0x00,
  0xF0, 0x06, 0x60, 0x0B, 0x00, 0x66, 0x01, 0xB0, 0x0C, 0x60, 0x1B, 0x00,
  0xC6, 0x01, 0x90, 0x0C, 0x60, 0x19, 0x80, 0xC3, 0x01, 0x98, 0x0C, 0x30,
  0x31, 0x81, 0x83, 0x03, 0x18, 0x18, 0x30, 0x30, 0xC1, 0x81, 0x83, 0x0C,
  0x18, 0x18, 0x60, 0xC1, 0x01, 0x86, 0x0C, 0x30, 0x18, 0x60, 0xC3, 0x01,
  0x86, 0x06, 0x30, 0x0C, 0x60, 0x63, 0x00, 0xCC, 0x06, 0x60, 0x0C, 0xC0,
  0x66, 0x00, 0xCC, 0x02, 0x60, 0x04, 0xC0, 0x36, 0x00, 0x68, 0x03, 0x60,
  0x07, 0x80, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x1C, 0x00, 0x38,
  0x01, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x60, 0x06, 0x30, 0x0E,
  0x30, 0x0C, 0x18, 0x0C, 0x18, 0x18, 0x1C, 0x18, 0x0C, 0x30, 0x0C, 0x30,
  0x06, 0x60, 0x06, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x30, 0x0C, 0x30,
  0x1C, 0x38, 0x18, 0x18, 0x38, 0x1C, 0x30, 0x0C, 0x70, 0x0C, 0x60, 0x06,
  0x60, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0x60, 0x03, 0x60, 0x03,
  0x60, 0x06, 0x70, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x38, 0x0C,
  0x18, 0x0C, 0x18, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x18, 0x0C, 0x18,
  0x0C, 0x30, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x60, 0x06, 0x60,
  0x03, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7C, 0x07, 0xF0,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x03, 0xC0,
  0x3C, 0x00, 0xF8, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x07,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0xF8, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E,
  0x03, 0xE0, 0x18, 0x00, 0x3E, 0x00, 0x2F, 0xF0, 0x07, 0x07, 0x83, 0xC0,
  0x3F, 0xE8, 0x01, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 39, 11, 4, -39 },
  { 16, 10, 14, 17, 4, -39 },
  { 34, 22, 39, 24, 1, -39 },
  { 142, 18, 45, 22, 2, -42 },
  { 244, 28, 41, 33, 2, -40 },
  { 388, 20, 41, 22, 2, -40 },
  { 491, 2, 14, 9, 4, -39 },
  { 495, 10, 48, 15, 3, -39 },
  { 555, 10, 48, 15, 2, -39 },
  { 615, 15, 15, 19, 2, -42 },
  { 644, 19, 25, 22, 2, -32 },
  { 704, 5, 13, 10, 2, -6 },
  { 713, 12, 2, 15, 1, -16 },
  { 716, 3, 4, 10, 4, -4 },
  { 718, 17, 39, 19, 1, -39 },
  { 801, 17, 40, 22, 3, -40 },
  { 886, 10, 39, 22, 4, -39 },
  { 935, 17, 40, 22, 2, -40 },
  { 1020, 17, 41, 22, 2, -40 },
  { 1108, 20, 39, 22, 1, -39 },
  { 1206, 17, 40, 22, 3, -39 },
  { 1291, 17, 41, 22, 3, -40 },
  { 1379, 17, 39, 22, 2, -39 },
  { 1462, 18, 41, 22, 2, -40 },
  { 1555, 17, 41, 22, 2, -40 },
  { 1643, 3, 29, 10, 4, -29 },
  { 1654, 5, 36, 10, 2, -29 },
  { 1677, 19, 23, 22, 2, -31 },
  { 1732, 19, 13, 22, 2, -26 },
  { 1763, 19, 23, 22, 2, -31 },
  { 1818, 13, 40, 15, 1, -40 },
  { 1883, 28, 45, 34, 3, -40 },
  { 2041, 22, 39, 22, 0, -39 },
  { 2149, 18, 39, 24, 4, -39 },
  { 2237, 19, 41, 23, 3, -40 },
  { 2335, 20, 39, 26, 4, -39 },
  { 2433, 15, 39, 21, 4, -39 },
  { 2507, 15, 39, 20, 4, -39 },
  { 2581, 23, 41, 29, 3, -40 },
  { 2699, 19, 39, 27, 4, -39 },
  { 2792, 9, 39, 13, 2, -39 },
  { 2836, 10, 49, 11, -3, -39 },
  { 2898, 18, 39, 22, 4, -39 },
  { 2986, 14, 39, 19, 4, -39 },
  { 3055, 28, 39, 37, 4, -39 },
  { 3192, 20, 39, 28, 4, -39 },
  { 3290, 23, 41, 29, 3, -40 },
  { 3408, 16, 39, 22, 4, -39 },
  { 3486, 23, 49, 29, 3, -40 },
  { 3627, 18, 39, 23, 4, -39 },
  { 3715, 17, 41, 22, 2, -40 },
  { 3803, 19, 39, 19, 0, -39 },
  { 3896, 19, 40, 27, 4, -39 },
  { 3991, 21, 39, 21, 0, -39 },
  { 4094, 36, 39, 36, 0, -39 },
  { 4270, 18, 39, 19, 0, -39 },
  { 4358, 18, 39, 18, 0, -39 },
  { 4446, 15, 39, 18, 2, -39 },
  { 4520, 10, 48, 17, 5, -39 },
  { 4580, 17, 39, 18, 1, -39 },
  { 4663, 10, 48, 17, 2, -39 },
  { 4723, 20, 19, 22, 1, -39 },
  { 4771, 22, 2, 22, 0, 5 },
  { 4777, 9, 9, 13, 2, -42 },
  { 4788, 15, 31, 21, 2, -30 },
  { 4847, 17, 43, 24, 4, -42 },
  { 4939, 14, 31, 18, 3, -30 },
  { 4994, 18, 43, 24, 2, -42 },
  { 5091, 16, 31, 21, 3, -30 },
  { 5153, 12, 42, 12, 1, -42 },
  { 5216, 18, 43, 24, 2, -30 },
  { 5313, 15, 42, 23, 4, -42 },
  { 5392, 3, 40, 10, 4, -40 },
  { 5407, 7, 53, 10, 0, -40 },
  { 5454, 14, 42, 19, 4, -42 },
  { 5528, 2, 42, 10, 4, -42 },
  { 5539, 27, 30, 34, 4, -30 },
  { 5641, 15, 30, 23, 4, -30 },
  { 5698, 18, 31, 23, 2, -30 },
  { 5768, 17, 43, 24, 4, -30 },
  { 5860, 18, 43, 24, 2, -30 },
  { 5957, 10, 30, 15, 4, -30 },
  { 5995, 14, 31, 17, 2, -30 },
  { 6050, 10, 37, 12, 1, -36 },
  { 6097, 15, 30, 23, 4, -29 },
  { 6154, 17, 29, 17, 0, -29 },
  { 6216, 28, 29, 29, 1, -29 },
  { 6318, 16, 29, 18, 1, -29 },
  { 6376, 16, 42, 18, 1, -29 },
  { 6460, 11, 29, 15, 2, -29 },
  { 6500, 14, 48, 19, 3, -39 },
  { 6584, 2, 55, 21, 10, -42 },
  { 6598, 13, 48, 19, 3, -39 },
  { 6676, 19, 5, 22, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight55pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT55PT7B_H_
