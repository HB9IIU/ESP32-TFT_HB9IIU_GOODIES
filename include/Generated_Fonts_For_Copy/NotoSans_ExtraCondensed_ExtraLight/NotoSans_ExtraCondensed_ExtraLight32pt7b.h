#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT32PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight32pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x40, 0x3C, 0x8E, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x08, 0x40, 0x84, 0x08, 0x40, 0x84, 0x08, 0x40, 0x84, 0x10, 0x8F,
  0xFF, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x30, 0x8F,
  0xFE, 0x21, 0x02, 0x10, 0x21, 0x02, 0x10, 0x21, 0x02, 0x10, 0x21, 0x00,
  0x04, 0x00, 0x80, 0xFF, 0x32, 0x24, 0x41, 0x08, 0x21, 0x04, 0x20, 0x84,
  0x08, 0x81, 0x90, 0x1E, 0x00, 0xE0, 0x0E, 0x01, 0x30, 0x22, 0x04, 0x60,
  0x84, 0x10, 0x82, 0x30, 0x45, 0x8B, 0x1F, 0xC0, 0x20, 0x04, 0x00, 0x80,
  0x38, 0x08, 0x22, 0x08, 0x11, 0x04, 0x08, 0x42, 0x04, 0x22, 0x06, 0x11,
  0x03, 0x08, 0x81, 0x84, 0x80, 0xC2, 0x40, 0x21, 0x27, 0x11, 0xA4, 0xC8,
  0x92, 0x26, 0x4A, 0x11, 0xC9, 0x08, 0x04, 0x84, 0x02, 0x42, 0x02, 0x21,
  0x81, 0x10, 0x80, 0x88, 0x40, 0x84, 0x20, 0x41, 0x10, 0x20, 0x88, 0x20,
  0x38, 0x1E, 0x03, 0x20, 0x21, 0x02, 0x10, 0x21, 0x02, 0x10, 0x21, 0x02,
  0x20, 0x12, 0x01, 0x40, 0x08, 0x03, 0x80, 0x24, 0x04, 0x42, 0xC2, 0x28,
  0x32, 0x81, 0x28, 0x0C, 0x80, 0xC8, 0x0C, 0x41, 0xE6, 0x32, 0x3E, 0x30,
  0xFF, 0x08, 0x84, 0x42, 0x21, 0x18, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x0C, 0x21, 0x0C, 0x21, 0x84, 0x10, 0xC1, 0x02, 0x0C, 0x10, 0x40,
  0x82, 0x08, 0x30, 0xC1, 0x04, 0x10, 0x41, 0x04, 0x30, 0xC2, 0x08, 0x21,
  0x04, 0x30, 0x86, 0x30, 0x08, 0x04, 0x22, 0x2F, 0xE0, 0x80, 0xA0, 0xC8,
  0xC6, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x07, 0xFF,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x25, 0xA4,
  0xA0, 0xFE, 0xF0, 0x00, 0x80, 0x40, 0x40, 0x20, 0x30, 0x10, 0x08, 0x0C,
  0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x80, 0x40, 0x60, 0x20, 0x10, 0x18,
  0x08, 0x04, 0x06, 0x02, 0x00, 0x1F, 0x0C, 0x62, 0x09, 0x82, 0x40, 0xD0,
  0x14, 0x05, 0x01, 0x40, 0x50, 0x1C, 0x07, 0x01, 0xC0, 0x50, 0x14, 0x05,
  0x01, 0x40, 0x50, 0x14, 0x05, 0x82, 0x20, 0x8C, 0x61, 0xF0, 0x04, 0x73,
  0x59, 0xC4, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x40, 0x3F, 0x18, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x10,
  0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x60, 0x10,
  0x08, 0x06, 0x01, 0x00, 0x80, 0x60, 0x10, 0x0F, 0xFC, 0x3F, 0x30, 0x68,
  0x08, 0x03, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x40, 0x60, 0x78,
  0x01, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xE0,
  0x6F, 0xF0, 0x00, 0xC0, 0x0C, 0x01, 0x40, 0x14, 0x02, 0x40, 0x24, 0x04,
  0x40, 0x44, 0x08, 0x40, 0x84, 0x10, 0x41, 0x04, 0x30, 0x42, 0x04, 0x60,
  0x44, 0x04, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0xFF, 0x60, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x5E,
  0x3B, 0xC0, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30,
  0x14, 0x1B, 0xF0, 0x0F, 0x18, 0x08, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00,
  0x80, 0x4F, 0x28, 0xD8, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x14, 0x1B, 0x08, 0xF8, 0xFF, 0xC0, 0x10, 0x04, 0x03, 0x00, 0x80,
  0x20, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x10, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0x1F, 0x04,
  0x31, 0x83, 0x20, 0x24, 0x04, 0x80, 0x90, 0x13, 0x06, 0x20, 0x82, 0x20,
  0x38, 0x07, 0x03, 0x10, 0xC1, 0x10, 0x16, 0x02, 0x80, 0x70, 0x0E, 0x01,
  0xE0, 0x24, 0x04, 0xC1, 0x0F, 0xC0, 0x1E, 0x08, 0x44, 0x09, 0x02, 0xC0,
  0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x14, 0x0D, 0x03, 0x61, 0x4F, 0x90,
  0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x00, 0xC7, 0xC0, 0xF4,
  0x00, 0x00, 0x03, 0xC0, 0x6C, 0x80, 0x00, 0x00, 0x00, 0x09, 0x69, 0x28,
  0x00, 0x20, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x02, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x08, 0x00, 0xF9,
  0x08, 0x18, 0x10, 0x20, 0x40, 0x83, 0x04, 0x18, 0x20, 0x81, 0x04, 0x08,
  0x10, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x03, 0xE0, 0x0C, 0x30,
  0x10, 0x08, 0x20, 0x04, 0x20, 0x06, 0x40, 0x02, 0x40, 0x02, 0xC3, 0xE3,
  0x86, 0x21, 0x84, 0x21, 0x84, 0x21, 0x8C, 0x21, 0x88, 0x21, 0x88, 0x61,
  0x88, 0x61, 0x8C, 0x61, 0x84, 0x62, 0x84, 0x62, 0x87, 0x9C, 0xC0, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x20, 0x07, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x40, 0x0A, 0x00, 0xD0, 0x04, 0x80, 0x26, 0x01,
  0x10, 0x18, 0x80, 0x84, 0x04, 0x30, 0x20, 0x81, 0x04, 0x1F, 0xE0, 0x81,
  0x84, 0x04, 0x20, 0x23, 0x01, 0x10, 0x08, 0x80, 0x64, 0x01, 0x60, 0x0A,
  0x00, 0x60, 0xFE, 0x18, 0x33, 0x03, 0x60, 0x2C, 0x05, 0x80, 0xB0, 0x16,
  0x02, 0xC0, 0xD8, 0x13, 0xFC, 0x7F, 0x8C, 0x0D, 0x80, 0xB0, 0x1E, 0x03,
  0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x2C, 0x0D, 0x83, 0x3F, 0xC0, 0x0F, 0xE3,
  0x08, 0xC0, 0x30, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x43, 0xF8, 0xFE, 0x0C, 0x38, 0xC0, 0xCC, 0x04,
  0xC0, 0x6C, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x6C, 0x04,
  0xC0, 0xCC, 0x38, 0xFE, 0x00, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x3F, 0xDF, 0xEC, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFE, 0xFF, 0xE0, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xF6, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x07, 0xE0, 0xC0,
  0xCC, 0x00, 0x40, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x0F, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0A, 0x00, 0x50, 0x02, 0xC0, 0x13, 0x00, 0x8C, 0x04, 0x3F, 0xC0, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x08, 0xF9, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x13, 0xE0, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0xC5, 0x6E, 0x00, 0xC0, 0x58, 0x1B, 0x02, 0x60, 0x8C, 0x31,
  0x84, 0x31, 0x86, 0x20, 0xC8, 0x1B, 0x03, 0x60, 0x74, 0x0E, 0xC1, 0x88,
  0x31, 0x06, 0x10, 0xC2, 0x18, 0x23, 0x04, 0x60, 0x4C, 0x09, 0x80, 0xB0,
  0x18, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0xFE, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x5F,
  0x00, 0x2E, 0x80, 0x37, 0x40, 0x13, 0xA0, 0x09, 0xC8, 0x04, 0xE4, 0x04,
  0x72, 0x02, 0x39, 0x81, 0x1C, 0x41, 0x8E, 0x20, 0x87, 0x18, 0x43, 0x84,
  0x61, 0xC2, 0x20, 0xE1, 0x10, 0x70, 0x48, 0x38, 0x28, 0x1C, 0x14, 0x0E,
  0x0E, 0x07, 0x03, 0x02, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xD0, 0x1D,
  0x01, 0xD8, 0x1C, 0x81, 0xCC, 0x1C, 0x41, 0xC4, 0x1C, 0x21, 0xC2, 0x1C,
  0x11, 0xC1, 0x1C, 0x19, 0xC0, 0x9C, 0x0D, 0xC0, 0x5C, 0x05, 0xC0, 0x3C,
  0x03, 0xC0, 0x30, 0x0F, 0x81, 0x86, 0x08, 0x08, 0x80, 0x64, 0x01, 0x60,
  0x0A, 0x00, 0x50, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1E, 0x00, 0x90, 0x04, 0x80, 0x66,
  0x02, 0x18, 0x20, 0x7E, 0x00, 0xFC, 0x31, 0xCC, 0x1B, 0x03, 0xC0, 0xF0,
  0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0B, 0x06, 0xFF, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x0F, 0x81,
  0x86, 0x08, 0x08, 0x80, 0x64, 0x01, 0x60, 0x0A, 0x00, 0x50, 0x03, 0x80,
  0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x1E, 0x00, 0x90, 0x04, 0x80, 0x62, 0x02, 0x18, 0x20, 0x7E, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0xFC, 0x18, 0x63, 0x02,
  0x60, 0x6C, 0x05, 0x80, 0xB0, 0x16, 0x02, 0xC0, 0xD8, 0x13, 0x06, 0x61,
  0x8F, 0xC1, 0x88, 0x30, 0x86, 0x10, 0xC3, 0x18, 0x23, 0x06, 0x60, 0x4C,
  0x0D, 0x80, 0xB0, 0x18, 0x1F, 0x8C, 0x16, 0x01, 0x00, 0x40, 0x30, 0x0C,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x20, 0x0C, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xE0, 0x6F, 0xF0, 0xFF, 0xE0, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x2C, 0x02, 0xC0, 0x24, 0x02, 0x40,
  0x63, 0x0C, 0x1F, 0x80, 0x80, 0x1C, 0x01, 0x40, 0x34, 0x02, 0x40, 0x24,
  0x02, 0x60, 0x62, 0x04, 0x20, 0x42, 0x04, 0x30, 0x41, 0x0C, 0x10, 0x81,
  0x08, 0x18, 0x80, 0x98, 0x09, 0x00, 0x90, 0x09, 0x00, 0xF0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x80, 0x20, 0x0E, 0x01, 0x00, 0xD0, 0x1C, 0x06, 0x80,
  0xA0, 0x24, 0x05, 0x01, 0x30, 0x28, 0x09, 0x81, 0x40, 0xC4, 0x1B, 0x04,
  0x20, 0x88, 0x21, 0x04, 0x41, 0x0C, 0x22, 0x08, 0x21, 0x10, 0xC1, 0x08,
  0xC4, 0x08, 0x82, 0x20, 0x44, 0x11, 0x03, 0x20, 0x98, 0x09, 0x04, 0x80,
  0x48, 0x34, 0x02, 0x80, 0xA0, 0x14, 0x05, 0x00, 0xE0, 0x38, 0x03, 0x01,
  0x80, 0x18, 0x0C, 0x00, 0x40, 0x64, 0x08, 0x81, 0x18, 0x41, 0x08, 0x23,
  0x06, 0x40, 0x48, 0x0B, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x14, 0x02,
  0x40, 0xC8, 0x11, 0x06, 0x10, 0x82, 0x10, 0x46, 0x04, 0x80, 0xB0, 0x18,
  0x80, 0x78, 0x09, 0x01, 0x20, 0x46, 0x08, 0x41, 0x08, 0x41, 0x88, 0x11,
  0x02, 0x40, 0x68, 0x05, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0xFF, 0x80, 0xC0, 0x40,
  0x20, 0x30, 0x10, 0x08, 0x08, 0x04, 0x06, 0x02, 0x01, 0x01, 0x80, 0x80,
  0x40, 0x60, 0x20, 0x10, 0x10, 0x08, 0x0C, 0x04, 0x03, 0xFE, 0xFE, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x80, 0x40, 0x10, 0x08, 0x06,
  0x01, 0x00, 0x80, 0x60, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x20, 0x10,
  0x08, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x0C, 0x02, 0xFC, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x7F, 0x04, 0x00, 0xC0, 0x28, 0x05, 0x81,
  0x10, 0x23, 0x08, 0x23, 0x06, 0x40, 0x58, 0x0E, 0x00, 0x80, 0xFF, 0xF8,
  0xC1, 0x0C, 0x30, 0x80, 0x3E, 0x20, 0x80, 0x60, 0x10, 0x08, 0x04, 0x02,
  0x0F, 0x38, 0xB0, 0x50, 0x38, 0x18, 0x1C, 0x0F, 0x06, 0x85, 0x3C, 0x80,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x7C, 0xA1, 0xA8,
  0x2C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07,
  0x01, 0xC0, 0x68, 0x2A, 0x1A, 0x7C, 0x1F, 0x98, 0x08, 0x0C, 0x04, 0x02,
  0x01, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0x60,
  0x1F, 0x80, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0xFB, 0x31, 0xEC, 0x1D, 0x01, 0xA0, 0x34, 0x06, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0D, 0x01, 0xA0, 0x34, 0x06, 0xC1, 0x48, 0x28, 0xF9, 0x1F,
  0x0C, 0x66, 0x09, 0x02, 0x40, 0x50, 0x14, 0x07, 0xFF, 0xC0, 0x30, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0xC1, 0x1F, 0x80, 0x1F, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0xFC, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F, 0x26, 0x15,
  0x83, 0xA0, 0x34, 0x06, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xA0, 0x34, 0x06, 0x80, 0xD8, 0x39, 0x0F, 0x1F, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x33, 0xBC, 0x1E, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x3E, 0xA1, 0x50, 0x70, 0x38, 0x1C, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x33, 0x00, 0x00, 0x22, 0x22, 0x22, 0x22,
  0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x2E, 0xC0, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x02, 0x82, 0x43, 0x21, 0x11, 0x88, 0x84,
  0x82, 0xE1, 0x50, 0xCC, 0x62, 0x21, 0x10, 0x48, 0x24, 0x1A, 0x05, 0x03,
  0xFF, 0xFF, 0xFF, 0x9E, 0x3C, 0xA3, 0x42, 0xC1, 0x42, 0xC1, 0x83, 0xC1,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x9F, 0x50, 0xE8, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x1F, 0x06, 0x11,
  0x83, 0x20, 0x24, 0x04, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x0D, 0x01,
  0xA0, 0x34, 0x04, 0x80, 0x98, 0x31, 0x84, 0x1F, 0x00, 0x9F, 0x2C, 0x6A,
  0x0B, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x01,
  0xC0, 0x70, 0x3A, 0x0A, 0x86, 0x9F, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x1F, 0x26, 0x34, 0x83, 0xA0, 0x34, 0x06, 0x80, 0xD0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xA0, 0x34, 0x06, 0x80, 0xD8, 0x39,
  0x8F, 0x1F, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x9E, 0xCA, 0x30, 0xC3, 0x0C, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x80, 0x3F, 0x41, 0xC0, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x03,
  0x01, 0x01, 0x01, 0x01, 0x82, 0xFE, 0x41, 0x04, 0x10, 0xFD, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x18, 0x3C, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0E, 0x0F, 0x06, 0x85, 0x3C, 0x80, 0x80, 0xF0, 0x24, 0x09, 0x02, 0x41,
  0x98, 0x42, 0x10, 0x84, 0x23, 0x0C, 0x81, 0x20, 0x48, 0x12, 0x05, 0x00,
  0xC0, 0x30, 0x0C, 0x00, 0xC0, 0x81, 0xA0, 0x60, 0x90, 0x50, 0x48, 0x28,
  0x24, 0x14, 0x11, 0x0A, 0x10, 0x84, 0x88, 0x44, 0x44, 0x22, 0x22, 0x19,
  0x13, 0x04, 0x89, 0x02, 0xC2, 0x81, 0x41, 0x40, 0xA0, 0xA0, 0x30, 0x70,
  0x18, 0x30, 0x0C, 0x08, 0x00, 0x81, 0xE0, 0x90, 0xCC, 0x42, 0x21, 0xA0,
  0x50, 0x30, 0x18, 0x0E, 0x05, 0x04, 0x82, 0x22, 0x11, 0x05, 0x82, 0x81,
  0x80, 0x40, 0x50, 0x14, 0x0D, 0x82, 0x20, 0x88, 0x22, 0x18, 0xC4, 0x11,
  0x04, 0x41, 0x30, 0x68, 0x0A, 0x02, 0x80, 0xE0, 0x30, 0x04, 0x01, 0x00,
  0xC0, 0x20, 0x08, 0x06, 0x01, 0x02, 0xC0, 0xC0, 0x00, 0xFE, 0x0C, 0x10,
  0x20, 0x81, 0x06, 0x08, 0x10, 0x60, 0x81, 0x04, 0x08, 0x30, 0x40, 0xFE,
  0x07, 0x0C, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x30, 0xE0, 0xE0, 0x30, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x18, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x18, 0x0E, 0x07, 0x08,
  0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x30, 0xC0,
  0x30, 0x39, 0x86, 0x0F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 23, 6, 2, -23 },
  { 7, 6, 8, 10, 2, -23 },
  { 13, 12, 23, 14, 1, -23 },
  { 48, 11, 26, 13, 1, -24 },
  { 84, 17, 23, 19, 1, -23 },
  { 133, 12, 23, 13, 1, -23 },
  { 168, 1, 8, 5, 2, -23 },
  { 169, 5, 28, 9, 2, -23 },
  { 187, 6, 28, 9, 1, -23 },
  { 208, 9, 8, 11, 1, -24 },
  { 217, 11, 15, 13, 1, -19 },
  { 238, 3, 7, 6, 1, -3 },
  { 241, 7, 1, 8, 1, -9 },
  { 242, 2, 2, 6, 2, -2 },
  { 243, 9, 23, 11, 1, -23 },
  { 269, 10, 23, 13, 1, -23 },
  { 298, 6, 23, 13, 2, -23 },
  { 316, 10, 23, 13, 1, -23 },
  { 345, 10, 23, 13, 1, -23 },
  { 374, 12, 23, 13, 0, -23 },
  { 409, 9, 23, 13, 2, -23 },
  { 435, 9, 23, 13, 2, -23 },
  { 461, 10, 23, 13, 1, -23 },
  { 490, 11, 23, 13, 1, -23 },
  { 522, 10, 23, 13, 1, -23 },
  { 551, 2, 17, 6, 2, -17 },
  { 556, 3, 21, 6, 1, -17 },
  { 564, 11, 13, 13, 1, -18 },
  { 582, 11, 8, 13, 1, -15 },
  { 593, 11, 13, 13, 1, -18 },
  { 611, 7, 23, 9, 1, -23 },
  { 632, 16, 26, 20, 2, -23 },
  { 684, 13, 23, 13, 0, -23 },
  { 722, 11, 23, 14, 2, -23 },
  { 754, 11, 23, 13, 2, -23 },
  { 786, 12, 23, 15, 2, -23 },
  { 821, 9, 23, 12, 2, -23 },
  { 847, 9, 23, 11, 2, -23 },
  { 873, 13, 23, 17, 2, -23 },
  { 911, 11, 23, 16, 2, -23 },
  { 943, 5, 23, 7, 1, -23 },
  { 958, 5, 29, 6, -1, -23 },
  { 977, 11, 23, 13, 2, -23 },
  { 1009, 9, 23, 11, 2, -23 },
  { 1035, 17, 23, 21, 2, -23 },
  { 1084, 12, 23, 17, 2, -23 },
  { 1119, 13, 23, 17, 2, -23 },
  { 1157, 10, 23, 13, 2, -23 },
  { 1186, 13, 28, 17, 2, -23 },
  { 1232, 11, 23, 13, 2, -23 },
  { 1264, 10, 23, 13, 1, -23 },
  { 1293, 11, 23, 11, 0, -23 },
  { 1325, 12, 23, 16, 2, -23 },
  { 1360, 12, 23, 12, 0, -23 },
  { 1395, 21, 23, 21, 0, -23 },
  { 1456, 11, 23, 11, 0, -23 },
  { 1488, 11, 23, 11, 0, -23 },
  { 1520, 9, 23, 11, 1, -23 },
  { 1546, 6, 28, 10, 3, -23 },
  { 1567, 9, 23, 11, 1, -23 },
  { 1593, 6, 28, 10, 1, -23 },
  { 1614, 11, 11, 13, 1, -23 },
  { 1630, 13, 1, 13, 0, 3 },
  { 1632, 5, 5, 7, 1, -24 },
  { 1636, 9, 17, 12, 1, -17 },
  { 1656, 10, 24, 14, 2, -24 },
  { 1686, 9, 17, 10, 1, -17 },
  { 1706, 11, 24, 14, 1, -24 },
  { 1739, 10, 17, 12, 1, -17 },
  { 1761, 8, 24, 7, 0, -24 },
  { 1785, 11, 25, 14, 1, -17 },
  { 1820, 9, 24, 13, 2, -24 },
  { 1847, 2, 23, 6, 2, -23 },
  { 1853, 4, 31, 6, 0, -23 },
  { 1869, 9, 24, 11, 2, -24 },
  { 1896, 1, 24, 6, 2, -24 },
  { 1899, 16, 17, 20, 2, -17 },
  { 1933, 9, 17, 13, 2, -17 },
  { 1953, 11, 17, 13, 1, -17 },
  { 1977, 10, 24, 14, 2, -17 },
  { 2007, 11, 24, 14, 1, -17 },
  { 2040, 6, 17, 9, 2, -17 },
  { 2053, 8, 17, 10, 1, -17 },
  { 2070, 6, 21, 7, 1, -21 },
  { 2086, 9, 17, 13, 2, -17 },
  { 2106, 10, 17, 10, 0, -17 },
  { 2128, 17, 17, 17, 0, -17 },
  { 2165, 9, 17, 10, 1, -17 },
  { 2185, 10, 25, 10, 0, -17 },
  { 2217, 7, 17, 9, 1, -17 },
  { 2232, 8, 28, 11, 2, -23 },
  { 2260, 1, 32, 12, 6, -24 },
  { 2264, 8, 28, 11, 2, -23 },
  { 2292, 11, 3, 13, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight32pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT32PT7B_H_
