#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT68PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight68pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1D,
  0x80, 0xEC, 0x07, 0x60, 0x3B, 0x01, 0xD8, 0x0E, 0xC0, 0x76, 0x03, 0x30,
  0x19, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0xE0, 0x18, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x60, 0x0C, 0x00, 0x0C, 0x03, 0x80, 0x01, 0x80, 0x70, 0x00, 0x30, 0x0C,
  0x00, 0x06, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x06, 0x01, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE0, 0x18, 0x03, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x60, 0x1C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0x70,
  0x0C, 0x00, 0x0E, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x30, 0x06, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x07, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0xE0, 0x18, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80,
  0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0E,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x38, 0x06, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x60, 0x0C, 0x00, 0x0C, 0x03, 0x80, 0x01, 0x80, 0x70, 0x00, 0x30,
  0x0C, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xFE, 0x0F, 0x98, 0x3C, 0x3C, 0x30, 0x10, 0x70, 0x60, 0x01, 0xC0,
  0xC0, 0x03, 0x81, 0x80, 0x06, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x38, 0x0C,
  0x00, 0x70, 0x18, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x60, 0x03, 0x80, 0xC0,
  0x03, 0x01, 0x80, 0x07, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x0C, 0x00,
  0x0F, 0x18, 0x00, 0x0F, 0x30, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x06, 0xF8, 0x00, 0x0C, 0x78, 0x00,
  0x18, 0x38, 0x00, 0x30, 0x38, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x30, 0x01,
  0x80, 0x70, 0x03, 0x00, 0xE0, 0x06, 0x01, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0x60, 0x03, 0x01, 0xD0, 0x06, 0x07, 0x38, 0x0C, 0x3C, 0x7F, 0x19, 0xF0,
  0x3F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x0F,
  0x80, 0x00, 0xC0, 0x07, 0xF8, 0x00, 0x30, 0x03, 0x86, 0x00, 0x1C, 0x00,
  0xC0, 0xC0, 0x06, 0x00, 0x70, 0x30, 0x01, 0x80, 0x18, 0x0E, 0x00, 0xE0,
  0x06, 0x01, 0x80, 0x30, 0x01, 0x80, 0x60, 0x0C, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0x38, 0x06, 0x01, 0x80, 0x0C, 0x01, 0xC0, 0x60, 0x03, 0x00, 0x70,
  0x38, 0x00, 0xC0, 0x1C, 0x0C, 0x00, 0x30, 0x07, 0x03, 0x00, 0x0C, 0x01,
  0xC1, 0xC0, 0x03, 0x00, 0x70, 0x60, 0x00, 0xC0, 0x1C, 0x18, 0x00, 0x30,
  0x07, 0x0E, 0x00, 0x0C, 0x01, 0xC3, 0x00, 0x03, 0x00, 0x70, 0xC0, 0xE0,
  0xE0, 0x18, 0x70, 0xFE, 0x38, 0x06, 0x18, 0x71, 0xC6, 0x01, 0x86, 0x38,
  0x31, 0x80, 0x63, 0x8C, 0x0E, 0x60, 0x38, 0xC3, 0x01, 0x9C, 0x0C, 0x31,
  0xC0, 0x63, 0x07, 0x1C, 0x60, 0x1C, 0xE3, 0x86, 0x18, 0x07, 0x1F, 0xE1,
  0x86, 0x00, 0xC3, 0xE0, 0xE1, 0x80, 0x30, 0x00, 0x30, 0x60, 0x0C, 0x00,
  0x0C, 0x18, 0x03, 0x00, 0x07, 0x06, 0x00, 0xC0, 0x01, 0x81, 0x80, 0x30,
  0x00, 0x60, 0x60, 0x0C, 0x00, 0x38, 0x18, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0xC0, 0x03, 0x01, 0x80, 0x30, 0x01, 0xC0, 0x60, 0x0C, 0x00, 0x60, 0x18,
  0x03, 0x00, 0x18, 0x06, 0x00, 0xC0, 0x0E, 0x01, 0x80, 0x70, 0x03, 0x00,
  0x60, 0x18, 0x00, 0xC0, 0x1C, 0x06, 0x00, 0x70, 0x03, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0xE0, 0x06, 0x00, 0x18, 0x70, 0x03, 0x80, 0x07, 0xF8, 0x00,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x03, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0xC0, 0x38, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x01,
  0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0C,
  0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x0C, 0x00,
  0x07, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x0E, 0x30,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x70, 0x60, 0x00, 0x38, 0x1C, 0x03, 0x0C, 0x03, 0x00, 0xC7, 0x00, 0xE0,
  0x31, 0x80, 0x18, 0x1C, 0x60, 0x07, 0x07, 0x38, 0x00, 0xE1, 0x8E, 0x00,
  0x18, 0x63, 0x80, 0x07, 0x38, 0xE0, 0x00, 0xCE, 0x38, 0x00, 0x3B, 0x0E,
  0x00, 0x07, 0xC3, 0x80, 0x01, 0xF0, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x0E,
  0x06, 0x00, 0x07, 0xC1, 0xC0, 0x03, 0xB0, 0x30, 0x01, 0xCE, 0x0E, 0x00,
  0xF1, 0xC1, 0xC0, 0x78, 0x70, 0x3F, 0xF8, 0x0E, 0x07, 0xFC, 0x03, 0xC0,
  0x38, 0x00, 0x00, 0xFF, 0xFE, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x00, 0x38,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C,
  0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x0C, 0x0B, 0xC3, 0x0F,
  0x7E, 0xDF, 0x83, 0xFE, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0x30, 0x01,
  0xCE, 0x00, 0xE1, 0xC0, 0x30, 0x30, 0x18, 0x06, 0x0E, 0x01, 0xC1, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x1C, 0x71, 0xCE, 0x38, 0xE3, 0x8C, 0x71, 0xC7, 0x18, 0xE3, 0x8C,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x77, 0xBF, 0xE7, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xE1, 0xE0, 0x1C, 0x07,
  0x00, 0xC0, 0x1C, 0x0E, 0x00, 0x60, 0x60, 0x03, 0x87, 0x00, 0x0C, 0x38,
  0x00, 0x61, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0x67, 0x00, 0x03,
  0x30, 0x00, 0x19, 0x80, 0x00, 0xEC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3B, 0x00, 0x01, 0xD8, 0x00, 0x0E, 0xC0, 0x00,
  0x77, 0x00, 0x03, 0x38, 0x00, 0x19, 0xC0, 0x01, 0xC6, 0x00, 0x0E, 0x38,
  0x00, 0x71, 0xC0, 0x03, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x1C,
  0x07, 0x01, 0xC0, 0x1E, 0x1E, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x00,
  0x30, 0x07, 0x00, 0xF0, 0x3F, 0x07, 0xF0, 0xF7, 0x1E, 0x73, 0xC7, 0x78,
  0x7E, 0x07, 0x40, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0x83, 0xE0, 0xE0, 0x07, 0x82,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFC,
  0x00, 0xFF, 0xF8, 0x1F, 0x03, 0xE1, 0xE0, 0x07, 0x8C, 0x00, 0x1E, 0x40,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x40, 0x00, 0xE3, 0x80,
  0x1E, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x06, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x18, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x07, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x07, 0x00,
  0x03, 0x01, 0xC0, 0x01, 0x80, 0x70, 0x00, 0x60, 0x1C, 0x00, 0x38, 0x07,
  0x00, 0x0C, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x06, 0x00, 0x1C, 0x03,
  0x80, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x18, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x7F, 0xC0, 0x3F, 0xFF, 0x81,
  0xF8, 0x3E, 0x04, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x40, 0x01, 0xE3, 0xC0, 0x3E, 0x1F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0x7E, 0x38, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0xF8, 0x06, 0x1F, 0xF0, 0x73, 0xFF, 0xE3,
  0x98, 0x07, 0x1D, 0x80, 0x1C, 0xF8, 0x00, 0x77, 0x80, 0x03, 0xBC, 0x00,
  0x0D, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x06, 0xC0, 0x00,
  0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70,
  0x00, 0x39, 0x80, 0x01, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE1, 0xC0, 0x0E,
  0x0E, 0x00, 0x70, 0x3C, 0x07, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1E, 0x0F, 0x80, 0x70, 0x07, 0x81, 0xC0,
  0x07, 0x03, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x30, 0x00,
  0x1C, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x71, 0x80, 0x00, 0xE3, 0x00, 0x01,
  0xC6, 0x00, 0x03, 0x8E, 0x00, 0x06, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x38, 0x0E, 0x00, 0x38, 0x38, 0x00,
  0x3D, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0x8E, 0x00, 0x1E, 0x0F, 0x00, 0x70, 0x0F, 0x01, 0xC0, 0x0F, 0x03, 0x80,
  0x0E, 0x0E, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0x19, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xB0, 0x00, 0x07, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x19,
  0xC0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x83, 0x80, 0x0E, 0x03,
  0xC0, 0x3C, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xC3, 0xC0, 0x38, 0x07, 0x03, 0x80, 0x1C,
  0x18, 0x00, 0x61, 0xC0, 0x03, 0x8C, 0x00, 0x0C, 0xE0, 0x00, 0x67, 0x00,
  0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B,
  0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xEC,
  0x00, 0x0F, 0x70, 0x00, 0xF9, 0x80, 0x05, 0xCE, 0x00, 0x6E, 0x3C, 0x0E,
  0x70, 0xFF, 0xE3, 0x03, 0xFE, 0x18, 0x01, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x01,
  0x00, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x77,
  0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xFE, 0xE0, 0x38, 0xF3,
  0xCF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x71, 0xC7, 0x38, 0xE3,
  0x8E, 0x31, 0xC7, 0x1C, 0x63, 0x8C, 0x30, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x7F, 0xF8, 0xF8, 0x7C, 0x40, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0xE3, 0x00, 0x0F, 0xC0, 0x19, 0xC0, 0x0F, 0xFC, 0x06, 0x60, 0x07, 0x06,
  0x01, 0x98, 0x03, 0x81, 0x80, 0x76, 0x00, 0xC0, 0x60, 0x1F, 0x80, 0x70,
  0x18, 0x03, 0xE0, 0x18, 0x06, 0x00, 0xF0, 0x0E, 0x01, 0x80, 0x3C, 0x03,
  0x80, 0x60, 0x0F, 0x00, 0xC0, 0x18, 0x03, 0xC0, 0x30, 0x06, 0x00, 0xF0,
  0x0C, 0x01, 0x80, 0x3C, 0x03, 0x00, 0x60, 0x0F, 0x01, 0xC0, 0x18, 0x03,
  0xC0, 0x70, 0x0E, 0x00, 0xF0, 0x1C, 0x03, 0x80, 0x3C, 0x07, 0x00, 0xE0,
  0x0F, 0x00, 0xC0, 0x38, 0x03, 0xC0, 0x30, 0x0E, 0x01, 0xF0, 0x0C, 0x03,
  0x80, 0x7C, 0x03, 0x00, 0xE0, 0x1B, 0x00, 0xE0, 0x78, 0x06, 0xC0, 0x38,
  0x1A, 0x03, 0xB8, 0x06, 0x0C, 0xC0, 0xCE, 0x01, 0xC7, 0x38, 0x71, 0x80,
  0x3F, 0x87, 0xF8, 0x60, 0x07, 0xC0, 0xFC, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x04, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x0E, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x06, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x38, 0x30, 0x00, 0x06, 0x07,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x18, 0x07, 0x00, 0x03, 0x00, 0x60, 0x00, 0xE0, 0x0C,
  0x00, 0x1C, 0x01, 0xC0, 0x03, 0x00, 0x38, 0x00, 0x60, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x60, 0x0E, 0x00, 0x0E, 0x01, 0x80,
  0x01, 0xC0, 0x70, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x70,
  0x30, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x38, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x38, 0x00, 0xF8, 0xE0, 0x00, 0xE3, 0x80, 0x01, 0xCE, 0x00, 0x07,
  0x38, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xB8,
  0x00, 0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00,
  0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x38,
  0xE0, 0x00, 0xE3, 0x80, 0x0F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0x80, 0x0F, 0x8E, 0x00, 0x0F, 0x38, 0x00, 0x1C, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x6E, 0x00, 0x03, 0xB8, 0x00, 0x1E, 0xE0, 0x00, 0xF3, 0x80, 0x07, 0x8E,
  0x00, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xFC, 0x07, 0xE0, 0xF8, 0x1E, 0x00, 0x20, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x40, 0x7C, 0x03, 0x80,
  0x7F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x80, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xE0, 0x07, 0xC0, 0xE0, 0x01, 0xE0, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x18, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x01, 0xE0, 0xE0,
  0x03, 0xC0, 0xE0, 0x7F, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xB8, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFF,
  0xEF, 0xFF, 0xFB, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x20, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x07, 0x18, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x01, 0xF0,
  0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0x00,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x06, 0xFF, 0xFF, 0xF3,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0xFF, 0xC0, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x3B, 0x1E, 0x7F, 0xCF, 0xE0, 0xE0,
  0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x38, 0xE0, 0x00,
  0xE3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x07, 0x03,
  0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x60, 0x0E, 0x03, 0x80, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x83, 0x80,
  0x0E, 0x0C, 0x00, 0x38, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E,
  0x78, 0x00, 0x39, 0xE0, 0x00, 0xEF, 0xC0, 0x03, 0xF3, 0x00, 0x0F, 0x8E,
  0x00, 0x3C, 0x18, 0x00, 0xF0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0x80,
  0x38, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x38,
  0x03, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x38, 0x38, 0x00,
  0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x38,
  0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x06, 0xFF, 0x00, 0x00, 0x01, 0xDF, 0x60, 0x00, 0x00, 0x3B, 0xEC, 0x00,
  0x00, 0x06, 0x7D, 0xC0, 0x00, 0x00, 0xCF, 0x98, 0x00, 0x00, 0x39, 0xF3,
  0x00, 0x00, 0x06, 0x3E, 0x70, 0x00, 0x00, 0xC7, 0xCE, 0x00, 0x00, 0x38,
  0xF8, 0xC0, 0x00, 0x07, 0x1F, 0x18, 0x00, 0x00, 0xC3, 0xE3, 0x80, 0x00,
  0x38, 0x7C, 0x30, 0x00, 0x07, 0x0F, 0x86, 0x00, 0x00, 0xC1, 0xF0, 0xE0,
  0x00, 0x18, 0x3E, 0x0C, 0x00, 0x07, 0x07, 0xC1, 0x80, 0x00, 0xC0, 0xF8,
  0x38, 0x00, 0x18, 0x1F, 0x07, 0x00, 0x07, 0x03, 0xE0, 0x60, 0x00, 0xE0,
  0x7C, 0x0C, 0x00, 0x18, 0x0F, 0x81, 0xC0, 0x07, 0x01, 0xF0, 0x18, 0x00,
  0xE0, 0x3E, 0x03, 0x00, 0x18, 0x07, 0xC0, 0x70, 0x03, 0x00, 0xF8, 0x0E,
  0x00, 0xE0, 0x1F, 0x00, 0xC0, 0x18, 0x03, 0xE0, 0x1C, 0x03, 0x00, 0x7C,
  0x03, 0x80, 0xE0, 0x0F, 0x80, 0x30, 0x1C, 0x01, 0xF0, 0x07, 0x03, 0x00,
  0x3E, 0x00, 0xE0, 0xE0, 0x07, 0xC0, 0x0C, 0x1C, 0x00, 0xF8, 0x01, 0x83,
  0x00, 0x1F, 0x00, 0x38, 0x60, 0x03, 0xE0, 0x07, 0x1C, 0x00, 0x7C, 0x00,
  0x63, 0x00, 0x0F, 0x80, 0x0E, 0x60, 0x01, 0xF0, 0x01, 0xDC, 0x00, 0x3E,
  0x00, 0x1B, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xD8, 0x00, 0x07, 0xEE,
  0x00, 0x03, 0xF3, 0x00, 0x01, 0xF9, 0xC0, 0x00, 0xFC, 0x60, 0x00, 0x7E,
  0x38, 0x00, 0x3F, 0x1C, 0x00, 0x1F, 0x86, 0x00, 0x0F, 0xC3, 0x80, 0x07,
  0xE0, 0xC0, 0x03, 0xF0, 0x70, 0x01, 0xF8, 0x18, 0x00, 0xFC, 0x0E, 0x00,
  0x7E, 0x03, 0x00, 0x3F, 0x01, 0xC0, 0x1F, 0x80, 0xE0, 0x0F, 0xC0, 0x30,
  0x07, 0xE0, 0x1C, 0x03, 0xF0, 0x06, 0x01, 0xF8, 0x03, 0x80, 0xFC, 0x00,
  0xC0, 0x7E, 0x00, 0x70, 0x3F, 0x00, 0x38, 0x1F, 0x80, 0x0C, 0x0F, 0xC0,
  0x07, 0x07, 0xE0, 0x01, 0x83, 0xF0, 0x00, 0xE1, 0xF8, 0x00, 0x30, 0xFC,
  0x00, 0x1C, 0x7E, 0x00, 0x06, 0x3F, 0x00, 0x03, 0x9F, 0x80, 0x01, 0xC7,
  0xC0, 0x00, 0x63, 0xE0, 0x00, 0x39, 0xF0, 0x00, 0x0C, 0xF8, 0x00, 0x07,
  0x7C, 0x00, 0x01, 0xBE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38,
  0x38, 0x00, 0x03, 0x83, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0x83, 0x80, 0x00, 0x38, 0x1C,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x0F, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0E, 0x00,
  0xF8, 0xE0, 0x03, 0xCE, 0x00, 0x1E, 0xE0, 0x00, 0xEE, 0x00, 0x06, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x1C, 0xE0, 0x03, 0xCE, 0x00, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x38, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x01, 0x83, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x7C, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x38, 0x03, 0xE0, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x8E, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x03, 0x38, 0x00,
  0x0C, 0xE0, 0x00, 0x33, 0x80, 0x00, 0xCE, 0x00, 0x03, 0x38, 0x00, 0x0C,
  0xE0, 0x00, 0x33, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0,
  0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x0F,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x38, 0x1C, 0x00, 0xE0, 0x38, 0x03,
  0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x03, 0x80,
  0x38, 0x0E, 0x00, 0x60, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x0E,
  0x0E, 0x00, 0x38, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x8E,
  0x00, 0x0E, 0x38, 0x00, 0x18, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xCE, 0x00,
  0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0x01, 0xFF, 0x80, 0x3F, 0xFF,
  0x83, 0xE0, 0x7C, 0x3C, 0x00, 0x63, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x40, 0x00, 0xE3, 0xC0, 0x1E, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x0E, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x3C, 0x1C, 0x00, 0x78, 0x1F, 0x00, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x06, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x70, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03,
  0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x60, 0x06, 0x00, 0x18,
  0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x03, 0x00,
  0x30, 0x00, 0xC0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x01,
  0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80,
  0x01, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x38, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x38, 0x00, 0x01, 0x98, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x38, 0x00, 0x07, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x36, 0x00, 0x01, 0x86,
  0x00, 0x01, 0xB0, 0x00, 0x1C, 0x38, 0x00, 0x0D, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0xEC, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x70, 0x00, 0x38, 0x30, 0x00,
  0x33, 0x80, 0x01, 0x81, 0xC0, 0x01, 0x8C, 0x00, 0x1C, 0x0E, 0x00, 0x0C,
  0x60, 0x00, 0xE0, 0x70, 0x00, 0xE3, 0x00, 0x07, 0x01, 0x80, 0x07, 0x1C,
  0x00, 0x30, 0x0C, 0x00, 0x30, 0xE0, 0x01, 0x80, 0x70, 0x01, 0x83, 0x00,
  0x1C, 0x03, 0x80, 0x0C, 0x18, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0xC0, 0x07,
  0x00, 0x60, 0x07, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0x80, 0xC0, 0x1C, 0x00, 0xE0, 0x0C, 0x06, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x30, 0x06, 0x00, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x00, 0xC0,
  0x30, 0x0E, 0x03, 0x80, 0x07, 0x01, 0x80, 0x30, 0x1C, 0x00, 0x38, 0x0C,
  0x01, 0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x0C, 0x06, 0x00, 0x06, 0x07, 0x00,
  0x70, 0x30, 0x00, 0x38, 0x30, 0x03, 0x83, 0x80, 0x01, 0xC1, 0x80, 0x0C,
  0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x60, 0xE0, 0x00, 0x30, 0xE0, 0x03, 0x06,
  0x00, 0x01, 0x87, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0xE3, 0x80,
  0x00, 0x71, 0x80, 0x03, 0x1C, 0x00, 0x03, 0x8C, 0x00, 0x18, 0xC0, 0x00,
  0x0C, 0xE0, 0x00, 0xC6, 0x00, 0x00, 0x67, 0x00, 0x07, 0x70, 0x00, 0x03,
  0xB8, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0x80, 0x00, 0xDC, 0x00, 0x00, 0xEC,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x00, 0x1F, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0xC0,
  0x00, 0x63, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x18, 0x00, 0x70, 0x70, 0x01,
  0xC1, 0xC0, 0x06, 0x03, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0x70, 0x1C, 0x01, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0E, 0x0E, 0x00, 0x38,
  0x30, 0x00, 0x61, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x18, 0x00, 0x0C, 0xE0,
  0x00, 0x3B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3B,
  0x00, 0x00, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0x60, 0x00, 0x61, 0xC0,
  0x03, 0x87, 0x00, 0x0C, 0x0C, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x06,
  0x01, 0x80, 0x38, 0x07, 0x00, 0xC0, 0x1C, 0x07, 0x00, 0x30, 0x1C, 0x00,
  0xE0, 0x60, 0x03, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0x31,
  0xC0, 0x00, 0xE6, 0x00, 0x03, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x39, 0x80, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00,
  0x03, 0x86, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x18, 0x00,
  0x70, 0x38, 0x00, 0xC0, 0x70, 0x01, 0x80, 0x60, 0x07, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x70, 0x03, 0x80, 0xC0, 0x07, 0x01, 0x80,
  0x06, 0x07, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x70, 0x00,
  0x38, 0xC0, 0x00, 0x71, 0x80, 0x00, 0x67, 0x00, 0x00, 0xEC, 0x00, 0x01,
  0xD8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0x86, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x60, 0x18, 0x00, 0x70,
  0x0E, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x18, 0x00, 0x60, 0x1C,
  0x00, 0x38, 0x0C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x06, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x00, 0xE0, 0x03,
  0xFF, 0x03, 0xFF, 0xE0, 0xE0, 0x1C, 0x20, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1F, 0xC0,
  0x7F, 0xF0, 0xFE, 0x1C, 0x78, 0x07, 0x38, 0x01, 0xDC, 0x00, 0x76, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x0B, 0xE0, 0x06, 0xDC,
  0x01, 0xB7, 0x80, 0xCC, 0xF9, 0xE3, 0x1F, 0xF0, 0xC0, 0xE0, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x0E, 0x00, 0xC1, 0xFF, 0x06, 0x3F, 0xFC, 0x33, 0x80,
  0xF1, 0x98, 0x03, 0xCD, 0x80, 0x0E, 0x68, 0x00, 0x33, 0xC0, 0x01, 0xDC,
  0x00, 0x06, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x6E, 0x00, 0x07, 0x78, 0x00, 0x3B,
  0x40, 0x03, 0x9B, 0x00, 0x1C, 0xCC, 0x01, 0xC6, 0x70, 0x1E, 0x31, 0xFF,
  0xE1, 0x87, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0xF0, 0x10, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x20, 0xFF, 0xF0,
  0x3F, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x07,
  0x03, 0xFE, 0x1C, 0x1F, 0xFC, 0x70, 0xF0, 0x39, 0xC7, 0x00, 0x77, 0x1C,
  0x00, 0xDC, 0xE0, 0x01, 0xF3, 0x80, 0x03, 0xDC, 0x00, 0x0F, 0x70, 0x00,
  0x3D, 0xC0, 0x00, 0x76, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x76,
  0x00, 0x01, 0xDC, 0x00, 0x0F, 0x70, 0x00, 0x3C, 0xC0, 0x00, 0xF3, 0x80,
  0x07, 0xCE, 0x00, 0x37, 0x1C, 0x00, 0xDC, 0x38, 0x0E, 0x30, 0xFF, 0xF0,
  0xC0, 0xFF, 0x83, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xE0, 0x07,
  0xFF, 0x00, 0xE0, 0x38, 0x1C, 0x01, 0xC1, 0x80, 0x0C, 0x38, 0x00, 0xE3,
  0x00, 0x06, 0x70, 0x00, 0x67, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x03,
  0x60, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x02, 0x0F, 0x00, 0xE0, 0x7F, 0xFE,
  0x01, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0xFE, 0x01, 0xFF, 0x03, 0xC6, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0xF8, 0x30, 0x7F, 0xF1, 0xC3, 0xC0, 0xE7,
  0x1C, 0x00, 0xDC, 0x70, 0x01, 0xF3, 0x80, 0x07, 0xCC, 0x00, 0x0F, 0x70,
  0x00, 0x3D, 0xC0, 0x00, 0xF6, 0x00, 0x01, 0xD8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x76, 0x00, 0x01, 0xD8, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0xF3,
  0x00, 0x07, 0xCE, 0x00, 0x1F, 0x38, 0x00, 0xDC, 0x70, 0x07, 0x70, 0xE0,
  0x39, 0xC1, 0xFF, 0xC7, 0x03, 0xFE, 0x1C, 0x01, 0xC0, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF1, 0x80, 0x07, 0x87, 0x80, 0x7C, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x01, 0x80, 0xC1, 0xFE, 0x18, 0xFF, 0xE3, 0x3C, 0x1E,
  0x66, 0x01, 0xCD, 0x80, 0x1D, 0xA0, 0x03, 0xBC, 0x00, 0x37, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x70, 0x7F, 0xF7, 0x60, 0x00, 0x00,
  0x00, 0x07, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x07, 0x0F, 0x0F, 0x07,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x1C, 0xFC,
  0xF8, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x03, 0xB0, 0x01, 0xCC, 0x00, 0x63, 0x00, 0x38, 0xC0, 0x1C,
  0x30, 0x07, 0x0C, 0x03, 0x83, 0x00, 0xC0, 0xC0, 0x70, 0x30, 0x38, 0x0C,
  0x0C, 0x03, 0x07, 0x00, 0xC3, 0x80, 0x30, 0xE0, 0x0C, 0x78, 0x03, 0x1E,
  0x00, 0xCD, 0xC0, 0x37, 0x70, 0x0D, 0x8E, 0x03, 0xC3, 0x80, 0xF0, 0x60,
  0x38, 0x1C, 0x0C, 0x03, 0x03, 0x00, 0xE0, 0xC0, 0x38, 0x30, 0x06, 0x0C,
  0x01, 0xC3, 0x00, 0x30, 0xC0, 0x0E, 0x30, 0x03, 0x8C, 0x00, 0x63, 0x00,
  0x1C, 0xC0, 0x03, 0x30, 0x00, 0xEC, 0x00, 0x3B, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x70, 0x00, 0xE0, 0x61, 0xFE, 0x03, 0xFC, 0x31, 0xFF, 0x83, 0xFF, 0x19,
  0xC1, 0xE3, 0x83, 0xCD, 0x80, 0x73, 0x80, 0xF6, 0xC0, 0x19, 0x80, 0x3B,
  0xC0, 0x0F, 0x80, 0x1D, 0xE0, 0x03, 0xC0, 0x06, 0xE0, 0x01, 0xC0, 0x03,
  0xF0, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x38, 0x00,
  0x7C, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x07, 0x00,
  0x0F, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x00, 0xE0,
  0x01, 0xF0, 0x00, 0x70, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x7C, 0x00, 0x1C,
  0x00, 0x3E, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x03,
  0x80, 0x07, 0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x01, 0xF0, 0x00,
  0x70, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x3E, 0x00,
  0x0E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x07, 0xC0,
  0x01, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0xF8,
  0x00, 0x38, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x18, 0x7F,
  0xC3, 0x1F, 0xFC, 0x67, 0x03, 0xCC, 0xC0, 0x3D, 0xB0, 0x03, 0xB4, 0x00,
  0x77, 0x80, 0x06, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xC0, 0xF0, 0x1C,
  0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0C, 0x00, 0x0C, 0x70, 0x00,
  0x39, 0xC0, 0x00, 0xE6, 0x00, 0x01, 0x98, 0x00, 0x06, 0xE0, 0x00, 0x1B,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x76,
  0x00, 0x01, 0x98, 0x00, 0x06, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE3, 0x00,
  0x03, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x70, 0x03, 0x80, 0xF0, 0x1C,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x06,
  0x0F, 0xF8, 0x31, 0xFF, 0xE1, 0x9C, 0x07, 0x8C, 0xC0, 0x1C, 0x6C, 0x00,
  0x73, 0x60, 0x01, 0x9E, 0x00, 0x0E, 0xF0, 0x00, 0x77, 0x00, 0x01, 0xB8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0x78, 0x00, 0x3B, 0xC0, 0x01, 0xDB, 0x00, 0x1C, 0xD8, 0x00, 0xE6,
  0x60, 0x0E, 0x33, 0x80, 0xE1, 0x8F, 0xFF, 0x0C, 0x1F, 0xE0, 0x60, 0x3C,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xF8, 0x30, 0x7F,
  0xF1, 0xC3, 0xC0, 0xE7, 0x1E, 0x00, 0xDC, 0x70, 0x03, 0x73, 0x80, 0x07,
  0xCE, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x00, 0x01, 0xD8,
  0x00, 0x07, 0x60, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x76, 0x00, 0x01, 0xD8, 0x00, 0x0F, 0x70, 0x00,
  0x3D, 0xC0, 0x00, 0xF3, 0x00, 0x07, 0xCE, 0x00, 0x1F, 0x3C, 0x00, 0xDC,
  0x70, 0x07, 0x70, 0xF0, 0x39, 0xC1, 0xFF, 0xC7, 0x03, 0xFE, 0x1C, 0x03,
  0xC0, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x46, 0x1F, 0xF1, 0xFF,
  0x8E, 0x1C, 0xC0, 0x6E, 0x03, 0x60, 0x1A, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFF,
  0x87, 0xFF, 0xE7, 0x80, 0x73, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x03, 0xBC, 0x03, 0x9F, 0xFF,
  0xC3, 0xFF, 0x80, 0x1E, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x03, 0xFF, 0xFF, 0xFE, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x70, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xDB, 0x00, 0x33,
  0x70, 0x06, 0x6F, 0x03, 0x8C, 0xFF, 0xE1, 0x8F, 0xF8, 0x30, 0x38, 0x00,
  0xE0, 0x00, 0x3B, 0x00, 0x01, 0x98, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00,
  0x07, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE0,
  0xC0, 0x06, 0x06, 0x00, 0x30, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x30, 0x18, 0x01,
  0x80, 0xC0, 0x0C, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x00, 0x0C, 0x18,
  0x00, 0x60, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x60, 0x00, 0x63, 0x00, 0x03,
  0x18, 0x00, 0x19, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00,
  0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0x80, 0x07, 0x80, 0x07, 0x60, 0x01, 0xF0, 0x01, 0x98, 0x00, 0x6C, 0x00,
  0x67, 0x00, 0x3B, 0x00, 0x19, 0xC0, 0x0E, 0xC0, 0x0E, 0x30, 0x03, 0x30,
  0x03, 0x8C, 0x00, 0xCE, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x30, 0xE0, 0x1C,
  0x60, 0x1C, 0x38, 0x07, 0x18, 0x07, 0x06, 0x01, 0x86, 0x01, 0x81, 0x80,
  0x61, 0xC0, 0x60, 0x70, 0x38, 0x30, 0x18, 0x1C, 0x0E, 0x0C, 0x0E, 0x03,
  0x03, 0x03, 0x03, 0x80, 0xC0, 0xC0, 0xE0, 0xC0, 0x30, 0x30, 0x38, 0x30,
  0x0E, 0x1C, 0x06, 0x0C, 0x03, 0x87, 0x01, 0x87, 0x00, 0x61, 0x80, 0x61,
  0xC0, 0x18, 0x60, 0x1C, 0x60, 0x07, 0x18, 0x07, 0x18, 0x01, 0xCE, 0x00,
  0xCE, 0x00, 0x33, 0x80, 0x33, 0x80, 0x0C, 0xC0, 0x0C, 0xC0, 0x03, 0x30,
  0x03, 0xB0, 0x00, 0xEC, 0x00, 0xEC, 0x00, 0x3F, 0x00, 0x1B, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x77, 0x00,
  0x0E, 0x38, 0x00, 0xE3, 0x80, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x18, 0x0C,
  0x03, 0x80, 0xE0, 0x30, 0x06, 0x07, 0x00, 0x70, 0x60, 0x03, 0x0E, 0x00,
  0x38, 0xE0, 0x03, 0x9C, 0x00, 0x19, 0xC0, 0x01, 0xD8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x19, 0xC0, 0x03, 0x9C, 0x00, 0x30, 0xC0, 0x07, 0x0E, 0x00, 0x70,
  0x60, 0x0E, 0x07, 0x00, 0xE0, 0x30, 0x0C, 0x03, 0x81, 0xC0, 0x38, 0x18,
  0x01, 0xC3, 0x80, 0x1C, 0x30, 0x00, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0x6E,
  0x00, 0x07, 0xE0, 0x00, 0x3B, 0x00, 0x01, 0x98, 0x00, 0x1C, 0xE0, 0x00,
  0xE7, 0x00, 0x07, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x38,
  0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x18,
  0x06, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x00, 0x30,
  0x18, 0x01, 0x81, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x60, 0x01, 0x83, 0x00,
  0x0C, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x67,
  0x00, 0x03, 0xB8, 0x00, 0x1D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x04, 0x70,
  0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x70, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x07, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1E, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0x3F, 0xF0, 0x03, 0xF0, 0xF8, 0x07, 0xC0, 0x1F, 0x1E,
  0x80, 0x0F, 0xFC, 0x80, 0x01, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 49, 14, 5, -49 },
  { 26, 13, 18, 21, 4, -49 },
  { 56, 27, 49, 29, 1, -49 },
  { 222, 23, 56, 27, 2, -52 },
  { 383, 34, 50, 40, 3, -49 },
  { 596, 26, 50, 27, 2, -49 },
  { 759, 3, 18, 12, 4, -49 },
  { 766, 13, 60, 18, 3, -49 },
  { 864, 12, 60, 18, 3, -49 },
  { 954, 18, 19, 24, 3, -52 },
  { 997, 24, 32, 28, 2, -40 },
  { 1093, 6, 16, 13, 3, -7 },
  { 1105, 14, 3, 18, 2, -20 },
  { 1111, 5, 5, 13, 4, -5 },
  { 1115, 20, 49, 23, 2, -49 },
  { 1238, 21, 49, 27, 3, -49 },
  { 1367, 12, 49, 27, 5, -49 },
  { 1441, 21, 49, 27, 3, -49 },
  { 1570, 21, 50, 27, 3, -49 },
  { 1702, 26, 49, 27, 1, -49 },
  { 1862, 21, 50, 27, 3, -49 },
  { 1994, 21, 50, 27, 3, -49 },
  { 2126, 21, 49, 27, 3, -49 },
  { 2255, 23, 50, 27, 2, -49 },
  { 2399, 21, 50, 27, 3, -49 },
  { 2531, 5, 36, 13, 4, -36 },
  { 2554, 6, 45, 13, 3, -36 },
  { 2588, 24, 28, 28, 2, -38 },
  { 2672, 24, 17, 28, 2, -32 },
  { 2723, 24, 28, 28, 2, -38 },
  { 2807, 16, 49, 19, 1, -49 },
  { 2905, 34, 55, 42, 4, -49 },
  { 3139, 27, 49, 27, 0, -49 },
  { 3305, 22, 49, 30, 5, -49 },
  { 3440, 23, 50, 29, 4, -49 },
  { 3584, 24, 49, 33, 5, -49 },
  { 3731, 18, 49, 26, 5, -49 },
  { 3842, 18, 49, 24, 5, -49 },
  { 3953, 28, 50, 36, 4, -49 },
  { 4128, 23, 49, 34, 5, -49 },
  { 4269, 10, 49, 16, 3, -49 },
  { 4331, 11, 61, 13, -3, -49 },
  { 4415, 22, 49, 27, 5, -49 },
  { 4550, 17, 49, 24, 5, -49 },
  { 4655, 35, 49, 45, 5, -49 },
  { 4870, 25, 49, 35, 5, -49 },
  { 5024, 28, 50, 35, 4, -49 },
  { 5199, 20, 49, 28, 5, -49 },
  { 5322, 28, 61, 35, 4, -49 },
  { 5536, 22, 49, 28, 5, -49 },
  { 5671, 21, 50, 27, 3, -49 },
  { 5803, 22, 49, 23, 1, -49 },
  { 5938, 24, 50, 34, 5, -49 },
  { 6088, 26, 49, 26, 0, -49 },
  { 6248, 45, 49, 45, 0, -49 },
  { 6524, 22, 49, 23, 1, -49 },
  { 6659, 23, 49, 23, 0, -49 },
  { 6800, 19, 49, 23, 2, -49 },
  { 6917, 13, 60, 21, 6, -49 },
  { 7015, 20, 49, 23, 2, -49 },
  { 7138, 13, 60, 21, 2, -49 },
  { 7236, 25, 23, 28, 1, -48 },
  { 7308, 27, 2, 27, 0, 6 },
  { 7315, 10, 11, 16, 3, -52 },
  { 7329, 18, 38, 26, 3, -37 },
  { 7415, 21, 53, 29, 5, -52 },
  { 7555, 17, 38, 22, 3, -37 },
  { 7636, 22, 53, 29, 3, -52 },
  { 7782, 20, 38, 26, 3, -37 },
  { 7877, 16, 52, 15, 1, -52 },
  { 7981, 22, 53, 29, 3, -37 },
  { 8127, 19, 52, 28, 5, -52 },
  { 8251, 4, 49, 13, 4, -49 },
  { 8276, 8, 65, 13, 0, -49 },
  { 8341, 18, 52, 23, 5, -52 },
  { 8458, 2, 52, 12, 5, -52 },
  { 8471, 33, 37, 42, 5, -37 },
  { 8624, 19, 37, 28, 5, -37 },
  { 8712, 22, 38, 28, 3, -37 },
  { 8817, 21, 53, 29, 5, -37 },
  { 8957, 22, 53, 29, 3, -37 },
  { 9103, 13, 37, 18, 5, -37 },
  { 9164, 17, 38, 22, 2, -37 },
  { 9245, 13, 46, 15, 1, -45 },
  { 9320, 19, 37, 28, 5, -36 },
  { 9408, 21, 36, 21, 0, -36 },
  { 9503, 34, 36, 36, 1, -36 },
  { 9656, 20, 36, 22, 1, -36 },
  { 9746, 21, 52, 22, 1, -36 },
  { 9883, 15, 36, 18, 2, -36 },
  { 9951, 17, 60, 24, 3, -49 },
  { 10079, 2, 68, 26, 12, -52 },
  { 10096, 17, 60, 24, 3, -49 },
  { 10224, 24, 6, 28, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight68pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT68PT7B_H_
