#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT67PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight67pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x0E, 0xFF,
  0xFF, 0xE0, 0x3F, 0x01, 0xF8, 0x0D, 0xC0, 0x6E, 0x03, 0x70, 0x1B, 0x80,
  0xDC, 0x06, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x19,
  0x80, 0xCC, 0x06, 0x60, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80,
  0x01, 0xC0, 0x30, 0x00, 0x38, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0,
  0x18, 0x00, 0x18, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x60, 0x18, 0x00,
  0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x01,
  0x80, 0x01, 0x80, 0x30, 0x0F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x00,
  0xC0, 0x38, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C,
  0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x01, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x38, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x1C, 0x00,
  0x0C, 0x03, 0x80, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01,
  0x80, 0x01, 0xC0, 0x30, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x18, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x60, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFC, 0xFE, 0x0F, 0x18, 0x18, 0x38, 0x30,
  0x10, 0x60, 0x60, 0x01, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x0E, 0x03, 0x00,
  0x1C, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x30, 0x01,
  0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x07, 0x03, 0x00, 0x07,
  0x06, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x18, 0x00, 0x07, 0xB0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x06,
  0x78, 0x00, 0x0C, 0x3C, 0x00, 0x18, 0x38, 0x00, 0x30, 0x38, 0x00, 0x60,
  0x38, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0xE0, 0x06, 0x01,
  0xC0, 0x0C, 0x03, 0x80, 0x18, 0x07, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18,
  0x00, 0xC0, 0x70, 0x01, 0x80, 0xC8, 0x03, 0x03, 0x9C, 0x06, 0x1E, 0x3F,
  0x8C, 0xF8, 0x1F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x70, 0x01, 0xDE,
  0x00, 0x18, 0x00, 0xE1, 0x80, 0x06, 0x00, 0x30, 0x30, 0x03, 0x80, 0x18,
  0x0C, 0x00, 0xC0, 0x06, 0x03, 0x80, 0x30, 0x01, 0x80, 0x60, 0x1C, 0x00,
  0xE0, 0x18, 0x06, 0x00, 0x38, 0x06, 0x01, 0x80, 0x0C, 0x01, 0x80, 0xE0,
  0x03, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x30, 0x06, 0x07,
  0x00, 0x0C, 0x01, 0x81, 0x80, 0x03, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x18,
  0x38, 0x00, 0x30, 0x06, 0x0C, 0x00, 0x0C, 0x01, 0x83, 0x00, 0x03, 0x00,
  0x61, 0xC0, 0x00, 0xC0, 0x18, 0x60, 0xFC, 0x38, 0x06, 0x18, 0x7F, 0x86,
  0x01, 0x86, 0x38, 0x61, 0x80, 0xE3, 0x0C, 0x0C, 0x60, 0x30, 0xC7, 0x03,
  0x1C, 0x0C, 0x31, 0x80, 0xE3, 0x07, 0x18, 0x60, 0x18, 0xE1, 0x86, 0x18,
  0x06, 0x1F, 0xE1, 0x86, 0x01, 0x83, 0xF0, 0xC3, 0x80, 0x60, 0x20, 0x30,
  0xE0, 0x18, 0x00, 0x0C, 0x30, 0x07, 0x00, 0x06, 0x0C, 0x01, 0xC0, 0x01,
  0x83, 0x00, 0x70, 0x00, 0x60, 0xC0, 0x1C, 0x00, 0x30, 0x30, 0x07, 0x00,
  0x0C, 0x0C, 0x01, 0xC0, 0x03, 0x03, 0x00, 0x70, 0x01, 0x80, 0xC0, 0x1C,
  0x00, 0x60, 0x38, 0x06, 0x00, 0x18, 0x06, 0x01, 0x80, 0x0C, 0x01, 0x80,
  0x60, 0x03, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x18, 0x0E, 0x00, 0x70, 0x07,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x00, 0x38, 0x70, 0x03, 0x80,
  0x07, 0xF8, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xE1, 0xC0, 0x00,
  0x60, 0x70, 0x00, 0x70, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x07, 0x00,
  0x0C, 0x03, 0x80, 0x06, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x01, 0x80, 0x70,
  0x00, 0xC0, 0x38, 0x00, 0x60, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x06, 0x07, 0x00, 0x03, 0x83, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x61,
  0x80, 0x00, 0x39, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x8C, 0x00, 0x03,
  0x87, 0x00, 0x03, 0x81, 0x80, 0x71, 0x80, 0xE0, 0x39, 0xC0, 0x30, 0x1C,
  0xE0, 0x1C, 0x0C, 0x60, 0x07, 0x06, 0x70, 0x01, 0x83, 0x38, 0x00, 0xE3,
  0x9C, 0x00, 0x31, 0xCE, 0x00, 0x1C, 0xC7, 0x00, 0x06, 0x63, 0x80, 0x03,
  0xF1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x3C, 0x18, 0x00,
  0x1E, 0x0E, 0x00, 0x1F, 0x87, 0x00, 0x1C, 0xE1, 0xC0, 0x1C, 0x70, 0x70,
  0x1C, 0x1C, 0x1F, 0xFC, 0x06, 0x07, 0xFC, 0x03, 0x80, 0x70, 0x00, 0x00,
  0xFF, 0xFF, 0xFB, 0x6D, 0xB6, 0xDB, 0x60, 0x00, 0x30, 0x06, 0x00, 0xE0,
  0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x00, 0x38, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x00,
  0x70, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x0C, 0x1B, 0xE3, 0x3E, 0x3F,
  0xFE, 0x01, 0xFC, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x03, 0x30, 0x01, 0x86,
  0x00, 0xC1, 0xC0, 0x70, 0x30, 0x38, 0x07, 0x0C, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x8C, 0x71, 0xC6,
  0x18, 0xE3, 0x0C, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xE0,
  0x01, 0xFF, 0xC0, 0x0E, 0x0F, 0x00, 0xE0, 0x38, 0x0E, 0x00, 0xE0, 0x60,
  0x03, 0x07, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0x80, 0x03, 0x1C, 0x00, 0x18,
  0xE0, 0x00, 0xE7, 0x00, 0x07, 0x30, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00,
  0x06, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x37, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x38, 0x00, 0x39, 0xC0,
  0x01, 0xCE, 0x00, 0x0C, 0x30, 0x00, 0x61, 0xC0, 0x07, 0x0E, 0x00, 0x38,
  0x38, 0x01, 0x81, 0xC0, 0x1C, 0x07, 0x01, 0xC0, 0x1C, 0x1E, 0x00, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x0F, 0x01, 0xF0, 0x3F, 0x07, 0x70,
  0xE7, 0x1C, 0x73, 0x87, 0xF0, 0x7E, 0x07, 0x40, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x40, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xC1,
  0xF8, 0x0F, 0x06, 0x00, 0x3C, 0x20, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x20, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF8, 0x0F, 0x01, 0xF0,
  0xF0, 0x01, 0xE1, 0x80, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF1, 0x00, 0x07, 0x87, 0x00, 0x3C, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x07, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00,
  0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60,
  0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x18, 0x06,
  0x00, 0x1C, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0E, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x18, 0x03, 0x80, 0x0C, 0x01, 0x80,
  0x06, 0x01, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x70, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC1, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xC0,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x88, 0x00, 0x3C, 0x70,
  0x07, 0xC3, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x07, 0xFF, 0x00, 0x78, 0x18, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC3, 0xFC, 0x0E, 0x3F, 0xF8, 0x73, 0x81, 0xE3, 0xB0, 0x07, 0x1F, 0x00,
  0x1C, 0xF8, 0x00, 0x77, 0x80, 0x03, 0xBC, 0x00, 0x0D, 0xC0, 0x00, 0x6E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xD8, 0x00, 0x0E, 0xC0, 0x00, 0x76, 0x00, 0x03, 0xB0,
  0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x03,
  0x8E, 0x00, 0x18, 0x38, 0x01, 0xC1, 0xC0, 0x0C, 0x07, 0x01, 0xE0, 0x1F,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xF0, 0x1E, 0x07, 0x80, 0x3C,
  0x1C, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8C, 0x00, 0x06, 0x30,
  0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00,
  0x18, 0xE0, 0x00, 0x63, 0x80, 0x03, 0x86, 0x00, 0x0C, 0x1C, 0x00, 0x70,
  0x38, 0x03, 0x80, 0x70, 0x1E, 0x01, 0xE0, 0xF0, 0x01, 0xC7, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xCF, 0x00, 0x1E, 0x0E,
  0x00, 0xF0, 0x1C, 0x07, 0x80, 0x38, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0xE3,
  0x00, 0x03, 0x9C, 0x00, 0x07, 0x70, 0x00, 0x1D, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x36, 0x00, 0x00,
  0xD8, 0x00, 0x03, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x73, 0x00, 0x03, 0x8E,
  0x00, 0x0E, 0x1C, 0x00, 0x70, 0x3C, 0x07, 0x80, 0x7F, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x38, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xC0, 0x0F, 0xFE, 0x01,
  0xE0, 0x70, 0x38, 0x03, 0x83, 0x80, 0x1C, 0x70, 0x00, 0xC7, 0x00, 0x0E,
  0x60, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0xF7, 0x00, 0x0B, 0x38, 0x01, 0xB3,
  0xC0, 0x73, 0x1F, 0xFE, 0x30, 0x7F, 0xC3, 0x01, 0xF0, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x40,
  0x3C, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x70, 0x00, 0x77, 0xBF, 0xEF,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0xF7, 0xFC, 0xE0, 0x38, 0xF3, 0xCF, 0x3C,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x71, 0xC7, 0x38, 0xE3, 0x8E, 0x31,
  0xC7, 0x18, 0x63, 0x8C, 0x30, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x3F, 0xE0, 0xFF, 0xF8, 0xF0, 0x3C, 0x40, 0x1C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x03, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x70, 0x0C, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x08, 0x00, 0xC7, 0x00, 0x3F, 0xE0, 0x39, 0x80, 0x1F, 0xF8, 0x0E, 0x60,
  0x0E, 0x06, 0x01, 0x98, 0x03, 0x01, 0x80, 0x6E, 0x01, 0xC0, 0x60, 0x1B,
  0x80, 0x60, 0x18, 0x06, 0xC0, 0x38, 0x0E, 0x01, 0xF0, 0x0C, 0x03, 0x80,
  0x7C, 0x03, 0x00, 0xE0, 0x1F, 0x00, 0xC0, 0x38, 0x07, 0xC0, 0x70, 0x0E,
  0x01, 0xF0, 0x1C, 0x03, 0x80, 0x7C, 0x07, 0x00, 0xE0, 0x1F, 0x01, 0xC0,
  0x38, 0x07, 0xC0, 0x70, 0x0E, 0x01, 0xF0, 0x1C, 0x03, 0x80, 0x7C, 0x07,
  0x00, 0xC0, 0x1B, 0x01, 0xC0, 0x30, 0x06, 0xC0, 0x70, 0x0C, 0x01, 0xB0,
  0x0C, 0x07, 0x80, 0x6C, 0x03, 0x01, 0xE0, 0x3B, 0x00, 0xE0, 0x58, 0x0C,
  0xC0, 0x38, 0x36, 0x07, 0x38, 0x07, 0x1C, 0xC3, 0x8E, 0x00, 0xFE, 0x3F,
  0xE1, 0x80, 0x3F, 0x07, 0xE0, 0x60, 0x01, 0x00, 0x20, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x03, 0x30, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x71, 0x80, 0x00, 0x1C,
  0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x38, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x70, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80,
  0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x18, 0x00, 0x60,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00,
  0x30, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x18, 0x18, 0x00, 0x07, 0x06, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x38, 0x00, 0xF8, 0xE0, 0x00, 0xE3, 0x80, 0x01, 0xCE, 0x00, 0x07,
  0x38, 0x00, 0x0C, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8,
  0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00,
  0x0C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0x38,
  0xE0, 0x03, 0xC3, 0x80, 0x3E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xE0,
  0x07, 0xC3, 0x80, 0x07, 0x8E, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x06, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0xEE, 0x00, 0x07, 0x38, 0x00, 0x3C, 0xE0, 0x01, 0xE3, 0x80, 0x3F, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xF8, 0x0F, 0x00, 0xE0, 0x38, 0x00, 0x40, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x40, 0x78, 0x03, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0xE0, 0x07, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x07, 0xC0, 0xE0, 0x7F, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEE, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x3C, 0x00, 0x0C, 0x0F, 0x00,
  0x00, 0x83, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x0C, 0x78, 0x00, 0x01, 0x87, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x06, 0x07, 0x80, 0x00, 0xC0, 0x7C, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x3F, 0xFF, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01,
  0xDF, 0xF3, 0xFC, 0x3F, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xB8, 0x00,
  0x19, 0xC0, 0x01, 0xCE, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0E, 0x1C,
  0x00, 0x60, 0xE0, 0x07, 0x07, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x38,
  0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0,
  0xE0, 0x07, 0x07, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00,
  0x73, 0x80, 0x03, 0x9E, 0x00, 0x1D, 0xF0, 0x00, 0xED, 0xC0, 0x07, 0xC6,
  0x00, 0x3E, 0x38, 0x01, 0xE0, 0xC0, 0x0E, 0x07, 0x00, 0x70, 0x18, 0x03,
  0x80, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x60, 0x38, 0x03,
  0x81, 0xC0, 0x0C, 0x0E, 0x00, 0x70, 0x70, 0x01, 0x83, 0x80, 0x0E, 0x1C,
  0x00, 0x70, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x39, 0xC0, 0x01,
  0xCE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFD, 0x80,
  0x00, 0x00, 0x7F, 0xB0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xBF,
  0x60, 0x00, 0x00, 0x77, 0xEC, 0x00, 0x00, 0x0E, 0xFD, 0xC0, 0x00, 0x01,
  0x9F, 0x98, 0x00, 0x00, 0x33, 0xF3, 0x00, 0x00, 0x0E, 0x7E, 0x70, 0x00,
  0x01, 0x8F, 0xCE, 0x00, 0x00, 0x31, 0xF8, 0xC0, 0x00, 0x0E, 0x3F, 0x18,
  0x00, 0x01, 0xC7, 0xE3, 0x80, 0x00, 0x30, 0xFC, 0x30, 0x00, 0x0E, 0x1F,
  0x86, 0x00, 0x01, 0xC3, 0xF0, 0xE0, 0x00, 0x30, 0x7E, 0x1C, 0x00, 0x06,
  0x0F, 0xC1, 0x80, 0x01, 0xC1, 0xF8, 0x38, 0x00, 0x30, 0x3F, 0x07, 0x00,
  0x06, 0x07, 0xE0, 0x60, 0x01, 0xC0, 0xFC, 0x0C, 0x00, 0x38, 0x1F, 0x81,
  0xC0, 0x06, 0x03, 0xF0, 0x18, 0x01, 0xC0, 0x7E, 0x03, 0x00, 0x38, 0x0F,
  0xC0, 0x70, 0x06, 0x01, 0xF8, 0x0E, 0x00, 0xC0, 0x3F, 0x00, 0xC0, 0x38,
  0x07, 0xE0, 0x1C, 0x06, 0x00, 0xFC, 0x03, 0x80, 0xC0, 0x1F, 0x80, 0x30,
  0x38, 0x03, 0xF0, 0x06, 0x07, 0x00, 0x7E, 0x00, 0xE0, 0xC0, 0x0F, 0xC0,
  0x0C, 0x38, 0x01, 0xF8, 0x01, 0x87, 0x00, 0x3F, 0x00, 0x38, 0xC0, 0x07,
  0xE0, 0x07, 0x18, 0x00, 0xFC, 0x00, 0x67, 0x00, 0x1F, 0x80, 0x0E, 0xC0,
  0x03, 0xF0, 0x01, 0xD8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xD8, 0x00, 0x07,
  0xEE, 0x00, 0x03, 0xF3, 0x00, 0x01, 0xF9, 0xC0, 0x00, 0xFC, 0x60, 0x00,
  0x7E, 0x38, 0x00, 0x3F, 0x0C, 0x00, 0x1F, 0x86, 0x00, 0x0F, 0xC3, 0x80,
  0x07, 0xE0, 0xC0, 0x03, 0xF0, 0x70, 0x01, 0xF8, 0x18, 0x00, 0xFC, 0x0E,
  0x00, 0x7E, 0x03, 0x00, 0x3F, 0x01, 0xC0, 0x1F, 0x80, 0xE0, 0x0F, 0xC0,
  0x30, 0x07, 0xE0, 0x1C, 0x03, 0xF0, 0x06, 0x01, 0xF8, 0x03, 0x80, 0xFC,
  0x00, 0xC0, 0x7E, 0x00, 0x70, 0x3F, 0x00, 0x38, 0x1F, 0x80, 0x0E, 0x0F,
  0xC0, 0x07, 0x07, 0xE0, 0x01, 0x83, 0xF0, 0x00, 0xE1, 0xF8, 0x00, 0x30,
  0xFC, 0x00, 0x1C, 0x7E, 0x00, 0x06, 0x3F, 0x00, 0x03, 0x9F, 0x80, 0x01,
  0xCF, 0xC0, 0x00, 0x67, 0xE0, 0x00, 0x3B, 0xF0, 0x00, 0x0D, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00,
  0x1C, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x37, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xE0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0xE0, 0x0E, 0x00, 0x38, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x0E, 0x00, 0xF8, 0xE0, 0x03, 0xCE, 0x00, 0x1C, 0xE0, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00,
  0x0E, 0xE0, 0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x07, 0x8E, 0x0F, 0xF0, 0xFF,
  0xFC, 0x0F, 0xFE, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x1C,
  0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x37, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0xE0, 0x0E, 0x00, 0x38, 0x01, 0xF0, 0x1E, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x38, 0x01, 0xE0, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x0E,
  0x38, 0x00, 0x18, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38,
  0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00,
  0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x06, 0x38, 0x00, 0x38,
  0xE0, 0x00, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x03, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x38, 0x0C, 0x00, 0xE0, 0x38,
  0x03, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x03,
  0x80, 0x38, 0x0E, 0x00, 0x60, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x03, 0x80,
  0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x03,
  0x8E, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xCE,
  0x00, 0x03, 0xB8, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xFC, 0x3E, 0x01, 0xE1, 0xC0, 0x02, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x40, 0x01, 0xE3, 0xC0, 0x1E, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFC, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0x60, 0x00, 0x0C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x71, 0xC0, 0x01, 0xC3,
  0xC0, 0x07, 0x83, 0xE0, 0x1E, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x38, 0x18, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0xC0, 0x30, 0x00, 0x70, 0x0C, 0x00, 0x1C, 0x03, 0x80, 0x06,
  0x00, 0xE0, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x06, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x00, 0x70, 0x00,
  0xC0, 0x1C, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x01, 0x80, 0x01, 0x80, 0xE0,
  0x00, 0x60, 0x38, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x86, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x06, 0x30, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x76, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x77, 0x00, 0x00, 0xF0, 0x00, 0x06,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x30,
  0x00, 0x0F, 0x80, 0x00, 0xE3, 0x00, 0x01, 0xF8, 0x00, 0x0C, 0x38, 0x00,
  0x1D, 0x80, 0x00, 0xC3, 0x80, 0x01, 0x98, 0x00, 0x1C, 0x18, 0x00, 0x19,
  0x80, 0x01, 0xC1, 0x80, 0x01, 0x9C, 0x00, 0x1C, 0x1C, 0x00, 0x39, 0xC0,
  0x01, 0x81, 0xC0, 0x03, 0x8C, 0x00, 0x38, 0x1C, 0x00, 0x30, 0xC0, 0x03,
  0x80, 0xC0, 0x03, 0x0C, 0x00, 0x38, 0x0C, 0x00, 0x30, 0xE0, 0x03, 0x00,
  0xE0, 0x07, 0x0E, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x60, 0x07, 0x00, 0xE0,
  0x06, 0x06, 0x00, 0x70, 0x06, 0x00, 0x60, 0x60, 0x07, 0x00, 0x60, 0x06,
  0x07, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x70, 0x06, 0x00, 0x70, 0x0E, 0x07,
  0x00, 0xE0, 0x07, 0x00, 0xC0, 0x30, 0x0E, 0x00, 0x30, 0x0C, 0x03, 0x00,
  0xE0, 0x03, 0x00, 0xC0, 0x38, 0x0C, 0x00, 0x38, 0x1C, 0x03, 0x81, 0xC0,
  0x03, 0x81, 0xC0, 0x38, 0x1C, 0x00, 0x18, 0x18, 0x01, 0x81, 0xC0, 0x01,
  0x81, 0x80, 0x18, 0x18, 0x00, 0x1C, 0x18, 0x01, 0x81, 0x80, 0x01, 0xC3,
  0x80, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x00, 0xC3, 0x00,
  0x0C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x00, 0xE3, 0x00, 0x0C,
  0x30, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x0E, 0x70,
  0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00,
  0x07, 0x60, 0x00, 0x66, 0x00, 0x00, 0x76, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x18, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x0E, 0x00,
  0x1C, 0x18, 0x00, 0x70, 0x70, 0x01, 0x81, 0xC0, 0x0E, 0x03, 0x00, 0x38,
  0x0E, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x70, 0x18, 0x01, 0xC0, 0xE0, 0x03,
  0x03, 0x80, 0x0E, 0x0C, 0x00, 0x38, 0x70, 0x00, 0x61, 0xC0, 0x01, 0xC6,
  0x00, 0x03, 0x38, 0x00, 0x0C, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x33, 0x00, 0x01, 0xCE, 0x00, 0x07, 0x38,
  0x00, 0x18, 0x60, 0x00, 0xE1, 0xC0, 0x03, 0x07, 0x00, 0x1C, 0x0C, 0x00,
  0x70, 0x38, 0x01, 0x80, 0xE0, 0x0E, 0x01, 0x80, 0x30, 0x07, 0x01, 0xC0,
  0x1C, 0x07, 0x00, 0x30, 0x18, 0x00, 0xE0, 0xE0, 0x01, 0x83, 0x00, 0x07,
  0x1C, 0x00, 0x1C, 0x70, 0x00, 0x31, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x76, 0x00, 0x01, 0x9C, 0x00,
  0x0E, 0x70, 0x00, 0x38, 0xC0, 0x00, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x18, 0x00, 0x60, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0x00, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x18, 0x01, 0xC0, 0x60, 0x07, 0x03,
  0x80, 0x0C, 0x0C, 0x00, 0x38, 0x30, 0x00, 0x61, 0xC0, 0x01, 0x86, 0x00,
  0x07, 0x18, 0x00, 0x0C, 0xE0, 0x00, 0x33, 0x00, 0x00, 0xEC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x03, 0x98, 0x00, 0x01, 0x8E, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x60, 0x38,
  0x00, 0x70, 0x0C, 0x00, 0x30, 0x07, 0x00, 0x38, 0x01, 0x80, 0x18, 0x00,
  0xE0, 0x1C, 0x00, 0x70, 0x0C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x06, 0x00,
  0x03, 0x87, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0x80,
  0x00, 0x0D, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80,
  0x70, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7C, 0x3E, 0x0C, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0xFF, 0xE0, 0x7F, 0xDC, 0x3E, 0x03, 0x8F, 0x00,
  0x73, 0x80, 0x0E, 0x70, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x60, 0x00,
  0xEC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x76, 0x00, 0x1E, 0xC0, 0x03,
  0xD8, 0x00, 0x5B, 0x80, 0x1B, 0x30, 0x02, 0x67, 0x01, 0xCC, 0x7C, 0xF1,
  0x87, 0xFC, 0x30, 0x3C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x1F, 0x80, 0xC3,
  0xFF, 0x06, 0x3C, 0x7C, 0x33, 0x00, 0xF1, 0xB0, 0x01, 0x8D, 0x80, 0x0E,
  0x78, 0x00, 0x33, 0xC0, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x37, 0x00,
  0x01, 0xB8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00, 0x1D, 0xC0, 0x00,
  0xEF, 0x00, 0x06, 0x68, 0x00, 0x73, 0x60, 0x03, 0x9B, 0x80, 0x38, 0xCE,
  0x07, 0x86, 0x3F, 0xF8, 0x30, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0xFF,
  0x01, 0xFF, 0xC1, 0xF0, 0xE1, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x41, 0xFF,
  0xE0, 0x7F, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x3F, 0x83, 0x07,
  0xFE, 0x18, 0x7C, 0x38, 0xC7, 0x80, 0x66, 0x38, 0x01, 0xB3, 0x80, 0x0D,
  0x9C, 0x00, 0x3D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3B, 0x00, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00,
  0x77, 0x00, 0x07, 0x9C, 0x00, 0x2C, 0xE0, 0x03, 0x63, 0x80, 0x33, 0x1E,
  0x03, 0x98, 0x7F, 0xF8, 0xC0, 0xFF, 0x86, 0x00, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xE0, 0x0F, 0x0F, 0x00, 0xE0, 0x38, 0x1C, 0x01, 0xC3, 0x80,
  0x0C, 0x30, 0x00, 0xE3, 0x00, 0x06, 0x70, 0x00, 0x66, 0x00, 0x06, 0x60,
  0x00, 0x76, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x20, 0xF0, 0x0E, 0x07,
  0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0xFE, 0x07, 0xFC, 0x0E,
  0x08, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0xC3, 0xE3, 0xE6, 0x3C, 0x03, 0x31, 0xC0, 0x0D, 0x9C, 0x00, 0x2C, 0xC0,
  0x01, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x00, 0x01, 0xD8, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xD8, 0x00, 0x0E, 0xC0, 0x00, 0x77, 0x00, 0x07, 0xB8,
  0x00, 0x3C, 0xE0, 0x01, 0x67, 0x00, 0x1B, 0x1C, 0x01, 0x98, 0x70, 0x1C,
  0xC3, 0xFF, 0xC6, 0x07, 0xF8, 0x30, 0x07, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x60, 0x01, 0xC3, 0xE0, 0x7C, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x07, 0xF0,
  0xC3, 0xFE, 0x31, 0xE3, 0xCC, 0xE0, 0x3B, 0x60, 0x0E, 0xD8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0C, 0x67, 0xFF, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x06, 0x0F, 0x0F, 0x0F,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x9C, 0xFC,
  0xF8, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x07, 0x60, 0x03, 0x30, 0x03, 0x98, 0x03, 0x8C, 0x01, 0x86, 0x01, 0xC3,
  0x00, 0xC1, 0x80, 0xE0, 0xC0, 0xE0, 0x60, 0x60, 0x30, 0x70, 0x18, 0x70,
  0x0C, 0x38, 0x06, 0x3C, 0x03, 0x1E, 0x01, 0x9B, 0x00, 0xDD, 0xC0, 0x6C,
  0x60, 0x3C, 0x38, 0x1E, 0x1C, 0x0E, 0x06, 0x06, 0x03, 0x83, 0x00, 0xC1,
  0x80, 0x70, 0xC0, 0x38, 0x60, 0x0C, 0x30, 0x07, 0x18, 0x01, 0x8C, 0x00,
  0xE6, 0x00, 0x73, 0x00, 0x19, 0x80, 0x0E, 0xC0, 0x03, 0x60, 0x01, 0xF0,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0xC7, 0xFC, 0x0F, 0xF8, 0xCF,
  0x1E, 0x1C, 0x3C, 0xCC, 0x07, 0x38, 0x1E, 0xD8, 0x07, 0x30, 0x0E, 0xD0,
  0x03, 0x60, 0x07, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0,
  0x01, 0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0x01, 0xFC, 0x30, 0xFF, 0x8C, 0x70, 0xF3, 0x30, 0x0E,
  0xD8, 0x01, 0xB6, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xF8, 0x78, 0x07, 0x80, 0x70, 0x1C,
  0x00, 0xE0, 0xE0, 0x01, 0x83, 0x00, 0x07, 0x1C, 0x00, 0x0C, 0x70, 0x00,
  0x31, 0x80, 0x00, 0xE6, 0x00, 0x03, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1B,
  0x80, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1B, 0x80,
  0x00, 0x6E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1B, 0x80, 0x00,
  0x6E, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x19, 0x80, 0x00, 0x66,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x30, 0xC0, 0x01, 0xC3, 0x80,
  0x07, 0x06, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x38, 0x0F, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x01, 0xFC, 0x06, 0x1F, 0xF8, 0x31,
  0xE1, 0xE1, 0x9C, 0x07, 0x8D, 0xC0, 0x1C, 0x6C, 0x00, 0x73, 0x40, 0x01,
  0x9E, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xB8, 0x00, 0x0D, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x37,
  0x00, 0x01, 0xB8, 0x00, 0x0D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x78, 0x00,
  0x33, 0x40, 0x03, 0x9B, 0x00, 0x18, 0xCC, 0x01, 0xC6, 0x70, 0x1C, 0x31,
  0xFF, 0xC1, 0x87, 0xFC, 0x0C, 0x07, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xF0, 0xC3, 0xE1, 0xE6, 0x1C, 0x03, 0x31, 0xC0, 0x0D,
  0x9C, 0x00, 0x2C, 0xE0, 0x01, 0xE6, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80,
  0x01, 0xD8, 0x00, 0x0E, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xD8, 0x00, 0x0E, 0xE0, 0x00,
  0x77, 0x00, 0x03, 0xB8, 0x00, 0x3C, 0xE0, 0x01, 0x67, 0x00, 0x1B, 0x1C,
  0x01, 0x98, 0x70, 0x1C, 0xC1, 0xFF, 0xC6, 0x07, 0xFC, 0x30, 0x07, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x01, 0xFE, 0x1F, 0xB1, 0xFD, 0x9C, 0x0C, 0xC0,
  0x6C, 0x03, 0x40, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x87, 0xC3, 0xE7, 0x00, 0x27,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x80,
  0x07, 0x78, 0x0F, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x7C, 0x00, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x07, 0xFF, 0xFF, 0xFE, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xFE, 0x07, 0xF0, 0x1E, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x6D, 0xC0, 0x3B,
  0x78, 0x1C, 0xCF, 0xFE, 0x31, 0xFF, 0x0C, 0x1E, 0x00, 0xE0, 0x00, 0x36,
  0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0E,
  0x30, 0x00, 0xE3, 0x80, 0x0C, 0x38, 0x00, 0xC1, 0x80, 0x1C, 0x18, 0x01,
  0xC1, 0xC0, 0x18, 0x1C, 0x01, 0x80, 0xC0, 0x38, 0x0C, 0x03, 0x80, 0xE0,
  0x30, 0x0E, 0x03, 0x00, 0x60, 0x30, 0x06, 0x07, 0x00, 0x60, 0x70, 0x07,
  0x06, 0x00, 0x30, 0x60, 0x03, 0x0E, 0x00, 0x30, 0xE0, 0x03, 0x8C, 0x00,
  0x18, 0xC0, 0x01, 0x9C, 0x00, 0x19, 0xC0, 0x01, 0xD8, 0x00, 0x0D, 0x80,
  0x00, 0xD8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x6E, 0x00, 0x1E,
  0x00, 0x19, 0x80, 0x07, 0x80, 0x06, 0x60, 0x01, 0xE0, 0x03, 0x98, 0x00,
  0xFC, 0x00, 0xE7, 0x00, 0x33, 0x00, 0x31, 0xC0, 0x0C, 0xC0, 0x0C, 0x30,
  0x03, 0x30, 0x03, 0x0C, 0x01, 0xCC, 0x01, 0xC3, 0x00, 0x73, 0x80, 0x70,
  0xE0, 0x18, 0x60, 0x18, 0x18, 0x06, 0x18, 0x06, 0x06, 0x01, 0x86, 0x03,
  0x81, 0x80, 0xE1, 0xC0, 0xE0, 0x70, 0x38, 0x70, 0x30, 0x1C, 0x0C, 0x0C,
  0x0C, 0x03, 0x03, 0x03, 0x03, 0x00, 0xC1, 0xC0, 0xC1, 0xC0, 0x30, 0x70,
  0x38, 0x70, 0x0E, 0x18, 0x0E, 0x18, 0x01, 0x86, 0x01, 0x86, 0x00, 0x61,
  0x80, 0x61, 0x80, 0x18, 0xE0, 0x18, 0xE0, 0x07, 0x38, 0x07, 0x30, 0x01,
  0xCC, 0x01, 0xCC, 0x00, 0x33, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x0C, 0xC0,
  0x03, 0x70, 0x03, 0x70, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xF3, 0x00, 0x0E, 0x38,
  0x01, 0xC1, 0x80, 0x1C, 0x1C, 0x01, 0x81, 0xC0, 0x38, 0x0E, 0x03, 0x00,
  0xE0, 0x70, 0x06, 0x06, 0x00, 0x70, 0xE0, 0x03, 0x0C, 0x00, 0x39, 0xC0,
  0x01, 0x9C, 0x00, 0x1D, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0x98, 0x00, 0x39,
  0xC0, 0x03, 0x0C, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0x60, 0x0E,
  0x07, 0x00, 0xC0, 0x30, 0x1C, 0x03, 0x81, 0x80, 0x18, 0x38, 0x01, 0xC3,
  0x00, 0x1C, 0x70, 0x00, 0xE6, 0x00, 0x0E, 0xE0, 0x00, 0x70, 0x60, 0x00,
  0x36, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00,
  0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x1C, 0x1C,
  0x01, 0xC1, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x30, 0x06, 0x03, 0x00, 0x60, 0x70, 0x06, 0x07, 0x00, 0x70, 0x60,
  0x03, 0x06, 0x00, 0x30, 0xE0, 0x03, 0x0E, 0x00, 0x38, 0xC0, 0x01, 0x8C,
  0x00, 0x19, 0xC0, 0x01, 0x9C, 0x00, 0x1D, 0x80, 0x00, 0xD8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x9E, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x0F,
  0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xC0,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x30, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x7F, 0xC0, 0x05, 0xFF, 0xE0, 0x1F, 0x01, 0xE0,
  0x7C, 0x00, 0xFF, 0xD0, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 48, 14, 5, -48 },
  { 25, 13, 17, 21, 4, -48 },
  { 53, 27, 48, 29, 1, -48 },
  { 215, 23, 55, 27, 2, -51 },
  { 374, 34, 50, 40, 3, -49 },
  { 587, 25, 50, 27, 2, -49 },
  { 744, 3, 17, 11, 4, -48 },
  { 751, 12, 59, 18, 3, -48 },
  { 840, 12, 59, 18, 3, -48 },
  { 929, 18, 18, 24, 3, -51 },
  { 970, 23, 31, 27, 2, -39 },
  { 1060, 6, 16, 12, 3, -7 },
  { 1072, 14, 3, 18, 2, -20 },
  { 1078, 4, 5, 13, 4, -5 },
  { 1081, 19, 48, 23, 2, -48 },
  { 1195, 21, 49, 27, 3, -49 },
  { 1324, 12, 48, 27, 5, -48 },
  { 1396, 21, 49, 27, 3, -49 },
  { 1525, 22, 50, 27, 2, -49 },
  { 1663, 25, 48, 27, 1, -48 },
  { 1813, 21, 49, 27, 3, -48 },
  { 1942, 21, 49, 27, 3, -48 },
  { 2071, 21, 48, 27, 3, -48 },
  { 2197, 22, 49, 27, 2, -48 },
  { 2332, 20, 50, 27, 3, -49 },
  { 2457, 5, 36, 13, 4, -36 },
  { 2480, 6, 45, 13, 3, -36 },
  { 2514, 23, 28, 27, 2, -38 },
  { 2595, 23, 17, 27, 2, -32 },
  { 2644, 23, 28, 27, 2, -38 },
  { 2725, 16, 49, 18, 1, -49 },
  { 2823, 34, 54, 41, 4, -48 },
  { 3053, 26, 48, 26, 0, -48 },
  { 3209, 22, 48, 29, 5, -48 },
  { 3341, 23, 50, 28, 4, -49 },
  { 3485, 24, 48, 32, 5, -48 },
  { 3629, 18, 48, 26, 5, -48 },
  { 3737, 18, 48, 24, 5, -48 },
  { 3845, 27, 50, 35, 4, -49 },
  { 4014, 23, 48, 33, 5, -48 },
  { 4152, 11, 48, 16, 2, -48 },
  { 4218, 11, 60, 13, -3, -48 },
  { 4301, 21, 48, 26, 5, -48 },
  { 4427, 17, 48, 23, 5, -48 },
  { 4529, 35, 48, 45, 5, -48 },
  { 4739, 25, 48, 35, 5, -48 },
  { 4889, 27, 50, 35, 4, -49 },
  { 5058, 20, 48, 27, 5, -48 },
  { 5178, 27, 60, 35, 4, -49 },
  { 5381, 22, 48, 28, 5, -48 },
  { 5513, 21, 50, 26, 3, -49 },
  { 5645, 22, 48, 23, 1, -48 },
  { 5777, 23, 49, 33, 5, -48 },
  { 5918, 26, 48, 26, 0, -48 },
  { 6074, 44, 48, 44, 0, -48 },
  { 6338, 22, 48, 23, 1, -48 },
  { 6470, 22, 48, 22, 0, -48 },
  { 6602, 19, 48, 22, 2, -48 },
  { 6716, 13, 59, 21, 5, -48 },
  { 6812, 19, 48, 23, 2, -48 },
  { 6926, 13, 59, 21, 2, -48 },
  { 7022, 25, 24, 27, 1, -48 },
  { 7097, 27, 2, 27, 0, 6 },
  { 7104, 10, 10, 16, 3, -51 },
  { 7117, 19, 37, 25, 2, -36 },
  { 7205, 21, 52, 29, 5, -51 },
  { 7342, 17, 37, 21, 3, -36 },
  { 7421, 21, 52, 29, 3, -51 },
  { 7558, 20, 37, 26, 3, -36 },
  { 7651, 15, 51, 15, 1, -51 },
  { 7747, 21, 52, 29, 3, -36 },
  { 7884, 18, 51, 28, 5, -51 },
  { 7999, 4, 49, 12, 4, -49 },
  { 8024, 8, 65, 12, 0, -49 },
  { 8089, 17, 51, 23, 5, -51 },
  { 8198, 2, 51, 12, 5, -51 },
  { 8211, 32, 36, 42, 5, -36 },
  { 8355, 18, 36, 28, 5, -36 },
  { 8436, 22, 37, 28, 3, -36 },
  { 8538, 21, 52, 29, 5, -36 },
  { 8675, 21, 52, 29, 3, -36 },
  { 8812, 13, 36, 18, 5, -36 },
  { 8871, 17, 37, 21, 2, -36 },
  { 8950, 13, 45, 15, 1, -44 },
  { 9024, 18, 36, 28, 5, -35 },
  { 9105, 20, 35, 21, 0, -35 },
  { 9193, 34, 35, 36, 1, -35 },
  { 9342, 20, 35, 22, 1, -35 },
  { 9430, 20, 51, 22, 1, -35 },
  { 9558, 14, 35, 18, 2, -35 },
  { 9620, 17, 59, 23, 3, -48 },
  { 9746, 2, 67, 26, 12, -51 },
  { 9763, 17, 59, 23, 3, -48 },
  { 9889, 23, 6, 27, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight67pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT67PT7B_H_
