#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT50PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight50pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x60, 0x00, 0x00, 0x67, 0xF6, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x68, 0x34, 0x18, 0x01, 0x81,
  0x00, 0x18, 0x10, 0x01, 0x01, 0x00, 0x10, 0x30, 0x01, 0x03, 0x00, 0x30,
  0x30, 0x03, 0x03, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x20, 0x03,
  0x02, 0x07, 0xFF, 0xFF, 0x02, 0x06, 0x00, 0x20, 0x60, 0x06, 0x06, 0x00,
  0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x04, 0x00, 0x40, 0x40,
  0x04, 0x04, 0x00, 0x40, 0xC0, 0x0C, 0x0C, 0x0F, 0xFF, 0xFC, 0x0C, 0x0C,
  0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0x80, 0x08, 0x08, 0x00, 0x80,
  0x80, 0x08, 0x18, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x18,
  0x18, 0x01, 0x81, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x07, 0xF0,
  0x1F, 0xFE, 0x39, 0x0E, 0x61, 0x00, 0xC1, 0x00, 0xC1, 0x00, 0xC1, 0x00,
  0x81, 0x00, 0x81, 0x00, 0xC1, 0x00, 0xC1, 0x00, 0xC1, 0x00, 0x61, 0x00,
  0x71, 0x00, 0x39, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x01, 0x78,
  0x01, 0x1C, 0x01, 0x0E, 0x01, 0x07, 0x01, 0x03, 0x01, 0x03, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x01, 0x03, 0x01, 0x06, 0x81, 0x0E,
  0xF1, 0x3C, 0x7F, 0xF0, 0x07, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x1E, 0x00, 0x30, 0x19, 0x80, 0x30, 0x08, 0x60, 0x18, 0x0C,
  0x10, 0x08, 0x06, 0x0C, 0x0C, 0x02, 0x06, 0x06, 0x03, 0x03, 0x02, 0x01,
  0x81, 0x83, 0x00, 0xC0, 0x41, 0x80, 0x60, 0x20, 0x80, 0x30, 0x10, 0xC0,
  0x18, 0x08, 0x60, 0x0C, 0x04, 0x20, 0x06, 0x06, 0x30, 0x03, 0x03, 0x18,
  0x71, 0x81, 0x88, 0xFC, 0x40, 0xCC, 0x43, 0x30, 0x66, 0x60, 0x98, 0x23,
  0x30, 0x64, 0x33, 0x10, 0x33, 0xB1, 0x88, 0x18, 0xF0, 0xCC, 0x0C, 0x00,
  0xC6, 0x02, 0x00, 0x63, 0x01, 0x00, 0x31, 0x80, 0x80, 0x30, 0xC0, 0x40,
  0x18, 0x60, 0x20, 0x0C, 0x30, 0x10, 0x0C, 0x18, 0x08, 0x06, 0x04, 0x0C,
  0x03, 0x02, 0x06, 0x03, 0x01, 0x83, 0x01, 0x80, 0xC1, 0x00, 0xC0, 0x21,
  0x80, 0xC0, 0x19, 0xC0, 0x60, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xF8, 0x01,
  0x86, 0x00, 0x60, 0x80, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0,
  0xC0, 0x30, 0x30, 0x04, 0x0C, 0x01, 0x03, 0x00, 0x60, 0x80, 0x18, 0x60,
  0x03, 0x10, 0x00, 0xCC, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01,
  0xB0, 0x00, 0xC6, 0x00, 0x61, 0x81, 0x98, 0x30, 0x6C, 0x04, 0x1B, 0x01,
  0x86, 0xC0, 0x31, 0xB0, 0x0C, 0x48, 0x01, 0xB2, 0x00, 0x6C, 0x80, 0x0F,
  0x30, 0x01, 0x8C, 0x00, 0xE3, 0x00, 0x3C, 0x60, 0x1B, 0x18, 0x0C, 0x63,
  0x8E, 0x18, 0x7F, 0x03, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xF5, 0x40, 0x03,
  0x81, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x18, 0x0C,
  0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x02,
  0x01, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60,
  0x30, 0x1C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0,
  0x70, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x03,
  0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C,
  0x06, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18,
  0x18, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x08, 0x30, 0xF9,
  0x1C, 0x7F, 0x80, 0x60, 0x07, 0x80, 0x64, 0x06, 0x30, 0x20, 0xC3, 0x03,
  0x10, 0x10, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x03, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x39, 0x8C, 0x63, 0x31, 0x8C, 0x66,
  0x31, 0x00, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xF0, 0x1C, 0x18, 0x18, 0x18, 0x30,
  0x0C, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x02, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x60, 0x02, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x18, 0x0C, 0x1C, 0x18, 0x0F,
  0x70, 0x07, 0xE0, 0x01, 0x81, 0xC3, 0xE3, 0xB3, 0x9B, 0x8F, 0x87, 0x83,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0F, 0xE0, 0x3F, 0xF0,
  0x60, 0x38, 0x40, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0, 0x7F, 0xF0,
  0xE0, 0x38, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x01, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x80, 0x1C, 0xF0, 0x78, 0x7F, 0xE0, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x58,
  0x00, 0x1B, 0x00, 0x02, 0x60, 0x00, 0xCC, 0x00, 0x11, 0x80, 0x06, 0x30,
  0x00, 0x86, 0x00, 0x30, 0xC0, 0x04, 0x18, 0x01, 0x83, 0x00, 0x20, 0x60,
  0x0C, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83,
  0xFF, 0xFF, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x3F, 0xFC, 0x3F, 0xFC, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0xF0, 0x78, 0x78, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x80, 0x38, 0xF0, 0xF0, 0x7F, 0xE0,
  0x00, 0xFC, 0x03, 0xFC, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x43, 0xE0, 0x47, 0xF8, 0xCC, 0x1C, 0xD0, 0x0C,
  0xF0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x40, 0x03, 0x40, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x02,
  0x60, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x18, 0x0C, 0x1C, 0x38, 0x07, 0xF0,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x38, 0x1C, 0x30, 0x0E, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x03, 0x60, 0x02, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x06, 0x30, 0x0C, 0x38, 0x1C, 0x1C, 0x38, 0x0E, 0x70, 0x03, 0xC0,
  0x03, 0xC0, 0x0E, 0x60, 0x1C, 0x38, 0x38, 0x1C, 0x70, 0x0C, 0x60, 0x06,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x1C, 0x38,
  0x0F, 0xF0, 0x01, 0x80, 0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0xE1, 0x80, 0xC6,
  0x00, 0xCC, 0x01, 0xB0, 0x01, 0x60, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x60, 0x06,
  0xC0, 0x1D, 0x80, 0x29, 0x80, 0xF1, 0xC7, 0x61, 0xFC, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE1, 0x87, 0x83, 0xFC, 0x00,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x33, 0x9E, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE6, 0x31, 0x8C, 0xC6, 0x31, 0x18, 0xC4, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x0F, 0xFC, 0x80, 0xC0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0xC0, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x03, 0xC0, 0xCC, 0x07, 0xF0,
  0x24, 0x06, 0x18, 0x1E, 0x06, 0x0C, 0x0F, 0x03, 0x06, 0x07, 0x81, 0x03,
  0x03, 0xC1, 0x81, 0x81, 0xE0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x70, 0x30,
  0x30, 0x38, 0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x07, 0x03,
  0x03, 0x03, 0x81, 0x81, 0x81, 0xE0, 0xC1, 0x40, 0xB0, 0x60, 0xA0, 0xD8,
  0x18, 0xD0, 0x6C, 0x0E, 0xCE, 0x66, 0x03, 0xE3, 0xE1, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x02, 0x00, 0x1E, 0x07,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x0B, 0x00, 0x00, 0xB0, 0x00, 0x19, 0x00, 0x01,
  0x98, 0x00, 0x19, 0x80, 0x01, 0x18, 0x00, 0x31, 0x80, 0x03, 0x08, 0x00,
  0x30, 0xC0, 0x02, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x04, 0x00, 0x60, 0x60,
  0x06, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80,
  0x18, 0x30, 0x01, 0x83, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x60,
  0x00, 0xC6, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0xC0, 0x38, 0xC0, 0x0C, 0xC0, 0x0E,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x38, 0xFF, 0xF0,
  0xFF, 0xE0, 0xC0, 0x38, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x1C, 0xFF, 0xF8,
  0xFF, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0xC3, 0x80, 0x41, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x41, 0xF1, 0xE0, 0x3F, 0xE0, 0x01, 0x00, 0xFE, 0x00, 0x7F,
  0xF0, 0x30, 0x1E, 0x18, 0x03, 0x8C, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x1D,
  0x80, 0x06, 0xC0, 0x03, 0x60, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x36, 0x00,
  0x3B, 0x00, 0x19, 0x80, 0x1C, 0xC0, 0x1C, 0x60, 0x3C, 0x3F, 0xFC, 0x1F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xFF, 0xF7, 0xFF, 0xB0, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xFD, 0xFF, 0xEC, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0x00, 0x70, 0xE0, 0x01, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x60, 0x00, 0x16, 0x00, 0x01, 0x60, 0x00,
  0x13, 0x00, 0x01, 0x30, 0x00, 0x11, 0x80, 0x01, 0x0C, 0x00, 0x10, 0xE0,
  0x01, 0x03, 0xC1, 0xF0, 0x1F, 0xFE, 0x00, 0x08, 0x00, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x30, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x38, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0xFC, 0xF8, 0xC0,
  0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0xC0,
  0x70, 0xC0, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC1, 0x80, 0xC3, 0x80, 0xC3,
  0x00, 0xC6, 0x00, 0xC6, 0x00, 0xCC, 0x00, 0xDC, 0x00, 0xDE, 0x00, 0xF6,
  0x00, 0xE3, 0x00, 0xE3, 0x00, 0xC1, 0x80, 0xC1, 0x80, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x38, 0xC0,
  0x18, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x07, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x06, 0xFC, 0x00, 0x01,
  0xBD, 0x00, 0x00, 0x6F, 0x60, 0x00, 0x33, 0xD8, 0x00, 0x0C, 0xF2, 0x00,
  0x03, 0x3C, 0xC0, 0x00, 0x8F, 0x30, 0x00, 0x63, 0xCC, 0x00, 0x18, 0xF1,
  0x80, 0x06, 0x3C, 0x60, 0x03, 0x0F, 0x18, 0x00, 0xC3, 0xC2, 0x00, 0x30,
  0xF0, 0xC0, 0x18, 0x3C, 0x30, 0x06, 0x0F, 0x04, 0x01, 0x83, 0xC1, 0x80,
  0x40, 0xF0, 0x60, 0x30, 0x3C, 0x18, 0x0C, 0x0F, 0x03, 0x03, 0x03, 0xC0,
  0xC1, 0x80, 0xF0, 0x30, 0x60, 0x3C, 0x04, 0x18, 0x0F, 0x01, 0x8C, 0x03,
  0xC0, 0x63, 0x00, 0xF0, 0x08, 0xC0, 0x3C, 0x03, 0x20, 0x0F, 0x00, 0xD8,
  0x03, 0xC0, 0x36, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0F, 0x00,
  0x70, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xF4, 0x00, 0x3D, 0x80, 0x0F, 0x60, 0x03, 0xCC, 0x00, 0xF3, 0x00,
  0x3C, 0x60, 0x0F, 0x18, 0x03, 0xC2, 0x00, 0xF0, 0xC0, 0x3C, 0x30, 0x0F,
  0x06, 0x03, 0xC1, 0x80, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x01, 0x83, 0xC0,
  0x60, 0xF0, 0x18, 0x3C, 0x03, 0x0F, 0x00, 0xC3, 0xC0, 0x18, 0xF0, 0x06,
  0x3C, 0x00, 0xCF, 0x00, 0x33, 0xC0, 0x04, 0xF0, 0x01, 0xBC, 0x00, 0x6F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0x03,
  0xFC, 0x00, 0x7F, 0xE0, 0x0E, 0x07, 0x01, 0x80, 0x18, 0x30, 0x00, 0xC3,
  0x00, 0x0C, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x02,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x06, 0x60, 0x00, 0x66,
  0x00, 0x06, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x01, 0x81, 0xC0, 0x38,
  0x0F, 0x1F, 0x00, 0x3F, 0xC0, 0x00, 0x60, 0x00, 0xFF, 0x01, 0xFF, 0xC3,
  0x03, 0xC6, 0x01, 0xCC, 0x01, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x58, 0x01, 0xB0, 0x03,
  0x60, 0x06, 0xC0, 0x19, 0x80, 0x73, 0x01, 0xC7, 0xFF, 0x0F, 0xF8, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x0E, 0x03, 0x01,
  0x80, 0x18, 0x38, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x36,
  0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0xC3, 0x00, 0x0C,
  0x18, 0x01, 0x81, 0xC0, 0x38, 0x0F, 0x1F, 0x00, 0x3F, 0xC0, 0x00, 0x5C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0xFF, 0x00, 0xFF,
  0xE0, 0xC0, 0xF0, 0xC0, 0x38, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x04, 0xC0,
  0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x70, 0xFF, 0xE0, 0xFF,
  0x80, 0xC1, 0x80, 0xC1, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0xC0,
  0x60, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x18, 0xC0,
  0x0C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x07, 0x07, 0xF8, 0x1F,
  0xFE, 0x38, 0x06, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x80, 0x1C, 0xF8, 0xF8, 0x7F, 0xE0, 0x02, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0C, 0xC0, 0x06,
  0x60, 0x07, 0x18, 0x07, 0x07, 0x8F, 0x01, 0xFF, 0x00, 0x08, 0x00, 0xC0,
  0x00, 0x78, 0x00, 0x0D, 0x00, 0x01, 0xB0, 0x00, 0x66, 0x00, 0x0C, 0xC0,
  0x01, 0x98, 0x00, 0x31, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0,
  0x06, 0x08, 0x00, 0x81, 0x80, 0x30, 0x30, 0x06, 0x06, 0x00, 0xC0, 0x40,
  0x10, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0x60,
  0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x02, 0x18, 0x00, 0x63,
  0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x11, 0x00, 0x03, 0x60, 0x00, 0x6C,
  0x00, 0x0D, 0x80, 0x01, 0xA0, 0x00, 0x14, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0xA0, 0x00, 0xE0, 0x00, 0xD8, 0x00, 0x70,
  0x00, 0xCC, 0x00, 0x38, 0x00, 0x66, 0x00, 0x14, 0x00, 0x33, 0x00, 0x0A,
  0x00, 0x18, 0xC0, 0x0D, 0x80, 0x0C, 0x60, 0x06, 0xC0, 0x0C, 0x30, 0x03,
  0x60, 0x06, 0x18, 0x01, 0xB0, 0x03, 0x0C, 0x00, 0x88, 0x01, 0x83, 0x00,
  0xC6, 0x01, 0x81, 0x80, 0x63, 0x00, 0xC0, 0xC0, 0x31, 0x80, 0x60, 0x60,
  0x18, 0xC0, 0x30, 0x30, 0x08, 0x20, 0x18, 0x0C, 0x0C, 0x18, 0x18, 0x06,
  0x06, 0x0C, 0x0C, 0x03, 0x03, 0x06, 0x06, 0x01, 0x81, 0x83, 0x03, 0x00,
  0x40, 0x80, 0x81, 0x00, 0x30, 0xC0, 0x61, 0x80, 0x18, 0x60, 0x30, 0xC0,
  0x0C, 0x30, 0x18, 0x60, 0x06, 0x18, 0x0C, 0x30, 0x01, 0x08, 0x02, 0x30,
  0x00, 0xCC, 0x01, 0x98, 0x00, 0x66, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x66,
  0x00, 0x19, 0x80, 0x33, 0x00, 0x06, 0x80, 0x0B, 0x00, 0x03, 0xC0, 0x05,
  0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x01, 0x98, 0x01, 0x8C, 0x00,
  0xC3, 0x00, 0xC1, 0x80, 0x60, 0x40, 0x30, 0x30, 0x30, 0x18, 0x18, 0x06,
  0x0C, 0x03, 0x0C, 0x01, 0x86, 0x00, 0x62, 0x00, 0x33, 0x00, 0x09, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x0C, 0x60, 0x06, 0x18, 0x03,
  0x0C, 0x03, 0x06, 0x01, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x20, 0x60, 0x18,
  0x60, 0x0C, 0x30, 0x03, 0x30, 0x01, 0x98, 0x00, 0xDC, 0x00, 0x30, 0xC0,
  0x03, 0xE0, 0x01, 0x98, 0x00, 0xCC, 0x00, 0xC6, 0x00, 0x61, 0x80, 0x30,
  0xC0, 0x10, 0x60, 0x18, 0x18, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x01, 0x83,
  0x00, 0xC1, 0x00, 0x61, 0x80, 0x18, 0xC0, 0x0C, 0x40, 0x06, 0x60, 0x01,
  0xB0, 0x00, 0xD0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x06, 0xC0, 0x01, 0x30, 0x00, 0xC6, 0x00, 0x21, 0x80, 0x18, 0x30, 0x06,
  0x0C, 0x03, 0x03, 0x00, 0xC0, 0x60, 0x60, 0x18, 0x18, 0x03, 0x0C, 0x00,
  0xC3, 0x00, 0x19, 0x80, 0x06, 0xE0, 0x00, 0xF0, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x0F,
  0xC1, 0xFF, 0x0C, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x3F, 0x8F, 0x84, 0xE0, 0x2C,
  0x01, 0x60, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x05, 0x60, 0x6B, 0x86, 0x4F, 0xE2, 0x08, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC3, 0xE0, 0xC7, 0xF8, 0xCC,
  0x1C, 0xD8, 0x0E, 0xD0, 0x06, 0xE0, 0x06, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x06, 0xF0, 0x06, 0xD0, 0x0E, 0xD8, 0x0C, 0xCE, 0x38, 0xC7,
  0xF0, 0x00, 0x80, 0x03, 0xF0, 0x3F, 0xC7, 0x02, 0x30, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xF0, 0xC1, 0xFE, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x03,
  0xC3, 0x0F, 0xF3, 0x1C, 0x1B, 0x38, 0x0F, 0x30, 0x07, 0x60, 0x07, 0x60,
  0x03, 0x60, 0x03, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x07, 0x60, 0x07, 0x30, 0x0F, 0x38,
  0x09, 0x1C, 0x31, 0x0F, 0xE1, 0x01, 0x00, 0x03, 0xC0, 0x1F, 0xE0, 0x60,
  0xE1, 0x80, 0xC3, 0x00, 0xCC, 0x01, 0x98, 0x01, 0xB0, 0x03, 0x60, 0x06,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x04, 0x1C, 0x38, 0x1F, 0xE0, 0x04, 0x00,
  0x03, 0xF0, 0x7B, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xFF, 0xC0, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x03, 0xE0, 0x0F,
  0xF1, 0x1C, 0x1B, 0x38, 0x0F, 0x30, 0x07, 0x60, 0x07, 0x60, 0x03, 0x60,
  0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x60,
  0x03, 0x60, 0x03, 0x60, 0x07, 0x60, 0x07, 0x30, 0x0F, 0x38, 0x1B, 0x1C,
  0x33, 0x0F, 0xE3, 0x01, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x60, 0x1C, 0x7F,
  0xF8, 0x1F, 0xE0, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x1F, 0x0C, 0x7F, 0x19, 0x83, 0x36, 0x07, 0x68, 0x06, 0xE0, 0x0D, 0xC0,
  0x1B, 0x80, 0x17, 0x00, 0x2C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xC0, 0xFF, 0xA0, 0x00, 0x01, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6D, 0xB0, 0x1C, 0x71, 0xC2, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x86, 0x18, 0x6F, 0x3C, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x02, 0xC0, 0x33, 0x00, 0xCC, 0x06, 0x30, 0x18, 0xC0, 0xC3, 0x06,
  0x0C, 0x18, 0x30, 0xC0, 0xC3, 0x03, 0x18, 0x0C, 0xE0, 0x33, 0xC0, 0xDB,
  0x03, 0x46, 0x0E, 0x18, 0x38, 0x60, 0xC0, 0xC3, 0x03, 0x0C, 0x06, 0x30,
  0x18, 0xC0, 0x63, 0x00, 0xCC, 0x03, 0x30, 0x06, 0xC0, 0x1B, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0,
  0x78, 0x67, 0xF8, 0xFF, 0x32, 0x0C, 0x41, 0xDA, 0x03, 0x40, 0x6D, 0x01,
  0xE0, 0x37, 0x00, 0xE0, 0x0F, 0x80, 0x30, 0x07, 0xC0, 0x18, 0x03, 0xC0,
  0x0C, 0x01, 0xE0, 0x06, 0x00, 0xF0, 0x03, 0x00, 0x78, 0x01, 0x80, 0x3C,
  0x00, 0xC0, 0x1E, 0x00, 0x60, 0x0F, 0x00, 0x30, 0x07, 0x80, 0x18, 0x03,
  0xC0, 0x0C, 0x01, 0xE0, 0x06, 0x00, 0xF0, 0x03, 0x00, 0x78, 0x01, 0x80,
  0x3C, 0x00, 0xC0, 0x1E, 0x00, 0x60, 0x0F, 0x00, 0x30, 0x07, 0x80, 0x18,
  0x03, 0xC0, 0x0C, 0x01, 0xE0, 0x06, 0x00, 0xF0, 0x03, 0x00, 0x60, 0x03,
  0xE1, 0x8F, 0xF3, 0x30, 0x66, 0xC0, 0x6D, 0x00, 0xDC, 0x01, 0xB8, 0x01,
  0x70, 0x02, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x18, 0x03, 0xE0, 0x0F, 0xF8, 0x18, 0x1C, 0x30, 0x0C, 0x30, 0x06,
  0x60, 0x06, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x06, 0x30, 0x06,
  0x30, 0x06, 0x18, 0x0C, 0x1E, 0x38, 0x07, 0xF0, 0x00, 0x80, 0x03, 0xE0,
  0xC7, 0xF8, 0xCC, 0x1C, 0xD8, 0x0C, 0xD0, 0x06, 0xF0, 0x06, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x06, 0xD0, 0x06, 0xD0, 0x0E, 0xC8, 0x0C,
  0xCE, 0x38, 0xC7, 0xF0, 0xC0, 0x80, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0xF1, 0x1C, 0x1B, 0x38, 0x0F,
  0x30, 0x07, 0x70, 0x07, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x07,
  0x70, 0x07, 0x30, 0x0F, 0x38, 0x1B, 0x1E, 0x33, 0x0F, 0xE3, 0x01, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x03, 0xF1,
  0xFC, 0xC3, 0x60, 0xD0, 0x34, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x0F, 0xC3, 0xFF, 0x70,
  0x36, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x6F, 0x1E, 0x7F,
  0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC1, 0xFF, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0,
  0x60, 0x39, 0x0F, 0x81, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x40, 0x0D, 0x80, 0x56, 0x01, 0x5C, 0x0D, 0x3C,
  0xE4, 0x7F, 0x10, 0x20, 0x00, 0xC0, 0x06, 0xC0, 0x0D, 0x80, 0x13, 0x00,
  0x66, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x30, 0x18, 0x20, 0x30,
  0x60, 0x60, 0xC1, 0x81, 0x83, 0x01, 0x06, 0x03, 0x0C, 0x06, 0x10, 0x0C,
  0x60, 0x08, 0xC0, 0x19, 0x80, 0x32, 0x00, 0x6C, 0x00, 0x58, 0x00, 0xB0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xD8, 0x03, 0x80,
  0x36, 0x00, 0xE0, 0x09, 0x80, 0x28, 0x06, 0x20, 0x1B, 0x01, 0x8C, 0x06,
  0xC0, 0x63, 0x01, 0xB0, 0x18, 0xC0, 0x4C, 0x04, 0x30, 0x31, 0x03, 0x06,
  0x0C, 0x60, 0xC1, 0x83, 0x18, 0x30, 0x60, 0xC6, 0x08, 0x18, 0x21, 0x86,
  0x02, 0x18, 0x21, 0x80, 0xC6, 0x0C, 0x60, 0x31, 0x83, 0x18, 0x0C, 0x60,
  0xC4, 0x03, 0x30, 0x33, 0x00, 0x4C, 0x04, 0xC0, 0x1B, 0x01, 0xB0, 0x06,
  0xC0, 0x68, 0x01, 0xA0, 0x1A, 0x00, 0x28, 0x03, 0x80, 0x0E, 0x00, 0xE0,
  0x03, 0x80, 0x38, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x0C, 0xC0, 0x30, 0xC0,
  0x61, 0x81, 0x81, 0x83, 0x03, 0x06, 0x06, 0x18, 0x06, 0x30, 0x0C, 0xC0,
  0x0D, 0x80, 0x1E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0x60, 0x0C, 0xC0, 0x18, 0xC0, 0x61, 0x80, 0xC1, 0x83, 0x03, 0x06, 0x06,
  0x18, 0x06, 0x30, 0x0C, 0xE0, 0x0D, 0x80, 0x1C, 0xC0, 0x07, 0x80, 0x09,
  0x80, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x0C, 0x06, 0x18, 0x0C, 0x30,
  0x18, 0x60, 0x20, 0x60, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x04, 0x03, 0x18,
  0x06, 0x30, 0x0C, 0x60, 0x18, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x6C, 0x00,
  0xD0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x7F, 0xE0, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0x40, 0x18, 0x03, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x07, 0xC0,
  0x70, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x7C, 0x03, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x7E, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x07, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x7C, 0x01, 0xE0, 0x38,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x3F, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x5F,
  0xE0, 0x1E, 0x0E, 0x1E, 0x00, 0xFE, 0x00, 0x04, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 36, 10, 3, -36 },
  { 19, 9, 13, 16, 3, -36 },
  { 34, 20, 36, 22, 1, -36 },
  { 124, 16, 41, 20, 2, -38 },
  { 206, 25, 36, 30, 2, -36 },
  { 319, 18, 37, 20, 2, -36 },
  { 403, 2, 13, 9, 3, -36 },
  { 407, 9, 44, 13, 3, -36 },
  { 457, 9, 44, 13, 2, -36 },
  { 507, 13, 14, 18, 2, -38 },
  { 530, 18, 23, 20, 1, -29 },
  { 582, 5, 12, 9, 2, -5 },
  { 590, 11, 2, 13, 1, -15 },
  { 593, 3, 4, 9, 3, -4 },
  { 595, 15, 36, 17, 1, -36 },
  { 663, 16, 36, 20, 2, -36 },
  { 735, 9, 36, 20, 4, -36 },
  { 776, 16, 36, 20, 2, -36 },
  { 848, 16, 37, 20, 2, -36 },
  { 922, 19, 36, 20, 1, -36 },
  { 1008, 16, 36, 20, 2, -36 },
  { 1080, 16, 37, 20, 2, -36 },
  { 1154, 16, 36, 20, 2, -36 },
  { 1226, 16, 37, 20, 2, -36 },
  { 1300, 15, 37, 20, 2, -36 },
  { 1370, 3, 27, 10, 3, -27 },
  { 1381, 5, 34, 9, 2, -27 },
  { 1403, 18, 21, 20, 1, -28 },
  { 1451, 18, 13, 20, 1, -24 },
  { 1481, 18, 21, 20, 1, -28 },
  { 1529, 12, 36, 14, 1, -36 },
  { 1583, 25, 41, 31, 3, -36 },
  { 1712, 20, 36, 20, 0, -36 },
  { 1802, 16, 36, 22, 4, -36 },
  { 1874, 17, 37, 21, 3, -36 },
  { 1953, 17, 36, 24, 4, -36 },
  { 2030, 13, 36, 19, 4, -36 },
  { 2089, 13, 36, 18, 4, -36 },
  { 2148, 20, 37, 26, 3, -36 },
  { 2241, 17, 36, 25, 4, -36 },
  { 2318, 8, 36, 12, 2, -36 },
  { 2354, 8, 45, 10, -2, -36 },
  { 2399, 16, 36, 20, 4, -36 },
  { 2471, 12, 36, 17, 4, -36 },
  { 2525, 26, 36, 33, 4, -36 },
  { 2642, 18, 36, 26, 4, -36 },
  { 2723, 20, 37, 26, 3, -36 },
  { 2816, 15, 36, 20, 4, -36 },
  { 2884, 20, 45, 26, 3, -36 },
  { 2997, 16, 36, 21, 4, -36 },
  { 3069, 16, 37, 20, 2, -36 },
  { 3143, 17, 36, 17, 0, -36 },
  { 3220, 17, 37, 25, 4, -36 },
  { 3299, 19, 36, 19, 0, -36 },
  { 3385, 33, 36, 33, 0, -36 },
  { 3534, 17, 36, 17, 0, -36 },
  { 3611, 17, 36, 17, 0, -36 },
  { 3688, 15, 36, 17, 1, -36 },
  { 3756, 10, 44, 15, 4, -36 },
  { 3811, 15, 36, 17, 1, -36 },
  { 3879, 9, 44, 15, 2, -36 },
  { 3929, 18, 18, 20, 1, -36 },
  { 3970, 20, 2, 20, 0, 4 },
  { 3975, 8, 8, 12, 2, -38 },
  { 3983, 13, 28, 19, 2, -27 },
  { 4029, 16, 39, 22, 3, -38 },
  { 4107, 13, 28, 16, 2, -27 },
  { 4153, 16, 39, 22, 2, -38 },
  { 4231, 15, 28, 19, 2, -27 },
  { 4284, 12, 38, 11, 0, -38 },
  { 4341, 16, 39, 22, 2, -27 },
  { 4419, 15, 38, 21, 3, -38 },
  { 4491, 3, 36, 9, 3, -36 },
  { 4505, 6, 48, 9, 0, -36 },
  { 4541, 14, 38, 17, 3, -38 },
  { 4608, 2, 38, 9, 3, -38 },
  { 4618, 25, 27, 31, 3, -27 },
  { 4703, 15, 27, 21, 3, -27 },
  { 4754, 16, 28, 21, 2, -27 },
  { 4810, 16, 39, 22, 3, -27 },
  { 4888, 16, 39, 22, 2, -27 },
  { 4966, 10, 27, 14, 3, -27 },
  { 5000, 12, 28, 16, 2, -27 },
  { 5042, 9, 34, 11, 1, -33 },
  { 5081, 14, 27, 21, 3, -26 },
  { 5129, 15, 26, 15, 0, -26 },
  { 5178, 26, 26, 27, 0, -26 },
  { 5263, 15, 26, 16, 1, -26 },
  { 5312, 15, 38, 16, 1, -26 },
  { 5384, 11, 26, 13, 1, -26 },
  { 5420, 13, 44, 17, 2, -36 },
  { 5492, 2, 50, 19, 9, -38 },
  { 5505, 13, 44, 17, 2, -36 },
  { 5577, 18, 5, 20, 1, -20 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight50pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT50PT7B_H_
