#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT60PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight60pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x2F, 0xFF, 0xF0, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x05, 0x80, 0xB0, 0x16, 0x02, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x03, 0x00, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80,
  0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0x06, 0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00,
  0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x03, 0x00,
  0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1E, 0x63, 0xC3,
  0x86, 0x04, 0x70, 0x60, 0x06, 0x06, 0x00, 0xE0, 0x60, 0x0C, 0x06, 0x00,
  0xC0, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60,
  0x0E, 0x06, 0x00, 0x60, 0x60, 0x07, 0x06, 0x00, 0x38, 0x60, 0x01, 0xE6,
  0x00, 0x0F, 0x60, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x6F, 0x00, 0x06, 0x38, 0x00, 0x61, 0xC0, 0x06, 0x0E, 0x00, 0x60, 0x60,
  0x06, 0x07, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03,
  0x00, 0x60, 0x30, 0x06, 0x07, 0x00, 0x60, 0x60, 0x06, 0x0E, 0x80, 0x61,
  0xCF, 0x06, 0x38, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x1F, 0x00, 0x06,
  0x00, 0xE6, 0x00, 0x30, 0x07, 0x0C, 0x00, 0xC0, 0x18, 0x30, 0x03, 0x00,
  0x60, 0x60, 0x18, 0x03, 0x01, 0x80, 0x60, 0x0C, 0x06, 0x01, 0x80, 0x30,
  0x18, 0x0C, 0x00, 0xC0, 0x30, 0x30, 0x03, 0x00, 0xC0, 0xC0, 0x0C, 0x03,
  0x06, 0x00, 0x30, 0x0C, 0x18, 0x00, 0xC0, 0x30, 0x60, 0x03, 0x00, 0xC3,
  0x00, 0x0C, 0x03, 0x0C, 0x00, 0x30, 0x0C, 0x30, 0x00, 0xC0, 0x31, 0x80,
  0x03, 0x01, 0xC6, 0x1F, 0x0C, 0x06, 0x18, 0xEE, 0x30, 0x18, 0xC3, 0x0C,
  0xC0, 0x63, 0x18, 0x31, 0x81, 0x8C, 0x60, 0x66, 0x0C, 0x63, 0x01, 0x9C,
  0x31, 0x8C, 0x06, 0x3F, 0x86, 0x30, 0x18, 0x7C, 0x30, 0xC0, 0x30, 0x00,
  0xC3, 0x00, 0xC0, 0x03, 0x0C, 0x03, 0x00, 0x18, 0x30, 0x0C, 0x00, 0x60,
  0xC0, 0x30, 0x01, 0x83, 0x00, 0xC0, 0x0C, 0x0C, 0x03, 0x00, 0x30, 0x30,
  0x0C, 0x00, 0xC0, 0xC0, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x06,
  0x00, 0x60, 0x30, 0x18, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x01, 0x81, 0x80,
  0x30, 0x06, 0x0E, 0x01, 0x80, 0x1C, 0x30, 0x06, 0x00, 0x39, 0x80, 0x18,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x60, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0xE1, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x38, 0x01, 0x80,
  0x60, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60,
  0x07, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x01,
  0x86, 0x00, 0x06, 0x38, 0x00, 0x0C, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3B, 0x00, 0x01, 0xCE, 0x00, 0x06, 0x18, 0x00,
  0x30, 0x70, 0x19, 0xC0, 0xC0, 0x66, 0x03, 0x81, 0x98, 0x06, 0x06, 0xE0,
  0x0C, 0x3B, 0x00, 0x30, 0xCC, 0x00, 0x63, 0x30, 0x01, 0xCC, 0xC0, 0x03,
  0x73, 0x00, 0x0F, 0x8C, 0x00, 0x1E, 0x30, 0x00, 0x30, 0xE0, 0x01, 0xE1,
  0x80, 0x07, 0x86, 0x00, 0x37, 0x1C, 0x01, 0xCC, 0x38, 0x0E, 0x38, 0x7F,
  0xF0, 0x60, 0xFF, 0x00, 0xC0, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x03,
  0x80, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0x70, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x70, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x10, 0x20, 0x78, 0x43,
  0xFE, 0x9F, 0x1F, 0xF0, 0x07, 0x00, 0x0B, 0x00, 0x32, 0x00, 0xC6, 0x03,
  0x06, 0x0E, 0x06, 0x38, 0x0E, 0x20, 0x08, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x71, 0x86,
  0x18, 0xE3, 0x8C, 0x31, 0xC6, 0x18, 0x63, 0x00, 0xFF, 0xFF, 0xFF, 0x4E,
  0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x00, 0xE0, 0xE0, 0x70, 0x18,
  0x38, 0x07, 0x0C, 0x00, 0xC3, 0x00, 0x39, 0xC0, 0x06, 0x60, 0x01, 0x98,
  0x00, 0x66, 0x00, 0x1B, 0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0x60, 0x01, 0xD8, 0x00, 0x66, 0x00, 0x19, 0xC0, 0x06,
  0x30, 0x03, 0x8C, 0x00, 0xC3, 0x80, 0x70, 0x70, 0x18, 0x0E, 0x0E, 0x03,
  0xFF, 0x00, 0x3F, 0x80, 0x00, 0x60, 0x1C, 0x07, 0x83, 0xB0, 0xE6, 0x38,
  0xCE, 0x1B, 0x83, 0xE0, 0x68, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x0F, 0xF8, 0x07, 0xFF, 0xC1, 0xE0, 0x3C, 0x10,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xF8, 0x07, 0xFF, 0xC1, 0xE0, 0x3C, 0x70, 0x01, 0xC4, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x7F,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0xE0, 0x07,
  0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x05, 0x80, 0x00, 0x36,
  0x00, 0x00, 0xD8, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0xC6, 0x00,
  0x03, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x03, 0x06, 0x00, 0x0C,
  0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x18,
  0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0x60, 0x18, 0x01, 0x80, 0xE0, 0x06, 0x03, 0x00, 0x18, 0x1C, 0x00,
  0x60, 0x60, 0x01, 0x83, 0x80, 0x06, 0x0C, 0x00, 0x18, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC7,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0xF8, 0x0F,
  0xFF, 0x83, 0xF9, 0xF8, 0x40, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x72, 0x00,
  0x1C, 0xC0, 0x1E, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x08, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x78, 0x08, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0xFF, 0x0C, 0x7F, 0xE3, 0x30, 0x1C, 0xD8, 0x03, 0x34, 0x00, 0x6E,
  0x00, 0x1B, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x01, 0xDC, 0x00, 0x63,
  0x00, 0x18, 0xE0, 0x0C, 0x1C, 0x07, 0x03, 0xC7, 0x80, 0x7F, 0xC0, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xF0, 0x1E, 0x07, 0x81, 0x80, 0x1C, 0x38, 0x00, 0xC3, 0x00, 0x0C, 0x70,
  0x00, 0xE7, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x70, 0x00, 0x67,
  0x00, 0x06, 0x30, 0x00, 0xE3, 0x00, 0x0C, 0x38, 0x01, 0xC1, 0xC0, 0x18,
  0x0E, 0x03, 0x00, 0x70, 0xE0, 0x03, 0x9C, 0x00, 0x1F, 0x80, 0x00, 0xF0,
  0x00, 0x3F, 0x80, 0x07, 0x1E, 0x00, 0xE0, 0x70, 0x1C, 0x03, 0x83, 0x80,
  0x1C, 0x30, 0x00, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0x6E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0x60, 0x00, 0x66, 0x00, 0x06, 0x70, 0x00, 0xE3, 0x80, 0x1C,
  0x1C, 0x03, 0x80, 0xF9, 0xF0, 0x07, 0xFE, 0x00, 0x06, 0x00, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x70, 0x1C, 0x0C, 0x01, 0x83, 0x80, 0x38, 0x60, 0x03,
  0x1C, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x1B, 0x80, 0x03,
  0x70, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xEC, 0x00, 0x1D, 0x80, 0x03, 0xB0, 0x00, 0x77, 0x00, 0x1E,
  0x60, 0x02, 0xCE, 0x00, 0xD8, 0xE0, 0x33, 0x0F, 0xBC, 0x60, 0xFF, 0x1C,
  0x03, 0x83, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x3C, 0x07,
  0xFF, 0x00, 0xFF, 0x80, 0x03, 0x80, 0x00, 0xEF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0xEF, 0xFE, 0x18,
  0xF3, 0xCF, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x1C, 0x61, 0x8E, 0x38,
  0xC3, 0x1C, 0x61, 0x86, 0x30, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x18, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xC3, 0xFF,
  0xCC, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC3,
  0x00, 0x1F, 0x00, 0xC6, 0x00, 0xFF, 0x01, 0x9C, 0x03, 0x86, 0x03, 0x30,
  0x0E, 0x0C, 0x06, 0x60, 0x18, 0x18, 0x0C, 0xC0, 0x60, 0x30, 0x1D, 0x80,
  0xC0, 0x60, 0x1F, 0x03, 0x80, 0xC0, 0x3E, 0x06, 0x01, 0x80, 0x78, 0x0C,
  0x03, 0x00, 0xF0, 0x18, 0x06, 0x01, 0xE0, 0x30, 0x0C, 0x03, 0xC0, 0x60,
  0x18, 0x07, 0x80, 0xC0, 0x30, 0x0F, 0x01, 0x80, 0xE0, 0x1E, 0x03, 0x01,
  0xC0, 0x7C, 0x06, 0x03, 0x80, 0xD8, 0x0C, 0x07, 0x01, 0xB8, 0x18, 0x0E,
  0x03, 0x70, 0x38, 0x34, 0x0E, 0x60, 0x30, 0x68, 0x18, 0xC0, 0x71, 0x98,
  0x71, 0x80, 0x7F, 0x1F, 0xC3, 0x00, 0x7C, 0x3F, 0x07, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x66, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x83, 0x00, 0x01, 0x83,
  0x00, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x03, 0x81, 0x80, 0x03, 0x01,
  0x80, 0x03, 0x01, 0xC0, 0x03, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x06, 0x00,
  0xC0, 0x06, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x60, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x0C, 0x00, 0x70, 0x1C, 0x00, 0x30, 0x1C, 0x00,
  0x30, 0x18, 0x00, 0x38, 0x18, 0x00, 0x38, 0x18, 0x00, 0x18, 0x38, 0x00,
  0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x70, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x06, 0xE0, 0x00,
  0x06, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0x00, 0xFC, 0x60,
  0x03, 0x8C, 0x00, 0x39, 0x80, 0x03, 0x30, 0x00, 0x76, 0x00, 0x06, 0xC0,
  0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80,
  0x03, 0xB0, 0x00, 0x76, 0x00, 0x0C, 0xC0, 0x03, 0x98, 0x00, 0xE3, 0x00,
  0x38, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x30, 0x01, 0xC6, 0x00,
  0x1C, 0xC0, 0x01, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0D, 0x80, 0x03, 0xB0, 0x00,
  0xE6, 0x00, 0x3C, 0xC0, 0x1F, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0xF0, 0x0C, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x18, 0x07,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x0C, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x30, 0x1F, 0x81, 0x80, 0x1E, 0x0C, 0x00, 0x78, 0x60, 0x01, 0xC3, 0x00,
  0x07, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xE6, 0x00, 0x03, 0x30, 0x00, 0x19,
  0x80, 0x00, 0xEC, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00,
  0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60,
  0x00, 0x1B, 0x00, 0x01, 0xD8, 0x00, 0x0E, 0xC0, 0x00, 0x66, 0x00, 0x03,
  0x30, 0x00, 0x39, 0x80, 0x01, 0x8C, 0x00, 0x1C, 0x60, 0x01, 0xC3, 0x00,
  0x0E, 0x18, 0x01, 0xE0, 0xC0, 0x3E, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x78, 0x01, 0xE0, 0x70, 0x00, 0x20, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x03, 0x30, 0x00,
  0x01, 0x98, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x18, 0x70, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x0F, 0x00, 0x03, 0x03,
  0xE0, 0x03, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x30,
  0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x3B, 0xFE, 0xFF,
  0x0F, 0x00, 0xC0, 0x01, 0xD8, 0x00, 0x33, 0x00, 0x0E, 0x60, 0x01, 0x8C,
  0x00, 0x71, 0x80, 0x1C, 0x30, 0x03, 0x06, 0x00, 0xE0, 0xC0, 0x18, 0x18,
  0x07, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x0C, 0x0E, 0x01, 0x81, 0x80, 0x30,
  0x70, 0x06, 0x1C, 0x00, 0xC3, 0x00, 0x18, 0xE0, 0x03, 0x18, 0x00, 0x67,
  0x00, 0x0D, 0xF0, 0x01, 0xB6, 0x00, 0x3C, 0xE0, 0x07, 0x8C, 0x00, 0xE1,
  0xC0, 0x18, 0x18, 0x03, 0x03, 0x80, 0x60, 0x30, 0x0C, 0x07, 0x01, 0x80,
  0x60, 0x30, 0x0E, 0x06, 0x00, 0xC0, 0xC0, 0x1C, 0x18, 0x01, 0x83, 0x00,
  0x38, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0E, 0x30, 0x00, 0xC6, 0x00,
  0x1C, 0xC0, 0x01, 0x98, 0x00, 0x3B, 0x00, 0x03, 0x80, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFD, 0x80, 0x00, 0x06, 0xF6, 0x00, 0x00, 0x1B,
  0xD8, 0x00, 0x00, 0xEF, 0x30, 0x00, 0x03, 0x3C, 0xC0, 0x00, 0x0C, 0xF3,
  0x00, 0x00, 0x33, 0xCE, 0x00, 0x01, 0x8F, 0x18, 0x00, 0x06, 0x3C, 0x60,
  0x00, 0x18, 0xF1, 0xC0, 0x00, 0xE3, 0xC3, 0x00, 0x03, 0x0F, 0x0C, 0x00,
  0x0C, 0x3C, 0x30, 0x00, 0x70, 0xF0, 0x60, 0x01, 0x83, 0xC1, 0x80, 0x06,
  0x0F, 0x06, 0x00, 0x18, 0x3C, 0x1C, 0x00, 0xC0, 0xF0, 0x30, 0x03, 0x03,
  0xC0, 0xC0, 0x0C, 0x0F, 0x03, 0x80, 0x70, 0x3C, 0x06, 0x01, 0x80, 0xF0,
  0x18, 0x06, 0x03, 0xC0, 0x60, 0x38, 0x0F, 0x00, 0xC0, 0xC0, 0x3C, 0x03,
  0x03, 0x00, 0xF0, 0x0C, 0x0C, 0x03, 0xC0, 0x38, 0x60, 0x0F, 0x00, 0x61,
  0x80, 0x3C, 0x01, 0x86, 0x00, 0xF0, 0x07, 0x38, 0x03, 0xC0, 0x0C, 0xC0,
  0x0F, 0x00, 0x33, 0x00, 0x3C, 0x00, 0xDC, 0x00, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xC0,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0x60, 0x00, 0x7B, 0x80, 0x03, 0xCC, 0x00, 0x1E,
  0x60, 0x00, 0xF1, 0x80, 0x07, 0x8C, 0x00, 0x3C, 0x70, 0x01, 0xE1, 0x80,
  0x0F, 0x0E, 0x00, 0x78, 0x30, 0x03, 0xC1, 0x80, 0x1E, 0x06, 0x00, 0xF0,
  0x30, 0x07, 0x80, 0xC0, 0x3C, 0x06, 0x01, 0xE0, 0x38, 0x0F, 0x00, 0xC0,
  0x78, 0x07, 0x03, 0xC0, 0x18, 0x1E, 0x00, 0xC0, 0xF0, 0x03, 0x07, 0x80,
  0x18, 0x3C, 0x00, 0xE1, 0xE0, 0x03, 0x0F, 0x00, 0x1C, 0x78, 0x00, 0x63,
  0xC0, 0x03, 0x9E, 0x00, 0x0C, 0xF0, 0x00, 0x67, 0x80, 0x01, 0xBC, 0x00,
  0x0D, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x06, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01,
  0xE0, 0x3C, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x01, 0x80, 0xE0, 0x00, 0xE0,
  0x60, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x07,
  0x18, 0x00, 0x03, 0x8C, 0x00, 0x01, 0x87, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0xE0, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x1E, 0x00, 0x70, 0x07, 0x80,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x30, 0x3F, 0x18, 0x03, 0xCC, 0x00, 0x76, 0x00, 0x1B,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xD8, 0x00, 0xEC, 0x00, 0x76, 0x00, 0x73, 0x01, 0xF1,
  0xFF, 0xF0, 0xFF, 0xC0, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0xE0, 0x01, 0x80, 0xE0,
  0x00, 0xE0, 0x60, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x06, 0x18,
  0x00, 0x03, 0x9C, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x70,
  0x00, 0x07, 0x18, 0x00, 0x03, 0x8C, 0x00, 0x01, 0x87, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x70,
  0x07, 0x80, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0xFF, 0x80, 0x1F, 0xFF, 0x03, 0x03, 0xF0,
  0x60, 0x0F, 0x0C, 0x00, 0x71, 0x80, 0x06, 0x30, 0x00, 0xE6, 0x00, 0x0C,
  0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x19,
  0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x03, 0x98, 0x00, 0x63,
  0x00, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0xE1, 0x80, 0xF8, 0x3F, 0xFC, 0x07,
  0xFE, 0x00, 0xC0, 0xC0, 0x18, 0x1C, 0x03, 0x01, 0x80, 0x60, 0x38, 0x0C,
  0x03, 0x01, 0x80, 0x70, 0x30, 0x06, 0x06, 0x00, 0xE0, 0xC0, 0x0C, 0x18,
  0x01, 0x83, 0x00, 0x38, 0x60, 0x03, 0x0C, 0x00, 0x71, 0x80, 0x06, 0x30,
  0x00, 0xE6, 0x00, 0x0C, 0xC0, 0x01, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x80,
  0x03, 0xFF, 0x80, 0xFF, 0xFC, 0x38, 0x03, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0xE0,
  0x07, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x76, 0x00, 0x03, 0xB8, 0x00,
  0x18, 0xE0, 0x01, 0xC7, 0x00, 0x1C, 0x1E, 0x01, 0xC0, 0x7F, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1D, 0x80,
  0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCE, 0x00, 0x03, 0x9C, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x70, 0xE0, 0x00,
  0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x18,
  0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x38, 0x03, 0x80,
  0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x70, 0x03,
  0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x0E, 0x00, 0x1C,
  0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x61, 0xC0, 0x00, 0xE3,
  0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x70,
  0x00, 0x0E, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0xC0, 0x00, 0x70, 0x00, 0x0D, 0x80, 0x00, 0xE0, 0x00, 0x1B,
  0x00, 0x01, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xC0, 0x00, 0xCE, 0x00, 0x07,
  0x80, 0x01, 0x8C, 0x00, 0x1B, 0x00, 0x03, 0x18, 0x00, 0x36, 0x00, 0x0E,
  0x30, 0x00, 0x6E, 0x00, 0x1C, 0x70, 0x00, 0xCC, 0x00, 0x30, 0xE0, 0x01,
  0x98, 0x00, 0x60, 0xC0, 0x07, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x60, 0x03,
  0x83, 0x00, 0x18, 0xC0, 0x07, 0x07, 0x00, 0x30, 0xC0, 0x0C, 0x06, 0x00,
  0x61, 0x80, 0x18, 0x0C, 0x01, 0xC3, 0x00, 0x30, 0x18, 0x03, 0x06, 0x00,
  0xE0, 0x30, 0x06, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x0C, 0x03, 0x00, 0x60,
  0x18, 0x18, 0x06, 0x00, 0xC0, 0x70, 0x30, 0x1C, 0x01, 0x80, 0xC0, 0x60,
  0x38, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x07, 0x03, 0x00, 0xC0, 0xC0, 0x06,
  0x06, 0x01, 0x81, 0x80, 0x0C, 0x1C, 0x03, 0x07, 0x00, 0x18, 0x30, 0x06,
  0x0E, 0x00, 0x38, 0x60, 0x0C, 0x18, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x00,
  0x61, 0x80, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x31, 0xC0, 0x01, 0x8C, 0x00,
  0x63, 0x00, 0x03, 0x98, 0x00, 0xC6, 0x00, 0x03, 0x30, 0x01, 0xCC, 0x00,
  0x06, 0x60, 0x01, 0xB8, 0x00, 0x0C, 0xC0, 0x03, 0x70, 0x00, 0x1B, 0x00,
  0x06, 0xC0, 0x00, 0x3E, 0x00, 0x0D, 0x80, 0x00, 0x3C, 0x00, 0x1B, 0x00,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x6E, 0x00, 0x1C, 0xC0, 0x03, 0x1C, 0x00,
  0xE1, 0x80, 0x18, 0x30, 0x03, 0x07, 0x00, 0xE0, 0x60, 0x18, 0x0C, 0x03,
  0x01, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x07, 0x00, 0x30, 0xC0, 0x06, 0x18,
  0x00, 0xC7, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xB8, 0x00, 0x33, 0x00, 0x0C, 0x60, 0x01, 0x8E, 0x00, 0x70, 0xC0,
  0x0C, 0x18, 0x01, 0x83, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x80, 0xE0,
  0x60, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x38, 0x60, 0x03, 0x1C, 0x00, 0x73,
  0x00, 0x0E, 0x60, 0x00, 0xDC, 0x00, 0x1F, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x7E, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0E, 0x70, 0x00, 0xC3, 0x00,
  0x0C, 0x30, 0x01, 0xC3, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x38, 0x1C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x00, 0xE0, 0x60, 0x06, 0x06, 0x00,
  0x60, 0xE0, 0x07, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x1C, 0x00, 0x19, 0x80,
  0x01, 0x98, 0x00, 0x19, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF,
  0x7F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x7F, 0xFF, 0xFE, 0xE0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1B, 0x00, 0x00, 0xEC, 0x00, 0x03, 0x18, 0x00, 0x1C, 0x60, 0x00,
  0x61, 0xC0, 0x03, 0x83, 0x00, 0x0C, 0x0E, 0x00, 0x70, 0x18, 0x01, 0x80,
  0x70, 0x0E, 0x00, 0xC0, 0x30, 0x03, 0x81, 0xC0, 0x06, 0x06, 0x00, 0x1C,
  0x38, 0x00, 0x30, 0xC0, 0x00, 0xE7, 0x00, 0x01, 0x98, 0x00, 0x07, 0xE0,
  0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x07, 0xF8, 0x3F,
  0xFC, 0x18, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x01, 0xFF, 0x07, 0xFB, 0x1E, 0x03, 0x38, 0x03, 0x30, 0x03, 0x60,
  0x03, 0x60, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0x60, 0x05, 0x70, 0x0D, 0x30, 0x19, 0x3E, 0x71, 0x1F,
  0xE1, 0x01, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x7F, 0x06, 0x3F, 0xF0, 0xCE, 0x07, 0x19, 0x00, 0x73, 0x60, 0x06,
  0x68, 0x00, 0xEF, 0x00, 0x0D, 0xC0, 0x01, 0xB8, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x37,
  0x80, 0x06, 0xF0, 0x01, 0xDB, 0x00, 0x33, 0x60, 0x0E, 0x66, 0x03, 0x8C,
  0x7F, 0xE1, 0x87, 0xF8, 0x00, 0x18, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x38,
  0x08, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x43, 0xF7, 0x83, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC1, 0xFC, 0x18, 0x7F, 0xE3, 0x1C,
  0x0E, 0x67, 0x00, 0xEC, 0xC0, 0x0D, 0xB8, 0x00, 0xB6, 0x00, 0x1E, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3B, 0x00, 0x0F, 0x70, 0x01, 0x6E, 0x00,
  0x6C, 0xE0, 0x0D, 0x8E, 0x03, 0x31, 0xFB, 0xC6, 0x0F, 0xF0, 0xC0, 0x30,
  0x00, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xC0, 0xE0, 0xE0, 0x18, 0x30, 0x03,
  0x1C, 0x00, 0xC6, 0x00, 0x39, 0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0x6C,
  0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x87, 0x00, 0x60, 0xFD, 0xF8, 0x0F,
  0xF8, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xF0, 0x78, 0x81, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x07, 0xFE, 0x3F, 0xF8, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x07, 0xF8, 0x61, 0xFF, 0x8C, 0x70, 0x39, 0x9C, 0x01, 0xB3, 0x00,
  0x36, 0xE0, 0x03, 0xD8, 0x00, 0x7B, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xEC, 0x00, 0x3D, 0x80, 0x05, 0xB8, 0x01, 0xF3, 0x80, 0x2E, 0x38, 0x1D,
  0xC3, 0xFF, 0x38, 0x3F, 0xC7, 0x00, 0x80, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x32, 0x00, 0x0E, 0x30, 0x07, 0x87, 0xFF, 0xE0,
  0x7F, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x0F,
  0xE1, 0x8F, 0xFC, 0xCE, 0x0E, 0x66, 0x03, 0xB6, 0x00, 0xDA, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0C, 0x5F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x04, 0x1C, 0x38, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xC1, 0x83,
  0x0E, 0xF9, 0xF1, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0xC0, 0x0E,
  0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0xE0,
  0xC0, 0xC0, 0xC1, 0xC0, 0xC1, 0x80, 0xC3, 0x00, 0xC7, 0x00, 0xC7, 0x00,
  0xCD, 0x80, 0xCD, 0x80, 0xD9, 0xC0, 0xF0, 0xC0, 0xF0, 0xC0, 0xE0, 0x60,
  0xC0, 0x60, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x38, 0xC0, 0x18, 0xC0, 0x18,
  0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC3, 0xF0, 0x1F, 0xC6, 0x3F, 0xE1, 0xFF, 0x33, 0x07, 0x18, 0x1D, 0xB0,
  0x1D, 0x80, 0x6D, 0x00, 0x6C, 0x03, 0xF8, 0x03, 0x40, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0x60, 0x03, 0xE0, 0x03, 0x00, 0x1F, 0x00, 0x18, 0x00,
  0xF8, 0x00, 0xC0, 0x07, 0x80, 0x06, 0x00, 0x3C, 0x00, 0x30, 0x01, 0xE0,
  0x01, 0x80, 0x0F, 0x00, 0x0C, 0x00, 0x78, 0x00, 0x60, 0x03, 0xC0, 0x03,
  0x00, 0x1E, 0x00, 0x18, 0x00, 0xF0, 0x00, 0xC0, 0x07, 0x80, 0x06, 0x00,
  0x3C, 0x00, 0x30, 0x01, 0xE0, 0x01, 0x80, 0x0F, 0x00, 0x0C, 0x00, 0x78,
  0x00, 0x60, 0x03, 0xC0, 0x03, 0x00, 0x1E, 0x00, 0x18, 0x00, 0xF0, 0x00,
  0xC0, 0x07, 0x80, 0x06, 0x00, 0x3C, 0x00, 0x30, 0x01, 0xE0, 0x01, 0x80,
  0x0F, 0x00, 0x0C, 0x00, 0x78, 0x00, 0x60, 0x03, 0xC3, 0xF8, 0x63, 0xFF,
  0x33, 0x83, 0x9B, 0x00, 0xED, 0x80, 0x36, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x70, 0x3C, 0x1C,
  0x01, 0x83, 0x00, 0x38, 0xE0, 0x03, 0x18, 0x00, 0x73, 0x00, 0x06, 0xE0,
  0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x06, 0x60, 0x00, 0xCC, 0x00, 0x19, 0xC0, 0x07, 0x18, 0x00, 0xC3, 0x80,
  0x38, 0x38, 0x0E, 0x03, 0xEF, 0x80, 0x3F, 0xE0, 0x00, 0x40, 0x00, 0xC1,
  0xFC, 0x18, 0xFF, 0xC3, 0x38, 0x1C, 0x66, 0x01, 0xCD, 0x80, 0x19, 0xA0,
  0x03, 0xBC, 0x00, 0x37, 0x00, 0x06, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xDE, 0x00,
  0x1B, 0x40, 0x07, 0x6C, 0x00, 0xCC, 0x80, 0x39, 0x9C, 0x0E, 0x31, 0xEF,
  0x86, 0x1F, 0xE0, 0xC0, 0x60, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x61, 0xFF, 0x8C, 0x78, 0x39, 0x9C, 0x01, 0xB3, 0x00,
  0x36, 0xE0, 0x02, 0xD8, 0x00, 0x7B, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0x60, 0x00,
  0xEC, 0x00, 0x3D, 0xC0, 0x05, 0x98, 0x01, 0xB3, 0x80, 0x2E, 0x38, 0x1D,
  0xC3, 0xFF, 0x38, 0x3F, 0xC7, 0x01, 0x80, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0xC3, 0xFC, 0x7E, 0xCE, 0x1C, 0xC0, 0xD8, 0x0D, 0x80,
  0xD0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x0F, 0xF8, 0x3F, 0xFC, 0xE0, 0x33, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xD8, 0x03, 0xBF,
  0xFE, 0x1F, 0xF8, 0x03, 0x80, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x01, 0xFF, 0xFF, 0xE3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1E, 0xC1, 0xF8, 0x0C,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xEC, 0x00, 0xB7,
  0x00, 0xDB, 0xC0, 0xCC, 0xFF, 0xC6, 0x3F, 0xC3, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0xD8, 0x00, 0x36, 0x00, 0x1D, 0x80, 0x06, 0x70, 0x01, 0x8C, 0x00,
  0x63, 0x00, 0x38, 0xC0, 0x0C, 0x30, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x70,
  0x60, 0x1C, 0x18, 0x06, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x0C,
  0x0C, 0x03, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x70, 0x06, 0x18, 0x01, 0x86,
  0x00, 0x31, 0x80, 0x0C, 0xE0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x1B, 0x00,
  0x06, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xC0,
  0x03, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x60, 0x07, 0x80, 0x19, 0x80, 0x1E, 0x00, 0x66, 0x00, 0xEC,
  0x01, 0x98, 0x03, 0x30, 0x06, 0x70, 0x0C, 0xC0, 0x30, 0xC0, 0x33, 0x00,
  0xC3, 0x00, 0xCC, 0x03, 0x0C, 0x07, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x70,
  0x60, 0x61, 0x81, 0x81, 0x81, 0x86, 0x06, 0x06, 0x06, 0x1C, 0x18, 0x18,
  0x30, 0x30, 0x60, 0x70, 0xC0, 0xC3, 0x80, 0xC3, 0x03, 0x0C, 0x03, 0x0C,
  0x0C, 0x30, 0x0C, 0x70, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x00, 0x66, 0x01,
  0x98, 0x01, 0x98, 0x06, 0x60, 0x06, 0x60, 0x19, 0x80, 0x1B, 0x80, 0x36,
  0x00, 0x6C, 0x00, 0xD8, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x01, 0x80, 0x60,
  0x01, 0x9C, 0x00, 0xE3, 0x00, 0x30, 0xC0, 0x1C, 0x38, 0x06, 0x06, 0x01,
  0x81, 0xC0, 0xC0, 0x30, 0x30, 0x0E, 0x1C, 0x01, 0x86, 0x00, 0x63, 0x80,
  0x0C, 0xC0, 0x03, 0x70, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x36, 0x00, 0x0C, 0xC0, 0x07, 0x30, 0x01, 0x86,
  0x00, 0xE1, 0x80, 0x30, 0x70, 0x1C, 0x0C, 0x06, 0x03, 0x81, 0x80, 0x60,
  0xC0, 0x1C, 0x30, 0x03, 0x1C, 0x00, 0xC6, 0x00, 0x3B, 0x80, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x36, 0x00, 0x1D, 0x80, 0x06, 0x60, 0x01, 0x9C, 0x00,
  0x63, 0x00, 0x38, 0xC0, 0x0C, 0x30, 0x03, 0x0E, 0x00, 0xC1, 0x80, 0x70,
  0x60, 0x18, 0x18, 0x06, 0x07, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x30, 0x0C,
  0x0C, 0x03, 0x83, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0xC6,
  0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xEC, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xF7, 0xFF,
  0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0xC0, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x01,
  0xF8, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0xF8, 0x01, 0xF0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x78, 0x03, 0xC0, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x03, 0xF8, 0x07, 0xC0, 0x08, 0x00, 0x00, 0x1F, 0x00, 0x0B, 0xFE,
  0x00, 0x78, 0x7C, 0x0F, 0x80, 0x7F, 0xE8, 0x01, 0xFE, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 43, 12, 4, -43 },
  { 23, 11, 16, 19, 4, -43 },
  { 45, 24, 43, 26, 1, -43 },
  { 174, 20, 49, 24, 2, -46 },
  { 297, 30, 44, 35, 3, -43 },
  { 462, 22, 44, 24, 2, -43 },
  { 583, 2, 16, 10, 4, -43 },
  { 587, 11, 52, 16, 3, -43 },
  { 659, 11, 52, 16, 2, -43 },
  { 731, 15, 17, 21, 3, -46 },
  { 763, 21, 28, 24, 2, -35 },
  { 837, 6, 14, 11, 2, -6 },
  { 848, 12, 2, 16, 2, -17 },
  { 851, 4, 5, 11, 4, -5 },
  { 854, 18, 43, 20, 1, -43 },
  { 951, 18, 43, 24, 3, -43 },
  { 1048, 11, 43, 24, 4, -43 },
  { 1108, 19, 43, 24, 2, -43 },
  { 1211, 19, 44, 24, 2, -43 },
  { 1316, 22, 43, 24, 1, -43 },
  { 1435, 18, 44, 24, 3, -43 },
  { 1534, 18, 44, 24, 3, -43 },
  { 1633, 19, 43, 24, 2, -43 },
  { 1736, 20, 44, 24, 2, -43 },
  { 1846, 19, 44, 24, 2, -43 },
  { 1951, 4, 32, 11, 4, -32 },
  { 1967, 6, 40, 11, 2, -32 },
  { 1997, 21, 25, 24, 2, -34 },
  { 2063, 21, 15, 24, 2, -29 },
  { 2103, 21, 25, 24, 2, -34 },
  { 2169, 14, 43, 16, 1, -43 },
  { 2245, 31, 48, 37, 3, -43 },
  { 2431, 24, 43, 24, 0, -43 },
  { 2560, 19, 43, 26, 5, -43 },
  { 2663, 21, 44, 25, 3, -43 },
  { 2779, 21, 43, 29, 5, -43 },
  { 2892, 15, 43, 23, 5, -43 },
  { 2973, 15, 43, 21, 5, -43 },
  { 3054, 25, 44, 32, 3, -43 },
  { 3192, 20, 43, 30, 5, -43 },
  { 3300, 10, 43, 14, 2, -43 },
  { 3354, 10, 54, 12, -3, -43 },
  { 3422, 19, 43, 24, 5, -43 },
  { 3525, 15, 43, 21, 5, -43 },
  { 3606, 30, 43, 40, 5, -43 },
  { 3768, 21, 43, 31, 5, -43 },
  { 3881, 25, 44, 31, 3, -43 },
  { 4019, 17, 43, 24, 5, -43 },
  { 4111, 25, 53, 31, 3, -43 },
  { 4277, 19, 43, 25, 5, -43 },
  { 4380, 19, 44, 24, 2, -43 },
  { 4485, 20, 43, 21, 0, -43 },
  { 4593, 21, 44, 30, 4, -43 },
  { 4709, 23, 43, 23, 0, -43 },
  { 4833, 39, 43, 40, 0, -43 },
  { 5043, 19, 43, 21, 1, -43 },
  { 5146, 20, 43, 20, 0, -43 },
  { 5254, 17, 43, 20, 2, -43 },
  { 5346, 11, 53, 18, 5, -43 },
  { 5419, 18, 43, 20, 1, -43 },
  { 5516, 12, 53, 18, 2, -43 },
  { 5596, 22, 21, 24, 1, -43 },
  { 5654, 24, 2, 24, 0, 5 },
  { 5660, 10, 10, 14, 2, -46 },
  { 5673, 16, 33, 23, 2, -32 },
  { 5739, 19, 47, 26, 4, -46 },
  { 5851, 15, 33, 19, 3, -32 },
  { 5913, 19, 47, 26, 3, -46 },
  { 6025, 18, 33, 23, 3, -32 },
  { 6100, 14, 46, 13, 1, -46 },
  { 6181, 19, 47, 26, 3, -32 },
  { 6293, 17, 46, 25, 4, -46 },
  { 6391, 3, 44, 11, 4, -44 },
  { 6408, 7, 59, 11, 0, -44 },
  { 6460, 16, 46, 20, 4, -46 },
  { 6552, 2, 46, 11, 4, -46 },
  { 6564, 29, 32, 37, 4, -32 },
  { 6680, 17, 32, 25, 4, -32 },
  { 6748, 19, 33, 25, 3, -32 },
  { 6827, 19, 46, 26, 4, -32 },
  { 6937, 19, 46, 26, 3, -32 },
  { 7047, 12, 32, 16, 4, -32 },
  { 7095, 15, 33, 19, 2, -32 },
  { 7157, 11, 40, 13, 1, -39 },
  { 7212, 17, 33, 25, 4, -32 },
  { 7283, 18, 32, 19, 0, -32 },
  { 7355, 30, 32, 32, 1, -32 },
  { 7475, 18, 32, 20, 1, -32 },
  { 7547, 18, 47, 20, 1, -32 },
  { 7653, 13, 32, 16, 2, -32 },
  { 7705, 15, 53, 21, 3, -43 },
  { 7805, 3, 60, 23, 10, -46 },
  { 7828, 15, 53, 21, 3, -43 },
  { 7928, 21, 5, 24, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight60pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT60PT7B_H_
