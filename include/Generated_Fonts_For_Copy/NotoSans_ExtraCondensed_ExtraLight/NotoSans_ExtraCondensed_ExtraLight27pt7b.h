#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT27PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight27pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xA0, 0x3C, 0x9C, 0x63, 0x18, 0xC6, 0x20, 0x08,
  0x81, 0x10, 0x22, 0x04, 0x40, 0x88, 0xFF, 0xC2, 0x20, 0x84, 0x10, 0x82,
  0x20, 0x44, 0x08, 0x8F, 0xFC, 0x22, 0x04, 0x41, 0x08, 0x21, 0x04, 0x40,
  0x88, 0x00, 0x08, 0x04, 0x0F, 0x89, 0x28, 0x84, 0x42, 0x21, 0x10, 0x88,
  0x24, 0x0E, 0x01, 0x80, 0xA0, 0x48, 0x22, 0x11, 0x08, 0x84, 0x62, 0x5F,
  0xC0, 0x80, 0x40, 0x20, 0x30, 0x21, 0x21, 0x04, 0x84, 0x22, 0x10, 0x84,
  0x82, 0x12, 0x08, 0x48, 0x21, 0x40, 0x85, 0x32, 0x25, 0x24, 0xA4, 0x96,
  0xA1, 0x22, 0x84, 0x12, 0x10, 0x48, 0x41, 0x21, 0x08, 0x84, 0x21, 0x20,
  0x84, 0x84, 0x0E, 0x10, 0x0B, 0x02, 0x41, 0x08, 0x42, 0x11, 0x02, 0x40,
  0x90, 0x28, 0x04, 0x03, 0x01, 0x20, 0x84, 0xA1, 0x28, 0x2A, 0x0A, 0x81,
  0x20, 0xE4, 0x29, 0xF1, 0xFE, 0x08, 0x88, 0x42, 0x21, 0x08, 0x46, 0x21,
  0x08, 0x41, 0x08, 0x42, 0x08, 0x43, 0x08, 0x20, 0xC2, 0x08, 0x41, 0x08,
  0x43, 0x08, 0x42, 0x10, 0x84, 0x22, 0x10, 0x84, 0x42, 0x23, 0x00, 0x10,
  0x20, 0x47, 0xB1, 0x85, 0x09, 0x23, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x43, 0xFE, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x69, 0x25, 0x20,
  0xF8, 0xC0, 0x03, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80, 0x08, 0x1B, 0x18,
  0x88, 0x24, 0x12, 0x0B, 0x05, 0x02, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x14,
  0x0A, 0x04, 0x82, 0x41, 0x20, 0x88, 0x83, 0x80, 0x19, 0x53, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x08, 0x33, 0x20, 0xC0,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40,
  0x40, 0x20, 0x20, 0x20, 0x10, 0x1F, 0xF0, 0x10, 0x37, 0x20, 0xC0, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x02, 0x06, 0x0F, 0x00, 0x40, 0x10, 0x08, 0x06,
  0x02, 0x01, 0x00, 0xA0, 0xDF, 0xC0, 0x01, 0x00, 0x60, 0x0C, 0x02, 0x80,
  0x50, 0x12, 0x02, 0x40, 0x88, 0x11, 0x04, 0x20, 0x84, 0x20, 0x84, 0x11,
  0xFF, 0xC0, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x7F, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0xB0, 0xE6, 0x00, 0x80, 0x40, 0x30, 0x08,
  0x04, 0x06, 0x02, 0x01, 0x41, 0x3F, 0x00, 0x1F, 0x10, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x01, 0x38, 0xA2, 0x60, 0xB0, 0x50, 0x38, 0x0C, 0x05, 0x02,
  0x82, 0x41, 0x30, 0x8F, 0x80, 0xFF, 0x80, 0x80, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x00, 0x08, 0x1B, 0x10, 0x48, 0x28, 0x16, 0x09, 0x04, 0x82,
  0x26, 0x0E, 0x05, 0x0C, 0x44, 0x14, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x90,
  0x47, 0xC0, 0x08, 0x36, 0x42, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x43, 0x67, 0x19, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x78, 0xC0, 0x0C,
  0x68, 0x00, 0x00, 0x00, 0x34, 0x92, 0x90, 0x00, 0x81, 0x83, 0x06, 0x0C,
  0x04, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x20, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x04, 0x0C,
  0x18, 0x30, 0x20, 0x20, 0x00, 0x11, 0xD8, 0x10, 0x10, 0x20, 0x40, 0x82,
  0x04, 0x10, 0x40, 0x82, 0x04, 0x08, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x0F,
  0xE0, 0x60, 0x43, 0x01, 0x88, 0x02, 0x60, 0x09, 0x0F, 0x14, 0x64, 0x51,
  0x11, 0x44, 0x46, 0x21, 0x18, 0x84, 0x62, 0x11, 0x88, 0x45, 0x13, 0x14,
  0x4C, 0x90, 0xCE, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x0F, 0xC0,
  0x0C, 0x01, 0x80, 0x28, 0x05, 0x01, 0x20, 0x24, 0x04, 0x40, 0x88, 0x31,
  0x04, 0x20, 0x82, 0x1F, 0xC2, 0x08, 0x81, 0x10, 0x32, 0x02, 0x40, 0x50,
  0x0A, 0x01, 0x80, 0xFE, 0x41, 0xA0, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x06,
  0xFE, 0x43, 0x20, 0x50, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x41, 0xBF,
  0x00, 0x02, 0x07, 0x73, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0,
  0x30, 0x08, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x3F, 0xFC, 0x20, 0xC8, 0x12, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x06, 0x81, 0x20,
  0x8F, 0xC0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFF, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0xF8, 0xFF, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00,
  0x01, 0x00, 0xEE, 0x10, 0x12, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0x81, 0xFC, 0x01, 0x40, 0x14, 0x01, 0x40, 0x14, 0x01,
  0x20, 0x12, 0x01, 0x10, 0x10, 0xFE, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x20, 0xF2, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x22, 0xF0, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x3E, 0x81, 0x41, 0x20, 0x90, 0x88, 0xC4, 0x42, 0x41, 0x20, 0xB0,
  0x68, 0x36, 0x11, 0x08, 0x84, 0x22, 0x11, 0x04, 0x82, 0x40, 0xA0, 0x60,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x03, 0xF8, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE8, 0x05,
  0xA0, 0x16, 0x80, 0x59, 0x02, 0x64, 0x09, 0x90, 0x26, 0x41, 0x18, 0x84,
  0x62, 0x11, 0x88, 0x46, 0x12, 0x18, 0x48, 0x61, 0x21, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x40, 0xC0, 0x70, 0x1E, 0x06, 0x81, 0xA0, 0x64, 0x19, 0x06,
  0x21, 0x88, 0x61, 0x18, 0x46, 0x11, 0x82, 0x60, 0x98, 0x16, 0x05, 0x80,
  0xE0, 0x38, 0x0C, 0x06, 0x01, 0x98, 0x20, 0x42, 0x04, 0x40, 0x24, 0x02,
  0x40, 0x24, 0x02, 0xC0, 0x28, 0x03, 0x80, 0x1C, 0x03, 0x40, 0x24, 0x02,
  0x40, 0x24, 0x02, 0x40, 0x22, 0x04, 0x30, 0xC1, 0xF8, 0xFC, 0x82, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x86, 0xF8, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x02, 0x01, 0xD8, 0x20, 0x42, 0x04, 0x40, 0x24,
  0x02, 0x40, 0x24, 0x02, 0xC0, 0x38, 0x03, 0x80, 0x1C, 0x03, 0x40, 0x24,
  0x02, 0x40, 0x24, 0x02, 0x40, 0x22, 0x04, 0x30, 0xC1, 0xF8, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0xFC, 0x41, 0x20, 0x50, 0x28, 0x14,
  0x0A, 0x05, 0x02, 0x82, 0x7E, 0x22, 0x11, 0x08, 0x44, 0x22, 0x09, 0x04,
  0x83, 0x40, 0xA0, 0x60, 0x08, 0x1D, 0x90, 0x18, 0x08, 0x04, 0x02, 0x00,
  0x80, 0x60, 0x18, 0x03, 0x00, 0x40, 0x10, 0x08, 0x06, 0x02, 0x01, 0x00,
  0xA0, 0xDF, 0xC0, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xA0, 0x8F, 0x80, 0x80,
  0x60, 0x14, 0x05, 0x02, 0x40, 0x90, 0x22, 0x08, 0x84, 0x21, 0x08, 0x41,
  0x10, 0x4C, 0x12, 0x04, 0x81, 0x20, 0x28, 0x0C, 0x03, 0x00, 0xC0, 0x80,
  0xC0, 0xD0, 0x30, 0x24, 0x0C, 0x09, 0x03, 0x02, 0x41, 0x40, 0x90, 0x48,
  0x42, 0x12, 0x10, 0x84, 0x84, 0x21, 0x21, 0x08, 0x88, 0x42, 0x21, 0x20,
  0x48, 0x48, 0x12, 0x12, 0x04, 0x84, 0x81, 0x41, 0x60, 0x50, 0x30, 0x0C,
  0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x40, 0x90, 0x88, 0x44, 0x21, 0x20,
  0x90, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x02, 0x81, 0x21, 0x10, 0x88, 0x42,
  0x41, 0x20, 0xF0, 0x20, 0x80, 0xA0, 0x90, 0x48, 0x22, 0x21, 0x10, 0x88,
  0x28, 0x14, 0x0A, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x00, 0xFE, 0x04, 0x18, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20, 0x41,
  0x02, 0x0C, 0x10, 0x20, 0x81, 0x03, 0xF8, 0xFC, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x43, 0xE0, 0x80, 0x80,
  0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04,
  0x04, 0x04, 0x02, 0x02, 0x03, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xE0, 0x04, 0x02, 0x80, 0xA0,
  0x44, 0x11, 0x08, 0x22, 0x09, 0x01, 0xC0, 0x40, 0xFF, 0xE0, 0x84, 0x23,
  0x10, 0x10, 0xC8, 0x08, 0x10, 0x20, 0x40, 0x9F, 0x43, 0x06, 0x0C, 0x18,
  0x38, 0xDE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x88, 0xB6, 0xC3,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC1, 0xC2, 0xBC,
  0x08, 0x65, 0x82, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x02, 0x04, 0x0C,
  0x0F, 0x80, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x22, 0x6D, 0x41,
  0xA0, 0xD0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0xD0, 0x68,
  0x53, 0xC8, 0x08, 0x36, 0x42, 0x41, 0x41, 0x81, 0x81, 0xFF, 0x80, 0x80,
  0x80, 0x40, 0x40, 0x61, 0x3F, 0x0C, 0x24, 0x81, 0x02, 0x04, 0x08, 0x7C,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00,
  0x08, 0x1B, 0x50, 0x68, 0x34, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x28, 0x34, 0x1A, 0x14, 0xF2, 0x01, 0x00, 0x80, 0x40, 0x40, 0x26, 0xE0,
  0xC0, 0x81, 0x02, 0x04, 0x08, 0x10, 0x22, 0x5B, 0xC3, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x20, 0xC3, 0xFF, 0xF0, 0x24,
  0x00, 0x09, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x3E, 0x00, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0xC2, 0x8D, 0x12, 0x44, 0x8B, 0x1A, 0x34, 0x44,
  0x89, 0x0A, 0x14, 0x28, 0x20, 0xFF, 0xFF, 0xF8, 0x18, 0x45, 0x65, 0xB1,
  0x43, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10,
  0x60, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x20, 0x09, 0x6F, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x80, 0x08,
  0x1B, 0x10, 0x48, 0x2C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x28,
  0x14, 0x13, 0x08, 0xF8, 0x08, 0xB6, 0xC3, 0xC1, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0xC1, 0xC2, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x08, 0x1B, 0x50, 0x68, 0x34, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x28, 0x34, 0x1B, 0x14, 0xF2, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x15, 0xF1, 0x88, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x00, 0x18,
  0xCE, 0x04, 0x08, 0x10, 0x10, 0x18, 0x08, 0x08, 0x18, 0x10, 0x30, 0xBE,
  0x00, 0x42, 0x10, 0x8F, 0xA1, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x43,
  0x80, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1C,
  0x6F, 0x40, 0x81, 0x41, 0x43, 0x42, 0x42, 0x22, 0x22, 0x24, 0x24, 0x24,
  0x14, 0x18, 0x18, 0x18, 0x81, 0x05, 0x0C, 0x14, 0x30, 0x90, 0xA2, 0x42,
  0x88, 0x92, 0x22, 0x48, 0x89, 0x24, 0x24, 0x50, 0x91, 0x41, 0x85, 0x06,
  0x14, 0x18, 0x20, 0x60, 0x80, 0x41, 0x22, 0x22, 0x26, 0x14, 0x14, 0x08,
  0x18, 0x14, 0x14, 0x22, 0x22, 0x41, 0xC1, 0x41, 0xA0, 0x90, 0x48, 0x22,
  0x21, 0x10, 0x88, 0x44, 0x14, 0x0A, 0x05, 0x02, 0x80, 0x80, 0x40, 0x20,
  0x10, 0x10, 0x08, 0x04, 0x1C, 0x04, 0x00, 0xFC, 0x20, 0x84, 0x10, 0x42,
  0x08, 0x61, 0x04, 0x20, 0x83, 0xF0, 0x0E, 0x30, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0xC6, 0x03, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x03, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x30, 0x20, 0x30, 0x83, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x38, 0x00, 0x70, 0xC6, 0x60, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 19, 5, 2, -19 },
  { 6, 5, 7, 8, 2, -19 },
  { 11, 11, 19, 12, 0, -19 },
  { 38, 9, 23, 11, 1, -21 },
  { 64, 14, 20, 16, 1, -20 },
  { 99, 10, 20, 11, 1, -20 },
  { 124, 1, 7, 5, 2, -19 },
  { 125, 5, 23, 7, 1, -19 },
  { 140, 5, 23, 7, 1, -19 },
  { 155, 7, 8, 9, 1, -21 },
  { 162, 9, 13, 11, 1, -16 },
  { 177, 3, 7, 5, 1, -3 },
  { 180, 5, 1, 7, 1, -8 },
  { 181, 1, 2, 5, 2, -2 },
  { 182, 8, 19, 9, 1, -19 },
  { 201, 9, 20, 11, 1, -20 },
  { 224, 5, 19, 11, 2, -19 },
  { 236, 9, 20, 11, 1, -20 },
  { 259, 9, 20, 11, 1, -20 },
  { 282, 11, 19, 11, 0, -19 },
  { 309, 9, 19, 11, 1, -19 },
  { 331, 9, 19, 11, 1, -19 },
  { 353, 9, 19, 11, 1, -19 },
  { 375, 9, 20, 11, 1, -20 },
  { 398, 8, 20, 11, 1, -20 },
  { 418, 1, 14, 5, 2, -14 },
  { 420, 3, 18, 5, 1, -14 },
  { 427, 9, 11, 11, 1, -15 },
  { 440, 9, 7, 11, 1, -13 },
  { 448, 9, 11, 11, 1, -15 },
  { 461, 7, 20, 7, 0, -20 },
  { 479, 14, 21, 17, 1, -19 },
  { 516, 11, 19, 11, 0, -19 },
  { 543, 9, 19, 12, 2, -19 },
  { 565, 10, 20, 11, 1, -20 },
  { 590, 10, 19, 13, 2, -19 },
  { 614, 7, 19, 10, 2, -19 },
  { 631, 7, 19, 10, 2, -19 },
  { 648, 12, 20, 14, 1, -20 },
  { 678, 9, 19, 13, 2, -19 },
  { 700, 4, 19, 6, 1, -19 },
  { 710, 4, 24, 5, -1, -19 },
  { 722, 9, 19, 11, 2, -19 },
  { 744, 7, 19, 9, 2, -19 },
  { 761, 14, 19, 18, 2, -19 },
  { 795, 10, 19, 14, 2, -19 },
  { 819, 12, 20, 14, 1, -20 },
  { 849, 8, 19, 11, 2, -19 },
  { 868, 12, 25, 14, 1, -20 },
  { 906, 9, 19, 11, 2, -19 },
  { 928, 9, 20, 11, 1, -20 },
  { 951, 9, 19, 9, 0, -19 },
  { 973, 9, 19, 13, 2, -19 },
  { 995, 10, 19, 10, 0, -19 },
  { 1019, 18, 19, 18, 0, -19 },
  { 1062, 9, 19, 9, 0, -19 },
  { 1084, 9, 19, 9, 0, -19 },
  { 1106, 7, 19, 9, 1, -19 },
  { 1123, 5, 23, 8, 2, -19 },
  { 1138, 8, 19, 9, 1, -19 },
  { 1157, 5, 23, 8, 1, -19 },
  { 1172, 10, 9, 11, 0, -19 },
  { 1184, 11, 1, 11, 0, 2 },
  { 1186, 4, 5, 6, 1, -21 },
  { 1189, 7, 15, 10, 1, -15 },
  { 1203, 8, 21, 12, 2, -21 },
  { 1224, 7, 15, 9, 1, -15 },
  { 1238, 9, 21, 12, 1, -21 },
  { 1262, 8, 15, 10, 1, -15 },
  { 1277, 7, 21, 6, 0, -21 },
  { 1296, 9, 22, 12, 1, -15 },
  { 1321, 7, 21, 11, 2, -21 },
  { 1340, 1, 20, 5, 2, -20 },
  { 1343, 3, 27, 5, 0, -20 },
  { 1354, 7, 21, 9, 2, -21 },
  { 1373, 1, 21, 5, 2, -21 },
  { 1376, 13, 15, 17, 2, -15 },
  { 1401, 7, 15, 11, 2, -15 },
  { 1415, 9, 15, 11, 1, -15 },
  { 1432, 8, 21, 12, 2, -15 },
  { 1453, 9, 21, 12, 1, -15 },
  { 1477, 5, 15, 7, 2, -15 },
  { 1487, 7, 15, 9, 1, -15 },
  { 1501, 5, 18, 6, 1, -18 },
  { 1513, 7, 14, 11, 2, -14 },
  { 1526, 8, 14, 8, 0, -14 },
  { 1540, 14, 14, 14, 0, -14 },
  { 1565, 8, 14, 9, 0, -14 },
  { 1579, 9, 21, 9, 0, -14 },
  { 1603, 6, 14, 7, 1, -14 },
  { 1614, 7, 23, 9, 1, -19 },
  { 1635, 1, 28, 10, 5, -21 },
  { 1639, 7, 23, 9, 1, -19 },
  { 1660, 9, 3, 11, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight27pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT27PT7B_H_
