#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT37PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xEA, 0xAA, 0xA8, 0x02, 0xF0, 0xC3, 0x87, 0x0E, 0x14,
  0x28, 0x50, 0xA1, 0x42, 0x04, 0x10, 0x10, 0xC0, 0x43, 0x03, 0x08, 0x0C,
  0x20, 0x30, 0x80, 0x82, 0x1F, 0xFF, 0x7F, 0xFC, 0x20, 0x80, 0x86, 0x02,
  0x18, 0x18, 0x40, 0x61, 0x01, 0x04, 0x04, 0x10, 0xFF, 0xF8, 0x41, 0x01,
  0x04, 0x04, 0x30, 0x10, 0xC0, 0xC2, 0x03, 0x08, 0x08, 0x20, 0x20, 0x80,
  0x82, 0x00, 0x02, 0x00, 0x10, 0x03, 0xF0, 0x75, 0xE6, 0x21, 0x21, 0x03,
  0x08, 0x18, 0x40, 0xC2, 0x06, 0x10, 0x10, 0x80, 0xC4, 0x03, 0x20, 0x0D,
  0x00, 0x1C, 0x00, 0x70, 0x02, 0x60, 0x11, 0x80, 0x84, 0x04, 0x20, 0x21,
  0x81, 0x0C, 0x08, 0x40, 0x42, 0x82, 0x27, 0x9F, 0x0F, 0xE0, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x38, 0x00, 0x1B, 0x03, 0x0C, 0x40, 0x82, 0x18, 0x20,
  0x82, 0x18, 0x20, 0x84, 0x08, 0x21, 0x02, 0x08, 0xC0, 0x82, 0x20, 0x20,
  0x88, 0x08, 0x26, 0x02, 0x09, 0x1C, 0x82, 0x48, 0xA1, 0xB6, 0x34, 0x49,
  0x05, 0xB2, 0x41, 0x31, 0x90, 0x40, 0x44, 0x10, 0x11, 0x04, 0x0C, 0x41,
  0x02, 0x10, 0x40, 0x84, 0x10, 0x61, 0x04, 0x10, 0x41, 0x04, 0x18, 0xC3,
  0x02, 0x20, 0x80, 0x70, 0x0E, 0x00, 0x7C, 0x01, 0x18, 0x0C, 0x20, 0x20,
  0x80, 0x82, 0x02, 0x08, 0x0C, 0x20, 0x10, 0x80, 0x46, 0x01, 0x90, 0x02,
  0x80, 0x0E, 0x00, 0x70, 0x03, 0x60, 0x08, 0x82, 0x41, 0x09, 0x06, 0x2C,
  0x08, 0xB0, 0x36, 0xC0, 0x53, 0x01, 0xCC, 0x02, 0x10, 0x1C, 0x40, 0xD9,
  0x86, 0x23, 0xF0, 0xC0, 0xFF, 0x55, 0x40, 0x0E, 0x10, 0x60, 0x83, 0x04,
  0x18, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x06,
  0x0C, 0x18, 0x10, 0x20, 0x60, 0x40, 0x81, 0x81, 0x03, 0x03, 0x03, 0xE0,
  0x40, 0xC0, 0x81, 0x81, 0x03, 0x06, 0x04, 0x08, 0x18, 0x30, 0x60, 0x40,
  0x81, 0x02, 0x04, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x10, 0x60, 0xC1,
  0x06, 0x18, 0x60, 0x08, 0x04, 0x02, 0x11, 0x17, 0xF0, 0x40, 0x50, 0x44,
  0x63, 0x20, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x33, 0x22, 0x66, 0x44, 0xC0,
  0xFF, 0xFF, 0x5F, 0x80, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02,
  0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x02,
  0x00, 0xC0, 0x18, 0x00, 0x0E, 0x07, 0xF0, 0x82, 0x30, 0x64, 0x04, 0x80,
  0xB0, 0x1E, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0x90, 0x13,
  0x06, 0x60, 0x86, 0x30, 0x7C, 0x00, 0x0C, 0x73, 0x59, 0xC4, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x0F, 0x03, 0xFC, 0x40, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x60, 0x04, 0x00, 0xFF, 0xF0, 0x0E, 0x03, 0xFC, 0xC0, 0x60,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x0C, 0x03, 0x81, 0xF0, 0x01, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x6C, 0x0C, 0x7F, 0x80,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x02, 0x80, 0x14, 0x01, 0xA0, 0x09, 0x00,
  0xC8, 0x04, 0x40, 0x62, 0x02, 0x10, 0x30, 0x81, 0x04, 0x18, 0x20, 0x81,
  0x0C, 0x08, 0x40, 0x46, 0x02, 0x20, 0x11, 0xFF, 0xFF, 0xFF, 0x80, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x7F, 0xC8, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0xF8, 0x7B,
  0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x06, 0x00, 0xC0, 0x10, 0x06, 0x81, 0x9F, 0xE0, 0x03, 0x81, 0xF8, 0x60,
  0x18, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x4F,
  0xCB, 0x0D, 0x40, 0xB0, 0x1E, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x80, 0x70, 0x1A, 0x03, 0x60, 0x46, 0x18, 0x7E, 0x00, 0xFF, 0xE0,
  0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x20,
  0x04, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x07, 0x00,
  0xFE, 0x0C, 0x18, 0xC0, 0x46, 0x03, 0x20, 0x19, 0x00, 0x48, 0x06, 0x60,
  0x31, 0x01, 0x0C, 0x18, 0x31, 0x80, 0x70, 0x07, 0x80, 0x66, 0x06, 0x08,
  0x60, 0x22, 0x01, 0x90, 0x05, 0x80, 0x2C, 0x01, 0xE0, 0x0B, 0x00, 0x48,
  0x06, 0x60, 0x31, 0x83, 0x07, 0xF0, 0x0F, 0x01, 0xF8, 0x30, 0xC6, 0x06,
  0x40, 0x24, 0x02, 0x40, 0x2C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x34, 0x03,
  0x40, 0x36, 0x03, 0x20, 0x73, 0x9B, 0x0F, 0x30, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x3F, 0x00, 0x5F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0B, 0xF0, 0x23, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x33, 0x22, 0x66, 0x44, 0xC0, 0x00, 0x08, 0x01, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x10, 0x00, 0x38, 0xFE, 0x83, 0x03, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x03, 0x02, 0x06, 0x04, 0x08, 0x18, 0x10, 0x10, 0x30, 0x20,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x30, 0x30, 0x30, 0x00, 0x40, 0x00, 0x7F,
  0x80, 0x30, 0x18, 0x0C, 0x01, 0x81, 0x00, 0x18, 0x60, 0x01, 0x08, 0x00,
  0x33, 0x00, 0x02, 0x40, 0xF8, 0x48, 0x31, 0x0B, 0x0C, 0x21, 0xE1, 0x04,
  0x38, 0x21, 0x83, 0x0C, 0x30, 0x61, 0x86, 0x0C, 0x30, 0xC1, 0x86, 0x18,
  0x70, 0xC3, 0x0E, 0x18, 0x61, 0x41, 0x0C, 0x2C, 0x22, 0x8D, 0x86, 0xDB,
  0x10, 0x71, 0xC2, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x80, 0x0F, 0xF0, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x0A, 0x00, 0x34, 0x00, 0x48, 0x00, 0x98, 0x01, 0x10, 0x06, 0x20, 0x0C,
  0x40, 0x10, 0xC0, 0x21, 0x80, 0xC1, 0x01, 0x82, 0x02, 0x06, 0x04, 0x0C,
  0x0F, 0xF8, 0x30, 0x10, 0x60, 0x20, 0x80, 0x61, 0x00, 0x46, 0x00, 0x8C,
  0x01, 0x10, 0x03, 0x20, 0x06, 0xC0, 0x05, 0x80, 0x0C, 0xFF, 0x88, 0x0C,
  0x80, 0x68, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x68, 0x06,
  0x80, 0xCF, 0xF8, 0xFF, 0x88, 0x0C, 0x80, 0x68, 0x02, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x02, 0x80, 0x68, 0x06, 0x83, 0xCF, 0xF0,
  0x03, 0xE0, 0x7F, 0xC6, 0x02, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x41, 0xFC, 0xFF, 0x04, 0x0E, 0x20,
  0x19, 0x00, 0xC8, 0x03, 0x40, 0x1A, 0x00, 0x50, 0x02, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xA0, 0x05, 0x00, 0x28, 0x03, 0x40, 0x12, 0x01, 0x90, 0x18, 0x83,
  0x87, 0xF0, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x03, 0xFE, 0xFF, 0xA0, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0,
  0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x3F, 0xE8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x00, 0xF0, 0x0F,
  0xFC, 0x30, 0x08, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x1F, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x14, 0x00,
  0x2C, 0x00, 0x48, 0x00, 0x98, 0x01, 0x18, 0x02, 0x18, 0x0C, 0x1F, 0xF0,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0xFC, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x13, 0xF0, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0xFE, 0x70, 0x80, 0x68, 0x04, 0x80, 0x88, 0x18, 0x81, 0x08,
  0x30, 0x82, 0x08, 0x60, 0x8C, 0x08, 0x80, 0x98, 0x09, 0x80, 0xB8, 0x0E,
  0x80, 0xCC, 0x08, 0x40, 0x86, 0x08, 0x20, 0x83, 0x08, 0x10, 0x81, 0x88,
  0x08, 0x80, 0xC8, 0x04, 0x80, 0x68, 0x03, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F,
  0xC0, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xD0, 0x00, 0x7A, 0x00,
  0x1F, 0x60, 0x02, 0xE4, 0x00, 0x5C, 0x80, 0x1B, 0x98, 0x02, 0x71, 0x00,
  0x4E, 0x20, 0x19, 0xC4, 0x03, 0x38, 0xC0, 0x47, 0x08, 0x08, 0xE1, 0x03,
  0x1C, 0x30, 0x43, 0x82, 0x08, 0x70, 0x43, 0x0E, 0x0C, 0x41, 0xC1, 0x88,
  0x38, 0x13, 0x07, 0x02, 0x60, 0xE0, 0x68, 0x1C, 0x05, 0x03, 0x80, 0xE0,
  0x70, 0x18, 0x0C, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0x40, 0x1B, 0x00, 0xC8,
  0x06, 0x60, 0x31, 0x01, 0x88, 0x0C, 0x60, 0x61, 0x03, 0x0C, 0x18, 0x20,
  0xC1, 0x86, 0x04, 0x30, 0x31, 0x80, 0x8C, 0x04, 0x60, 0x33, 0x00, 0x98,
  0x06, 0xC0, 0x16, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x03, 0x80,
  0x1F, 0xE0, 0x60, 0x61, 0x80, 0x46, 0x00, 0xCC, 0x00, 0x90, 0x01, 0x20,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x34,
  0x00, 0x68, 0x00, 0x98, 0x03, 0x10, 0x06, 0x30, 0x18, 0x30, 0x60, 0x3F,
  0x80, 0xFF, 0x10, 0x32, 0x03, 0x40, 0x28, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0x40, 0x68, 0x19, 0x0F, 0x3F, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x00, 0x03, 0xC0, 0x1F, 0xE0, 0x60, 0x61, 0x80, 0x46, 0x00, 0xCC, 0x00,
  0x90, 0x01, 0x60, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x34, 0x00, 0x68, 0x00, 0x98, 0x03, 0x10, 0x06, 0x30, 0x18,
  0x30, 0x60, 0x3F, 0x80, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0xFF, 0x08, 0x18, 0x80, 0xC8, 0x04, 0x80, 0x68, 0x06,
  0x80, 0x68, 0x06, 0x80, 0x68, 0x04, 0x80, 0x48, 0x0C, 0x83, 0x8F, 0xE0,
  0x84, 0x08, 0x60, 0x82, 0x08, 0x30, 0x81, 0x08, 0x18, 0x80, 0x88, 0x0C,
  0x80, 0x48, 0x06, 0x80, 0x68, 0x03, 0x0F, 0x87, 0xFD, 0x80, 0xE0, 0x0C,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0xD0, 0x33, 0xFC, 0x00, 0xFF, 0xF0, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x40, 0x0B, 0x00,
  0xC8, 0x04, 0x70, 0x60, 0xFE, 0x00, 0xC0, 0x0F, 0x00, 0x34, 0x00, 0x90,
  0x02, 0x60, 0x09, 0x80, 0x62, 0x01, 0x08, 0x04, 0x20, 0x10, 0xC0, 0xC1,
  0x03, 0x04, 0x08, 0x10, 0x20, 0x61, 0x81, 0x86, 0x02, 0x10, 0x08, 0x40,
  0x33, 0x00, 0xCC, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x78, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x40, 0x18, 0x03, 0x40, 0x18,
  0x03, 0x40, 0x1C, 0x02, 0x60, 0x14, 0x02, 0x60, 0x34, 0x02, 0x20, 0x24,
  0x06, 0x20, 0x24, 0x06, 0x20, 0x26, 0x04, 0x30, 0x26, 0x04, 0x30, 0x62,
  0x0C, 0x10, 0x62, 0x0C, 0x10, 0x42, 0x0C, 0x18, 0x43, 0x08, 0x18, 0x43,
  0x08, 0x08, 0xC1, 0x18, 0x08, 0xC1, 0x18, 0x08, 0x81, 0x10, 0x0C, 0x81,
  0x90, 0x0C, 0x81, 0x90, 0x05, 0x80, 0xB0, 0x05, 0x80, 0xB0, 0x05, 0x00,
  0xA0, 0x07, 0x00, 0xA0, 0x07, 0x00, 0xE0, 0x03, 0x00, 0x60, 0x60, 0x12,
  0x03, 0x30, 0x21, 0x06, 0x10, 0x41, 0x84, 0x08, 0xC0, 0xC8, 0x04, 0x80,
  0x58, 0x07, 0x00, 0x30, 0x03, 0x00, 0x70, 0x05, 0x00, 0x58, 0x0C, 0x80,
  0x88, 0x18, 0xC1, 0x04, 0x10, 0x43, 0x06, 0x20, 0x26, 0x03, 0x40, 0x3C,
  0x01, 0xC0, 0x34, 0x03, 0x40, 0x26, 0x06, 0x20, 0x62, 0x04, 0x30, 0x41,
  0x0C, 0x10, 0x81, 0x88, 0x09, 0x80, 0x90, 0x0D, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0xFF, 0xC0, 0x08, 0x03, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x02,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0xC0, 0x1F, 0xFC, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7F, 0xC0, 0x08, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0xFE, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFF,
  0x03, 0x00, 0x38, 0x01, 0x60, 0x19, 0x00, 0x8C, 0x0C, 0x20, 0x41, 0x86,
  0x0C, 0x20, 0x23, 0x01, 0x90, 0x05, 0x80, 0x38, 0x00, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0xE0, 0x83, 0x06, 0x0C, 0x10, 0x1F, 0x0C, 0x60, 0x0C, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x43, 0xF3, 0x05, 0x81, 0x40, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0xD0, 0x36, 0x14, 0xF9, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x8F, 0x17, 0x32, 0x83, 0x60,
  0x2C, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0xC0, 0x58, 0x1A, 0x86, 0x4F, 0x80, 0x0F,
  0x9C, 0xC8, 0x0C, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x23, 0xF0, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x1E, 0x26, 0x35,
  0x82, 0xA0, 0x3C, 0x07, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x68, 0x0D, 0x82, 0x9F,
  0x90, 0x1E, 0x07, 0x71, 0x82, 0x20, 0x6C, 0x05, 0x80, 0xA0, 0x1C, 0x03,
  0x80, 0x7F, 0xFE, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0xC1, 0x0F, 0xE0, 0x0F, 0x84, 0x06, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x3E, 0x7F, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x00, 0x1F, 0x27, 0x75, 0x83, 0xA0, 0x3C, 0x07, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x03, 0xC0,
  0x68, 0x14, 0x86, 0x9F, 0x90, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x0E, 0x03, 0x79, 0xC3, 0xE0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x8F, 0x2E, 0xEA, 0x0B, 0x03, 0xC0, 0xE0, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x5D, 0x00, 0x02, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x49, 0x00, 0x11, 0xC4, 0x00, 0x00, 0x02, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x11,
  0xB9, 0xC0, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x81,
  0xC0, 0xA0, 0xD0, 0xC8, 0x44, 0x62, 0x21, 0x30, 0xB8, 0x54, 0x32, 0x19,
  0x88, 0x44, 0x32, 0x09, 0x04, 0x83, 0x40, 0xA0, 0x70, 0x10, 0xFF, 0xFF,
  0xFF, 0xF0, 0x9E, 0x1E, 0x2C, 0xCC, 0xCC, 0x1A, 0x1B, 0x03, 0x02, 0x80,
  0xC0, 0xA0, 0x20, 0x38, 0x08, 0x0E, 0x02, 0x03, 0x80, 0x80, 0xE0, 0x20,
  0x38, 0x08, 0x0E, 0x02, 0x03, 0x80, 0x80, 0xE0, 0x20, 0x38, 0x08, 0x0E,
  0x02, 0x03, 0x80, 0x80, 0xE0, 0x20, 0x38, 0x08, 0x0E, 0x02, 0x03, 0x8F,
  0x2E, 0xEA, 0x0B, 0x03, 0xC0, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x1F, 0x03, 0x18, 0x60, 0xC4, 0x06, 0xC0, 0x6C, 0x02, 0x80, 0x28, 0x02,
  0x80, 0x28, 0x03, 0x80, 0x38, 0x03, 0x80, 0x28, 0x02, 0x80, 0x2C, 0x02,
  0x40, 0x66, 0x04, 0x30, 0xC1, 0xF8, 0x8F, 0x17, 0x32, 0x83, 0x60, 0x2C,
  0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0E, 0x03, 0xC0, 0x5C, 0x1A, 0xC6, 0x4F, 0x88, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x1F, 0x27,
  0x75, 0x82, 0xA0, 0x3C, 0x07, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x03, 0x40, 0x6C, 0x14, 0xC6,
  0x8F, 0x90, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x9F, 0x7A, 0x86, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x00, 0x1F, 0x0C, 0x66, 0x01,
  0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01,
  0x80, 0x20, 0x08, 0x03, 0x00, 0x80, 0x2C, 0x19, 0xFC, 0x20, 0x40, 0x81,
  0x07, 0xFF, 0xC8, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x1F, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xF0, 0x5C, 0x35, 0xF9, 0xC0, 0x38, 0x05, 0x01, 0xA0,
  0x36, 0x04, 0xC0, 0x88, 0x31, 0x06, 0x20, 0x86, 0x10, 0x46, 0x08, 0xC1,
  0x10, 0x32, 0x02, 0xC0, 0x58, 0x0A, 0x01, 0xC0, 0x18, 0x03, 0x00, 0xC0,
  0x60, 0x28, 0x0C, 0x05, 0x01, 0x81, 0xA0, 0x70, 0x36, 0x0F, 0x04, 0xC1,
  0x60, 0x88, 0x24, 0x11, 0x04, 0x86, 0x21, 0x90, 0xC6, 0x33, 0x10, 0x44,
  0x22, 0x08, 0x84, 0x41, 0x10, 0x98, 0x36, 0x12, 0x06, 0x83, 0x40, 0x50,
  0x28, 0x0A, 0x05, 0x01, 0x40, 0xE0, 0x38, 0x18, 0x02, 0x03, 0x00, 0xC0,
  0x70, 0x34, 0x09, 0x86, 0x21, 0x0C, 0x41, 0x30, 0x68, 0x0E, 0x03, 0x00,
  0xC0, 0x38, 0x12, 0x04, 0xC3, 0x10, 0x84, 0x61, 0x90, 0x2C, 0x0E, 0x01,
  0x40, 0x34, 0x03, 0x60, 0x26, 0x02, 0x20, 0x62, 0x06, 0x30, 0x43, 0x04,
  0x10, 0xC1, 0x08, 0x18, 0x81, 0x88, 0x09, 0x80, 0x90, 0x0D, 0x00, 0xD0,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x18, 0x0B, 0x00, 0xE0, 0x00, 0x7F, 0x7F, 0x03, 0x02,
  0x06, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x18, 0x10, 0x30, 0x20, 0x20, 0x60,
  0x40, 0x40, 0xC0, 0xFF, 0x07, 0x86, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0xC1, 0xC0, 0x70, 0x08,
  0x06, 0x03, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x60, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF0, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x60, 0x18, 0x07, 0x07, 0x06, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC1,
  0xC1, 0xC0, 0x38, 0x0B, 0xF0, 0x60, 0xFD, 0x00, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 26, 7, 3, -26 },
  { 8, 7, 9, 11, 2, -26 },
  { 16, 14, 26, 16, 1, -26 },
  { 62, 13, 30, 15, 1, -28 },
  { 111, 18, 27, 22, 2, -27 },
  { 172, 14, 27, 15, 1, -27 },
  { 220, 2, 9, 6, 2, -26 },
  { 223, 7, 32, 10, 2, -26 },
  { 251, 7, 32, 10, 1, -26 },
  { 279, 9, 10, 13, 2, -28 },
  { 291, 13, 17, 15, 1, -22 },
  { 319, 4, 9, 7, 1, -4 },
  { 324, 8, 2, 10, 1, -11 },
  { 326, 3, 3, 7, 2, -3 },
  { 328, 11, 26, 12, 1, -26 },
  { 364, 11, 27, 15, 2, -27 },
  { 402, 6, 26, 15, 3, -26 },
  { 422, 12, 27, 15, 1, -27 },
  { 463, 12, 27, 15, 1, -27 },
  { 504, 13, 27, 15, 1, -27 },
  { 548, 11, 26, 15, 2, -26 },
  { 584, 11, 27, 15, 2, -27 },
  { 622, 11, 26, 15, 2, -26 },
  { 658, 13, 27, 15, 1, -27 },
  { 702, 12, 27, 15, 1, -27 },
  { 743, 3, 20, 7, 2, -20 },
  { 751, 4, 25, 7, 1, -20 },
  { 764, 13, 16, 15, 1, -21 },
  { 790, 13, 10, 15, 1, -18 },
  { 807, 13, 16, 15, 1, -21 },
  { 833, 8, 27, 10, 1, -27 },
  { 860, 19, 30, 23, 2, -27 },
  { 932, 15, 26, 15, 0, -26 },
  { 981, 12, 26, 16, 3, -26 },
  { 1020, 13, 27, 16, 2, -27 },
  { 1064, 13, 26, 18, 3, -26 },
  { 1107, 10, 26, 14, 3, -26 },
  { 1140, 10, 26, 13, 3, -26 },
  { 1173, 15, 27, 19, 2, -27 },
  { 1224, 13, 26, 18, 3, -26 },
  { 1267, 6, 26, 9, 1, -26 },
  { 1287, 6, 33, 7, -2, -26 },
  { 1312, 12, 26, 15, 3, -26 },
  { 1351, 9, 26, 13, 3, -26 },
  { 1381, 19, 26, 25, 3, -26 },
  { 1443, 13, 26, 19, 3, -26 },
  { 1486, 15, 27, 19, 2, -27 },
  { 1537, 11, 26, 15, 3, -26 },
  { 1573, 15, 33, 19, 2, -27 },
  { 1635, 12, 26, 15, 3, -26 },
  { 1674, 11, 27, 15, 2, -27 },
  { 1712, 12, 26, 13, 0, -26 },
  { 1751, 13, 26, 18, 3, -26 },
  { 1794, 14, 26, 14, 0, -26 },
  { 1840, 24, 26, 25, 0, -26 },
  { 1918, 12, 26, 13, 0, -26 },
  { 1957, 12, 26, 12, 0, -26 },
  { 1996, 11, 26, 12, 1, -26 },
  { 2032, 7, 32, 11, 3, -26 },
  { 2060, 11, 26, 12, 1, -26 },
  { 2096, 7, 32, 11, 1, -26 },
  { 2124, 13, 13, 15, 1, -26 },
  { 2146, 15, 2, 15, 0, 3 },
  { 2150, 6, 6, 9, 1, -28 },
  { 2155, 10, 20, 14, 1, -20 },
  { 2180, 11, 28, 16, 3, -28 },
  { 2219, 9, 20, 12, 2, -20 },
  { 2242, 11, 28, 16, 2, -28 },
  { 2281, 11, 20, 14, 2, -20 },
  { 2309, 9, 28, 8, 0, -28 },
  { 2341, 11, 29, 16, 2, -20 },
  { 2381, 10, 28, 15, 3, -28 },
  { 2416, 3, 27, 7, 2, -27 },
  { 2427, 5, 36, 7, 0, -27 },
  { 2450, 9, 28, 13, 3, -28 },
  { 2482, 1, 28, 7, 3, -28 },
  { 2486, 18, 20, 23, 3, -20 },
  { 2531, 10, 20, 15, 3, -20 },
  { 2556, 12, 20, 15, 2, -20 },
  { 2586, 11, 29, 16, 3, -20 },
  { 2626, 11, 29, 16, 2, -20 },
  { 2666, 7, 20, 10, 3, -20 },
  { 2684, 10, 20, 12, 1, -20 },
  { 2709, 7, 24, 8, 1, -24 },
  { 2730, 10, 20, 15, 3, -20 },
  { 2755, 11, 20, 11, 0, -20 },
  { 2783, 19, 20, 20, 0, -20 },
  { 2831, 10, 20, 12, 1, -20 },
  { 2856, 12, 29, 12, 0, -20 },
  { 2900, 8, 20, 10, 1, -20 },
  { 2920, 9, 32, 13, 2, -26 },
  { 2956, 2, 37, 14, 6, -28 },
  { 2966, 9, 32, 13, 2, -26 },
  { 3002, 13, 4, 15, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight37pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT37PT7B_H_
