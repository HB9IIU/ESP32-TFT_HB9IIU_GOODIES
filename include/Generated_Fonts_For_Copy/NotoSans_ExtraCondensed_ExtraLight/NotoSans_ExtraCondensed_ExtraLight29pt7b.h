#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT29PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFA, 0xAA, 0x03, 0xC0, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x08, 0x82, 0x10, 0x42, 0x08, 0x41, 0x08, 0x21, 0x3F, 0xF8, 0x88, 0x11,
  0x02, 0x20, 0x84, 0x10, 0x82, 0x11, 0xFF, 0x88, 0x41, 0x10, 0x22, 0x04,
  0x40, 0x88, 0x21, 0x04, 0x20, 0x08, 0x02, 0x03, 0xF9, 0x22, 0x88, 0x22,
  0x08, 0x82, 0x20, 0x88, 0x12, 0x03, 0x80, 0x30, 0x0B, 0x02, 0x60, 0x88,
  0x21, 0x08, 0x42, 0x10, 0x8A, 0x26, 0x7E, 0x02, 0x00, 0x80, 0x20, 0x38,
  0x20, 0x90, 0x41, 0x10, 0x84, 0x22, 0x08, 0x44, 0x10, 0x88, 0x21, 0x20,
  0x42, 0x40, 0x84, 0x99, 0x0A, 0x49, 0x14, 0x92, 0x4A, 0x13, 0xA4, 0x20,
  0x48, 0x40, 0x90, 0x82, 0x21, 0x04, 0x42, 0x08, 0x84, 0x21, 0x10, 0x41,
  0x20, 0x83, 0xC0, 0x1C, 0x04, 0xC0, 0x88, 0x31, 0x04, 0x20, 0x44, 0x08,
  0x81, 0x20, 0x14, 0x03, 0x00, 0xE0, 0x34, 0x04, 0x45, 0x08, 0xA0, 0x94,
  0x1E, 0x81, 0x90, 0x12, 0x06, 0x21, 0x23, 0xC6, 0xFF, 0x0C, 0x21, 0x04,
  0x20, 0x86, 0x10, 0x41, 0x04, 0x30, 0xC3, 0x04, 0x10, 0x41, 0x04, 0x18,
  0x20, 0x81, 0x04, 0x08, 0x10, 0x82, 0x08, 0x43, 0x08, 0x41, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x46, 0x21, 0x18, 0x8C, 0x44, 0x00, 0x08, 0x08,
  0x89, 0x6E, 0x18, 0x14, 0x24, 0x42, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x0F, 0xFC, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x6D,
  0x25, 0x20, 0xFC, 0xF0, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x30, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80,
  0x80, 0x1E, 0x19, 0x88, 0x48, 0x24, 0x0A, 0x05, 0x03, 0x81, 0xC0, 0xC0,
  0x60, 0x30, 0x18, 0x0E, 0x07, 0x02, 0x81, 0x40, 0xA0, 0xD8, 0x44, 0x61,
  0xE0, 0x08, 0xCA, 0x98, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x80, 0x3E, 0x21, 0x80, 0x40, 0x30, 0x08, 0x04, 0x02, 0x03,
  0x01, 0x00, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x30, 0x10, 0x10, 0x10,
  0x08, 0x0F, 0xF8, 0x3C, 0x61, 0xA0, 0x40, 0x10, 0x08, 0x04, 0x02, 0x02,
  0x01, 0x03, 0x0F, 0x00, 0x60, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x70, 0x6F, 0xE0, 0x01, 0x80, 0x30, 0x0A, 0x01, 0x40, 0x28, 0x09, 0x01,
  0x20, 0x44, 0x08, 0x82, 0x10, 0x42, 0x10, 0x42, 0x08, 0x81, 0x10, 0x27,
  0xFF, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x7F, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0x00, 0x40, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x70, 0x6F, 0xE0, 0x0F, 0x0C, 0x0C, 0x04,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x4E, 0x79, 0xB8, 0x78, 0x1C, 0x0E, 0x07,
  0x02, 0x81, 0x40, 0xA0, 0x50, 0x24, 0x21, 0xE0, 0xFF, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40,
  0x20, 0x10, 0x10, 0x08, 0x04, 0x06, 0x02, 0x00, 0x1E, 0x08, 0x44, 0x09,
  0x02, 0x40, 0x90, 0x24, 0x09, 0x84, 0x23, 0x07, 0x01, 0xC0, 0x88, 0x41,
  0x10, 0x28, 0x0A, 0x03, 0x80, 0xE0, 0x2C, 0x09, 0x86, 0x3F, 0x00, 0x1C,
  0x11, 0x90, 0x48, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x50, 0x6C,
  0x53, 0xC8, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0xC0, 0xC7, 0xC0, 0xF0,
  0x00, 0x00, 0x3C, 0x6C, 0x00, 0x00, 0x00, 0x06, 0xD2, 0x52, 0x00, 0x00,
  0xC0, 0xE0, 0x60, 0x60, 0x60, 0x20, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x18, 0x18, 0x08, 0x0C, 0x0C,
  0x02, 0x00, 0x79, 0x8C, 0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x18, 0x20,
  0x81, 0x02, 0x04, 0x08, 0x00, 0x00, 0x01, 0x83, 0x00, 0x07, 0x80, 0x61,
  0x83, 0x01, 0x08, 0x02, 0x40, 0x09, 0x00, 0x18, 0x3C, 0x61, 0x11, 0x88,
  0x46, 0x21, 0x18, 0x84, 0x62, 0x31, 0x88, 0x86, 0x22, 0x18, 0x88, 0x62,
  0x31, 0x8D, 0x4A, 0x18, 0xC8, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x8C, 0x00, 0xC0, 0x04, 0x00, 0xC0, 0x28, 0x05, 0x00, 0xA0, 0x12, 0x06,
  0x40, 0x88, 0x11, 0x02, 0x10, 0x42, 0x10, 0x43, 0xF8, 0x41, 0x88, 0x12,
  0x02, 0x40, 0x48, 0x0D, 0x00, 0xC0, 0x18, 0x02, 0xFC, 0x20, 0xC8, 0x1A,
  0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x81, 0x21, 0x8F, 0xE2, 0x06, 0x80,
  0xA0, 0x28, 0x0E, 0x03, 0x80, 0xE0, 0x28, 0x0A, 0x04, 0xFE, 0x00, 0x0F,
  0xCC, 0x22, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC1,
  0x1F, 0x80, 0xFC, 0x21, 0xC8, 0x1A, 0x02, 0x80, 0xE0, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x28, 0x1A, 0x0C, 0xFC, 0x00, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x0F,
  0xC1, 0x82, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x1F, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0,
  0x14, 0x01, 0x60, 0x13, 0x01, 0x0F, 0xE0, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1F, 0xFE, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0xF9, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x4F, 0x80,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x1E, 0x80, 0xC0, 0xA0, 0x50, 0x48, 0x64, 0x22, 0x21, 0x10, 0x90, 0x58,
  0x2C, 0x19, 0x0C, 0x84, 0x22, 0x11, 0x04, 0x82, 0x40, 0xA0, 0x50, 0x38,
  0x08, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1D, 0x00, 0x7A, 0x00, 0xB4, 0x01, 0x64, 0x02, 0xC8,
  0x09, 0x90, 0x13, 0x10, 0x26, 0x20, 0x8C, 0x41, 0x18, 0x82, 0x30, 0x8C,
  0x61, 0x10, 0xC2, 0x21, 0x82, 0x43, 0x05, 0x06, 0x0A, 0x0C, 0x0C, 0x18,
  0x10, 0x20, 0xC0, 0x38, 0x07, 0x80, 0xD0, 0x1A, 0x03, 0x20, 0x64, 0x0C,
  0x41, 0x88, 0x31, 0x86, 0x10, 0xC2, 0x18, 0x23, 0x04, 0x60, 0x4C, 0x09,
  0x80, 0xB0, 0x16, 0x03, 0xC0, 0x38, 0x06, 0x1F, 0x03, 0x18, 0x40, 0x44,
  0x04, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x38,
  0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x24, 0x06, 0x40, 0x42,
  0x08, 0x1F, 0x00, 0xF8, 0x43, 0x20, 0x50, 0x28, 0x0C, 0x06, 0x03, 0x01,
  0x81, 0xC0, 0xA0, 0xDF, 0xC8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x00, 0x1F, 0x03, 0x18, 0x60, 0x44, 0x04, 0x80, 0x28, 0x02,
  0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x38, 0x03, 0x80, 0x28, 0x02,
  0x80, 0x28, 0x02, 0x80, 0x24, 0x06, 0x40, 0x42, 0x08, 0x1F, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0xF8, 0x23, 0x88, 0x12, 0x06, 0x80,
  0xA0, 0x28, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x63, 0xE0, 0x8C, 0x21, 0x08,
  0x62, 0x08, 0x82, 0x20, 0x48, 0x12, 0x02, 0x80, 0xC0, 0x1F, 0x10, 0x50,
  0x08, 0x0C, 0x04, 0x03, 0x00, 0x80, 0x60, 0x18, 0x03, 0x00, 0x40, 0x10,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x70, 0x6F, 0xE0, 0xFF, 0xC3, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x0D,
  0x82, 0x3F, 0x00, 0x80, 0x30, 0x05, 0x01, 0xA0, 0x24, 0x04, 0x80, 0x98,
  0x31, 0x04, 0x20, 0x84, 0x10, 0x82, 0x08, 0x81, 0x10, 0x22, 0x04, 0x40,
  0x50, 0x0A, 0x01, 0x40, 0x28, 0x05, 0x00, 0x40, 0x80, 0x40, 0x38, 0x08,
  0x05, 0x01, 0x81, 0xA0, 0x50, 0x24, 0x0A, 0x04, 0x81, 0x40, 0x98, 0x28,
  0x11, 0x05, 0x84, 0x21, 0x10, 0x84, 0x22, 0x10, 0x84, 0x42, 0x08, 0x88,
  0xC1, 0x11, 0x90, 0x24, 0x12, 0x04, 0x82, 0x40, 0x90, 0x48, 0x0A, 0x0B,
  0x01, 0x41, 0x40, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x40, 0xD8,
  0x22, 0x08, 0x84, 0x31, 0x04, 0x41, 0x20, 0x28, 0x0E, 0x03, 0x00, 0xC0,
  0x30, 0x0A, 0x04, 0x81, 0x20, 0xC4, 0x21, 0x08, 0x64, 0x09, 0x02, 0xC0,
  0xC0, 0x80, 0xF0, 0x24, 0x09, 0x06, 0x61, 0x08, 0x42, 0x30, 0xC8, 0x12,
  0x05, 0x81, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x00, 0xFF, 0x01, 0x02, 0x02, 0x06, 0x04, 0x04, 0x0C,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x60, 0x40, 0x40, 0xC0, 0x80,
  0xFF, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0xF0, 0x80, 0x80, 0xC0,
  0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x0C, 0x04,
  0x04, 0x02, 0x02, 0x02, 0x01, 0x01, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x07, 0xF0, 0x02, 0x00, 0xC0, 0x1C, 0x04, 0x81, 0x90, 0x21, 0x0C, 0x21,
  0x02, 0x60, 0x58, 0x04, 0xFF, 0xF0, 0xC3, 0x08, 0x30, 0x08, 0x66, 0x03,
  0x01, 0x01, 0x01, 0x01, 0x0F, 0x31, 0x41, 0x81, 0x81, 0x81, 0x83, 0x43,
  0x7D, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x21, 0x6E, 0xC1, 0x60,
  0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x2A,
  0x15, 0xF0, 0x06, 0x3B, 0x20, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80,
  0xC0, 0x40, 0x40, 0x40, 0x20, 0x1F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x8C, 0xFB, 0x61, 0xD0, 0x34, 0x0F, 0x03, 0xC0, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0xF0, 0x34, 0x0D, 0x05, 0x21, 0x4F, 0x90, 0x08, 0x19,
  0x18, 0x48, 0x24, 0x0E, 0x06, 0x03, 0xFF, 0x80, 0x40, 0x30, 0x08, 0x04,
  0x02, 0x00, 0x82, 0x3E, 0x1E, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x7E, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x00,
  0x0C, 0x19, 0x58, 0x68, 0x14, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x28, 0x14, 0x0A, 0x04, 0x86, 0x7D, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0A,
  0x18, 0xF8, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x8C, 0xB6, 0xC3, 0xC1,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xB0, 0x0A, 0xAA, 0xAA, 0xAA, 0x80, 0x23, 0x00, 0x00, 0x22, 0x22, 0x22,
  0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x2C, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x82, 0x84, 0x8C, 0x88, 0x90, 0x90, 0xB0, 0xD8, 0xC8,
  0x88, 0x84, 0x84, 0x82, 0x82, 0x83, 0xFF, 0xFF, 0xFC, 0x08, 0x22, 0x9B,
  0x6C, 0x28, 0xF0, 0xC1, 0x83, 0x06, 0x04, 0x18, 0x10, 0x60, 0x41, 0x81,
  0x06, 0x04, 0x18, 0x10, 0x60, 0x41, 0x81, 0x06, 0x04, 0x18, 0x10, 0x60,
  0x41, 0x08, 0xB6, 0xC3, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x0C, 0x0C, 0xC6, 0x19, 0x02, 0x40, 0xB0,
  0x28, 0x0E, 0x01, 0x80, 0x60, 0x3C, 0x0D, 0x02, 0x40, 0x90, 0x22, 0x10,
  0x7C, 0x08, 0x5B, 0xB0, 0x58, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x1C, 0x0E, 0x0A, 0x85, 0x3C, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x00, 0x0C, 0x1F, 0x58, 0x68, 0x14, 0x0E, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x28, 0x14, 0x0A, 0x04, 0x86, 0x7D, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x0E, 0xEA, 0x30, 0xC2, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x18, 0xCF, 0x04, 0x08, 0x10, 0x10, 0x18,
  0x18, 0x08, 0x08, 0x10, 0x20, 0x61, 0xFE, 0x42, 0x10, 0x8F, 0xA1, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x0E, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0x45, 0x7D, 0x81, 0xA0,
  0x90, 0x48, 0x24, 0x11, 0x10, 0x88, 0x44, 0x22, 0x0A, 0x05, 0x02, 0x81,
  0x40, 0xC0, 0x20, 0xC1, 0x82, 0x83, 0x05, 0x06, 0x12, 0x14, 0x24, 0x28,
  0x44, 0x48, 0x88, 0x91, 0x13, 0x24, 0x24, 0x48, 0x68, 0x90, 0x50, 0xA0,
  0xA1, 0x41, 0x83, 0x03, 0x06, 0x02, 0x0C, 0x00, 0x41, 0x90, 0x88, 0xC2,
  0x41, 0x20, 0xA0, 0x30, 0x18, 0x1C, 0x0A, 0x04, 0x84, 0x42, 0x12, 0x0B,
  0x02, 0x40, 0xA0, 0x50, 0x64, 0x22, 0x11, 0x08, 0x8C, 0x24, 0x12, 0x09,
  0x05, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x03,
  0x07, 0x00, 0xFC, 0x30, 0x82, 0x18, 0x41, 0x08, 0x20, 0x84, 0x10, 0xC2,
  0x0F, 0xC0, 0x03, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0xE0, 0x60, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x18, 0x08, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x30, 0x18, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x07, 0x06, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x70, 0x80, 0x20, 0x37,
  0x18, 0x78,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 21, 6, 2, -21 },
  { 7, 5, 8, 9, 2, -21 },
  { 12, 11, 21, 13, 1, -21 },
  { 41, 10, 24, 12, 1, -22 },
  { 71, 15, 21, 17, 1, -21 },
  { 111, 11, 21, 12, 1, -21 },
  { 140, 1, 8, 5, 2, -21 },
  { 141, 6, 26, 8, 1, -21 },
  { 161, 5, 26, 8, 1, -21 },
  { 178, 8, 8, 10, 1, -22 },
  { 186, 10, 13, 12, 1, -17 },
  { 203, 3, 7, 5, 1, -3 },
  { 206, 6, 1, 8, 1, -8 },
  { 207, 2, 2, 5, 2, -2 },
  { 208, 8, 21, 10, 1, -21 },
  { 229, 9, 21, 12, 1, -21 },
  { 253, 5, 21, 12, 2, -21 },
  { 267, 9, 21, 12, 1, -21 },
  { 291, 9, 21, 12, 1, -21 },
  { 315, 11, 21, 12, 0, -21 },
  { 344, 9, 21, 12, 1, -21 },
  { 368, 9, 21, 12, 1, -21 },
  { 392, 9, 21, 12, 1, -21 },
  { 416, 10, 21, 12, 1, -21 },
  { 443, 9, 21, 12, 1, -21 },
  { 467, 2, 15, 6, 2, -15 },
  { 471, 3, 19, 5, 1, -15 },
  { 479, 10, 12, 12, 1, -16 },
  { 494, 10, 7, 12, 1, -14 },
  { 503, 10, 12, 12, 1, -16 },
  { 518, 7, 21, 8, 0, -21 },
  { 537, 14, 24, 18, 2, -21 },
  { 579, 11, 21, 11, 0, -21 },
  { 608, 10, 21, 13, 2, -21 },
  { 635, 10, 21, 12, 2, -21 },
  { 662, 10, 21, 14, 2, -21 },
  { 689, 8, 21, 11, 2, -21 },
  { 710, 8, 21, 10, 2, -21 },
  { 731, 12, 21, 15, 2, -21 },
  { 763, 10, 21, 14, 2, -21 },
  { 790, 5, 21, 7, 1, -21 },
  { 804, 4, 26, 6, -1, -21 },
  { 817, 9, 21, 11, 2, -21 },
  { 841, 8, 21, 10, 2, -21 },
  { 862, 15, 21, 19, 2, -21 },
  { 902, 11, 21, 15, 2, -21 },
  { 931, 12, 21, 15, 2, -21 },
  { 963, 9, 21, 12, 2, -21 },
  { 987, 12, 26, 15, 2, -21 },
  { 1026, 10, 21, 12, 2, -21 },
  { 1053, 9, 21, 11, 1, -21 },
  { 1077, 10, 21, 10, 0, -21 },
  { 1104, 10, 21, 14, 2, -21 },
  { 1131, 11, 21, 11, 0, -21 },
  { 1160, 19, 21, 19, 0, -21 },
  { 1210, 10, 21, 10, 0, -21 },
  { 1237, 10, 21, 10, 0, -21 },
  { 1264, 8, 21, 10, 1, -21 },
  { 1285, 6, 26, 9, 2, -21 },
  { 1305, 8, 21, 10, 1, -21 },
  { 1326, 6, 26, 9, 1, -21 },
  { 1346, 11, 10, 12, 0, -21 },
  { 1360, 12, 1, 12, 0, 3 },
  { 1362, 5, 4, 7, 1, -22 },
  { 1365, 8, 16, 11, 1, -16 },
  { 1381, 9, 22, 13, 2, -22 },
  { 1406, 8, 16, 9, 1, -16 },
  { 1422, 10, 22, 13, 1, -22 },
  { 1450, 9, 16, 11, 1, -16 },
  { 1468, 7, 22, 6, 0, -22 },
  { 1488, 9, 23, 12, 1, -16 },
  { 1514, 8, 22, 12, 2, -22 },
  { 1536, 2, 21, 5, 2, -21 },
  { 1542, 4, 28, 5, 0, -21 },
  { 1556, 8, 22, 10, 2, -22 },
  { 1578, 1, 22, 5, 2, -22 },
  { 1581, 14, 16, 18, 2, -16 },
  { 1609, 8, 16, 12, 2, -16 },
  { 1625, 10, 16, 12, 1, -16 },
  { 1645, 9, 23, 13, 2, -16 },
  { 1671, 9, 23, 12, 1, -16 },
  { 1697, 6, 16, 8, 2, -16 },
  { 1709, 7, 16, 9, 1, -16 },
  { 1723, 5, 19, 6, 1, -19 },
  { 1735, 8, 15, 12, 2, -15 },
  { 1750, 9, 15, 9, 0, -15 },
  { 1767, 15, 15, 15, 0, -15 },
  { 1796, 9, 15, 9, 0, -15 },
  { 1813, 9, 22, 9, 0, -15 },
  { 1838, 6, 15, 8, 1, -15 },
  { 1850, 8, 26, 10, 1, -21 },
  { 1876, 1, 29, 11, 5, -22 },
  { 1880, 8, 26, 10, 1, -21 },
  { 1906, 10, 3, 12, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight29pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT29PT7B_H_
