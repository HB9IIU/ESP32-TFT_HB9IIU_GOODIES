#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT25PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xC0, 0x99, 0x99, 0x99, 0x90, 0x08, 0x82, 0x20, 0x88,
  0x24, 0x11, 0x1F, 0xF1, 0x10, 0x44, 0x11, 0x04, 0x41, 0x13, 0xFF, 0x12,
  0x08, 0x82, 0x20, 0x88, 0x22, 0x08, 0x80, 0x10, 0x10, 0x77, 0x90, 0x90,
  0x90, 0x90, 0x90, 0x50, 0x30, 0x1C, 0x12, 0x11, 0x11, 0x11, 0x11, 0x13,
  0xFC, 0x10, 0x10, 0x70, 0x42, 0x44, 0x22, 0x21, 0x11, 0x08, 0x90, 0x44,
  0x82, 0x24, 0x11, 0x4C, 0x8A, 0x92, 0x54, 0x9D, 0x22, 0x09, 0x10, 0x48,
  0x84, 0x44, 0x22, 0x21, 0x12, 0x10, 0x90, 0x83, 0x80, 0x38, 0x22, 0x11,
  0x08, 0x84, 0x42, 0x20, 0xA0, 0x50, 0x30, 0x28, 0x12, 0x31, 0x18, 0x54,
  0x1A, 0x0D, 0x06, 0x85, 0x3C, 0x40, 0xFE, 0x08, 0x88, 0x44, 0x21, 0x08,
  0x84, 0x21, 0x08, 0x41, 0x08, 0x42, 0x08, 0x41, 0x0C, 0x84, 0x42, 0x21,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x12, 0x26, 0x48, 0x10, 0x23, 0x59, 0xC2,
  0x89, 0x11, 0x00, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x55, 0xA0, 0xF8, 0xC0, 0x02, 0x04, 0x10, 0x20, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x40, 0x81, 0x00, 0x3C,
  0x62, 0x42, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x42, 0x42, 0x62, 0x3C, 0x13, 0x59, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x7C, 0x86, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0xFF, 0x7C, 0x86, 0x02, 0x01,
  0x01, 0x02, 0x02, 0x04, 0x38, 0x0C, 0x02, 0x01, 0x01, 0x01, 0x01, 0x02,
  0x02, 0xFC, 0x03, 0x00, 0xC0, 0x50, 0x14, 0x09, 0x02, 0x41, 0x10, 0x44,
  0x21, 0x08, 0x44, 0x11, 0x04, 0x41, 0x3F, 0xF0, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x7E, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0xB8, 0x46, 0x02, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x02, 0x82, 0xFC, 0x1E, 0x20, 0x60, 0x40, 0x40,
  0x40, 0x80, 0x9C, 0xA2, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x41, 0x41, 0x42,
  0x3C, 0xFF, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x3C, 0x42, 0x41, 0x81, 0x81,
  0x41, 0x42, 0x24, 0x18, 0x24, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42,
  0x3C, 0x3C, 0x46, 0x82, 0x82, 0x81, 0x81, 0x81, 0x81, 0x83, 0x43, 0x3D,
  0x01, 0x02, 0x02, 0x02, 0x06, 0x04, 0x78, 0xC0, 0x18, 0x50, 0x00, 0x05,
  0x5A, 0x01, 0x06, 0x08, 0x30, 0xC0, 0xC0, 0x20, 0x18, 0x06, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x18, 0x04, 0x03, 0x03, 0x04,
  0x18, 0x60, 0x80, 0x7A, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x42, 0x08,
  0x20, 0x80, 0x00, 0x20, 0x80, 0x07, 0x80, 0xC3, 0x08, 0x08, 0x40, 0x24,
  0x01, 0x21, 0xC5, 0x12, 0x31, 0x11, 0x88, 0x8C, 0x44, 0x62, 0x23, 0x11,
  0x18, 0x88, 0xC4, 0xC9, 0x1D, 0xC8, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x1F, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x50, 0x12, 0x04, 0x81, 0x20, 0x88,
  0x21, 0x08, 0x43, 0xF0, 0x84, 0x41, 0x10, 0x24, 0x09, 0x02, 0x80, 0xA0,
  0x10, 0xFC, 0x86, 0x82, 0x81, 0x81, 0x81, 0x82, 0x82, 0xFC, 0x86, 0x83,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x0F, 0x98, 0x08, 0x08, 0x04,
  0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00,
  0x40, 0x30, 0x07, 0xC0, 0xF8, 0x43, 0x20, 0x90, 0x28, 0x14, 0x0A, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x14, 0x0A, 0x05, 0x04, 0x86, 0x7C,
  0x00, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFE, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x83, 0xF0, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0xF8, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x00, 0x0F, 0xC2, 0x0C, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x7E, 0x00, 0xC0, 0x14, 0x02, 0x80,
  0x50, 0x09, 0x01, 0x30, 0x21, 0xFC, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xF4, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x4F, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1E, 0x83, 0x82, 0x84, 0x84,
  0x88, 0x90, 0x90, 0xA0, 0xA0, 0xD0, 0x90, 0x88, 0x88, 0x84, 0x84, 0x82,
  0x82, 0x81, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x83, 0xF0, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x5A, 0x02,
  0xD0, 0x16, 0x81, 0x32, 0x09, 0x90, 0x4C, 0x84, 0x64, 0x23, 0x11, 0x18,
  0x88, 0xC4, 0x86, 0x14, 0x30, 0xA1, 0x86, 0x0C, 0x10, 0x40, 0x80, 0xE0,
  0x70, 0x34, 0x1A, 0x0D, 0x06, 0x43, 0x21, 0x88, 0xC4, 0x61, 0x30, 0x98,
  0x4C, 0x16, 0x0B, 0x03, 0x81, 0xC0, 0x40, 0x1F, 0x04, 0x11, 0x82, 0x20,
  0x24, 0x04, 0x80, 0xA0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x14,
  0x04, 0x80, 0x90, 0x13, 0x06, 0x20, 0x83, 0xE0, 0xF9, 0x0A, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x87, 0x3B, 0x84, 0x08, 0x10, 0x20, 0x40, 0x81, 0x00,
  0x1F, 0x04, 0x11, 0x82, 0x20, 0x24, 0x04, 0x80, 0xA0, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x14, 0x04, 0x80, 0x90, 0x13, 0x06, 0x20, 0x83,
  0xE0, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0xF0, 0x84, 0x82, 0x82, 0x82,
  0x82, 0x82, 0x82, 0x84, 0xF8, 0x98, 0x88, 0x88, 0x84, 0x84, 0x82, 0x82,
  0x81, 0x3F, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x40, 0x60, 0x30, 0x0C, 0x02,
  0x02, 0x01, 0x01, 0x01, 0x02, 0x02, 0xFC, 0xFF, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x05, 0x02, 0x43, 0x1F, 0x00, 0x80, 0xE0,
  0x24, 0x09, 0x02, 0x40, 0x90, 0x44, 0x10, 0x84, 0x21, 0x08, 0x82, 0x20,
  0x48, 0x12, 0x05, 0x01, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x81, 0x81,
  0x81, 0x41, 0x81, 0x41, 0x81, 0x41, 0x42, 0x41, 0x42, 0x42, 0x42, 0x22,
  0x42, 0x22, 0x42, 0x22, 0x24, 0x22, 0x24, 0x14, 0x24, 0x14, 0x24, 0x14,
  0x24, 0x14, 0x18, 0x14, 0x18, 0x08, 0x18, 0x08, 0x18, 0x41, 0x41, 0x22,
  0x22, 0x22, 0x14, 0x14, 0x14, 0x08, 0x08, 0x14, 0x14, 0x24, 0x22, 0x22,
  0x41, 0x41, 0x81, 0x81, 0x81, 0x41, 0x42, 0x42, 0x22, 0x24, 0x24, 0x14,
  0x18, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFE, 0x08, 0x10,
  0x20, 0x81, 0x02, 0x08, 0x10, 0x60, 0x81, 0x04, 0x08, 0x10, 0x40, 0x81,
  0xFC, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x7C, 0x81, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20,
  0x40, 0x40, 0x81, 0x01, 0x02, 0x04, 0x04, 0xF8, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xFC, 0x04, 0x03, 0x00,
  0xA0, 0x48, 0x11, 0x08, 0x42, 0x09, 0x02, 0xC0, 0xC0, 0xFF, 0xC0, 0x84,
  0x21, 0x7C, 0x08, 0x08, 0x10, 0x23, 0xD8, 0xE1, 0x83, 0x06, 0x1C, 0x37,
  0xA0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x90, 0xAC, 0xC2, 0x82, 0x82, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0xC2, 0xBC, 0x3E, 0x81, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x01, 0x02, 0x03, 0xC0, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x3D, 0x43, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x41, 0x43, 0x3D, 0x3C, 0x42, 0x42, 0x82, 0x81, 0xFF, 0x80, 0x80, 0x80,
  0x80, 0x40, 0x41, 0x3E, 0x1C, 0x82, 0x08, 0x20, 0x8F, 0x88, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x00, 0x3D, 0x43, 0x41, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01,
  0x82, 0x7C, 0x81, 0x02, 0x04, 0x08, 0x12, 0x2B, 0x62, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0xC7, 0xFF, 0xC0, 0x24, 0x00,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x4E, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x62, 0x92, 0x4A, 0x28, 0xD2, 0x48, 0xA2, 0x8A, 0x18, 0x40, 0xFF, 0xFF,
  0xE0, 0xF9, 0xE8, 0x61, 0x86, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x18,
  0x41, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x10, 0xBD, 0x8A, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x3E, 0x42, 0x41,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42, 0x3C, 0xBC, 0xC2,
  0x82, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0xC2, 0xBC, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x3D, 0x43, 0x41, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x41, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0xBE, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x00, 0x7E, 0x08, 0x20,
  0x81, 0x81, 0x02, 0x04, 0x10, 0x61, 0xF8, 0x21, 0x09, 0xF2, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x87, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x1C, 0x37, 0xA0, 0x83, 0x42, 0x42, 0x42, 0x44, 0x44, 0x24,
  0x24, 0x24, 0x28, 0x18, 0x18, 0x18, 0x82, 0x0A, 0x18, 0x50, 0xC4, 0x8A,
  0x24, 0x51, 0x22, 0x88, 0x92, 0x45, 0x14, 0x28, 0xA1, 0x45, 0x06, 0x18,
  0x30, 0x81, 0x04, 0x00, 0x43, 0x42, 0x24, 0x24, 0x14, 0x18, 0x18, 0x18,
  0x24, 0x24, 0x22, 0x42, 0xC3, 0xC1, 0x41, 0x42, 0x42, 0x22, 0x22, 0x24,
  0x24, 0x14, 0x14, 0x18, 0x18, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0xE0,
  0xF8, 0x44, 0x21, 0x10, 0x88, 0x42, 0x21, 0x0F, 0x80, 0x0E, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x61, 0x87, 0x02, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0xC1, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x40, 0xC3, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x33, 0x80, 0x71, 0x8F,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 18, 5, 2, -18 },
  { 4, 4, 7, 8, 2, -18 },
  { 8, 10, 18, 11, 0, -18 },
  { 31, 8, 20, 10, 1, -19 },
  { 51, 13, 18, 15, 1, -18 },
  { 81, 9, 18, 10, 1, -18 },
  { 102, 1, 7, 4, 2, -18 },
  { 103, 5, 22, 7, 1, -18 },
  { 117, 4, 22, 7, 1, -18 },
  { 128, 7, 7, 9, 1, -19 },
  { 135, 8, 12, 10, 1, -15 },
  { 147, 2, 6, 5, 1, -3 },
  { 149, 5, 1, 7, 1, -7 },
  { 150, 1, 2, 5, 2, -2 },
  { 151, 7, 18, 8, 1, -18 },
  { 167, 8, 18, 10, 1, -18 },
  { 185, 4, 18, 10, 2, -18 },
  { 194, 8, 18, 10, 1, -18 },
  { 212, 8, 18, 10, 1, -18 },
  { 230, 10, 18, 10, 0, -18 },
  { 253, 8, 18, 10, 1, -18 },
  { 271, 8, 18, 10, 1, -18 },
  { 289, 8, 18, 10, 1, -18 },
  { 307, 8, 18, 10, 1, -18 },
  { 325, 8, 18, 10, 1, -18 },
  { 343, 1, 13, 5, 2, -13 },
  { 345, 2, 16, 5, 1, -13 },
  { 349, 8, 10, 10, 1, -14 },
  { 359, 8, 6, 10, 1, -12 },
  { 365, 8, 10, 10, 1, -14 },
  { 375, 6, 18, 7, 0, -18 },
  { 389, 13, 20, 15, 1, -18 },
  { 422, 10, 18, 10, 0, -18 },
  { 445, 8, 18, 11, 2, -18 },
  { 463, 9, 18, 11, 1, -18 },
  { 484, 9, 18, 12, 2, -18 },
  { 505, 6, 18, 10, 2, -18 },
  { 519, 6, 18, 9, 2, -18 },
  { 533, 11, 18, 13, 1, -18 },
  { 558, 8, 18, 12, 2, -18 },
  { 576, 4, 18, 6, 1, -18 },
  { 585, 4, 22, 5, -1, -18 },
  { 596, 8, 18, 10, 2, -18 },
  { 614, 6, 18, 9, 2, -18 },
  { 628, 13, 18, 17, 2, -18 },
  { 658, 9, 18, 13, 2, -18 },
  { 679, 11, 18, 13, 1, -18 },
  { 704, 7, 18, 10, 2, -18 },
  { 720, 11, 22, 13, 1, -18 },
  { 751, 8, 18, 10, 2, -18 },
  { 769, 8, 18, 10, 1, -18 },
  { 787, 8, 18, 9, 0, -18 },
  { 805, 9, 18, 12, 2, -18 },
  { 826, 10, 18, 10, 0, -18 },
  { 849, 16, 18, 17, 0, -18 },
  { 885, 8, 18, 9, 0, -18 },
  { 903, 8, 18, 8, 0, -18 },
  { 921, 7, 18, 8, 1, -18 },
  { 937, 5, 22, 8, 2, -18 },
  { 951, 7, 18, 8, 1, -18 },
  { 967, 5, 22, 8, 1, -18 },
  { 981, 10, 9, 10, 0, -18 },
  { 993, 10, 1, 10, 0, 2 },
  { 995, 4, 4, 6, 1, -19 },
  { 997, 7, 13, 9, 1, -13 },
  { 1009, 8, 19, 11, 2, -19 },
  { 1028, 7, 13, 8, 1, -13 },
  { 1040, 8, 19, 11, 1, -19 },
  { 1059, 8, 13, 10, 1, -13 },
  { 1072, 6, 19, 6, 0, -19 },
  { 1087, 8, 19, 11, 1, -13 },
  { 1106, 7, 19, 10, 2, -19 },
  { 1123, 1, 18, 5, 2, -18 },
  { 1126, 3, 24, 5, 0, -18 },
  { 1135, 6, 19, 8, 2, -19 },
  { 1150, 1, 19, 4, 2, -19 },
  { 1153, 12, 13, 16, 2, -13 },
  { 1173, 7, 13, 10, 2, -13 },
  { 1185, 8, 13, 10, 1, -13 },
  { 1198, 8, 19, 11, 2, -13 },
  { 1217, 8, 19, 11, 1, -13 },
  { 1236, 5, 13, 7, 2, -13 },
  { 1245, 6, 13, 8, 1, -13 },
  { 1255, 5, 16, 5, 0, -16 },
  { 1265, 7, 13, 10, 2, -13 },
  { 1277, 8, 13, 8, 0, -13 },
  { 1290, 13, 13, 13, 0, -13 },
  { 1312, 8, 13, 8, 0, -13 },
  { 1325, 8, 19, 8, 0, -13 },
  { 1344, 5, 13, 7, 1, -13 },
  { 1353, 7, 22, 9, 1, -18 },
  { 1373, 1, 25, 10, 4, -19 },
  { 1377, 6, 22, 9, 1, -18 },
  { 1394, 8, 2, 10, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight25pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT25PT7B_H_
