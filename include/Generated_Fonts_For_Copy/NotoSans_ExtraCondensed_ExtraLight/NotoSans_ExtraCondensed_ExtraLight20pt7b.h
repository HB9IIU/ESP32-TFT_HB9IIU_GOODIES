#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT20PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight20pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x50, 0x70, 0x99, 0x99, 0x90, 0x12, 0x12, 0x12, 0x12,
  0x7F, 0x22, 0x24, 0x24, 0x24, 0xFF, 0x24, 0x24, 0x24, 0x44, 0x21, 0xFA,
  0x28, 0xA2, 0x8E, 0x08, 0x38, 0x92, 0x49, 0x27, 0xA3, 0x08, 0xE3, 0x24,
  0x89, 0x22, 0x48, 0x94, 0x25, 0x69, 0x66, 0xA9, 0x4A, 0x42, 0x91, 0x24,
  0x49, 0x12, 0x48, 0x60, 0x70, 0x91, 0x22, 0x45, 0x0A, 0x18, 0x50, 0x93,
  0x16, 0x34, 0x28, 0xCE, 0x40, 0xF8, 0x32, 0x44, 0x88, 0x88, 0x88, 0x88,
  0x84, 0x42, 0x30, 0x89, 0x12, 0x49, 0x24, 0x92, 0x52, 0x80, 0x25, 0x5C,
  0xAD, 0x80, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10, 0x20, 0x6A,
  0x80, 0xF0, 0xB0, 0x04, 0x10, 0x42, 0x08, 0x41, 0x04, 0x20, 0x82, 0x10,
  0x43, 0x00, 0x79, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x49,
  0xE0, 0x35, 0x91, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF8, 0x10, 0x41, 0x04,
  0x10, 0x82, 0x10, 0x82, 0x10, 0x83, 0xF0, 0xF8, 0x10, 0x41, 0x04, 0x27,
  0x02, 0x04, 0x10, 0x41, 0x07, 0xE0, 0x04, 0x0C, 0x0C, 0x14, 0x14, 0x24,
  0x24, 0x44, 0x44, 0x84, 0xFF, 0x04, 0x04, 0x04, 0xFA, 0x08, 0x20, 0x83,
  0xC8, 0x81, 0x04, 0x10, 0x41, 0x0B, 0xE0, 0x3D, 0x04, 0x20, 0x82, 0xEC,
  0x61, 0x86, 0x18, 0x61, 0x45, 0xE0, 0xFC, 0x10, 0x82, 0x08, 0x21, 0x04,
  0x10, 0x82, 0x08, 0x41, 0x00, 0x7A, 0x18, 0x61, 0x85, 0x23, 0x12, 0x86,
  0x18, 0x61, 0x85, 0xE0, 0x7A, 0x28, 0x61, 0x86, 0x18, 0x53, 0x34, 0x10,
  0x42, 0x0B, 0xC0, 0xB0, 0x00, 0x2C, 0xB0, 0x00, 0x1A, 0xA0, 0x06, 0x31,
  0x84, 0x0C, 0x06, 0x02, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x80, 0xC0,
  0x60, 0x30, 0xC2, 0x18, 0x40, 0xF0, 0x42, 0x10, 0x88, 0x44, 0x21, 0x00,
  0x02, 0x30, 0x1F, 0x08, 0x24, 0x05, 0x01, 0x8E, 0x64, 0x99, 0x26, 0x49,
  0x92, 0x64, 0x99, 0x66, 0x36, 0x40, 0x10, 0x02, 0x00, 0x78, 0x18, 0x18,
  0x18, 0x28, 0x24, 0x24, 0x24, 0x44, 0x7E, 0x42, 0x42, 0x82, 0x81, 0x81,
  0xFA, 0x18, 0x61, 0x86, 0x2F, 0x22, 0x86, 0x18, 0x61, 0x8B, 0xC0, 0x3E,
  0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x02, 0x02, 0x03, 0xC0,
  0xF9, 0x12, 0x14, 0x28, 0x30, 0x60, 0xC1, 0x83, 0x0A, 0x14, 0x28, 0x9E,
  0x00, 0xFC, 0x21, 0x08, 0x43, 0xF0, 0x84, 0x21, 0x08, 0x7C, 0xFC, 0x21,
  0x08, 0x42, 0x1F, 0x84, 0x21, 0x08, 0x40, 0x3F, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x87, 0x81, 0x81, 0x81, 0x41, 0x21, 0x1F, 0x86, 0x18, 0x61,
  0x86, 0x1F, 0xE1, 0x86, 0x18, 0x61, 0x86, 0x10, 0xE9, 0x24, 0x92, 0x49,
  0x25, 0xC0, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x38, 0x8E, 0x29, 0x24,
  0xA3, 0x0C, 0x28, 0xA2, 0x49, 0x22, 0x8A, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x7C, 0x80, 0xE0, 0x38, 0x0F, 0x05, 0xC1, 0x68,
  0x5A, 0x26, 0x89, 0xA2, 0x64, 0x99, 0x46, 0x51, 0x8C, 0x62, 0x10, 0x83,
  0x07, 0x0E, 0x1A, 0x34, 0x64, 0xC9, 0x93, 0x16, 0x2C, 0x38, 0x70, 0x40,
  0x3E, 0x42, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41,
  0x42, 0x3C, 0xF4, 0x63, 0x18, 0xC6, 0x3E, 0x84, 0x21, 0x08, 0x40, 0x3E,
  0x42, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42,
  0x3C, 0x04, 0x04, 0x02, 0xF2, 0x28, 0xA1, 0x86, 0x29, 0xB8, 0x92, 0x49,
  0x22, 0x8A, 0x10, 0x7E, 0x08, 0x20, 0x81, 0x02, 0x06, 0x04, 0x10, 0x41,
  0x07, 0xE0, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x00, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x14, 0x27, 0x80, 0x81, 0x82, 0x42, 0x42, 0x42, 0x44, 0x44, 0x24,
  0x24, 0x28, 0x28, 0x18, 0x18, 0x10, 0x82, 0x0C, 0x10, 0x50, 0xC2, 0x8A,
  0x24, 0x51, 0x22, 0x89, 0x14, 0x44, 0x92, 0x28, 0xA1, 0x45, 0x0A, 0x28,
  0x51, 0x41, 0x04, 0x08, 0x20, 0x46, 0x88, 0x91, 0x42, 0x82, 0x04, 0x08,
  0x28, 0x51, 0x12, 0x24, 0x50, 0x40, 0x87, 0x09, 0x12, 0x44, 0x85, 0x0C,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0xF8, 0x44, 0x21, 0x10, 0x84,
  0x42, 0x21, 0x08, 0x7C, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0xE0, 0xC1,
  0x04, 0x08, 0x20, 0x81, 0x04, 0x08, 0x20, 0x81, 0x04, 0x10, 0xF1, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x18, 0x18, 0x24, 0x24, 0x42,
  0x42, 0x81, 0xFF, 0x88, 0x80, 0xF0, 0x42, 0x10, 0xBE, 0x31, 0x8C, 0x7E,
  0x81, 0x02, 0x04, 0x0B, 0x98, 0xB1, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x38,
  0xAE, 0x00, 0x3A, 0x21, 0x08, 0x42, 0x10, 0x82, 0x1E, 0x04, 0x10, 0x41,
  0x35, 0x38, 0x61, 0x86, 0x18, 0x61, 0x86, 0x17, 0xC0, 0x31, 0x28, 0x61,
  0x87, 0xF8, 0x20, 0x81, 0x07, 0xC0, 0x39, 0x10, 0x8F, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x00, 0x35, 0x38, 0x61, 0x86, 0x18, 0x61, 0x86, 0x17,
  0xC1, 0x04, 0x18, 0x5E, 0x82, 0x08, 0x20, 0xBB, 0x1C, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x40, 0xCF, 0xFE, 0x50, 0x55, 0x55, 0x55, 0x57, 0x82,
  0x08, 0x20, 0x8A, 0x29, 0x24, 0xA3, 0x4D, 0x24, 0x8A, 0x28, 0x40, 0xFF,
  0xFE, 0xB1, 0xB2, 0x98, 0x46, 0x11, 0x84, 0x61, 0x18, 0x46, 0x11, 0x84,
  0x61, 0x18, 0x44, 0xBB, 0x1C, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x40,
  0x39, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x17, 0x80, 0xB9, 0x8B, 0x14,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x8A, 0xE4, 0x08, 0x10, 0x20, 0x40, 0x35,
  0x38, 0x61, 0x86, 0x18, 0x61, 0x86, 0x17, 0xC1, 0x04, 0x10, 0x41, 0xBC,
  0xC8, 0x88, 0x88, 0x88, 0x80, 0x7C, 0x21, 0x08, 0x30, 0x41, 0x08, 0x7C,
  0x44, 0xF4, 0x44, 0x44, 0x44, 0x44, 0x30, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x17, 0xC0, 0x86, 0x18, 0x52, 0x49, 0x24, 0x8C, 0x30, 0xC1,
  0x00, 0x84, 0x61, 0x14, 0xC5, 0x29, 0x4A, 0x52, 0xA5, 0x28, 0xCA, 0x31,
  0x8C, 0x42, 0x10, 0x85, 0x14, 0x8A, 0x30, 0x43, 0x0A, 0x49, 0x18, 0x40,
  0x85, 0x14, 0x51, 0x48, 0xA2, 0x8A, 0x30, 0x41, 0x04, 0x20, 0x82, 0x30,
  0xF1, 0x22, 0x24, 0x44, 0x88, 0xF0, 0x19, 0x08, 0x42, 0x10, 0x84, 0xC1,
  0x08, 0x42, 0x10, 0x84, 0x18, 0xFF, 0xFF, 0xF0, 0xC1, 0x08, 0x42, 0x10,
  0x84, 0x19, 0x08, 0x42, 0x10, 0x84, 0xC0, 0xE3, 0x38,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 14, 4, 1, -14 },
  { 5, 4, 5, 6, 1, -14 },
  { 8, 8, 14, 9, 0, -14 },
  { 22, 6, 16, 8, 1, -15 },
  { 34, 10, 14, 12, 1, -14 },
  { 52, 7, 14, 8, 1, -14 },
  { 65, 1, 5, 3, 1, -14 },
  { 66, 4, 17, 5, 1, -14 },
  { 75, 3, 17, 5, 1, -14 },
  { 82, 5, 5, 7, 1, -15 },
  { 86, 7, 10, 8, 1, -12 },
  { 95, 2, 5, 4, 1, -2 },
  { 97, 4, 1, 5, 1, -6 },
  { 98, 2, 2, 4, 1, -2 },
  { 99, 6, 14, 7, 0, -14 },
  { 110, 6, 14, 8, 1, -14 },
  { 121, 4, 14, 8, 1, -14 },
  { 128, 6, 14, 8, 1, -14 },
  { 139, 6, 14, 8, 1, -14 },
  { 150, 8, 14, 8, 0, -14 },
  { 164, 6, 14, 8, 1, -14 },
  { 175, 6, 14, 8, 1, -14 },
  { 186, 6, 14, 8, 1, -14 },
  { 197, 6, 14, 8, 1, -14 },
  { 208, 6, 14, 8, 1, -14 },
  { 219, 2, 11, 4, 1, -11 },
  { 222, 2, 14, 4, 1, -11 },
  { 226, 7, 8, 8, 1, -11 },
  { 233, 7, 5, 8, 1, -10 },
  { 238, 7, 8, 8, 1, -11 },
  { 245, 5, 14, 5, 0, -14 },
  { 254, 10, 16, 12, 1, -14 },
  { 274, 8, 14, 8, 0, -14 },
  { 288, 6, 14, 9, 2, -14 },
  { 299, 7, 14, 8, 1, -14 },
  { 312, 7, 14, 10, 2, -14 },
  { 325, 5, 14, 8, 2, -14 },
  { 334, 5, 14, 7, 2, -14 },
  { 343, 8, 14, 11, 1, -14 },
  { 357, 6, 14, 10, 2, -14 },
  { 368, 3, 14, 5, 1, -14 },
  { 374, 3, 18, 4, -1, -14 },
  { 381, 6, 14, 8, 2, -14 },
  { 392, 5, 14, 7, 2, -14 },
  { 401, 10, 14, 13, 2, -14 },
  { 419, 7, 14, 10, 2, -14 },
  { 432, 8, 14, 10, 1, -14 },
  { 446, 5, 14, 8, 2, -14 },
  { 455, 8, 17, 10, 1, -14 },
  { 472, 6, 14, 8, 2, -14 },
  { 483, 6, 14, 8, 1, -14 },
  { 494, 7, 14, 7, 0, -14 },
  { 507, 7, 14, 10, 1, -14 },
  { 520, 8, 14, 8, 0, -14 },
  { 534, 13, 14, 13, 0, -14 },
  { 557, 7, 14, 7, 0, -14 },
  { 570, 7, 14, 7, 0, -14 },
  { 583, 5, 14, 7, 1, -14 },
  { 592, 3, 17, 6, 2, -14 },
  { 599, 6, 14, 7, 0, -14 },
  { 610, 4, 17, 6, 1, -14 },
  { 619, 8, 7, 8, 0, -14 },
  { 626, 8, 1, 8, 0, 2 },
  { 627, 3, 3, 5, 1, -15 },
  { 629, 5, 11, 8, 1, -11 },
  { 636, 7, 15, 9, 1, -15 },
  { 650, 5, 11, 6, 1, -11 },
  { 657, 6, 15, 9, 1, -15 },
  { 669, 6, 11, 8, 1, -11 },
  { 678, 5, 15, 4, 0, -15 },
  { 688, 6, 16, 9, 1, -11 },
  { 700, 6, 15, 8, 1, -15 },
  { 712, 1, 15, 4, 1, -15 },
  { 714, 2, 20, 4, 0, -15 },
  { 719, 6, 15, 7, 1, -15 },
  { 731, 1, 15, 4, 1, -15 },
  { 733, 10, 11, 12, 1, -11 },
  { 747, 6, 11, 8, 1, -11 },
  { 756, 6, 11, 8, 1, -11 },
  { 765, 7, 16, 9, 1, -11 },
  { 779, 6, 16, 9, 1, -11 },
  { 791, 4, 11, 5, 1, -11 },
  { 797, 5, 11, 6, 1, -11 },
  { 804, 4, 13, 4, 0, -13 },
  { 811, 6, 11, 8, 1, -11 },
  { 820, 6, 11, 6, 0, -11 },
  { 829, 10, 11, 11, 0, -11 },
  { 843, 6, 11, 7, 0, -11 },
  { 852, 6, 16, 7, 0, -11 },
  { 864, 4, 11, 5, 1, -11 },
  { 870, 5, 17, 7, 1, -14 },
  { 881, 1, 20, 8, 3, -15 },
  { 884, 5, 17, 7, 1, -14 },
  { 895, 7, 2, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight20pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT20PT7B_H_
