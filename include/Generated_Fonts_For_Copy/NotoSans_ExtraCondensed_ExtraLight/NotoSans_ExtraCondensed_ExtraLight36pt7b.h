#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT36PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xAA, 0xAA, 0xAA, 0xAA, 0x02, 0xF0, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xA1, 0x42, 0x84, 0x04, 0x30, 0x10, 0x80, 0x42, 0x03, 0x08,
  0x0C, 0x20, 0x20, 0x80, 0x82, 0x02, 0x08, 0xFF, 0xFC, 0x21, 0x80, 0x84,
  0x06, 0x10, 0x18, 0x40, 0x41, 0x01, 0x04, 0x04, 0x10, 0xFF, 0xFB, 0xFF,
  0xE1, 0x0C, 0x04, 0x20, 0x30, 0x80, 0xC2, 0x02, 0x08, 0x08, 0x20, 0x20,
  0x80, 0x86, 0x00, 0x06, 0x00, 0x60, 0x1F, 0xC3, 0x66, 0x66, 0x04, 0x60,
  0xC6, 0x08, 0x60, 0xC6, 0x0C, 0x60, 0x46, 0x06, 0x60, 0x3E, 0x00, 0xE0,
  0x07, 0x80, 0x6C, 0x06, 0x60, 0x63, 0x06, 0x10, 0x61, 0x06, 0x10, 0x61,
  0x06, 0x38, 0x62, 0xF7, 0xC3, 0xF0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x38,
  0x08, 0x13, 0x02, 0x0C, 0x40, 0x82, 0x10, 0x40, 0x86, 0x10, 0x20, 0x84,
  0x08, 0x22, 0x02, 0x08, 0x80, 0x82, 0x20, 0x20, 0x90, 0x08, 0x24, 0x62,
  0x19, 0x24, 0x84, 0x90, 0xB1, 0x24, 0x24, 0xC9, 0x08, 0xE4, 0x43, 0x01,
  0x30, 0xC0, 0x4C, 0x30, 0x23, 0x0C, 0x08, 0xC3, 0x02, 0x10, 0xC1, 0x04,
  0x20, 0x41, 0x08, 0x10, 0x42, 0x0C, 0x19, 0x82, 0x03, 0xC0, 0x0E, 0x00,
  0x44, 0x03, 0x18, 0x08, 0x20, 0x20, 0x80, 0x82, 0x02, 0x08, 0x0C, 0x20,
  0x11, 0x80, 0x44, 0x01, 0xB0, 0x03, 0x80, 0x0C, 0x00, 0xD0, 0x02, 0x20,
  0x18, 0xC2, 0x41, 0x1B, 0x06, 0x6C, 0x09, 0x20, 0x34, 0x80, 0x73, 0x00,
  0x8C, 0x07, 0x10, 0x34, 0x61, 0x98, 0xFC, 0x30, 0xFF, 0xFD, 0x50, 0x04,
  0x21, 0x84, 0x30, 0x86, 0x18, 0x41, 0x0C, 0x30, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0xC3, 0x04, 0x10, 0x61, 0x82, 0x0C, 0x10, 0x60, 0x81, 0xC0,
  0xC0, 0x81, 0x81, 0x03, 0x02, 0x06, 0x0C, 0x08, 0x10, 0x20, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x60, 0x83,
  0x04, 0x18, 0x60, 0x08, 0x04, 0x02, 0x19, 0x33, 0xE0, 0xC0, 0xD0, 0x44,
  0x43, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x33, 0x22, 0x66, 0x44, 0xC0, 0xFF,
  0x5F, 0x00, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40,
  0x18, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0,
  0x10, 0x00, 0x1E, 0x06, 0x61, 0x82, 0x20, 0x64, 0x0D, 0x80, 0xB0, 0x14,
  0x02, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0x60, 0x2C, 0x04, 0x80, 0x90, 0x33, 0x04, 0x31,
  0x83, 0xE0, 0x04, 0x33, 0x59, 0xC6, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x1F, 0x07,
  0x1C, 0x40, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0F,
  0xFF, 0x1F, 0x07, 0x1C, 0xC0, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x1E, 0x00, 0x38, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x06, 0xC0, 0xC7, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x50, 0x02, 0x80, 0x34,
  0x01, 0x20, 0x19, 0x00, 0x88, 0x0C, 0x40, 0x42, 0x06, 0x10, 0x20, 0x83,
  0x04, 0x10, 0x20, 0x81, 0x08, 0x08, 0x40, 0x44, 0x02, 0x20, 0x11, 0xFF,
  0xF0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x7F,
  0xCF, 0xF9, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0x7F, 0x88, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x83, 0x9F, 0xC0, 0x07,
  0xC3, 0x88, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10,
  0x02, 0x38, 0x5D, 0xCA, 0x0D, 0x80, 0xB0, 0x14, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x80, 0xD0, 0x13, 0x06, 0x20, 0x83, 0xE0, 0xFF,
  0xFF, 0xFF, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x0F, 0x83, 0x8C, 0x20, 0x66, 0x02, 0x40, 0x24, 0x03, 0x40,
  0x36, 0x02, 0x60, 0x23, 0x06, 0x18, 0xC0, 0xF8, 0x06, 0x01, 0x98, 0x30,
  0xC2, 0x06, 0x40, 0x24, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x40,
  0x36, 0x02, 0x30, 0x61, 0xF8, 0x0F, 0x03, 0x98, 0x20, 0x46, 0x04, 0x40,
  0x64, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x2C, 0x03, 0x40, 0x34, 0x03, 0x40,
  0x76, 0x07, 0x30, 0xA1, 0xF2, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x08, 0x03, 0x03, 0xE0, 0xDD, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x5F, 0x00, 0x37, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x32, 0x26, 0x64, 0x48, 0x00, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x20, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x02, 0x00, 0x00, 0x7C, 0xC6, 0x03,
  0x03, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x18, 0x10,
  0x30, 0x30, 0x20, 0x20, 0x20, 0x00, 0x00, 0x00, 0x20, 0x30, 0x30, 0x01,
  0xF0, 0x01, 0xC7, 0x00, 0xC0, 0x60, 0x60, 0x0C, 0x30, 0x01, 0x08, 0x00,
  0x66, 0x00, 0x09, 0x01, 0x03, 0x41, 0xF8, 0x70, 0xC6, 0x1C, 0x21, 0x06,
  0x08, 0x41, 0x86, 0x10, 0x61, 0x04, 0x18, 0x41, 0x06, 0x10, 0x41, 0x84,
  0x10, 0x61, 0x04, 0x18, 0x63, 0x0E, 0x08, 0xA2, 0xC3, 0x69, 0x90, 0x71,
  0xC4, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x20, 0x07, 0xF0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xA0,
  0x04, 0x80, 0x12, 0x00, 0x48, 0x03, 0x30, 0x08, 0x40, 0x21, 0x00, 0x84,
  0x06, 0x18, 0x18, 0x20, 0x40, 0x81, 0x02, 0x07, 0xFC, 0x30, 0x30, 0x80,
  0x42, 0x01, 0x08, 0x06, 0x60, 0x19, 0x80, 0x24, 0x00, 0x90, 0x03, 0xC0,
  0x0F, 0x00, 0x10, 0xFC, 0x1F, 0xF2, 0x03, 0x40, 0x28, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0A, 0x03, 0x40, 0xCF, 0xE1, 0x03, 0x20, 0x14,
  0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x06,
  0x83, 0x9F, 0xE0, 0x07, 0xE0, 0xC3, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x10, 0x7F, 0xFC, 0x0F, 0xF0, 0x80, 0xC8, 0x04,
  0x80, 0x68, 0x02, 0x80, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x28, 0x06, 0x80, 0x48, 0x0C, 0x83, 0x8F, 0xE0, 0xFF, 0xFF, 0xE0,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0F, 0xFC,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0xE0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x07, 0xFE, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x00, 0x03, 0xF8, 0x1C,
  0x3C, 0x60, 0x11, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x0F, 0xE0,
  0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x16, 0x00,
  0x2C, 0x00, 0x4C, 0x00, 0x8C, 0x01, 0x0C, 0x06, 0x0F, 0xF8, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0xFF, 0xF8, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x13, 0xF0, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0xFE, 0x80, 0x70, 0x0A,
  0x03, 0x40, 0xC8, 0x11, 0x06, 0x20, 0x84, 0x30, 0x8C, 0x11, 0x02, 0x60,
  0x48, 0x0B, 0x81, 0x50, 0x33, 0x04, 0x20, 0x86, 0x10, 0x42, 0x0C, 0x40,
  0x88, 0x11, 0x01, 0x20, 0x24, 0x06, 0x80, 0x50, 0x0C, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x7F, 0xC0, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07,
  0xA0, 0x01, 0x68, 0x00, 0x5B, 0x00, 0x36, 0x40, 0x09, 0x90, 0x02, 0x66,
  0x01, 0x99, 0x80, 0x46, 0x20, 0x11, 0x88, 0x04, 0x63, 0x03, 0x18, 0x40,
  0x86, 0x10, 0x21, 0x86, 0x18, 0x60, 0x84, 0x18, 0x21, 0x06, 0x0C, 0xC1,
  0x83, 0x20, 0x60, 0x48, 0x18, 0x12, 0x06, 0x07, 0x81, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1A, 0x00, 0xD8, 0x06,
  0x40, 0x33, 0x01, 0x88, 0x0C, 0x40, 0x61, 0x03, 0x08, 0x18, 0x60, 0xC1,
  0x06, 0x0C, 0x30, 0x21, 0x81, 0x8C, 0x04, 0x60, 0x23, 0x01, 0x98, 0x04,
  0xC0, 0x36, 0x00, 0xB0, 0x07, 0x80, 0x1C, 0x00, 0xC0, 0x07, 0xC0, 0x38,
  0xE0, 0xC0, 0x41, 0x00, 0xC6, 0x00, 0x88, 0x01, 0x90, 0x01, 0x60, 0x02,
  0xC0, 0x05, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x12, 0x00, 0x24, 0x00,
  0xCC, 0x01, 0x88, 0x02, 0x18, 0x0C, 0x18, 0x30, 0x1F, 0xC0, 0xF8, 0x3F,
  0xC8, 0x1A, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x03, 0x80, 0xA0, 0xEF, 0xE2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x07, 0xC0, 0x38, 0xE0, 0xC0,
  0x41, 0x00, 0xC6, 0x00, 0x88, 0x01, 0x90, 0x01, 0x60, 0x02, 0xC0, 0x05,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x12, 0x00, 0x24, 0x00, 0xCC, 0x01,
  0x88, 0x02, 0x18, 0x0C, 0x18, 0x30, 0x1F, 0xC0, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0xFC, 0x1F, 0xE2, 0x06, 0x40,
  0x68, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x03, 0x40, 0x68,
  0x19, 0xFE, 0x3F, 0x04, 0x20, 0x86, 0x10, 0x42, 0x0C, 0x40, 0x88, 0x19,
  0x01, 0x20, 0x34, 0x02, 0x80, 0x70, 0x04, 0x0F, 0xC1, 0x86, 0x20, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0xC0, 0xC7, 0xF8, 0xFF, 0xFF,
  0xFF, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0xC0, 0x34,
  0x02, 0x70, 0xC3, 0xF8, 0x80, 0x0F, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40,
  0x19, 0x80, 0x66, 0x01, 0x08, 0x04, 0x20, 0x30, 0x80, 0xC3, 0x02, 0x04,
  0x08, 0x10, 0x60, 0x41, 0x81, 0x84, 0x02, 0x10, 0x08, 0x40, 0x23, 0x00,
  0xC8, 0x03, 0x20, 0x04, 0x80, 0x16, 0x00, 0x50, 0x01, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x02, 0x40, 0x18, 0x02, 0x40,
  0x18, 0x02, 0x40, 0x38, 0x06, 0x60, 0x2C, 0x06, 0x60, 0x2C, 0x04, 0x20,
  0x24, 0x04, 0x20, 0x24, 0x0C, 0x30, 0x64, 0x0C, 0x30, 0x66, 0x08, 0x10,
  0x46, 0x08, 0x10, 0x42, 0x08, 0x10, 0x42, 0x18, 0x18, 0xC2, 0x18, 0x18,
  0xC3, 0x10, 0x08, 0x83, 0x10, 0x08, 0x81, 0x10, 0x08, 0x81, 0x30, 0x0D,
  0x81, 0x30, 0x0D, 0x81, 0xA0, 0x05, 0x01, 0xA0, 0x05, 0x00, 0xE0, 0x05,
  0x00, 0xE0, 0x07, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x60, 0x32, 0x03, 0x20,
  0x23, 0x06, 0x10, 0x41, 0x04, 0x18, 0xC0, 0x88, 0x0C, 0x80, 0x58, 0x05,
  0x00, 0x70, 0x02, 0x00, 0x70, 0x05, 0x00, 0x50, 0x0D, 0x80, 0x88, 0x18,
  0x81, 0x0C, 0x10, 0x43, 0x04, 0x20, 0x66, 0x02, 0x40, 0x3C, 0x03, 0x80,
  0x3C, 0x03, 0x40, 0x24, 0x06, 0x60, 0x62, 0x04, 0x20, 0xC3, 0x0C, 0x10,
  0x81, 0x18, 0x19, 0x80, 0x90, 0x0B, 0x00, 0xF0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0xFF, 0xFF, 0xF0, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x10, 0x0C,
  0x02, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x10, 0x04,
  0x03, 0x00, 0x80, 0x20, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x3F, 0xF0, 0xFF,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x7F, 0x80, 0x30, 0x04, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x02,
  0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x10,
  0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0xFF, 0x02, 0x00, 0x38, 0x01, 0x40, 0x1B, 0x00, 0x88,
  0x0C, 0x40, 0x41, 0x06, 0x08, 0x20, 0x63, 0x01, 0x10, 0x0D, 0x80, 0x28,
  0x01, 0x80, 0xFF, 0xFE, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x3F, 0x08, 0x20,
  0x0C, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x07, 0xCE, 0x16, 0x05, 0x01,
  0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x40, 0xD8, 0x53, 0xE4, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x9F, 0x14, 0x33, 0x03,
  0x60, 0x28, 0x05, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x16, 0x02, 0xC0, 0xD4, 0x32, 0x7C, 0x00, 0x1F,
  0x98, 0x18, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x03, 0x01, 0x80, 0x60, 0x18, 0x47, 0xE0, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x3F, 0x2C, 0x35, 0x02,
  0xE0, 0x3C, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xF0, 0x1E, 0x03, 0x40, 0xAC, 0x34, 0xFC, 0x80, 0x3F,
  0x08, 0x64, 0x0B, 0x03, 0xC0, 0x60, 0x18, 0x06, 0x01, 0xFF, 0xE0, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x11, 0xF8, 0x02,
  0x07, 0xC6, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x7F, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x3F, 0x2C, 0x15, 0x02, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xF0, 0x1E, 0x03, 0x40, 0xAC, 0x34, 0xFC, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x50, 0x1B, 0xFE, 0x0F, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x9F, 0x28, 0x6C, 0x0B,
  0x02, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0xF4, 0x01, 0x55, 0x55,
  0x55, 0x55, 0x50, 0x33, 0x10, 0x00, 0x01, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x13, 0x3E, 0xC0, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x81, 0xC1, 0xA0, 0x90, 0x88, 0xC4,
  0x42, 0x61, 0x60, 0xB8, 0x64, 0x33, 0x10, 0x88, 0x44, 0x32, 0x09, 0x06,
  0x81, 0x40, 0xA0, 0x60, 0xFF, 0xFF, 0xFF, 0xE0, 0xBE, 0x3E, 0x51, 0x91,
  0xB0, 0x50, 0x70, 0x38, 0x38, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01,
  0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C,
  0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20,
  0x20, 0x9F, 0x28, 0x6C, 0x0B, 0x02, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0C, 0x3F, 0x0C, 0x11, 0x03, 0x60, 0x28, 0x07, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x1E, 0x02, 0x40,
  0xC4, 0x10, 0x7C, 0x00, 0x9F, 0x14, 0x33, 0x03, 0x60, 0x28, 0x05, 0x00,
  0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x16, 0x02, 0xC0, 0xD4, 0x32, 0x7C, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x00, 0x1F, 0x24, 0x35, 0x82, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xF0, 0x1E, 0x03, 0x40, 0xAC, 0x34, 0xFC, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x9E, 0x8C, 0x30, 0xC2,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x00, 0x3F,
  0xB0, 0x50, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x20, 0x18, 0x04, 0x02, 0x01, 0x01, 0xE1, 0x9F, 0x80, 0x20, 0x82, 0x08,
  0x23, 0xF2, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x0F, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1A,
  0x07, 0x40, 0xEC, 0x2C, 0xF9, 0x80, 0xC0, 0x68, 0x0D, 0x01, 0x20, 0x26,
  0x0C, 0x41, 0x88, 0x21, 0x04, 0x30, 0x86, 0x30, 0x44, 0x08, 0x81, 0x10,
  0x36, 0x02, 0x80, 0x50, 0x0A, 0x01, 0xC0, 0x10, 0x00, 0xC0, 0x60, 0x68,
  0x0C, 0x09, 0x03, 0x81, 0x20, 0x50, 0x26, 0x0A, 0x0C, 0x41, 0x61, 0x88,
  0x64, 0x21, 0x0C, 0x84, 0x31, 0x10, 0x86, 0x22, 0x30, 0x44, 0x64, 0x09,
  0x84, 0x81, 0x20, 0x90, 0x34, 0x12, 0x02, 0x82, 0xC0, 0x50, 0x70, 0x0E,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x00, 0xC0, 0xD0, 0x26, 0x18, 0x84,
  0x21, 0x0C, 0x81, 0x20, 0x78, 0x0C, 0x03, 0x00, 0xC0, 0x58, 0x12, 0x0C,
  0xC2, 0x11, 0x86, 0x40, 0xB0, 0x28, 0x0C, 0x40, 0x28, 0x05, 0x81, 0x90,
  0x32, 0x04, 0x40, 0x8C, 0x30, 0x86, 0x10, 0x82, 0x10, 0x66, 0x04, 0xC0,
  0x90, 0x12, 0x03, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x03, 0xC0, 0x30, 0x00, 0xFF, 0x03,
  0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x18, 0x10, 0x30, 0x20, 0x20,
  0x60, 0x40, 0x40, 0xC0, 0xFF, 0x01, 0x83, 0xC3, 0x01, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x41, 0xC0, 0xE0,
  0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0x80, 0x60, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x78, 0x06, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x0F, 0x07, 0x86, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC3,
  0xC1, 0x80, 0x7C, 0x0C, 0x19, 0xA0, 0x78,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 26, 7, 3, -26 },
  { 8, 7, 10, 11, 2, -26 },
  { 17, 14, 26, 16, 1, -26 },
  { 63, 12, 29, 14, 1, -27 },
  { 107, 18, 26, 21, 2, -26 },
  { 166, 14, 26, 15, 1, -26 },
  { 212, 2, 10, 6, 2, -26 },
  { 215, 6, 32, 10, 2, -26 },
  { 239, 7, 32, 10, 1, -26 },
  { 267, 9, 9, 13, 2, -27 },
  { 278, 13, 17, 15, 1, -21 },
  { 306, 4, 9, 7, 1, -4 },
  { 311, 8, 1, 10, 1, -10 },
  { 312, 3, 3, 7, 2, -3 },
  { 314, 11, 26, 12, 1, -26 },
  { 350, 11, 26, 14, 2, -26 },
  { 386, 6, 26, 14, 3, -26 },
  { 406, 12, 26, 14, 1, -26 },
  { 445, 12, 26, 14, 1, -26 },
  { 484, 13, 26, 14, 1, -26 },
  { 527, 11, 26, 14, 2, -26 },
  { 563, 11, 26, 14, 2, -26 },
  { 599, 12, 26, 14, 1, -26 },
  { 638, 12, 26, 14, 1, -26 },
  { 677, 12, 26, 14, 1, -26 },
  { 716, 3, 19, 7, 2, -19 },
  { 724, 4, 24, 7, 1, -19 },
  { 736, 13, 15, 15, 1, -20 },
  { 761, 13, 9, 15, 1, -17 },
  { 776, 13, 15, 15, 1, -20 },
  { 801, 8, 26, 10, 1, -26 },
  { 827, 18, 29, 22, 2, -26 },
  { 893, 14, 26, 14, 0, -26 },
  { 939, 11, 26, 16, 3, -26 },
  { 975, 12, 26, 15, 2, -26 },
  { 1014, 12, 26, 17, 3, -26 },
  { 1053, 9, 26, 14, 3, -26 },
  { 1083, 9, 26, 13, 3, -26 },
  { 1113, 15, 26, 19, 2, -26 },
  { 1162, 12, 26, 18, 3, -26 },
  { 1201, 6, 26, 8, 1, -26 },
  { 1221, 6, 32, 7, -2, -26 },
  { 1245, 11, 26, 14, 3, -26 },
  { 1281, 9, 26, 12, 3, -26 },
  { 1311, 18, 26, 24, 3, -26 },
  { 1370, 13, 26, 19, 3, -26 },
  { 1413, 15, 26, 19, 2, -26 },
  { 1462, 10, 26, 15, 3, -26 },
  { 1495, 15, 32, 19, 2, -26 },
  { 1555, 11, 26, 15, 3, -26 },
  { 1591, 12, 26, 14, 1, -26 },
  { 1630, 12, 26, 12, 0, -26 },
  { 1669, 12, 26, 18, 3, -26 },
  { 1708, 14, 26, 14, 0, -26 },
  { 1754, 24, 26, 24, 0, -26 },
  { 1832, 12, 26, 12, 0, -26 },
  { 1871, 12, 26, 12, 0, -26 },
  { 1910, 10, 26, 12, 1, -26 },
  { 1943, 7, 32, 11, 3, -26 },
  { 1971, 10, 26, 12, 1, -26 },
  { 2004, 7, 32, 11, 1, -26 },
  { 2032, 13, 13, 15, 1, -26 },
  { 2054, 15, 1, 14, 0, 3 },
  { 2056, 6, 6, 8, 1, -28 },
  { 2061, 10, 19, 14, 1, -19 },
  { 2085, 11, 27, 16, 3, -27 },
  { 2123, 9, 19, 12, 2, -19 },
  { 2145, 11, 27, 16, 2, -27 },
  { 2183, 10, 19, 14, 2, -19 },
  { 2207, 9, 28, 8, 0, -28 },
  { 2239, 11, 28, 15, 2, -19 },
  { 2278, 10, 27, 15, 3, -27 },
  { 2312, 2, 26, 7, 2, -26 },
  { 2319, 4, 35, 7, 0, -26 },
  { 2337, 9, 27, 12, 3, -27 },
  { 2368, 1, 27, 6, 3, -27 },
  { 2372, 17, 19, 22, 3, -19 },
  { 2413, 10, 19, 15, 3, -19 },
  { 2437, 11, 19, 15, 2, -19 },
  { 2464, 11, 27, 16, 3, -19 },
  { 2502, 11, 27, 15, 2, -19 },
  { 2540, 6, 19, 10, 3, -19 },
  { 2555, 9, 19, 11, 1, -19 },
  { 2577, 6, 24, 8, 1, -24 },
  { 2595, 11, 19, 15, 2, -19 },
  { 2622, 11, 19, 11, 0, -19 },
  { 2649, 19, 19, 19, 0, -19 },
  { 2695, 10, 19, 12, 1, -19 },
  { 2719, 11, 28, 12, 0, -19 },
  { 2758, 8, 19, 10, 1, -19 },
  { 2777, 9, 32, 13, 2, -26 },
  { 2813, 2, 36, 14, 6, -27 },
  { 2822, 9, 32, 13, 2, -26 },
  { 2858, 13, 3, 15, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight36pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT36PT7B_H_
