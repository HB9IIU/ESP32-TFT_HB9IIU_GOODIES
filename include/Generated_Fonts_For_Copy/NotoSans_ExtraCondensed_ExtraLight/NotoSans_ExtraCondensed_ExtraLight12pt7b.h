#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT12PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xFF, 0x32, 0x95, 0xF5, 0x2B, 0xEA, 0x50, 0x3E, 0xAA,
  0x63, 0x33, 0xE2, 0x93, 0x4D, 0x3A, 0xF6, 0xD5, 0x55, 0x58, 0x22, 0x94,
  0xC4, 0x56, 0x52, 0x78, 0xF0, 0x6A, 0xAA, 0xA4, 0x89, 0x12, 0x49, 0x4A,
  0x00, 0x5F, 0x00, 0x21, 0x3E, 0x42, 0x10, 0x68, 0xE0, 0x80, 0x11, 0x22,
  0x24, 0x44, 0x80, 0x56, 0xDB, 0x6D, 0xE0, 0x75, 0x55, 0x40, 0x61, 0x11,
  0x12, 0x24, 0xF0, 0x69, 0x11, 0x61, 0x11, 0xF0, 0x10, 0x8C, 0xA5, 0x4B,
  0xE2, 0x10, 0xF2, 0x4E, 0x49, 0xE0, 0x72, 0x6B, 0x6D, 0xE0, 0xF1, 0x11,
  0x22, 0x24, 0x40, 0x69, 0x95, 0x25, 0x99, 0x70, 0x69, 0x99, 0x97, 0x11,
  0x60, 0x84, 0x40, 0x1A, 0x09, 0xB0, 0xC1, 0x80, 0xF8, 0x3E, 0x83, 0x06,
  0x6C, 0x00, 0xC4, 0x94, 0x90, 0x40, 0x72, 0x28, 0x6D, 0xD7, 0x5D, 0x6A,
  0x81, 0xC0, 0x23, 0x18, 0xA5, 0x3A, 0x51, 0x88, 0xE9, 0x99, 0xE9, 0x99,
  0xE0, 0x78, 0x88, 0x88, 0x88, 0x70, 0xE9, 0x99, 0x99, 0x99, 0xE0, 0xF2,
  0x4F, 0x24, 0xE0, 0xF2, 0x4F, 0x24, 0x80, 0x7C, 0x21, 0x09, 0x46, 0x31,
  0x78, 0x99, 0x99, 0xF9, 0x99, 0x90, 0xD5, 0x55, 0xC0, 0x55, 0x55, 0x5C,
  0x9A, 0xAC, 0xCC, 0xAA, 0x90, 0x92, 0x49, 0x24, 0xE0, 0x86, 0x18, 0xF3,
  0xCF, 0x3B, 0x6D, 0xA4, 0x99, 0x9D, 0xBB, 0xB9, 0x90, 0x64, 0xA3, 0x18,
  0xC6, 0x32, 0x70, 0xD6, 0xDB, 0xA4, 0x80, 0x64, 0xA3, 0x18, 0xC6, 0x32,
  0xD1, 0x04, 0xCA, 0x99, 0xAC, 0xAA, 0x90, 0x78, 0x84, 0x21, 0x11, 0xF0,
  0xF2, 0x22, 0x22, 0x22, 0x20, 0x99, 0x99, 0x99, 0x99, 0xF0, 0x8C, 0x65,
  0x25, 0x29, 0x84, 0x20, 0x91, 0x91, 0x99, 0x9A, 0x5A, 0x6A, 0x66, 0x24,
  0x24, 0x95, 0x62, 0x22, 0x69, 0x90, 0x99, 0x96, 0x64, 0x44, 0x40, 0xF1,
  0x22, 0x24, 0x48, 0xF0, 0xEA, 0xAA, 0xAC, 0x88, 0x44, 0x42, 0x21, 0x10,
  0xE4, 0x92, 0x49, 0x27, 0x80, 0x21, 0x14, 0xA8, 0x80, 0xF8, 0xD0, 0x71,
  0x79, 0x9F, 0x88, 0xE9, 0x99, 0x99, 0xE0, 0xF2, 0x49, 0xC0, 0x25, 0xDB,
  0x6D, 0xE0, 0xF7, 0xC9, 0xC0, 0x6B, 0x24, 0x92, 0x40, 0xF6, 0xDB, 0xC9,
  0xE0, 0x93, 0x5B, 0x6D, 0xA0, 0x9F, 0x80, 0x9F, 0xF0, 0x92, 0x5D, 0xB5,
  0xA0, 0xFF, 0x80, 0xFE, 0x9A, 0x69, 0xA6, 0x90, 0xF6, 0xDB, 0x40, 0xF6,
  0xDB, 0xC0, 0xF9, 0x99, 0x9E, 0x88, 0x80, 0xF6, 0xDB, 0xC9, 0x20, 0xEA,
  0xA0, 0xF1, 0x13, 0xC0, 0x75, 0x55, 0xB6, 0xDB, 0xC0, 0x9A, 0xA6, 0x44,
  0x96, 0x5B, 0x5A, 0x49, 0x20, 0x96, 0x46, 0x69, 0x99, 0x66, 0x62, 0x44,
  0x80, 0xE5, 0x29, 0xC0, 0x29, 0x29, 0x22, 0x49, 0x80, 0xFF, 0xF0, 0x89,
  0x24, 0xD2, 0x4A, 0x00, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 9, 2, 1, -9 },
  { 3, 2, 4, 4, 1, -9 },
  { 4, 5, 9, 5, 0, -9 },
  { 10, 4, 10, 5, 0, -9 },
  { 15, 6, 9, 7, 1, -9 },
  { 22, 5, 9, 5, 0, -9 },
  { 28, 1, 4, 2, 1, -9 },
  { 29, 2, 11, 3, 1, -9 },
  { 32, 3, 11, 3, 0, -9 },
  { 37, 3, 3, 4, 1, -9 },
  { 39, 5, 6, 5, 0, -7 },
  { 43, 2, 3, 2, 0, -1 },
  { 44, 3, 1, 3, 0, -4 },
  { 45, 1, 1, 2, 1, -1 },
  { 46, 4, 9, 4, 0, -9 },
  { 51, 3, 9, 5, 1, -9 },
  { 55, 2, 9, 5, 1, -9 },
  { 58, 4, 9, 5, 0, -9 },
  { 63, 4, 9, 5, 0, -9 },
  { 68, 5, 9, 5, 0, -9 },
  { 74, 3, 9, 5, 1, -9 },
  { 78, 3, 9, 5, 1, -9 },
  { 82, 4, 9, 5, 0, -9 },
  { 87, 4, 9, 5, 0, -9 },
  { 92, 4, 9, 5, 0, -9 },
  { 97, 1, 6, 2, 1, -6 },
  { 98, 2, 8, 2, 0, -6 },
  { 100, 5, 5, 5, 0, -7 },
  { 104, 5, 3, 5, 0, -6 },
  { 106, 5, 5, 5, 0, -7 },
  { 110, 3, 9, 3, 0, -9 },
  { 114, 6, 10, 7, 1, -9 },
  { 122, 5, 9, 5, 0, -9 },
  { 128, 4, 9, 5, 1, -9 },
  { 133, 4, 9, 5, 1, -9 },
  { 138, 4, 9, 6, 1, -9 },
  { 143, 3, 9, 5, 1, -9 },
  { 147, 3, 9, 4, 1, -9 },
  { 151, 5, 9, 6, 1, -9 },
  { 157, 4, 9, 6, 1, -9 },
  { 162, 2, 9, 3, 0, -9 },
  { 165, 2, 11, 2, -1, -9 },
  { 168, 4, 9, 5, 1, -9 },
  { 173, 3, 9, 4, 1, -9 },
  { 177, 6, 9, 8, 1, -9 },
  { 184, 4, 9, 6, 1, -9 },
  { 189, 5, 9, 6, 1, -9 },
  { 195, 3, 9, 5, 1, -9 },
  { 199, 5, 11, 6, 1, -9 },
  { 206, 4, 9, 5, 1, -9 },
  { 211, 4, 9, 5, 0, -9 },
  { 216, 4, 9, 4, 0, -9 },
  { 221, 4, 9, 6, 1, -9 },
  { 226, 5, 9, 5, 0, -9 },
  { 232, 8, 9, 8, 0, -9 },
  { 241, 4, 9, 4, 0, -9 },
  { 246, 4, 9, 4, 0, -9 },
  { 251, 4, 9, 4, 0, -9 },
  { 256, 2, 11, 4, 1, -9 },
  { 259, 4, 9, 4, 0, -9 },
  { 264, 3, 11, 4, 0, -9 },
  { 269, 5, 5, 5, 0, -9 },
  { 273, 5, 1, 5, 0, 1 },
  { 274, 2, 2, 3, 0, -9 },
  { 275, 4, 6, 5, 0, -6 },
  { 278, 4, 9, 5, 1, -9 },
  { 283, 3, 6, 4, 1, -6 },
  { 286, 3, 9, 5, 1, -9 },
  { 290, 3, 6, 5, 1, -6 },
  { 293, 3, 9, 3, 0, -9 },
  { 297, 3, 9, 5, 1, -6 },
  { 301, 3, 9, 5, 1, -9 },
  { 305, 1, 9, 2, 1, -9 },
  { 307, 1, 12, 2, 0, -9 },
  { 309, 3, 9, 4, 1, -9 },
  { 313, 1, 9, 2, 1, -9 },
  { 315, 6, 6, 7, 1, -6 },
  { 320, 3, 6, 5, 1, -6 },
  { 323, 3, 6, 5, 1, -6 },
  { 326, 4, 9, 5, 1, -6 },
  { 331, 3, 9, 5, 1, -6 },
  { 335, 2, 6, 3, 1, -6 },
  { 337, 3, 6, 4, 0, -6 },
  { 340, 2, 8, 3, 0, -8 },
  { 342, 3, 6, 5, 1, -6 },
  { 345, 4, 6, 4, 0, -6 },
  { 348, 6, 6, 6, 0, -6 },
  { 353, 4, 6, 4, 0, -6 },
  { 356, 4, 9, 4, 0, -6 },
  { 361, 3, 6, 3, 0, -6 },
  { 364, 3, 11, 4, 1, -9 },
  { 369, 1, 12, 5, 2, -9 },
  { 371, 3, 11, 4, 1, -9 },
  { 376, 5, 1, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight12pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT12PT7B_H_
