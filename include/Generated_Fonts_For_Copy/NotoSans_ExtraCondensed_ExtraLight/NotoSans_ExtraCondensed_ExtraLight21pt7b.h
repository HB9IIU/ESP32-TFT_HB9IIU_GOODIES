#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT21PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight21pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x54, 0x1C, 0x99, 0x99, 0x90, 0x12, 0x09, 0x04, 0x82,
  0x47, 0xF8, 0x90, 0x88, 0x44, 0x22, 0x7F, 0x89, 0x04, 0x82, 0x41, 0x20,
  0x90, 0x10, 0x73, 0x54, 0x89, 0x12, 0x24, 0x28, 0x30, 0x38, 0x48, 0x91,
  0x22, 0xB7, 0x18, 0x10, 0x61, 0x24, 0x49, 0x22, 0x48, 0x92, 0x25, 0x09,
  0x5E, 0x59, 0x6A, 0x42, 0x90, 0xA4, 0x49, 0x12, 0x44, 0x92, 0x1C, 0x70,
  0x48, 0x48, 0x48, 0x48, 0x50, 0x30, 0x60, 0x92, 0x92, 0x8A, 0x84, 0x84,
  0x8A, 0x73, 0xF8, 0x12, 0x44, 0x48, 0x88, 0x88, 0x88, 0x84, 0x44, 0x23,
  0x84, 0x42, 0x22, 0x21, 0x11, 0x12, 0x22, 0x24, 0x48, 0x21, 0x3E, 0x45,
  0x44, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10, 0x5A, 0x80, 0xF0,
  0xB0, 0x02, 0x08, 0x10, 0x20, 0x81, 0x04, 0x08, 0x10, 0x40, 0x81, 0x04,
  0x08, 0x30, 0x00, 0x39, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x85, 0x13, 0x80, 0x2E, 0x92, 0x49, 0x24, 0x92, 0x48, 0xF8, 0x10, 0x41,
  0x04, 0x10, 0x42, 0x08, 0x42, 0x08, 0x42, 0x0F, 0xC0, 0xFA, 0x10, 0x41,
  0x04, 0x10, 0x9E, 0x04, 0x10, 0x41, 0x04, 0x1F, 0x80, 0x04, 0x04, 0x0C,
  0x0C, 0x14, 0x14, 0x24, 0x24, 0x44, 0x44, 0x84, 0x7F, 0x04, 0x04, 0x04,
  0x7D, 0x02, 0x04, 0x08, 0x10, 0x3E, 0x02, 0x04, 0x04, 0x08, 0x20, 0x40,
  0xBE, 0x00, 0x3C, 0x81, 0x04, 0x08, 0x10, 0x2E, 0x62, 0x85, 0x06, 0x0C,
  0x18, 0x48, 0x9E, 0x00, 0xFC, 0x10, 0x41, 0x08, 0x20, 0x84, 0x10, 0x42,
  0x08, 0x21, 0x04, 0x00, 0x79, 0x0A, 0x14, 0x28, 0x48, 0x8E, 0x18, 0x4D,
  0x0A, 0x0C, 0x18, 0x30, 0x9E, 0x00, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x7C, 0x10, 0x41, 0x04, 0x2F, 0x00, 0xE0, 0x00, 0x2C, 0xD0, 0x00, 0x16,
  0xA0, 0x02, 0x18, 0xC2, 0x08, 0x0C, 0x04, 0x06, 0x02, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x80, 0x80, 0xC0, 0x60, 0x21, 0x8C, 0x20, 0x80, 0xF0, 0x42,
  0x10, 0x84, 0x42, 0x21, 0x08, 0x00, 0x10, 0x80, 0x1F, 0x04, 0x11, 0x01,
  0x20, 0x24, 0x73, 0x12, 0x64, 0x4C, 0x89, 0x92, 0x32, 0x46, 0x48, 0xC9,
  0xA8, 0xC8, 0x80, 0x10, 0x01, 0x00, 0x1F, 0x00, 0x18, 0x18, 0x18, 0x14,
  0x24, 0x24, 0x24, 0x22, 0x7E, 0x42, 0x42, 0x42, 0x41, 0x81, 0x81, 0xFA,
  0x18, 0x61, 0x86, 0x18, 0xBE, 0x86, 0x18, 0x61, 0x86, 0x1F, 0x80, 0x1E,
  0x41, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x02, 0x04, 0x04, 0x07,
  0x80, 0xF1, 0x1A, 0x14, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x51, 0x3C, 0x00, 0xFC, 0x21, 0x08, 0x42, 0x1F, 0x84, 0x21, 0x08, 0x43,
  0xE0, 0xFC, 0x21, 0x08, 0x42, 0x1F, 0x84, 0x21, 0x08, 0x42, 0x00, 0x1F,
  0x90, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x0E, 0x80, 0xC0, 0x60, 0x28,
  0x14, 0x09, 0x04, 0x7E, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0x80, 0xE9, 0x24, 0x92, 0x49, 0x24, 0xB8,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x12, 0xC0, 0x86, 0x28,
  0xA4, 0xA2, 0x8C, 0x38, 0xA2, 0x49, 0x22, 0x8A, 0x18, 0x40, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x43, 0xE0, 0x80, 0x60, 0x1C, 0x0F,
  0x03, 0xC0, 0xE8, 0x5A, 0x16, 0x85, 0xA1, 0x64, 0x99, 0x26, 0x49, 0x8C,
  0x63, 0x18, 0xC4, 0x83, 0x07, 0x0E, 0x1A, 0x34, 0x64, 0xC9, 0x93, 0x16,
  0x2C, 0x38, 0x70, 0x60, 0x80, 0x3E, 0x20, 0x90, 0x50, 0x28, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x24, 0x12, 0x08, 0xF8, 0xF2, 0x28,
  0x61, 0x86, 0x18, 0x62, 0xF2, 0x08, 0x20, 0x82, 0x08, 0x00, 0x3E, 0x20,
  0x90, 0x50, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x24,
  0x12, 0x08, 0xF8, 0x08, 0x02, 0x01, 0x00, 0x40, 0xF2, 0x28, 0x61, 0x86,
  0x18, 0xB4, 0xA2, 0x49, 0x22, 0x8A, 0x18, 0x40, 0x7E, 0x08, 0x20, 0x82,
  0x06, 0x04, 0x0C, 0x10, 0x41, 0x04, 0x1F, 0x80, 0xFE, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x00, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42,
  0x3C, 0x81, 0x81, 0x81, 0x42, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x24,
  0x18, 0x18, 0x18, 0x18, 0x82, 0x06, 0x0C, 0x14, 0x30, 0x90, 0xC2, 0x43,
  0x09, 0x12, 0x24, 0x49, 0x09, 0x24, 0x24, 0x90, 0x92, 0x42, 0x89, 0x0A,
  0x18, 0x18, 0x60, 0x61, 0x81, 0x06, 0x00, 0x42, 0x85, 0x11, 0x22, 0x83,
  0x06, 0x08, 0x18, 0x50, 0x92, 0x24, 0x48, 0x60, 0x80, 0x83, 0x05, 0x12,
  0x24, 0x45, 0x0A, 0x14, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x00, 0xF8,
  0x20, 0x84, 0x10, 0x42, 0x08, 0x21, 0x04, 0x10, 0x82, 0x0F, 0xC0, 0xF8,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0xC0, 0x81, 0x01, 0x02,
  0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80, 0x80, 0xF1, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x08, 0x18, 0x14, 0x24, 0x22,
  0x42, 0xC1, 0xFF, 0x88, 0x80, 0x78, 0x42, 0x11, 0xB6, 0x31, 0x8C, 0x5E,
  0x81, 0x02, 0x04, 0x08, 0x17, 0xB0, 0xE1, 0x83, 0x06, 0x0C, 0x18, 0x38,
  0x71, 0x5E, 0x3A, 0x21, 0x08, 0x42, 0x10, 0x82, 0x1E, 0x02, 0x04, 0x08,
  0x10, 0x2F, 0x51, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x51, 0xBD, 0x79,
  0x18, 0x61, 0x87, 0xE8, 0x20, 0x81, 0x03, 0xC0, 0x39, 0x08, 0x42, 0x78,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x7A, 0x8E, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x86, 0x8D, 0xE8, 0x10, 0x20, 0x81, 0x7C, 0x82, 0x08, 0x20, 0x82,
  0xFC, 0x71, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0xC0, 0xAA, 0xAA, 0xA8,
  0x60, 0x04, 0x92, 0x49, 0x24, 0x92, 0x49, 0x60, 0x82, 0x08, 0x20, 0x82,
  0x38, 0xA4, 0x92, 0x8D, 0x24, 0x8A, 0x28, 0xA1, 0xFF, 0xFF, 0xB9, 0xD8,
  0xC6, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x21, 0x84, 0x30, 0x86,
  0x10, 0x80, 0xBF, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x40, 0x78,
  0x8A, 0x14, 0x18, 0x30, 0x60, 0xC1, 0x84, 0x89, 0xE0, 0xBD, 0x87, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0xC3, 0x8A, 0xF4, 0x08, 0x10, 0x20, 0x40, 0x7A,
  0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x8D, 0xE8, 0x10, 0x20, 0x40,
  0x81, 0xBE, 0x31, 0x08, 0x42, 0x10, 0x84, 0x20, 0x7C, 0x21, 0x04, 0x10,
  0x41, 0x08, 0x7C, 0x44, 0x4F, 0x44, 0x44, 0x44, 0x44, 0x43, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x85, 0x17, 0xC0, 0x86, 0x14, 0x51, 0x49, 0x22,
  0x8A, 0x30, 0xC1, 0x00, 0x84, 0x30, 0x85, 0x19, 0x25, 0x24, 0xA4, 0x94,
  0x8A, 0x51, 0x8C, 0x31, 0x86, 0x30, 0x42, 0x00, 0x44, 0x88, 0xA1, 0x41,
  0x02, 0x0A, 0x14, 0x48, 0x8A, 0x18, 0x82, 0x89, 0x12, 0x24, 0x45, 0x0A,
  0x14, 0x28, 0x20, 0x40, 0x81, 0x04, 0x08, 0x60, 0xF1, 0x22, 0x24, 0x44,
  0x88, 0xF0, 0x19, 0x08, 0x42, 0x10, 0x84, 0x66, 0x08, 0x42, 0x10, 0x84,
  0x20, 0xC0, 0xFF, 0xFF, 0xF8, 0xC1, 0x08, 0x42, 0x10, 0x84, 0x10, 0xC8,
  0x42, 0x10, 0x84, 0x27, 0x00, 0xF2, 0x18,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 15, 4, 1, -15 },
  { 5, 4, 5, 7, 1, -15 },
  { 8, 9, 15, 9, 0, -15 },
  { 25, 7, 17, 8, 1, -16 },
  { 40, 10, 15, 12, 1, -15 },
  { 59, 8, 15, 8, 1, -15 },
  { 74, 1, 5, 4, 1, -15 },
  { 75, 4, 18, 6, 1, -15 },
  { 84, 4, 18, 6, 1, -15 },
  { 93, 5, 6, 7, 1, -16 },
  { 97, 7, 9, 9, 1, -12 },
  { 105, 2, 5, 4, 1, -2 },
  { 107, 4, 1, 6, 1, -6 },
  { 108, 2, 2, 4, 1, -2 },
  { 109, 7, 15, 7, 0, -15 },
  { 123, 6, 15, 8, 1, -15 },
  { 135, 3, 15, 8, 2, -15 },
  { 141, 6, 15, 8, 1, -15 },
  { 153, 6, 15, 8, 1, -15 },
  { 165, 8, 15, 8, 0, -15 },
  { 180, 7, 15, 8, 1, -15 },
  { 194, 7, 15, 8, 1, -15 },
  { 208, 6, 15, 8, 1, -15 },
  { 220, 7, 15, 8, 1, -15 },
  { 234, 6, 15, 8, 1, -15 },
  { 246, 2, 11, 4, 1, -11 },
  { 249, 2, 14, 4, 1, -11 },
  { 253, 7, 9, 9, 1, -12 },
  { 261, 7, 5, 9, 1, -10 },
  { 266, 7, 9, 9, 1, -12 },
  { 274, 5, 15, 6, 0, -15 },
  { 284, 11, 17, 13, 1, -15 },
  { 308, 8, 15, 8, 0, -15 },
  { 323, 6, 15, 9, 2, -15 },
  { 335, 7, 15, 9, 1, -15 },
  { 349, 7, 15, 10, 2, -15 },
  { 363, 5, 15, 8, 2, -15 },
  { 373, 5, 15, 8, 2, -15 },
  { 383, 9, 15, 11, 1, -15 },
  { 400, 7, 15, 10, 2, -15 },
  { 414, 3, 15, 5, 1, -15 },
  { 420, 4, 19, 4, -1, -15 },
  { 430, 6, 15, 8, 2, -15 },
  { 442, 5, 15, 7, 2, -15 },
  { 452, 10, 15, 14, 2, -15 },
  { 471, 7, 15, 11, 2, -15 },
  { 485, 9, 15, 11, 1, -15 },
  { 502, 6, 15, 9, 2, -15 },
  { 514, 9, 19, 11, 1, -15 },
  { 536, 6, 15, 9, 2, -15 },
  { 548, 6, 15, 8, 1, -15 },
  { 560, 7, 15, 7, 0, -15 },
  { 574, 8, 15, 10, 1, -15 },
  { 589, 8, 15, 8, 0, -15 },
  { 604, 14, 15, 14, 0, -15 },
  { 631, 7, 15, 7, 0, -15 },
  { 645, 7, 15, 7, 0, -15 },
  { 659, 6, 15, 7, 1, -15 },
  { 671, 4, 18, 6, 2, -15 },
  { 680, 7, 15, 7, 0, -15 },
  { 694, 4, 18, 6, 1, -15 },
  { 703, 8, 7, 9, 0, -15 },
  { 710, 8, 1, 8, 0, 2 },
  { 711, 3, 3, 5, 1, -16 },
  { 713, 5, 11, 8, 1, -11 },
  { 720, 7, 16, 9, 1, -16 },
  { 734, 5, 11, 7, 1, -11 },
  { 741, 7, 16, 9, 1, -16 },
  { 755, 6, 11, 8, 1, -11 },
  { 764, 5, 16, 5, 0, -16 },
  { 774, 7, 16, 9, 1, -11 },
  { 788, 6, 16, 9, 1, -16 },
  { 800, 2, 15, 4, 1, -15 },
  { 804, 3, 20, 4, 0, -15 },
  { 812, 6, 16, 7, 1, -16 },
  { 824, 1, 16, 4, 1, -16 },
  { 826, 11, 11, 13, 1, -11 },
  { 842, 6, 11, 9, 1, -11 },
  { 851, 7, 11, 9, 1, -11 },
  { 861, 7, 16, 9, 1, -11 },
  { 875, 7, 16, 9, 1, -11 },
  { 889, 5, 11, 6, 1, -11 },
  { 896, 5, 11, 7, 1, -11 },
  { 903, 4, 14, 5, 0, -14 },
  { 910, 6, 11, 9, 1, -11 },
  { 919, 6, 11, 6, 0, -11 },
  { 928, 11, 11, 11, 0, -11 },
  { 944, 7, 11, 7, 0, -11 },
  { 954, 7, 16, 7, 0, -11 },
  { 968, 4, 11, 6, 1, -11 },
  { 974, 5, 18, 7, 1, -15 },
  { 986, 1, 21, 8, 4, -16 },
  { 989, 5, 18, 7, 1, -15 },
  { 1001, 7, 2, 9, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight21pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT21PT7B_H_
