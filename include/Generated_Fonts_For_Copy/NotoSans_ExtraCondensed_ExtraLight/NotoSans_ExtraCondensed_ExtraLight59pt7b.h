#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT59PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight59pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x1B,
  0x03, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x30, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C,
  0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0x80,
  0x06, 0x03, 0x00, 0x0C, 0x06, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0,
  0x60, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x06, 0x01, 0x80, 0x0C,
  0x03, 0x00, 0x18, 0x04, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0,
  0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x04, 0x03, 0x03, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xE0, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0,
  0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x10, 0x0C, 0x00,
  0x60, 0x18, 0x00, 0xC0, 0x20, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06,
  0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x1C,
  0x41, 0xC3, 0x84, 0x04, 0x70, 0x40, 0x06, 0x04, 0x00, 0xE0, 0x40, 0x0C,
  0x04, 0x00, 0xC0, 0x40, 0x0C, 0x04, 0x00, 0xC0, 0x40, 0x0C, 0x04, 0x00,
  0xE0, 0x40, 0x06, 0x04, 0x00, 0x70, 0x40, 0x03, 0x84, 0x00, 0x1C, 0x40,
  0x00, 0xF4, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x05,
  0xE0, 0x00, 0x47, 0x80, 0x04, 0x3C, 0x00, 0x40, 0xC0, 0x04, 0x0E, 0x00,
  0x40, 0x60, 0x04, 0x07, 0x00, 0x40, 0x30, 0x04, 0x03, 0x00, 0x40, 0x30,
  0x04, 0x07, 0x00, 0x40, 0x60, 0x04, 0x06, 0x00, 0x40, 0xC8, 0x04, 0x1C,
  0xF0, 0x47, 0x8F, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x60, 0x0C, 0x60, 0x03, 0x00, 0xC1, 0x80, 0x18, 0x06, 0x0C,
  0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x06,
  0x00, 0xC0, 0x60, 0x30, 0x06, 0x03, 0x01, 0x80, 0x30, 0x18, 0x18, 0x01,
  0x80, 0xC0, 0xC0, 0x0C, 0x06, 0x06, 0x00, 0x60, 0x38, 0x60, 0x03, 0x01,
  0xC3, 0x00, 0x18, 0x0C, 0x18, 0x00, 0xC0, 0x61, 0x80, 0x06, 0x03, 0x0C,
  0x1C, 0x30, 0x18, 0x63, 0xF9, 0x80, 0xC6, 0x38, 0xCC, 0x06, 0x31, 0x83,
  0x60, 0x31, 0x98, 0x19, 0x83, 0x18, 0xC0, 0xCC, 0x18, 0xC6, 0x03, 0x31,
  0x86, 0x30, 0x19, 0xF8, 0x61, 0x80, 0xC3, 0x83, 0x0C, 0x06, 0x00, 0x18,
  0xC0, 0x30, 0x01, 0x86, 0x01, 0x80, 0x0C, 0x30, 0x0C, 0x00, 0x61, 0x80,
  0x60, 0x06, 0x0C, 0x03, 0x00, 0x30, 0x60, 0x18, 0x01, 0x81, 0x00, 0xC0,
  0x18, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x30, 0x06, 0x03, 0x01, 0x80, 0x60,
  0x18, 0x0C, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x03, 0x06, 0x01, 0x80, 0x18,
  0x70, 0x0C, 0x00, 0x67, 0x00, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x02, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x73, 0x80, 0x03, 0x07, 0x00, 0x0C,
  0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x0C,
  0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x1C, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0xC1, 0xC0, 0x03, 0x86, 0x00, 0x06, 0x38, 0x00, 0x18,
  0xC0, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0xEC, 0x00, 0x06, 0x38, 0x00, 0x38, 0x60, 0x00, 0xC0, 0xC0, 0x66,
  0x03, 0x03, 0x98, 0x06, 0x0C, 0xE0, 0x1C, 0x33, 0x00, 0x30, 0xCC, 0x00,
  0xE3, 0x30, 0x01, 0x9C, 0xC0, 0x03, 0x63, 0x00, 0x0D, 0x8C, 0x00, 0x1C,
  0x30, 0x00, 0x70, 0xC0, 0x01, 0xC3, 0x80, 0x0F, 0x86, 0x00, 0x36, 0x1C,
  0x01, 0x8C, 0x38, 0x1C, 0x30, 0x7F, 0xE0, 0x60, 0xFF, 0x01, 0xC0, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x30, 0x0E, 0x01, 0x80, 0x70,
  0x0C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07,
  0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x30, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00,
  0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x10, 0x20, 0x7C, 0x47, 0xBE, 0xFC, 0x07, 0xC0, 0x07, 0x00, 0x1B, 0x00,
  0x63, 0x01, 0xC6, 0x03, 0x06, 0x0C, 0x06, 0x30, 0x0C, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x0C, 0x31,
  0xC6, 0x18, 0x43, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xFE,
  0x00, 0xF3, 0xC0, 0x70, 0x38, 0x18, 0x06, 0x0E, 0x01, 0xC3, 0x00, 0x31,
  0xC0, 0x0C, 0x60, 0x03, 0x98, 0x00, 0x66, 0x00, 0x1B, 0x80, 0x06, 0xE0,
  0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x01, 0x98, 0x00,
  0x66, 0x00, 0x19, 0x80, 0x0E, 0x70, 0x03, 0x0C, 0x00, 0xC3, 0x80, 0x70,
  0x60, 0x18, 0x1E, 0x0C, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0xE0, 0x3C,
  0x0F, 0x83, 0xB0, 0xE6, 0x38, 0xCE, 0x1F, 0x83, 0x60, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xE0, 0x01, 0xFF, 0x80,
  0xF8, 0xF8, 0x38, 0x03, 0x82, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xE0, 0x03, 0xFF, 0x80, 0xF8, 0xF8, 0x78, 0x03, 0x84,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0xE0, 0x0F, 0x1F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0x60, 0x00, 0x0D,
  0x80, 0x00, 0x36, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x31, 0x80,
  0x00, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0xC1, 0x80, 0x03,
  0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x06,
  0x00, 0x70, 0x18, 0x01, 0x80, 0x60, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01,
  0xC0, 0x18, 0x06, 0x00, 0x60, 0x38, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00,
  0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x06, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x37, 0xFC, 0x0F,
  0xFF, 0xC1, 0x80, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC8, 0x00, 0xE3, 0x00,
  0x78, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x3F,
  0xC0, 0x3F, 0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x7C,
  0x0C, 0x7F, 0xC3, 0x38, 0x78, 0xD8, 0x07, 0x34, 0x00, 0xCF, 0x00, 0x1B,
  0x80, 0x06, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x36, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x01, 0x9C, 0x00, 0x63, 0x00, 0x38,
  0xE0, 0x0C, 0x1C, 0x06, 0x03, 0xC7, 0x80, 0x7F, 0xC0, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x0F, 0x1F, 0x01, 0xC0,
  0x38, 0x38, 0x01, 0x83, 0x00, 0x1C, 0x30, 0x00, 0xC7, 0x00, 0x0C, 0x60,
  0x00, 0xE6, 0x00, 0x0E, 0x60, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xC3,
  0x00, 0x0C, 0x38, 0x01, 0xC1, 0x80, 0x18, 0x1C, 0x03, 0x80, 0xE0, 0x70,
  0x07, 0x1E, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0x9C,
  0x00, 0xE0, 0xE0, 0x1C, 0x07, 0x03, 0x80, 0x38, 0x30, 0x01, 0xC7, 0x00,
  0x0C, 0x60, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x6E, 0x00, 0x06, 0x60, 0x00, 0x66,
  0x00, 0x0E, 0x70, 0x00, 0xC3, 0x80, 0x1C, 0x1C, 0x03, 0x80, 0xF9, 0xF0,
  0x07, 0xFE, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x3C, 0xF8,
  0x0E, 0x03, 0x03, 0x80, 0x30, 0x60, 0x07, 0x1C, 0x00, 0x63, 0x00, 0x0C,
  0x60, 0x01, 0xCC, 0x00, 0x1B, 0x80, 0x03, 0x70, 0x00, 0x6E, 0x00, 0x0D,
  0xC0, 0x01, 0xB8, 0x00, 0x37, 0x00, 0x06, 0xE0, 0x00, 0xEC, 0x00, 0x1D,
  0x80, 0x03, 0xB0, 0x00, 0x76, 0x00, 0x1E, 0xE0, 0x03, 0xCC, 0x00, 0xF9,
  0xC0, 0x36, 0x1E, 0x1C, 0xC1, 0xFF, 0x18, 0x0F, 0xC3, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x07, 0xBF, 0x00, 0xFF, 0x80, 0x03,
  0x00, 0x00, 0x4E, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0xEF, 0xEE, 0x10, 0xE3, 0xCF, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC7, 0x18, 0x63, 0x8E, 0x30, 0xC3, 0x1C, 0x61, 0x84, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x08,
  0x00, 0x00, 0x0F, 0x01, 0xFF, 0x8F, 0x9F, 0x10, 0x1C, 0x00, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x00, 0x01,
  0xC0, 0x18, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x06, 0x30, 0x07, 0xF8, 0x19, 0xC0, 0x3C, 0xE0, 0x66, 0x01,
  0xC1, 0x80, 0xD8, 0x06, 0x06, 0x03, 0x60, 0x30, 0x18, 0x0D, 0x80, 0xC0,
  0x60, 0x3E, 0x06, 0x01, 0x80, 0xF0, 0x18, 0x0E, 0x03, 0xC0, 0x60, 0x38,
  0x0F, 0x01, 0x80, 0xE0, 0x3C, 0x06, 0x03, 0x00, 0xF0, 0x18, 0x0C, 0x03,
  0xC0, 0x60, 0x30, 0x0F, 0x01, 0x80, 0xC0, 0x3C, 0x06, 0x03, 0x00, 0xF0,
  0x18, 0x0C, 0x03, 0xC0, 0x60, 0x30, 0x0F, 0x01, 0x81, 0xC0, 0x6E, 0x06,
  0x07, 0x81, 0x98, 0x0C, 0x16, 0x06, 0x60, 0x30, 0xCC, 0x31, 0x80, 0x7E,
  0x3F, 0xC6, 0x00, 0xF8, 0x7C, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x08, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x39, 0x80, 0x00,
  0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xE0, 0x01, 0x80,
  0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x07, 0x00, 0x38, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x07, 0x00, 0x70,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x30, 0x01, 0x80, 0xE0, 0x03, 0x81,
  0xC0, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x38,
  0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xE7, 0x00,
  0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x0C, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0x00, 0x78, 0x60,
  0x03, 0x8C, 0x00, 0x39, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0E, 0xC0,
  0x01, 0xD8, 0x00, 0x3B, 0x00, 0x07, 0x60, 0x00, 0xEC, 0x00, 0x1D, 0x80,
  0x03, 0x30, 0x00, 0x66, 0x00, 0x1C, 0xC0, 0x03, 0x18, 0x01, 0xC3, 0x00,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0x80, 0x3C, 0x30, 0x01, 0xC6, 0x00,
  0x1C, 0xC0, 0x01, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1B, 0x00, 0x03, 0x60, 0x00, 0xEC, 0x00, 0x1D, 0x80, 0x07, 0x30, 0x01,
  0xC6, 0x00, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x0F,
  0xFE, 0x01, 0xF9, 0xF0, 0x38, 0x01, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x10, 0x1F, 0xDF, 0x00, 0x7F, 0xE0, 0x00, 0x60, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0xC0, 0x3E, 0x0C, 0x00, 0xF0, 0xC0, 0x03, 0x8C, 0x00,
  0x38, 0xC0, 0x01, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xEC, 0x00, 0x0E, 0xC0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0,
  0x01, 0xCC, 0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00, 0x70, 0xC0, 0x0E, 0x0C,
  0x03, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0xFF, 0xEF, 0xFF, 0xD8, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xBF, 0xFF, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x3E, 0x1F, 0xC0, 0x78, 0x00, 0xE0, 0x78, 0x00,
  0x10, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xE0, 0x00,
  0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x0E,
  0x00, 0x03, 0x03, 0xC0, 0x07, 0x80, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0x00,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xFF, 0xDF, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0xFF, 0xBF, 0xF0, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0xEF, 0xF3, 0xF8, 0x30, 0x00,
  0xC0, 0x01, 0xF0, 0x00, 0xEC, 0x00, 0x33, 0x00, 0x1C, 0xC0, 0x0E, 0x30,
  0x03, 0x0C, 0x01, 0xC3, 0x00, 0x60, 0xC0, 0x38, 0x30, 0x1C, 0x0C, 0x06,
  0x03, 0x03, 0x80, 0xC0, 0xC0, 0x30, 0x70, 0x0C, 0x18, 0x03, 0x0C, 0x00,
  0xC7, 0x00, 0x31, 0x80, 0x0C, 0xE0, 0x03, 0x38, 0x00, 0xDF, 0x00, 0x3C,
  0xC0, 0x0F, 0x38, 0x03, 0x86, 0x00, 0xC1, 0xC0, 0x30, 0x30, 0x0C, 0x0E,
  0x03, 0x01, 0x80, 0xC0, 0x70, 0x30, 0x0C, 0x0C, 0x03, 0x83, 0x00, 0x60,
  0xC0, 0x1C, 0x30, 0x03, 0x0C, 0x00, 0xE3, 0x00, 0x18, 0xC0, 0x07, 0x30,
  0x00, 0xCC, 0x00, 0x3B, 0x00, 0x06, 0xC0, 0x01, 0xF0, 0x00, 0x30, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x6F, 0xC0, 0x00, 0x01, 0xBD,
  0x80, 0x00, 0x0E, 0xF6, 0x00, 0x00, 0x33, 0xD8, 0x00, 0x00, 0xCF, 0x30,
  0x00, 0x03, 0x3C, 0xC0, 0x00, 0x18, 0xF3, 0x00, 0x00, 0x63, 0xCE, 0x00,
  0x01, 0x8F, 0x18, 0x00, 0x0E, 0x3C, 0x60, 0x00, 0x30, 0xF1, 0x80, 0x00,
  0xC3, 0xC3, 0x00, 0x07, 0x0F, 0x0C, 0x00, 0x18, 0x3C, 0x30, 0x00, 0x60,
  0xF0, 0x60, 0x01, 0x83, 0xC1, 0x80, 0x0C, 0x0F, 0x06, 0x00, 0x30, 0x3C,
  0x1C, 0x00, 0xC0, 0xF0, 0x30, 0x07, 0x03, 0xC0, 0xC0, 0x18, 0x0F, 0x03,
  0x00, 0x60, 0x3C, 0x06, 0x03, 0x80, 0xF0, 0x18, 0x0C, 0x03, 0xC0, 0x60,
  0x30, 0x0F, 0x01, 0xC0, 0xC0, 0x3C, 0x03, 0x06, 0x00, 0xF0, 0x0C, 0x18,
  0x03, 0xC0, 0x38, 0x60, 0x0F, 0x00, 0x63, 0x80, 0x3C, 0x01, 0x8C, 0x00,
  0xF0, 0x06, 0x30, 0x03, 0xC0, 0x0D, 0xC0, 0x0F, 0x00, 0x36, 0x00, 0x3C,
  0x00, 0xD8, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0x00,
  0x1C, 0x00, 0x30, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0x60, 0x00, 0x7B, 0x80, 0x03,
  0xCC, 0x00, 0x1E, 0x60, 0x00, 0xF1, 0x80, 0x07, 0x8C, 0x00, 0x3C, 0x30,
  0x01, 0xE1, 0x80, 0x0F, 0x0E, 0x00, 0x78, 0x30, 0x03, 0xC1, 0xC0, 0x1E,
  0x06, 0x00, 0xF0, 0x30, 0x07, 0x80, 0xC0, 0x3C, 0x06, 0x01, 0xE0, 0x38,
  0x0F, 0x00, 0xC0, 0x78, 0x07, 0x03, 0xC0, 0x18, 0x1E, 0x00, 0xC0, 0xF0,
  0x03, 0x07, 0x80, 0x18, 0x3C, 0x00, 0x61, 0xE0, 0x03, 0x0F, 0x00, 0x1C,
  0x78, 0x00, 0x63, 0xC0, 0x03, 0x9E, 0x00, 0x0C, 0xF0, 0x00, 0x67, 0x80,
  0x01, 0xBC, 0x00, 0x0D, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xF8, 0xF8, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x00,
  0xC0, 0x60, 0x00, 0x70, 0x70, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x18, 0x00,
  0x03, 0x1C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0x70,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03,
  0x70, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0x70, 0x00,
  0x06, 0x38, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x07,
  0x80, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0xFF, 0xC0, 0x7F, 0xFC, 0x30, 0x0F, 0x18, 0x01, 0xCC, 0x00, 0x76, 0x00,
  0x3B, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0x60, 0x01, 0xB0, 0x01, 0xD8, 0x00, 0xCC, 0x00, 0xE6, 0x01, 0xE3, 0xFF,
  0xE1, 0xFF, 0xC0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xF8, 0xF8, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x00,
  0xC0, 0x60, 0x00, 0x70, 0x70, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x18, 0x00,
  0x03, 0x1C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0x70,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03,
  0x70, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0x70, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x07,
  0x80, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0xFF, 0xC0, 0x3F, 0xFE, 0x0C, 0x03, 0xC3, 0x00,
  0x38, 0xC0, 0x07, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0E, 0xC0, 0x01,
  0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C,
  0x00, 0x3B, 0x00, 0x0E, 0xC0, 0x03, 0x30, 0x01, 0xCC, 0x00, 0x63, 0x00,
  0x38, 0xC0, 0x3C, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0x03, 0x00, 0xC0, 0xC0,
  0x30, 0x38, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xC0, 0x30, 0x30, 0x0E, 0x0C,
  0x01, 0x83, 0x00, 0x70, 0xC0, 0x0C, 0x30, 0x03, 0x8C, 0x00, 0x63, 0x00,
  0x18, 0xC0, 0x07, 0x30, 0x00, 0xCC, 0x00, 0x3B, 0x00, 0x06, 0xC0, 0x01,
  0xF0, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x3F, 0x3F, 0x0F, 0x00,
  0x63, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0xE0, 0x0F, 0x1F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0x67, 0x00, 0x07, 0x18, 0x00,
  0x30, 0xE0, 0x03, 0x83, 0xC0, 0x38, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00,
  0x07, 0x60, 0x00, 0x19, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x0E,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18,
  0x00, 0x70, 0x60, 0x01, 0x81, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00,
  0xE0, 0x30, 0x03, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0,
  0x18, 0x06, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x80, 0x0C,
  0x0C, 0x00, 0x30, 0x30, 0x00, 0xE0, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x18,
  0x00, 0x18, 0x60, 0x00, 0x71, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x38, 0x00,
  0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0xC0, 0x00, 0x70, 0x00, 0x19, 0x80, 0x00, 0xE0, 0x00,
  0x33, 0x00, 0x01, 0xC0, 0x00, 0x67, 0x00, 0x06, 0x80, 0x01, 0xCE, 0x00,
  0x0D, 0x80, 0x03, 0x8C, 0x00, 0x1B, 0x00, 0x06, 0x18, 0x00, 0x36, 0x00,
  0x0C, 0x30, 0x00, 0x6C, 0x00, 0x18, 0x70, 0x01, 0xD8, 0x00, 0x70, 0x60,
  0x03, 0x38, 0x00, 0xC0, 0xC0, 0x06, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x60,
  0x03, 0x03, 0x00, 0x18, 0xC0, 0x0E, 0x07, 0x00, 0x71, 0x80, 0x1C, 0x06,
  0x00, 0xC3, 0x80, 0x30, 0x0C, 0x01, 0x83, 0x00, 0x60, 0x18, 0x03, 0x06,
  0x00, 0xC0, 0x38, 0x06, 0x0C, 0x03, 0x80, 0x70, 0x1C, 0x18, 0x07, 0x00,
  0x60, 0x30, 0x38, 0x0C, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x07, 0x07, 0x01, 0x81, 0x80,
  0x06, 0x0C, 0x03, 0x83, 0x00, 0x0C, 0x18, 0x03, 0x06, 0x00, 0x18, 0x30,
  0x06, 0x1C, 0x00, 0x38, 0x60, 0x0C, 0x38, 0x00, 0x31, 0xC0, 0x18, 0x60,
  0x00, 0x63, 0x00, 0x38, 0xC0, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x01, 0x8C,
  0x00, 0x67, 0x00, 0x03, 0x98, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x01, 0x98,
  0x00, 0x06, 0xC0, 0x03, 0x30, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0x1B,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xEE, 0x00, 0x18, 0xC0, 0x07, 0x1C, 0x00, 0xC1, 0x80, 0x18, 0x30,
  0x07, 0x07, 0x00, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x01, 0xC0, 0xC0, 0x18,
  0x38, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x06, 0x38, 0x00, 0xC6, 0x00, 0x0C,
  0xC0, 0x01, 0xB0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x0D, 0x80, 0x01, 0xB8, 0x00, 0x63,
  0x00, 0x0C, 0x60, 0x03, 0x8E, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x03,
  0x80, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x00, 0xE0, 0x60, 0x0C, 0x18, 0x01,
  0xC3, 0x00, 0x18, 0xE0, 0x03, 0x18, 0x00, 0x73, 0x00, 0x06, 0xC0, 0x00,
  0xD8, 0x00, 0x1C, 0xE0, 0x00, 0x76, 0x00, 0x06, 0x60, 0x00, 0xE6, 0x00,
  0x0C, 0x30, 0x00, 0xC3, 0x00, 0x1C, 0x30, 0x01, 0x81, 0x80, 0x18, 0x18,
  0x03, 0x81, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x0C, 0x06, 0x00,
  0x60, 0x60, 0x06, 0x0E, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0xC0,
  0x03, 0x18, 0x00, 0x19, 0x80, 0x01, 0xB8, 0x00, 0x1B, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0xFF, 0xFF,
  0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1B, 0x00, 0x00, 0xCC, 0x00, 0x03,
  0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0E,
  0x00, 0x60, 0x18, 0x01, 0x80, 0x70, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x81,
  0x80, 0x06, 0x06, 0x00, 0x1C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00,
  0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80,
  0x03, 0xE0, 0x1F, 0xF8, 0x3C, 0x1C, 0x10, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0xFF, 0x07, 0xFF, 0x0F, 0x03, 0x3C, 0x03,
  0x30, 0x03, 0x70, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x60, 0x0B, 0x70, 0x1B,
  0x3C, 0x73, 0x1F, 0xE3, 0x03, 0x80, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x81, 0xE0, 0x30, 0xFF, 0x06, 0x38, 0xF0, 0xCC, 0x07, 0x1B, 0x00,
  0x73, 0x40, 0x06, 0x78, 0x00, 0xEE, 0x00, 0x0D, 0xC0, 0x01, 0xB8, 0x00,
  0x37, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x6E, 0x00, 0x0D, 0xC0, 0x01,
  0xB8, 0x00, 0x77, 0x80, 0x0C, 0xD0, 0x01, 0x9B, 0x00, 0x63, 0x30, 0x1C,
  0x63, 0xDF, 0x0C, 0x3F, 0xC0, 0x00, 0x80, 0x00, 0x00, 0xF8, 0x0F, 0xFC,
  0x3E, 0x30, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x43, 0xEF, 0x83, 0xFF, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x78, 0x30, 0xFF, 0x8C, 0x78, 0x73, 0x1C, 0x06,
  0xCE, 0x00, 0xF7, 0x00, 0x3D, 0x80, 0x07, 0x60, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x76,
  0x00, 0x1D, 0x80, 0x07, 0x70, 0x03, 0xCC, 0x01, 0xB3, 0x80, 0xE4, 0x7C,
  0xF1, 0x07, 0xF8, 0x40, 0x20, 0x00, 0x01, 0xC0, 0x03, 0xFC, 0x07, 0x87,
  0x03, 0x01, 0xC3, 0x00, 0x61, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x08, 0xE0, 0x18, 0x3E, 0x7C,
  0x0F, 0xFC, 0x00, 0x60, 0x00, 0x01, 0xF8, 0x3F, 0xC1, 0xC0, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x03, 0xFF, 0x9F, 0xFC, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x03, 0xFE, 0x11,
  0xF1, 0xCC, 0xE0, 0x1B, 0x30, 0x03, 0xDC, 0x00, 0x76, 0x00, 0x1D, 0x80,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x1D, 0xC0, 0x0F, 0x30, 0x06,
  0xC6, 0x03, 0x31, 0xF7, 0xCC, 0x1F, 0xC3, 0x00, 0x80, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xE8, 0x00, 0x71, 0x80, 0x38, 0x7F, 0xFC,
  0x07, 0xFC, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x07, 0x83, 0x0F, 0xF1, 0x9E,
  0x3C, 0xCC, 0x0E, 0x6C, 0x03, 0xB4, 0x00, 0xDE, 0x00, 0x6E, 0x00, 0x37,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x38, 0xFF, 0xF4, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x1C, 0x38, 0x70,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x87, 0x7C, 0xF0, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x30,
  0xC0, 0x60, 0xC0, 0xE0, 0xC0, 0xC0, 0xC1, 0xC0, 0xC1, 0x80, 0xC3, 0x00,
  0xC7, 0x00, 0xC7, 0x00, 0xCF, 0x80, 0xCD, 0x80, 0xD9, 0x80, 0xF1, 0xC0,
  0xF0, 0xC0, 0xE0, 0xE0, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x70, 0xC0, 0x30,
  0xC0, 0x38, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0E,
  0xC0, 0x06, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x0F, 0x06, 0x3F, 0xC1, 0xFE, 0x33,
  0x8F, 0x1C, 0x79, 0xB0, 0x19, 0x80, 0xED, 0x00, 0xEC, 0x07, 0x78, 0x03,
  0xC0, 0x1B, 0x80, 0x1E, 0x00, 0xDC, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x00,
  0x3F, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0x00, 0xF0, 0x61, 0xFE, 0x33, 0xC7, 0x99, 0x80, 0xCD, 0x80, 0x76, 0x80,
  0x1B, 0xC0, 0x0D, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x01, 0xE0, 0x00, 0xFF,
  0x80, 0x78, 0x78, 0x1C, 0x03, 0x83, 0x00, 0x30, 0xE0, 0x03, 0x18, 0x00,
  0x63, 0x00, 0x0E, 0xE0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00,
  0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01,
  0xB0, 0x00, 0x37, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x39, 0x80, 0x06,
  0x18, 0x01, 0xC3, 0x80, 0x30, 0x38, 0x0E, 0x03, 0xEF, 0x80, 0x3F, 0xE0,
  0x00, 0xC0, 0x00, 0x00, 0xF0, 0x18, 0x7F, 0x83, 0x1C, 0x78, 0x66, 0x03,
  0x8D, 0x80, 0x39, 0xA0, 0x03, 0x3C, 0x00, 0x77, 0x00, 0x06, 0xE0, 0x00,
  0xDC, 0x00, 0x1B, 0x80, 0x03, 0x70, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x37, 0x00, 0x06,
  0xE0, 0x00, 0xDC, 0x00, 0x3B, 0xC0, 0x06, 0x6C, 0x01, 0xCD, 0x80, 0x31,
  0x98, 0x0E, 0x31, 0xEF, 0x86, 0x1F, 0xE0, 0xC0, 0x40, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xFE, 0x10, 0xF1, 0xCC,
  0x70, 0x1B, 0x38, 0x02, 0xCC, 0x00, 0xF7, 0x00, 0x1D, 0x80, 0x07, 0x60,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xD8, 0x00, 0x76, 0x00, 0x1D, 0xC0, 0x0F, 0x38, 0x06, 0xC7, 0x03,
  0x31, 0xF7, 0xCC, 0x1F, 0xC3, 0x00, 0x80, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0xD8, 0x7F, 0x1F, 0xE6, 0x0D, 0x81, 0xB0, 0x34, 0x07, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x03, 0xE0, 0x3F,
  0xFC, 0xF0, 0xF3, 0x80, 0x26, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x68, 0x01, 0xD8, 0x07, 0x3F, 0xFE, 0x3F, 0xF0, 0x07, 0x00, 0x08,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0xFF, 0xFF,
  0xFC, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x1E, 0xC1, 0xF8, 0x0C, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xF0,
  0x02, 0xD8, 0x03, 0x6E, 0x01, 0x37, 0x01, 0x99, 0xFF, 0x8C, 0x7F, 0x86,
  0x0E, 0x00, 0xE0, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x19, 0x80, 0x06, 0x70,
  0x01, 0x8C, 0x00, 0xE3, 0x00, 0x30, 0xC0, 0x0C, 0x38, 0x03, 0x06, 0x01,
  0xC1, 0x80, 0x60, 0x60, 0x18, 0x18, 0x06, 0x03, 0x03, 0x80, 0xC0, 0xC0,
  0x30, 0x30, 0x0C, 0x0C, 0x01, 0x87, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06,
  0x18, 0x01, 0xC6, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0C, 0x00,
  0xC0, 0x07, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x6C, 0x00, 0x78, 0x01, 0xB8,
  0x01, 0xE0, 0x06, 0x60, 0x07, 0x80, 0x19, 0x80, 0x36, 0x00, 0xC6, 0x00,
  0xD8, 0x03, 0x18, 0x03, 0x30, 0x0C, 0x30, 0x0C, 0xC0, 0x30, 0xC0, 0x33,
  0x01, 0xC3, 0x01, 0x8C, 0x06, 0x0C, 0x06, 0x38, 0x18, 0x38, 0x18, 0x60,
  0x60, 0x60, 0x61, 0x81, 0x81, 0x83, 0x86, 0x0E, 0x06, 0x0C, 0x18, 0x30,
  0x18, 0x30, 0x30, 0xC0, 0x30, 0xC0, 0xC3, 0x00, 0xC3, 0x03, 0x0C, 0x03,
  0x18, 0x0C, 0x60, 0x0C, 0x60, 0x31, 0x80, 0x39, 0x80, 0x66, 0x00, 0x66,
  0x01, 0x98, 0x01, 0x98, 0x06, 0x60, 0x06, 0xC0, 0x1B, 0x00, 0x1B, 0x00,
  0x6C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0E,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x60, 0x03, 0xB8,
  0x01, 0x8C, 0x01, 0xC7, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x60, 0x30, 0x30,
  0x18, 0x38, 0x06, 0x18, 0x03, 0x1C, 0x01, 0xCC, 0x00, 0x6E, 0x00, 0x36,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x01, 0xB0, 0x00,
  0xDC, 0x00, 0xE6, 0x00, 0x63, 0x80, 0x70, 0xC0, 0x30, 0x60, 0x38, 0x18,
  0x18, 0x0C, 0x1C, 0x07, 0x0C, 0x01, 0x86, 0x00, 0xE6, 0x00, 0x33, 0x00,
  0x1F, 0x80, 0x06, 0xE0, 0x01, 0xD8, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06,
  0x70, 0x03, 0x8C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x07, 0x06,
  0x01, 0x81, 0x80, 0x60, 0x60, 0x18, 0x18, 0x0E, 0x03, 0x03, 0x00, 0xC0,
  0xC0, 0x30, 0x30, 0x0C, 0x1C, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60,
  0x06, 0x38, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x70, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x01, 0xFC,
  0x07, 0x80, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xF0, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xFC, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0,
  0x01, 0xF8, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xF8, 0x00, 0x3C,
  0x01, 0xF8, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x04,
  0x00, 0x03, 0xF8, 0x01, 0xFB, 0xE0, 0x3C, 0x07, 0x87, 0x80, 0x1F, 0xE8,
  0x00, 0x78,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 42, 12, 4, -42 },
  { 22, 11, 15, 18, 4, -42 },
  { 43, 23, 42, 25, 1, -42 },
  { 164, 20, 48, 24, 2, -45 },
  { 284, 29, 44, 35, 3, -43 },
  { 444, 22, 44, 24, 2, -43 },
  { 565, 2, 15, 10, 4, -42 },
  { 569, 11, 51, 16, 3, -42 },
  { 640, 11, 51, 16, 2, -42 },
  { 711, 15, 16, 21, 3, -45 },
  { 741, 20, 27, 24, 2, -34 },
  { 809, 6, 14, 11, 2, -6 },
  { 820, 12, 2, 16, 2, -17 },
  { 823, 3, 4, 11, 4, -4 },
  { 825, 18, 42, 20, 1, -42 },
  { 920, 18, 43, 24, 3, -43 },
  { 1017, 11, 42, 24, 4, -42 },
  { 1075, 19, 43, 24, 2, -43 },
  { 1178, 19, 44, 24, 2, -43 },
  { 1283, 22, 42, 24, 1, -42 },
  { 1399, 18, 43, 24, 3, -42 },
  { 1496, 18, 44, 24, 3, -43 },
  { 1595, 19, 42, 24, 2, -42 },
  { 1695, 20, 44, 24, 2, -43 },
  { 1805, 19, 44, 24, 2, -43 },
  { 1910, 4, 32, 11, 4, -32 },
  { 1926, 6, 40, 11, 2, -32 },
  { 1956, 20, 24, 24, 2, -33 },
  { 2016, 20, 15, 24, 2, -28 },
  { 2054, 20, 24, 24, 2, -33 },
  { 2114, 14, 43, 16, 1, -43 },
  { 2190, 30, 47, 36, 3, -42 },
  { 2367, 23, 42, 23, 0, -42 },
  { 2488, 19, 42, 26, 5, -42 },
  { 2588, 20, 44, 25, 3, -43 },
  { 2698, 20, 42, 28, 5, -42 },
  { 2803, 15, 42, 23, 5, -42 },
  { 2882, 15, 42, 21, 5, -42 },
  { 2961, 25, 44, 31, 3, -43 },
  { 3099, 20, 42, 29, 5, -42 },
  { 3204, 10, 42, 14, 2, -42 },
  { 3257, 10, 53, 11, -3, -42 },
  { 3324, 18, 42, 23, 5, -42 },
  { 3419, 14, 42, 20, 5, -42 },
  { 3493, 30, 42, 39, 5, -42 },
  { 3651, 21, 42, 31, 5, -42 },
  { 3762, 25, 44, 31, 3, -43 },
  { 3900, 17, 42, 24, 5, -42 },
  { 3990, 25, 53, 31, 3, -43 },
  { 4156, 18, 42, 25, 5, -42 },
  { 4251, 19, 44, 23, 2, -43 },
  { 4356, 20, 42, 20, 0, -42 },
  { 4461, 21, 43, 29, 4, -42 },
  { 4574, 22, 42, 22, 0, -42 },
  { 4690, 39, 42, 39, 0, -42 },
  { 4895, 19, 42, 20, 1, -42 },
  { 4995, 20, 42, 20, 0, -42 },
  { 5100, 16, 42, 20, 2, -42 },
  { 5184, 11, 51, 18, 5, -42 },
  { 5255, 18, 42, 20, 1, -42 },
  { 5350, 11, 51, 18, 2, -42 },
  { 5421, 22, 21, 24, 1, -42 },
  { 5479, 24, 2, 24, 0, 5 },
  { 5485, 9, 9, 14, 2, -45 },
  { 5496, 16, 33, 22, 2, -32 },
  { 5562, 19, 46, 25, 4, -45 },
  { 5672, 15, 33, 19, 3, -32 },
  { 5734, 18, 46, 25, 3, -45 },
  { 5838, 17, 33, 23, 3, -32 },
  { 5909, 13, 45, 13, 1, -45 },
  { 5983, 18, 46, 25, 3, -32 },
  { 6087, 17, 45, 25, 4, -45 },
  { 6183, 3, 43, 11, 4, -43 },
  { 6200, 7, 57, 11, 0, -43 },
  { 6250, 16, 45, 20, 4, -45 },
  { 6340, 2, 45, 10, 4, -45 },
  { 6352, 29, 32, 37, 4, -32 },
  { 6468, 17, 32, 25, 4, -32 },
  { 6536, 19, 33, 24, 3, -32 },
  { 6615, 19, 46, 25, 4, -32 },
  { 6725, 18, 46, 25, 3, -32 },
  { 6829, 11, 32, 16, 4, -32 },
  { 6873, 15, 33, 19, 2, -32 },
  { 6935, 11, 40, 13, 1, -39 },
  { 6990, 17, 32, 25, 4, -31 },
  { 7058, 18, 31, 18, 0, -31 },
  { 7128, 30, 31, 31, 1, -31 },
  { 7245, 17, 31, 19, 1, -31 },
  { 7311, 18, 45, 19, 1, -31 },
  { 7413, 12, 31, 16, 2, -31 },
  { 7460, 15, 51, 21, 3, -42 },
  { 7556, 2, 59, 23, 10, -45 },
  { 7571, 15, 51, 21, 3, -42 },
  { 7667, 20, 6, 24, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight59pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT59PT7B_H_
