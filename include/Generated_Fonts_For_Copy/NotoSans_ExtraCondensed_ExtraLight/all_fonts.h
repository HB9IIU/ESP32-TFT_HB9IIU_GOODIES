#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_ExtraCondensed_ExtraLight
// Headers: 67

#include "NotoSans_ExtraCondensed_ExtraLight6pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight7pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight8pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight9pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight10pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight11pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight12pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight13pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight14pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight15pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight16pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight17pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight18pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight19pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight20pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight21pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight22pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight23pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight24pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight25pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight26pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight27pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight28pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight29pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight30pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight31pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight32pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight33pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight34pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight35pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight36pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight37pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight38pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight39pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight40pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight41pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight42pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight43pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight44pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight45pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight46pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight47pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight48pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight49pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight50pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight51pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight52pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight53pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight54pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight55pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight56pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight57pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight58pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight59pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight60pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight61pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight62pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight63pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight64pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight65pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight66pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight67pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight68pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight69pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight70pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight71pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraLight72pt7b.h"
