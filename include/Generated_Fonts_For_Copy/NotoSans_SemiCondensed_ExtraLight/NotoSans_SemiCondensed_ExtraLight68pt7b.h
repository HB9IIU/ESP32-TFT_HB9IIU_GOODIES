#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT68PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight68pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x3F, 0xFF, 0x71, 0x00, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x36,
  0x01, 0xB0, 0x0D, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0,
  0x36, 0x01, 0x80, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x06, 0x00,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x70, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x03, 0x80, 0x0C,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x0E, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x06, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x07, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x7C, 0x60, 0xFC, 0x3C, 0x18, 0x06, 0x1E, 0x06, 0x00, 0x07, 0x01,
  0x80, 0x03, 0x80, 0x60, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0C,
  0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x06, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0x80, 0x60, 0x00, 0xE0, 0x18, 0x00, 0x1C, 0x06,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x78, 0x60, 0x00, 0x0F, 0x98, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x06, 0xFC, 0x00, 0x01, 0x87, 0xC0, 0x00, 0x60, 0x78, 0x00, 0x18,
  0x0F, 0x00, 0x06, 0x01, 0xC0, 0x01, 0x80, 0x38, 0x00, 0x60, 0x06, 0x00,
  0x18, 0x01, 0xC0, 0x06, 0x00, 0x70, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x07,
  0x00, 0x18, 0x01, 0xC0, 0x06, 0x00, 0x70, 0x01, 0x80, 0x18, 0x00, 0x60,
  0x0E, 0x00, 0x18, 0x03, 0x00, 0x06, 0x01, 0xCC, 0x01, 0x81, 0xE3, 0xF0,
  0x61, 0xF0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x01, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0xE0, 0x03, 0xC3, 0xC0, 0x00, 0x30, 0x00, 0xE0, 0x30, 0x00, 0x1C,
  0x00, 0x70, 0x0E, 0x00, 0x06, 0x00, 0x18, 0x01, 0x80, 0x03, 0x80, 0x06,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x03,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x80, 0x70, 0x00,
  0x30, 0x00, 0xE0, 0x18, 0x00, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x81, 0xC0, 0x00, 0x30, 0x00, 0xE0,
  0x60, 0x00, 0x0C, 0x00, 0x30, 0x38, 0x00, 0x03, 0x00, 0x0C, 0x0C, 0x07,
  0x80, 0xC0, 0x03, 0x07, 0x07, 0xF8, 0x38, 0x00, 0xC1, 0x83, 0xCF, 0x0E,
  0x00, 0x70, 0xE1, 0xC0, 0xE1, 0x80, 0x1C, 0x30, 0x60, 0x1C, 0x60, 0x06,
  0x1C, 0x38, 0x03, 0x1C, 0x03, 0x86, 0x0C, 0x00, 0xE3, 0x81, 0xC1, 0x87,
  0x00, 0x38, 0xF0, 0xF0, 0xE1, 0xC0, 0x06, 0x1F, 0xF8, 0x30, 0x60, 0x01,
  0x81, 0xF8, 0x1C, 0x18, 0x00, 0x60, 0x00, 0x06, 0x06, 0x00, 0x1C, 0x00,
  0x03, 0x81, 0x80, 0x07, 0x00, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0x00, 0x70,
  0x18, 0x00, 0x70, 0x00, 0x18, 0x06, 0x00, 0x1C, 0x00, 0x0E, 0x01, 0x80,
  0x07, 0x00, 0x03, 0x00, 0x60, 0x01, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x70,
  0x00, 0x60, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x00, 0x38, 0x03,
  0x00, 0x0C, 0x00, 0x06, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x01,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF7, 0x00, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0xE0,
  0x00, 0xC3, 0x80, 0x07, 0x00, 0x0C, 0x38, 0x00, 0x38, 0x01, 0xC7, 0x00,
  0x01, 0xC0, 0x1C, 0x70, 0x00, 0x1E, 0x01, 0x86, 0x00, 0x00, 0xE0, 0x38,
  0x60, 0x00, 0x07, 0x03, 0x8E, 0x00, 0x00, 0x38, 0x30, 0xE0, 0x00, 0x01,
  0xC7, 0x0E, 0x00, 0x00, 0x0E, 0xE0, 0xE0, 0x00, 0x00, 0xFE, 0x06, 0x00,
  0x00, 0x07, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0xC0,
  0x70, 0x00, 0x00, 0xFE, 0x03, 0x80, 0x00, 0x1E, 0x70, 0x3C, 0x00, 0x03,
  0xC7, 0x81, 0xE0, 0x00, 0x78, 0x38, 0x0F, 0x80, 0x3E, 0x01, 0xC0, 0x7F,
  0xFF, 0xC0, 0x0E, 0x01, 0xFF, 0xF0, 0x00, 0x70, 0x03, 0xF0, 0x00, 0x00,
  0xFF, 0xED, 0xB6, 0xDB, 0x6D, 0xB6, 0xD8, 0x00, 0x38, 0x03, 0x80, 0x38,
  0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x80, 0x18, 0x01, 0x70, 0x0C, 0x03, 0xBF, 0x06, 0x0F, 0xE7, 0xF3, 0x3F,
  0x80, 0x3F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x61, 0x80, 0x00, 0x70, 0x60, 0x00, 0x70,
  0x38, 0x00, 0x30, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x38,
  0x00, 0x70, 0x04, 0x00, 0x20, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x71, 0xC7, 0x1C, 0xE3, 0x8E, 0x38, 0xC7, 0x1C, 0x63,
  0x8E, 0x30, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0xBF, 0xFF,
  0x10, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x01, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x18, 0x38, 0x00, 0x03, 0x86, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x06, 0x38,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x01, 0xF0, 0x1E,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x70, 0x07, 0xC0, 0x3F, 0x01, 0xEC, 0x0F, 0x30, 0xF0, 0xC7,
  0x83, 0x3C, 0x0F, 0xE0, 0x36, 0x00, 0xD0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x03, 0xE0, 0x1F,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0x20, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x03, 0xF0, 0x3E, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x79, 0x80, 0x00, 0x1E, 0x3F, 0x00,
  0x1F, 0x83, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x07, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x06, 0x00, 0x03,
  0x80, 0x03, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x06, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x3F, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x88, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x78, 0x3E, 0x00,
  0x3E, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xF8, 0x0C, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x0F, 0xE0, 0x0E, 0x0F, 0xFF, 0x81, 0xC7,
  0xF1, 0xF8, 0x39, 0xE0, 0x07, 0x87, 0x70, 0x00, 0x38, 0xEC, 0x00, 0x03,
  0x9F, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x06, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x06, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x1E, 0x00,
  0xF0, 0x0F, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0x03, 0xF0, 0x07, 0x80, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x70, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x18, 0xE0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0x3C, 0x0F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x01, 0xE0,
  0x07, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x1C, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x07, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x78, 0x38, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0x83, 0xE0, 0x07, 0x80, 0x0E, 0x01, 0xE0, 0x00, 0xE0, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0x63, 0x80, 0x00, 0xCC, 0x38, 0x00,
  0x71, 0x83, 0xC0, 0x3C, 0x30, 0x3F, 0xFF, 0x06, 0x01, 0xFF, 0x81, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x08, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x77, 0xFF, 0xE7, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0xF7, 0xFF, 0xE2, 0x00, 0x1C, 0x7C, 0xF9, 0xE1, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x87, 0x0E, 0x38,
  0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0x03, 0xE1, 0xC0, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xC3, 0x80, 0x01, 0xFF, 0xF0,
  0x03, 0x0C, 0x00, 0x1F, 0xCF, 0xC0, 0x0E, 0x70, 0x00, 0xF0, 0x03, 0x00,
  0x39, 0xC0, 0x07, 0x80, 0x0C, 0x00, 0x66, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xB8, 0x00, 0xE0, 0x01, 0xC0, 0x06, 0xE0, 0x03, 0x00, 0x07, 0x00, 0x1F,
  0x80, 0x1C, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0x60, 0x00, 0x70, 0x01, 0xF0,
  0x01, 0x80, 0x01, 0xC0, 0x07, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x1F, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xF0, 0x03,
  0x80, 0x01, 0x80, 0x07, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0x1F, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x6C, 0x00, 0xE0, 0x00, 0x60, 0x01, 0xB0, 0x03, 0x80,
  0x03, 0x80, 0x06, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x3B, 0x00, 0x18, 0x00,
  0x38, 0x00, 0xCC, 0x00, 0x70, 0x01, 0xB0, 0x03, 0x38, 0x01, 0xC0, 0x06,
  0xC0, 0x1C, 0xE0, 0x03, 0x80, 0x33, 0x00, 0xE1, 0x80, 0x0F, 0x01, 0xC6,
  0x07, 0x06, 0x00, 0x1F, 0xFE, 0x1F, 0xF8, 0x1C, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x70, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x03, 0xF0, 0xE0,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x0E, 0x00,
  0x03, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x0E, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0xF0, 0xE0, 0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x07,
  0xF8, 0x03, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x40,
  0x1F, 0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0xE0,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x0F, 0x80, 0xE0, 0x00, 0x3F, 0x00, 0xE0, 0x0F, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0x00, 0xFF, 0x80, 0x3E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x04, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x00,
  0x61, 0xE0, 0x00, 0x00, 0x0C, 0x1E, 0x00, 0x00, 0x01, 0x81, 0xE0, 0x00,
  0x00, 0x30, 0x1E, 0x00, 0x00, 0x06, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xCF, 0x7E, 0x3F,
  0xF0, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x0E, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0,
  0x1C, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE3, 0xE0, 0x00, 0x0E,
  0x77, 0x00, 0x00, 0xEF, 0x78, 0x00, 0x0E, 0xE3, 0x80, 0x00, 0xFC, 0x1C,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70,
  0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xB0,
  0x00, 0x00, 0x00, 0x6F, 0xDC, 0x00, 0x00, 0x00, 0x77, 0xE6, 0x00, 0x00,
  0x00, 0x3B, 0xF3, 0x80, 0x00, 0x00, 0x19, 0xF9, 0xC0, 0x00, 0x00, 0x1C,
  0xFC, 0x60, 0x00, 0x00, 0x0E, 0x7E, 0x38, 0x00, 0x00, 0x06, 0x3F, 0x1C,
  0x00, 0x00, 0x07, 0x1F, 0x86, 0x00, 0x00, 0x03, 0x0F, 0xC3, 0x80, 0x00,
  0x01, 0x87, 0xE1, 0xC0, 0x00, 0x01, 0xC3, 0xF0, 0x70, 0x00, 0x00, 0xC1,
  0xF8, 0x38, 0x00, 0x00, 0xE0, 0xFC, 0x0C, 0x00, 0x00, 0x70, 0x7E, 0x07,
  0x00, 0x00, 0x30, 0x3F, 0x03, 0x80, 0x00, 0x38, 0x1F, 0x80, 0xC0, 0x00,
  0x1C, 0x0F, 0xC0, 0x70, 0x00, 0x0C, 0x07, 0xE0, 0x38, 0x00, 0x0E, 0x03,
  0xF0, 0x0C, 0x00, 0x06, 0x01, 0xF8, 0x07, 0x00, 0x07, 0x00, 0xFC, 0x03,
  0x80, 0x03, 0x80, 0x7E, 0x00, 0xE0, 0x01, 0x80, 0x3F, 0x00, 0x70, 0x01,
  0xC0, 0x1F, 0x80, 0x18, 0x00, 0xE0, 0x0F, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0xF0, 0x01, 0x80, 0x30, 0x01, 0xF8, 0x00,
  0xE0, 0x18, 0x00, 0xFC, 0x00, 0x70, 0x1C, 0x00, 0x7E, 0x00, 0x18, 0x0C,
  0x00, 0x3F, 0x00, 0x0E, 0x0E, 0x00, 0x1F, 0x80, 0x07, 0x07, 0x00, 0x0F,
  0xC0, 0x01, 0xC3, 0x00, 0x07, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0xF0, 0x00,
  0x31, 0xC0, 0x01, 0xF8, 0x00, 0x1C, 0xC0, 0x00, 0xFC, 0x00, 0x0E, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0x60, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFB, 0x80, 0x00, 0x01, 0xF7, 0x00, 0x00, 0x03, 0xE7,
  0x00, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x0F, 0x8E, 0x00, 0x00, 0x1F, 0x0E,
  0x00, 0x00, 0x3E, 0x1C, 0x00, 0x00, 0x7C, 0x1C, 0x00, 0x00, 0xF8, 0x38,
  0x00, 0x01, 0xF0, 0x38, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x07, 0xC0, 0x70,
  0x00, 0x0F, 0x80, 0x70, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0xE0,
  0x00, 0x7C, 0x01, 0xC0, 0x00, 0xF8, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xC0,
  0x03, 0xE0, 0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x0F, 0x80, 0x07, 0x00,
  0x1F, 0x00, 0x07, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0E, 0x00,
  0xF8, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0x1C, 0x03, 0xE0, 0x00, 0x1C, 0x07,
  0xC0, 0x00, 0x38, 0x0F, 0x80, 0x00, 0x38, 0x1F, 0x00, 0x00, 0x38, 0x3E,
  0x00, 0x00, 0x70, 0x7C, 0x00, 0x00, 0x70, 0xF8, 0x00, 0x00, 0xE1, 0xF0,
  0x00, 0x00, 0xE3, 0xE0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x01, 0xCF, 0x80,
  0x00, 0x01, 0xDF, 0x00, 0x00, 0x03, 0xBE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0x80, 0x03,
  0xF0, 0xE0, 0x00, 0x3E, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x7E,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x0E, 0x00, 0x0F, 0xC0, 0xE0, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0xF8, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0xE0, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xC0, 0x00, 0xC1,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x79, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0x87, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x3C, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0E, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1D, 0x80,
  0x00, 0x0C, 0x38, 0x00, 0x01, 0x98, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x19,
  0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x30, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x70, 0x60, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x60, 0x70, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x07, 0x00,
  0x07, 0x00, 0x70, 0x00, 0xE0, 0x30, 0x00, 0x60, 0x07, 0x00, 0x0C, 0x03,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x18, 0x00, 0xC0, 0x03, 0x80,
  0x18, 0x01, 0x80, 0x1C, 0x00, 0x18, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x01,
  0xC0, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x0C, 0x01, 0x80,
  0x01, 0xC0, 0x30, 0x00, 0xC0, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x60, 0x70, 0x00, 0x06, 0x06, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0E,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x38, 0xE0, 0x00,
  0x03, 0x9C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x39, 0x80, 0x00, 0x19, 0xC0,
  0x00, 0x01, 0x98, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x1D,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x60,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x01,
  0xC0, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x39, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x18, 0x03, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x0C,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0,
  0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0x00, 0x78, 0x08, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xE7,
  0x0F, 0xC0, 0x07, 0x1E, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x78, 0x00, 0x07,
  0x70, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0x70, 0x00, 0x37, 0x78, 0x00, 0x67, 0x3C, 0x01, 0xC7,
  0x1F, 0xFF, 0x87, 0x07, 0xFF, 0x03, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0xF8, 0x00, 0xC0, 0xFF, 0xE0, 0x18, 0x7F, 0xFF, 0x03, 0x1E, 0x00,
  0xF0, 0x67, 0x00, 0x0F, 0x0D, 0xC0, 0x00, 0xF1, 0xB0, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x06, 0x70, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x0E, 0x36, 0x00, 0x01, 0xC6,
  0xE0, 0x00, 0x70, 0xCE, 0x00, 0x1C, 0x18, 0xE0, 0x0F, 0x03, 0x0F, 0xFF,
  0xC0, 0x60, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0x00, 0x60, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x30, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x70, 0x07, 0x00, 0xFF, 0xE0, 0xE0, 0x7F, 0xFE, 0x1C, 0x1E,
  0x00, 0xE3, 0x87, 0x00, 0x0E, 0x71, 0xC0, 0x00, 0x6E, 0x78, 0x00, 0x0D,
  0xCE, 0x00, 0x00, 0xFB, 0x80, 0x00, 0x1F, 0x70, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xB8,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x3E, 0x60, 0x00, 0x07, 0xCE, 0x00, 0x01,
  0xB8, 0xE0, 0x00, 0x37, 0x1E, 0x00, 0x0C, 0xE1, 0xF0, 0x07, 0x1C, 0x1F,
  0xFF, 0xC3, 0x80, 0xFF, 0xF0, 0x30, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x01,
  0xC0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x30, 0x00,
  0x03, 0x38, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x81, 0xF0, 0x03, 0xC0, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x07,
  0xFF, 0x00, 0xF8, 0x70, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFC,
  0x1C, 0x0F, 0xFF, 0xC3, 0x83, 0xC0, 0x1E, 0x70, 0xE0, 0x00, 0xCE, 0x38,
  0x00, 0x0D, 0xCE, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x1F, 0x70, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xB0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0xCE,
  0x00, 0x00, 0xF9, 0xC0, 0x00, 0x37, 0x1C, 0x00, 0x0E, 0xE3, 0xC0, 0x03,
  0x9C, 0x3E, 0x00, 0xE3, 0x83, 0xFF, 0xF8, 0x70, 0x1F, 0xFC, 0x0E, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x40, 0x00, 0x07, 0x0E, 0x00, 0x03, 0xC1, 0xF8, 0x01, 0xF0, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x0F, 0x00, 0xC0, 0xFF, 0xE0, 0xC3, 0xFF, 0xF0, 0xC7,
  0x80, 0x78, 0xCE, 0x00, 0x1C, 0xDC, 0x00, 0x0E, 0xD8, 0x00, 0x0E, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x21, 0xE7, 0xF8, 0xFE, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x3D, 0x80, 0x00, 0xE3, 0x00, 0x03, 0xC6, 0x00, 0x07, 0x0C, 0x00, 0x1C,
  0x18, 0x00, 0x70, 0x30, 0x01, 0xC0, 0x60, 0x07, 0x80, 0xC0, 0x0E, 0x01,
  0x80, 0x38, 0x03, 0x00, 0xE0, 0x06, 0x03, 0x80, 0x0C, 0x0E, 0x00, 0x18,
  0x1C, 0x00, 0x30, 0x70, 0x00, 0x61, 0xE0, 0x00, 0xC7, 0xE0, 0x01, 0x9D,
  0xC0, 0x03, 0x31, 0xC0, 0x06, 0xC1, 0x80, 0x0F, 0x83, 0x80, 0x1E, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x60, 0x07, 0x00, 0xC0, 0x07, 0x01, 0x80, 0x0E,
  0x03, 0x00, 0x0E, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x1C,
  0x30, 0x00, 0x38, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x73,
  0x00, 0x00, 0x76, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x30, 0x7F, 0xE0, 0x0F, 0xFE, 0x0C, 0x3F, 0xFC, 0x07, 0xFF, 0xC3, 0x1C,
  0x07, 0x83, 0xC0, 0x78, 0xCC, 0x00, 0x71, 0xC0, 0x07, 0x36, 0x00, 0x0E,
  0xE0, 0x01, 0xED, 0x00, 0x03, 0xB0, 0x00, 0x3B, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xB8, 0x00, 0x07, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0xC0, 0xFF, 0xE0, 0xC3, 0xFF, 0xF0, 0xC7, 0x80, 0x7C, 0xCE, 0x00,
  0x1C, 0xDC, 0x00, 0x0E, 0xD8, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x78, 0x03, 0xE0, 0x0E, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x70, 0x3C, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x18, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C,
  0x60, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x18, 0x1F, 0xFC, 0x03, 0x0F, 0xFF, 0xE0,
  0x63, 0xC0, 0x1E, 0x0C, 0xE0, 0x01, 0xE1, 0x98, 0x00, 0x1E, 0x36, 0x00,
  0x01, 0xC6, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00,
  0xCF, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xC6, 0xC0,
  0x00, 0x38, 0xDC, 0x00, 0x0E, 0x19, 0xC0, 0x03, 0xC3, 0x1E, 0x01, 0xF0,
  0x61, 0xFF, 0xF8, 0x0C, 0x0F, 0xFE, 0x01, 0x80, 0x3C, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF8, 0x30, 0x3F, 0xFF, 0x0C, 0x1E,
  0x00, 0xE3, 0x0E, 0x00, 0x1C, 0xC7, 0x00, 0x03, 0xB3, 0x80, 0x00, 0x6C,
  0xE0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x1B, 0x1C, 0x00, 0x0E,
  0xC7, 0x80, 0x07, 0x30, 0xF8, 0x07, 0x8C, 0x1F, 0xFF, 0xC3, 0x01, 0xFF,
  0xC0, 0xC0, 0x0F, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0xC1, 0xFF, 0xC3, 0xFF,
  0xC7, 0x81, 0xCE, 0x00, 0xDC, 0x00, 0xD8, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0xFF, 0x80, 0xFF, 0xFF, 0x87, 0x80, 0x1E, 0x38, 0x00, 0x09, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x3A, 0x00, 0x01, 0xCF, 0x00, 0x1E, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xF0, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF6, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x7D, 0xC0, 0x00, 0x36, 0x70, 0x00, 0x33, 0x3C,
  0x00, 0x31, 0x8F, 0x00, 0x70, 0xC3, 0xFF, 0xF0, 0x60, 0xFF, 0xF0, 0x30,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x07, 0x38, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x18, 0x70, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xE0, 0x30, 0x00, 0x18, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x0C,
  0x00, 0x18, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x18,
  0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xC0, 0x18, 0x00, 0x1C,
  0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x18, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x66, 0x00, 0x01, 0xE0, 0x00, 0x19, 0xC0, 0x00, 0x7C,
  0x00, 0x0E, 0x70, 0x00, 0x1F, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0xC0, 0x00,
  0xC3, 0x00, 0x03, 0x30, 0x00, 0x30, 0xE0, 0x00, 0xCE, 0x00, 0x1C, 0x38,
  0x00, 0x73, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x60, 0x01, 0x81, 0x80, 0x06,
  0x18, 0x00, 0x60, 0x70, 0x01, 0x87, 0x00, 0x38, 0x1C, 0x00, 0xE1, 0xC0,
  0x0E, 0x07, 0x00, 0x38, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x0E, 0x00, 0xC0,
  0x38, 0x07, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x60, 0x1C, 0x03, 0x80,
  0x60, 0x18, 0x06, 0x00, 0x60, 0x18, 0x07, 0x01, 0x80, 0x1C, 0x0E, 0x01,
  0xC0, 0xE0, 0x07, 0x03, 0x80, 0x30, 0x38, 0x00, 0xC0, 0xC0, 0x0E, 0x0C,
  0x00, 0x30, 0x70, 0x03, 0x83, 0x00, 0x0E, 0x1C, 0x00, 0x61, 0xC0, 0x03,
  0x86, 0x00, 0x18, 0x70, 0x00, 0x63, 0x80, 0x07, 0x18, 0x00, 0x18, 0xE0,
  0x01, 0xC6, 0x00, 0x07, 0x38, 0x00, 0x33, 0x80, 0x01, 0xCC, 0x00, 0x0C,
  0xE0, 0x00, 0x37, 0x00, 0x03, 0xB0, 0x00, 0x0D, 0xC0, 0x00, 0xEC, 0x00,
  0x03, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x70, 0x70, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x38, 0x0E, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x70, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0xE0,
  0x00, 0x38, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07,
  0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x03, 0x18, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03,
  0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x01, 0x80,
  0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x00, 0x60, 0x00, 0xE0,
  0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0x00, 0x06, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00,
  0x1C, 0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x18, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x10, 0x78, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x20, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x3F, 0x00,
  0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x09, 0xFF, 0xE0, 0x00, 0xDE, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC1, 0xE8, 0x00, 0x1F, 0xFE, 0x40, 0x00, 0x3F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 50, 15, 5, -49 },
  { 33, 13, 18, 22, 5, -49 },
  { 63, 35, 49, 39, 2, -49 },
  { 278, 26, 56, 35, 4, -52 },
  { 460, 42, 50, 49, 4, -49 },
  { 723, 36, 50, 41, 3, -49 },
  { 948, 3, 18, 12, 5, -49 },
  { 955, 13, 60, 18, 3, -49 },
  { 1053, 13, 60, 18, 2, -49 },
  { 1151, 25, 25, 33, 4, -52 },
  { 1230, 29, 32, 35, 3, -40 },
  { 1346, 6, 17, 13, 3, -8 },
  { 1359, 16, 3, 20, 2, -20 },
  { 1365, 5, 6, 15, 5, -5 },
  { 1369, 21, 49, 23, 1, -49 },
  { 1498, 27, 50, 35, 4, -49 },
  { 1667, 14, 49, 35, 6, -49 },
  { 1753, 27, 49, 35, 3, -49 },
  { 1919, 27, 50, 35, 3, -49 },
  { 2088, 33, 49, 35, 1, -49 },
  { 2291, 27, 50, 35, 4, -49 },
  { 2460, 27, 50, 35, 4, -49 },
  { 2629, 28, 49, 35, 3, -49 },
  { 2801, 27, 50, 35, 4, -49 },
  { 2970, 27, 50, 35, 3, -49 },
  { 3139, 5, 37, 15, 5, -36 },
  { 3163, 7, 45, 15, 3, -36 },
  { 3203, 29, 30, 35, 3, -39 },
  { 3312, 29, 16, 35, 3, -32 },
  { 3370, 29, 30, 35, 3, -39 },
  { 3479, 21, 50, 25, 2, -49 },
  { 3611, 46, 54, 53, 4, -48 },
  { 3922, 35, 49, 35, 0, -49 },
  { 4137, 28, 49, 38, 6, -49 },
  { 4309, 31, 50, 37, 4, -49 },
  { 4503, 32, 49, 42, 6, -49 },
  { 4699, 24, 49, 33, 6, -49 },
  { 4846, 24, 49, 30, 6, -49 },
  { 4993, 35, 50, 44, 4, -49 },
  { 5212, 31, 49, 43, 6, -49 },
  { 5402, 12, 49, 19, 3, -49 },
  { 5476, 14, 61, 15, -5, -49 },
  { 5583, 28, 49, 34, 6, -49 },
  { 5755, 23, 49, 31, 6, -49 },
  { 5896, 41, 49, 53, 6, -49 },
  { 6148, 31, 49, 44, 6, -49 },
  { 6338, 38, 50, 46, 4, -49 },
  { 6576, 26, 49, 35, 6, -49 },
  { 6736, 38, 61, 46, 4, -49 },
  { 7026, 28, 49, 36, 6, -49 },
  { 7198, 27, 50, 33, 3, -49 },
  { 7367, 30, 49, 31, 0, -49 },
  { 7551, 31, 50, 43, 6, -49 },
  { 7745, 34, 49, 34, 0, -49 },
  { 7954, 52, 49, 54, 1, -49 },
  { 8273, 31, 49, 31, 0, -49 },
  { 8463, 31, 49, 31, 0, -49 },
  { 8653, 29, 49, 33, 2, -49 },
  { 8831, 13, 60, 21, 6, -49 },
  { 8929, 21, 49, 23, 1, -49 },
  { 9058, 14, 60, 21, 2, -49 },
  { 9163, 30, 28, 35, 2, -49 },
  { 9268, 27, 2, 27, 0, 6 },
  { 9275, 11, 11, 17, 3, -52 },
  { 9291, 24, 38, 32, 3, -37 },
  { 9405, 27, 53, 36, 6, -52 },
  { 9584, 23, 38, 28, 4, -37 },
  { 9694, 27, 53, 36, 4, -52 },
  { 9873, 25, 38, 33, 4, -37 },
  { 9992, 20, 52, 18, 1, -52 },
  { 10122, 27, 53, 36, 4, -37 },
  { 10301, 24, 52, 36, 6, -52 },
  { 10457, 4, 49, 14, 5, -49 },
  { 10482, 11, 65, 14, -2, -49 },
  { 10572, 23, 52, 29, 6, -52 },
  { 10722, 2, 52, 14, 6, -52 },
  { 10735, 42, 37, 53, 6, -37 },
  { 10930, 24, 37, 36, 6, -37 },
  { 11041, 28, 38, 35, 4, -37 },
  { 11174, 27, 53, 36, 6, -37 },
  { 11353, 26, 53, 36, 4, -37 },
  { 11526, 16, 37, 23, 6, -37 },
  { 11600, 22, 38, 28, 3, -37 },
  { 11705, 17, 46, 20, 1, -45 },
  { 11803, 25, 37, 36, 5, -36 },
  { 11919, 27, 36, 27, 0, -36 },
  { 12041, 42, 36, 44, 1, -36 },
  { 12230, 27, 36, 29, 1, -36 },
  { 12352, 27, 52, 27, 0, -36 },
  { 12528, 22, 36, 26, 2, -36 },
  { 12627, 19, 60, 24, 2, -49 },
  { 12770, 2, 69, 33, 15, -52 },
  { 12788, 18, 60, 24, 3, -49 },
  { 12923, 29, 6, 35, 3, -27 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight68pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT68PT7B_H_
