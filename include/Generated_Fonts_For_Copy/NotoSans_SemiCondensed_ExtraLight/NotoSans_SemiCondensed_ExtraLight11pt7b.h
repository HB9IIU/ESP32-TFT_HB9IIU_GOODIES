#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT11PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFC, 0x28, 0xA7, 0xCA, 0x4B, 0xF5, 0x14, 0x7C, 0xCC, 0x65,
  0x5E, 0x40, 0xCA, 0xAB, 0x2B, 0xF4, 0xD5, 0x53, 0x64, 0xA8, 0x8A, 0xCE,
  0x5F, 0xE0, 0x29, 0x49, 0x22, 0x44, 0x95, 0x55, 0x60, 0x4F, 0x4A, 0x21,
  0x3E, 0x42, 0x00, 0x60, 0xE0, 0x80, 0x12, 0x22, 0x44, 0x88, 0xE9, 0x99,
  0x99, 0x9E, 0x75, 0x55, 0xE1, 0x11, 0x24, 0x8F, 0x70, 0x42, 0x60, 0x84,
  0x3E, 0x10, 0x8A, 0x94, 0xFC, 0x21, 0xF8, 0x8E, 0x11, 0x1E, 0x78, 0x8E,
  0x99, 0x9F, 0xF1, 0x22, 0x24, 0x44, 0xE9, 0x96, 0xA9, 0x9F, 0xE9, 0x99,
  0xF1, 0x1E, 0x84, 0x40, 0x18, 0x1B, 0x38, 0x30, 0xFF, 0xC0, 0xE0, 0x87,
  0xC0, 0xE1, 0x12, 0x44, 0x04, 0x7D, 0x06, 0x6D, 0x5C, 0xB9, 0x6D, 0x40,
  0x78, 0x20, 0xC3, 0x14, 0x79, 0x28, 0xA1, 0xF4, 0x63, 0xE9, 0x46, 0x3E,
  0x7C, 0x21, 0x08, 0x42, 0x0F, 0xF4, 0x63, 0x18, 0xC6, 0x3E, 0xF8, 0x8F,
  0x88, 0x8F, 0xF8, 0x88, 0xF8, 0x88, 0x7C, 0x21, 0x09, 0xC6, 0x2F, 0x8C,
  0x63, 0xF8, 0xC6, 0x31, 0xFF, 0x55, 0x55, 0x70, 0x94, 0xA9, 0x8A, 0x52,
  0x53, 0x88, 0x88, 0x88, 0x8F, 0x83, 0x0F, 0x1E, 0x5A, 0xB5, 0x6C, 0xC9,
  0x8C, 0x73, 0x5A, 0xCE, 0x71, 0x72, 0x28, 0x61, 0x86, 0x18, 0x5E, 0xE9,
  0x99, 0xE8, 0x88, 0x72, 0x28, 0x61, 0x86, 0x18, 0x5A, 0x10, 0x20, 0xE4,
  0xA5, 0x2E, 0x52, 0x53, 0xF8, 0x8C, 0x21, 0x1E, 0xF9, 0x08, 0x42, 0x10,
  0x84, 0x8C, 0x63, 0x18, 0xC6, 0x2E, 0x86, 0x28, 0x92, 0x51, 0x42, 0x08,
  0x88, 0xC4, 0x56, 0x4A, 0xA5, 0x52, 0xA8, 0x98, 0x44, 0x8A, 0x94, 0x42,
  0x29, 0x51, 0x8C, 0x54, 0xA2, 0x10, 0x84, 0x78, 0x44, 0x42, 0x21, 0x1F,
  0xEA, 0xAA, 0xB0, 0x88, 0x44, 0x42, 0x21, 0xE4, 0x92, 0x49, 0x3C, 0x21,
  0x94, 0x98, 0x80, 0xF0, 0xC0, 0x71, 0x35, 0x97, 0x88, 0xF9, 0x99, 0x9F,
  0x72, 0x49, 0xC0, 0x11, 0xF9, 0x99, 0x9F, 0xE9, 0xF8, 0x8F, 0x6B, 0xA4,
  0x92, 0xF9, 0x99, 0x9F, 0x11, 0xE0, 0x88, 0xE9, 0x99, 0x99, 0xBF, 0xBF,
  0xE0, 0x88, 0xAA, 0xCC, 0xA9, 0xFF, 0xED, 0x26, 0x4C, 0x99, 0x32, 0x40,
  0xE9, 0x99, 0x99, 0xE9, 0x99, 0x9F, 0xF9, 0x99, 0x9F, 0x88, 0x80, 0xF9,
  0x99, 0x9F, 0x11, 0x10, 0xF2, 0x49, 0x00, 0x78, 0x43, 0x1F, 0x5D, 0x24,
  0x98, 0x99, 0x99, 0x9F, 0x99, 0x95, 0x62, 0x93, 0x26, 0xAB, 0x66, 0x48,
  0x80, 0x95, 0x22, 0x59, 0x99, 0x55, 0x62, 0x24, 0x80, 0x71, 0x24, 0x4F,
  0x29, 0x2C, 0x92, 0x44, 0xFF, 0xE0, 0xC4, 0x92, 0x49, 0x58, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 8, 2, 1, -8 },
  { 2, 2, 3, 4, 1, -8 },
  { 3, 6, 8, 6, 0, -8 },
  { 9, 4, 9, 6, 1, -8 },
  { 14, 6, 8, 8, 1, -8 },
  { 20, 5, 8, 7, 1, -8 },
  { 25, 1, 3, 2, 0, -8 },
  { 26, 3, 10, 3, 0, -8 },
  { 30, 2, 10, 3, 0, -8 },
  { 33, 4, 4, 5, 1, -8 },
  { 35, 5, 5, 6, 0, -6 },
  { 39, 2, 2, 2, 0, -1 },
  { 40, 3, 1, 3, 0, -3 },
  { 41, 1, 1, 2, 1, -1 },
  { 42, 4, 8, 4, 0, -8 },
  { 46, 4, 8, 6, 1, -8 },
  { 50, 2, 8, 6, 1, -8 },
  { 52, 4, 8, 6, 1, -8 },
  { 56, 5, 8, 6, 0, -8 },
  { 61, 5, 8, 6, 0, -8 },
  { 66, 4, 8, 6, 1, -8 },
  { 70, 4, 8, 6, 1, -8 },
  { 74, 4, 8, 6, 1, -8 },
  { 78, 4, 8, 6, 1, -8 },
  { 82, 4, 8, 6, 1, -8 },
  { 86, 1, 6, 2, 1, -6 },
  { 87, 2, 7, 2, 0, -6 },
  { 89, 5, 4, 6, 0, -6 },
  { 92, 5, 2, 6, 0, -5 },
  { 94, 5, 4, 6, 0, -6 },
  { 97, 4, 8, 4, 0, -8 },
  { 101, 7, 9, 9, 1, -8 },
  { 109, 6, 8, 6, 0, -8 },
  { 115, 5, 8, 6, 1, -8 },
  { 120, 5, 8, 6, 1, -8 },
  { 125, 5, 8, 7, 1, -8 },
  { 130, 4, 8, 5, 1, -8 },
  { 134, 4, 8, 5, 1, -8 },
  { 138, 5, 8, 7, 1, -8 },
  { 143, 5, 8, 7, 1, -8 },
  { 148, 1, 8, 3, 1, -8 },
  { 149, 2, 10, 2, -1, -8 },
  { 152, 5, 8, 6, 1, -8 },
  { 157, 4, 8, 5, 1, -8 },
  { 161, 7, 8, 9, 1, -8 },
  { 168, 5, 8, 7, 1, -8 },
  { 173, 6, 8, 7, 1, -8 },
  { 179, 4, 8, 6, 1, -8 },
  { 183, 6, 10, 7, 1, -8 },
  { 191, 5, 8, 6, 1, -8 },
  { 196, 4, 8, 5, 1, -8 },
  { 200, 5, 8, 5, 0, -8 },
  { 205, 5, 8, 7, 1, -8 },
  { 210, 6, 8, 6, 0, -8 },
  { 216, 9, 8, 9, 0, -8 },
  { 225, 5, 8, 5, 0, -8 },
  { 230, 5, 8, 5, 0, -8 },
  { 235, 5, 8, 5, 0, -8 },
  { 240, 2, 10, 3, 1, -8 },
  { 243, 4, 8, 4, 0, -8 },
  { 247, 3, 10, 3, 0, -8 },
  { 251, 5, 5, 6, 0, -8 },
  { 255, 4, 1, 4, 0, 1 },
  { 256, 2, 1, 3, 0, -8 },
  { 257, 4, 6, 5, 0, -6 },
  { 260, 4, 8, 6, 1, -8 },
  { 264, 3, 6, 5, 1, -6 },
  { 267, 4, 8, 6, 1, -8 },
  { 271, 4, 6, 5, 1, -6 },
  { 274, 3, 8, 3, 0, -8 },
  { 277, 4, 9, 6, 1, -6 },
  { 282, 4, 8, 6, 1, -8 },
  { 286, 1, 8, 2, 1, -8 },
  { 287, 1, 11, 2, 0, -8 },
  { 289, 4, 8, 5, 1, -8 },
  { 293, 1, 8, 2, 1, -8 },
  { 294, 7, 6, 9, 1, -6 },
  { 300, 4, 6, 6, 1, -6 },
  { 303, 4, 6, 6, 1, -6 },
  { 306, 4, 9, 6, 1, -6 },
  { 311, 4, 9, 6, 1, -6 },
  { 316, 3, 6, 4, 1, -6 },
  { 319, 4, 6, 5, 0, -6 },
  { 322, 3, 7, 3, 0, -7 },
  { 325, 4, 6, 6, 1, -6 },
  { 328, 4, 6, 4, 0, -6 },
  { 331, 7, 6, 7, 0, -6 },
  { 337, 4, 6, 5, 0, -6 },
  { 340, 4, 9, 4, 0, -6 },
  { 345, 4, 6, 4, 0, -6 },
  { 348, 3, 10, 4, 0, -8 },
  { 352, 1, 11, 5, 2, -8 },
  { 354, 3, 10, 4, 0, -8 },
  { 358, 5, 1, 6, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight11pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT11PT7B_H_
