#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT15PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0xD0, 0x12, 0x12, 0x12, 0x5B, 0x24, 0x24, 0x24,
  0xFF, 0x24, 0x24, 0x48, 0x72, 0xAA, 0x28, 0xA1, 0xC2, 0x89, 0x24, 0xAF,
  0x08, 0x62, 0x49, 0x25, 0x12, 0x89, 0xB5, 0x65, 0xB2, 0x29, 0x14, 0x92,
  0x48, 0xE0, 0x30, 0x48, 0x48, 0x48, 0x50, 0x60, 0x92, 0x8A, 0x86, 0x84,
  0x7B, 0xF0, 0x5A, 0xAA, 0xAA, 0x40, 0xA5, 0x55, 0x55, 0x80, 0x25, 0x5C,
  0xA4, 0x80, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x00, 0xF0, 0xE0, 0x80, 0x08,
  0x44, 0x22, 0x10, 0x88, 0x42, 0x20, 0x72, 0x28, 0x61, 0x86, 0x18, 0x61,
  0x86, 0x27, 0x80, 0x2E, 0x92, 0x49, 0x24, 0x80, 0x72, 0x20, 0x82, 0x08,
  0x21, 0x08, 0x42, 0x0F, 0xC0, 0x72, 0x20, 0x42, 0x09, 0xC0, 0x81, 0x04,
  0x1F, 0x80, 0x04, 0x18, 0x50, 0xA2, 0x44, 0x91, 0x42, 0x7E, 0x08, 0x10,
  0x7A, 0x08, 0x20, 0xF0, 0x20, 0x41, 0x04, 0x1F, 0x80, 0x39, 0x08, 0x20,
  0xB3, 0x28, 0x61, 0x86, 0x17, 0x80, 0xFC, 0x10, 0x82, 0x08, 0x41, 0x08,
  0x20, 0x84, 0x00, 0x72, 0x28, 0x61, 0x49, 0xC8, 0xA1, 0x86, 0x17, 0x80,
  0x72, 0x28, 0x61, 0x86, 0x37, 0x41, 0x08, 0x2F, 0x00, 0x81, 0x83, 0xC0,
  0x04, 0x66, 0x20, 0x60, 0x60, 0x40, 0xFC, 0x00, 0x3F, 0x81, 0x81, 0x81,
  0x19, 0x88, 0x00, 0xF0, 0x42, 0x10, 0x88, 0x84, 0x00, 0x08, 0x1E, 0x08,
  0x64, 0x0A, 0x39, 0x92, 0x68, 0x9A, 0x26, 0x89, 0x96, 0xE2, 0x44, 0x00,
  0xFC, 0x10, 0x18, 0x18, 0x28, 0x24, 0x24, 0x7C, 0x42, 0x42, 0x82, 0x81,
  0xF9, 0x0A, 0x14, 0x28, 0x5F, 0x21, 0x41, 0x83, 0x0B, 0xE0, 0x3E, 0x82,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x80, 0xF8, 0xF9, 0x0A, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x0B, 0xE0, 0xFE, 0x08, 0x20, 0x83, 0xE8, 0x20,
  0x82, 0x0F, 0xC0, 0xFE, 0x08, 0x20, 0x83, 0xE8, 0x20, 0x82, 0x08, 0x00,
  0x3F, 0x40, 0x80, 0x80, 0x80, 0x8E, 0x81, 0x81, 0x81, 0x41, 0x3F, 0x83,
  0x06, 0x0C, 0x18, 0x3F, 0xE0, 0xC1, 0x83, 0x06, 0x08, 0xD5, 0x55, 0x5C,
  0x24, 0x92, 0x49, 0x24, 0x93, 0x80, 0x85, 0x0A, 0x24, 0x8A, 0x1C, 0x24,
  0x48, 0x89, 0x0A, 0x18, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x3E, 0x80,
  0xE0, 0x70, 0x74, 0x3A, 0x1D, 0x16, 0x4B, 0x25, 0x94, 0xC6, 0x62, 0x20,
  0x83, 0x87, 0x0D, 0x19, 0x32, 0x62, 0xC5, 0x87, 0x06, 0x08, 0x3C, 0x42,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0xFA, 0x18, 0x61,
  0x86, 0x2F, 0x20, 0x82, 0x08, 0x00, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x42, 0x3C, 0x04, 0x04, 0x02, 0xF9, 0x0A, 0x14, 0x28,
  0x51, 0x3C, 0x44, 0x89, 0x0A, 0x18, 0x7A, 0x08, 0x20, 0x81, 0xC0, 0x81,
  0x04, 0x1F, 0x80, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x84, 0xF0, 0x81,
  0x82, 0x82, 0x42, 0x44, 0x44, 0x24, 0x28, 0x28, 0x18, 0x10, 0x84, 0x18,
  0x61, 0x46, 0x24, 0x62, 0x49, 0x24, 0x92, 0x29, 0x42, 0x94, 0x30, 0xC1,
  0x08, 0x10, 0x80, 0x82, 0x89, 0x11, 0x42, 0x82, 0x0A, 0x14, 0x44, 0x8A,
  0x08, 0x83, 0x09, 0x12, 0x42, 0x86, 0x04, 0x08, 0x10, 0x20, 0x40, 0x7E,
  0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x40, 0x83, 0xF8, 0xF2, 0x49, 0x24,
  0x92, 0x4E, 0x84, 0x10, 0x82, 0x10, 0x82, 0x10, 0x82, 0xE4, 0x92, 0x49,
  0x24, 0x9E, 0x20, 0xC5, 0x12, 0x8A, 0x10, 0xFC, 0x90, 0xF0, 0x42, 0x7C,
  0xC6, 0x3F, 0x82, 0x08, 0x3E, 0x86, 0x18, 0x61, 0x86, 0x1F, 0x80, 0x7C,
  0x21, 0x08, 0x42, 0x0F, 0x04, 0x10, 0x5F, 0x86, 0x18, 0x61, 0x86, 0x17,
  0xC0, 0x72, 0x28, 0x7F, 0x82, 0x08, 0x1E, 0x3A, 0x11, 0xE4, 0x21, 0x08,
  0x42, 0x10, 0x7E, 0x18, 0x61, 0x86, 0x18, 0x5F, 0x04, 0x18, 0x9C, 0x82,
  0x08, 0x3E, 0x86, 0x18, 0x61, 0x86, 0x18, 0x40, 0x9F, 0xE0, 0x20, 0x12,
  0x49, 0x24, 0x92, 0x70, 0x84, 0x21, 0x19, 0x52, 0x9C, 0x94, 0x62, 0xFF,
  0xE0, 0xFB, 0xA3, 0x18, 0x86, 0x21, 0x88, 0x62, 0x18, 0x86, 0x21, 0xFA,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x5E, 0xFA,
  0x18, 0x61, 0x86, 0x18, 0x7E, 0x82, 0x08, 0x20, 0x7E, 0x18, 0x61, 0x86,
  0x18, 0x5F, 0x04, 0x10, 0x41, 0xF8, 0x88, 0x88, 0x88, 0xF4, 0x20, 0x83,
  0x04, 0x3E, 0x44, 0xF4, 0x44, 0x44, 0x47, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x5F, 0x86, 0x14, 0x92, 0x48, 0xC3, 0x08, 0x88, 0xC6, 0x53, 0x2A, 0x95,
  0x2A, 0x98, 0x8C, 0x42, 0xC5, 0x22, 0x84, 0x30, 0xA4, 0xA1, 0x86, 0x14,
  0x92, 0x48, 0xC3, 0x04, 0x20, 0x82, 0x30, 0xF1, 0x22, 0x44, 0x8F, 0x34,
  0x44, 0x44, 0x84, 0x44, 0x44, 0x70, 0xFF, 0xFE, 0x84, 0x44, 0x44, 0x32,
  0x44, 0x44, 0xC0, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 11, 3, 1, -11 },
  { 3, 3, 4, 5, 1, -11 },
  { 5, 8, 11, 9, 0, -11 },
  { 16, 6, 12, 8, 1, -11 },
  { 25, 9, 11, 11, 1, -11 },
  { 38, 8, 11, 9, 1, -11 },
  { 49, 1, 4, 3, 1, -11 },
  { 50, 2, 13, 4, 1, -11 },
  { 54, 2, 13, 4, 1, -11 },
  { 58, 5, 5, 7, 1, -11 },
  { 62, 6, 7, 8, 1, -9 },
  { 68, 1, 4, 3, 1, -2 },
  { 69, 3, 1, 5, 1, -5 },
  { 70, 1, 1, 3, 1, -1 },
  { 71, 5, 11, 5, 0, -11 },
  { 78, 6, 11, 8, 1, -11 },
  { 87, 3, 11, 8, 1, -11 },
  { 92, 6, 11, 8, 1, -11 },
  { 101, 6, 11, 8, 1, -11 },
  { 110, 7, 11, 8, 0, -11 },
  { 120, 6, 11, 8, 1, -11 },
  { 129, 6, 11, 8, 1, -11 },
  { 138, 6, 11, 8, 1, -11 },
  { 147, 6, 11, 8, 1, -11 },
  { 156, 6, 11, 8, 1, -11 },
  { 165, 1, 8, 3, 1, -8 },
  { 166, 1, 10, 3, 1, -8 },
  { 168, 6, 7, 8, 1, -9 },
  { 174, 6, 4, 8, 1, -7 },
  { 177, 6, 7, 8, 1, -9 },
  { 183, 5, 11, 5, 0, -11 },
  { 190, 10, 12, 12, 1, -11 },
  { 205, 8, 11, 8, 0, -11 },
  { 216, 7, 11, 8, 1, -11 },
  { 226, 7, 11, 8, 1, -11 },
  { 236, 7, 11, 9, 1, -11 },
  { 246, 6, 11, 7, 1, -11 },
  { 255, 6, 11, 7, 1, -11 },
  { 264, 8, 11, 10, 1, -11 },
  { 275, 7, 11, 10, 1, -11 },
  { 285, 2, 11, 4, 1, -11 },
  { 288, 3, 14, 3, -1, -11 },
  { 294, 7, 11, 8, 1, -11 },
  { 304, 5, 11, 7, 1, -11 },
  { 311, 9, 11, 12, 1, -11 },
  { 324, 7, 11, 10, 1, -11 },
  { 334, 8, 11, 10, 1, -11 },
  { 345, 6, 11, 8, 1, -11 },
  { 354, 8, 14, 10, 1, -11 },
  { 368, 7, 11, 8, 1, -11 },
  { 378, 6, 11, 7, 1, -11 },
  { 387, 7, 11, 7, 0, -11 },
  { 397, 7, 11, 10, 1, -11 },
  { 407, 8, 11, 8, 0, -11 },
  { 418, 12, 11, 12, 0, -11 },
  { 435, 7, 11, 7, 0, -11 },
  { 445, 7, 11, 7, 0, -11 },
  { 455, 7, 11, 7, 0, -11 },
  { 465, 3, 13, 5, 1, -11 },
  { 470, 5, 11, 5, 0, -11 },
  { 477, 3, 13, 5, 0, -11 },
  { 482, 6, 6, 8, 1, -11 },
  { 487, 6, 1, 6, 0, 1 },
  { 488, 2, 2, 4, 1, -11 },
  { 489, 5, 8, 7, 1, -8 },
  { 494, 6, 11, 8, 1, -11 },
  { 503, 5, 8, 6, 1, -8 },
  { 508, 6, 11, 8, 1, -11 },
  { 517, 6, 8, 7, 1, -8 },
  { 523, 5, 11, 4, 0, -11 },
  { 530, 6, 12, 8, 1, -8 },
  { 539, 6, 11, 8, 1, -11 },
  { 548, 1, 11, 3, 1, -11 },
  { 550, 3, 15, 3, -1, -11 },
  { 556, 5, 11, 6, 1, -11 },
  { 563, 1, 11, 3, 1, -11 },
  { 565, 10, 8, 12, 1, -8 },
  { 575, 6, 8, 8, 1, -8 },
  { 581, 6, 8, 8, 1, -8 },
  { 587, 6, 12, 8, 1, -8 },
  { 596, 6, 12, 8, 1, -8 },
  { 605, 4, 8, 5, 1, -8 },
  { 609, 5, 8, 6, 1, -8 },
  { 614, 4, 10, 4, 0, -10 },
  { 619, 6, 8, 8, 1, -8 },
  { 625, 6, 8, 6, 0, -8 },
  { 631, 9, 8, 10, 0, -8 },
  { 640, 6, 8, 6, 0, -8 },
  { 646, 6, 12, 6, 0, -8 },
  { 655, 4, 8, 6, 1, -8 },
  { 659, 4, 13, 5, 1, -11 },
  { 666, 1, 15, 7, 3, -11 },
  { 668, 4, 13, 5, 1, -11 },
  { 675, 6, 1, 8, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight15pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT15PT7B_H_
