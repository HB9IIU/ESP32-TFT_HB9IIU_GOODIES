#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT72PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight72pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x76, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF4, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x6E, 0x01, 0xB8, 0x06, 0xE0, 0x1B, 0x80, 0x6E, 0x01, 0xB8, 0x06,
  0xE0, 0x1B, 0x80, 0x6E, 0x01, 0xB8, 0x06, 0xE0, 0x1B, 0x80, 0x60, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x07, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0xFE, 0xE7, 0xFC, 0x1E,
  0x0E, 0x03, 0x83, 0xC0, 0xE0, 0x08, 0x78, 0x0E, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x0E,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x78, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF8,
  0xE0, 0x00, 0x07, 0xEE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xEF, 0xC0, 0x00,
  0x0E, 0x3E, 0x00, 0x00, 0xE0, 0xF8, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0,
  0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0xE0, 0x06, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0xE0, 0x06, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x0E,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x80, 0x0E, 0x03, 0x8E, 0x00,
  0xE0, 0xF0, 0xFF, 0x0E, 0x7E, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x10, 0x00, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0xE0, 0x00, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x30, 0x00, 0x18, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80,
  0x06, 0x00, 0x38, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xE0, 0x01, 0x80, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x0C, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x0C, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x0C, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0xE0, 0x01, 0xC1, 0xC0, 0x10, 0x0E, 0x00, 0x18, 0x1C, 0x0F, 0xE0, 0xE0,
  0x01, 0x81, 0x83, 0xFF, 0x8E, 0x00, 0x38, 0x38, 0x78, 0x38, 0x60, 0x03,
  0x83, 0x07, 0x01, 0xC7, 0x00, 0x38, 0x70, 0xE0, 0x0E, 0x70, 0x07, 0x06,
  0x0C, 0x00, 0xE3, 0x80, 0x70, 0xE1, 0xC0, 0x06, 0x38, 0x0E, 0x0C, 0x1C,
  0x00, 0x71, 0xE1, 0xC1, 0xC1, 0x80, 0x07, 0x0F, 0xF8, 0x18, 0x18, 0x00,
  0x70, 0x3F, 0x03, 0x81, 0x80, 0x03, 0x00, 0x00, 0x30, 0x38, 0x00, 0x30,
  0x00, 0x07, 0x03, 0x80, 0x03, 0x00, 0x00, 0x60, 0x38, 0x00, 0x30, 0x00,
  0x0E, 0x03, 0x80, 0x03, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x30, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x30, 0x00, 0x38, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x80, 0x38, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x18, 0x00, 0x70, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0, 0x06, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0xE0, 0x01, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x38,
  0x00, 0x06, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x70, 0x38, 0x00, 0x70, 0x00,
  0x03, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x01,
  0xC3, 0xC0, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x1E, 0x00, 0x18, 0x70, 0x00,
  0x38, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x03, 0x8E, 0x00, 0x00, 0xE0, 0x0E,
  0x38, 0x00, 0x01, 0xC0, 0x70, 0xE0, 0x00, 0x07, 0x81, 0xC3, 0x00, 0x00,
  0x0F, 0x06, 0x0C, 0x00, 0x00, 0x1C, 0x38, 0x30, 0x00, 0x00, 0x39, 0xC0,
  0xC0, 0x00, 0x00, 0x77, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0x00,
  0x03, 0xE0, 0x38, 0x00, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x3E, 0x01,
  0xC0, 0x00, 0x01, 0xDC, 0x07, 0x80, 0x00, 0x1E, 0x38, 0x0F, 0x00, 0x00,
  0xF0, 0x70, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x3E, 0x00, 0xFC, 0x03, 0xC0,
  0x7F, 0xFF, 0xC0, 0x07, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x3F,
  0x80, 0xC0, 0x7F, 0xFC, 0x30, 0xFF, 0x0F, 0xED, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0xE0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x0E, 0x00, 0x1C,
  0x01, 0x80, 0x02, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x3C, 0x70, 0xE1,
  0xC3, 0x8F, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x73, 0xFE, 0xF7, 0x98, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x70, 0x00, 0xF0,
  0x07, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x18,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x1C, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x7F, 0x00, 0xF7, 0x01, 0xE7, 0x03, 0xC7, 0x0F, 0x87, 0x1E, 0x07, 0x3C,
  0x07, 0xF8, 0x07, 0x70, 0x07, 0x20, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x03,
  0xE0, 0x03, 0xE0, 0x78, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFC,
  0x3F, 0x80, 0x7E, 0x00, 0x1E, 0x0F, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x01,
  0xE1, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x90, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07,
  0x87, 0xF0, 0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x80, 0x00, 0x0F, 0x0C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0xFC,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF9, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x30, 0x3F, 0xFE, 0x01, 0x83, 0xFF, 0xF8, 0x1C, 0x7C,
  0x01, 0xE0, 0xE7, 0x80, 0x03, 0x87, 0x30, 0x00, 0x0E, 0x3B, 0x00, 0x00,
  0x39, 0xF0, 0x00, 0x01, 0xCF, 0x80, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x00, 0xDE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x39, 0x80, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x1F, 0x00, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFE, 0x3F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x78, 0x0E,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0xE0, 0x1E, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xF0, 0x1E,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x38, 0x78, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x1E,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0xF0, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x70, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xF7, 0x00, 0x00,
  0x1F, 0x38, 0x00, 0x03, 0x73, 0xC0, 0x00, 0x77, 0x1E, 0x00, 0x1E, 0x70,
  0xFC, 0x0F, 0xC7, 0x03, 0xFF, 0xF0, 0x70, 0x0F, 0xFC, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x02, 0x00, 0x3E,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x23, 0xDF, 0xF7, 0xBC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xFF, 0xBD,
  0xE6, 0x08, 0x3C, 0x78, 0xF1, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x1E, 0x38, 0x70, 0xE1, 0xC7, 0x0E, 0x1C,
  0x38, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x60, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xFE, 0x0F, 0xF1, 0xFC, 0x3C, 0x00, 0x78, 0x40, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x1F,
  0xFF, 0x80, 0x0C, 0x38, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0x18, 0x00, 0x1E,
  0x00, 0x60, 0x03, 0x9C, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xCE, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x67, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x33, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1B, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x0F, 0xC0, 0x07,
  0x00, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x00, 0x01, 0xC0, 0x03, 0xF0, 0x03,
  0x80, 0x00, 0xE0, 0x01, 0xF8, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xF8, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x3E, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0D, 0x80,
  0x0E, 0x00, 0x03, 0x00, 0x06, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x03, 0x60,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0xB8, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xDC,
  0x00, 0x60, 0x00, 0x78, 0x00, 0xCE, 0x00, 0x38, 0x00, 0x6C, 0x00, 0xE7,
  0x00, 0x1C, 0x00, 0x36, 0x00, 0x71, 0x80, 0x07, 0x00, 0x33, 0x00, 0x70,
  0xC0, 0x03, 0xC0, 0x39, 0xC0, 0x70, 0x70, 0x00, 0xF8, 0x78, 0x78, 0xF8,
  0x38, 0x00, 0x3F, 0xF8, 0x1F, 0xF0, 0x0C, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x30, 0x00, 0x1F, 0xC1, 0x80, 0x00, 0x1F, 0x0C, 0x00, 0x00, 0x3C, 0x60,
  0x00, 0x00, 0xF3, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x79, 0x80, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x07,
  0x83, 0x00, 0x03, 0xF8, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x06,
  0x00, 0x07, 0xF8, 0x30, 0x00, 0x03, 0xE1, 0x80, 0x00, 0x07, 0x8C, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x0F, 0x18, 0x00, 0x01, 0xF0, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x07,
  0xE0, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x10, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x00, 0x1F, 0x80, 0x07,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x7F,
  0xC0, 0x18, 0x00, 0x03, 0xF0, 0x0C, 0x00, 0x00, 0x3C, 0x06, 0x00, 0x00,
  0x0F, 0x03, 0x00, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x00, 0xF0, 0xC0, 0x00,
  0x00, 0x3C, 0x60, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x07, 0x98, 0x00,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x00, 0x1E, 0x30, 0x00, 0x00, 0x0E, 0x18, 0x00,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x1E, 0x03, 0x00,
  0x00, 0x3E, 0x01, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x00, 0x30, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC8,
  0x0F, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0x00, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0x30, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07, 0x8C, 0x00, 0x00,
  0x78, 0x60, 0x00, 0x07, 0x83, 0x00, 0x00, 0x38, 0x18, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x38, 0x06, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x3C, 0x01, 0x80,
  0x03, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x18, 0x01, 0xE0, 0x00, 0xC0, 0x1E, 0x00, 0x06, 0x01, 0xE0, 0x00,
  0x30, 0x1E, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x60,
  0xF0, 0x00, 0x03, 0x0F, 0x80, 0x00, 0x18, 0xFE, 0x00, 0x00, 0xC7, 0x70,
  0x00, 0x06, 0x71, 0xC0, 0x00, 0x37, 0x0F, 0x00, 0x01, 0xF0, 0x38, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0xC0, 0x06, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0x78, 0x01, 0x80, 0x01, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0x60, 0x00, 0x3C,
  0x03, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1E, 0x06,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0F, 0x0C, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x07, 0x98, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x00, 0xF6, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFD, 0xC0, 0x00, 0x00, 0x00, 0x6F,
  0xB8, 0x00, 0x00, 0x00, 0x1D, 0xF3, 0x00, 0x00, 0x00, 0x03, 0xBE, 0x70,
  0x00, 0x00, 0x00, 0x67, 0xCE, 0x00, 0x00, 0x00, 0x1C, 0xF8, 0xC0, 0x00,
  0x00, 0x03, 0x9F, 0x1C, 0x00, 0x00, 0x00, 0x63, 0xE3, 0x80, 0x00, 0x00,
  0x1C, 0x7C, 0x38, 0x00, 0x00, 0x03, 0x8F, 0x87, 0x00, 0x00, 0x00, 0xE1,
  0xF0, 0xE0, 0x00, 0x00, 0x1C, 0x3E, 0x0E, 0x00, 0x00, 0x03, 0x07, 0xC1,
  0xC0, 0x00, 0x00, 0xE0, 0xF8, 0x18, 0x00, 0x00, 0x1C, 0x1F, 0x03, 0x80,
  0x00, 0x03, 0x03, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x7C, 0x07, 0x00, 0x00,
  0x1C, 0x0F, 0x80, 0xE0, 0x00, 0x03, 0x01, 0xF0, 0x1C, 0x00, 0x00, 0xE0,
  0x3E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xF8,
  0x07, 0x00, 0x00, 0xE0, 0x1F, 0x00, 0x70, 0x00, 0x18, 0x03, 0xE0, 0x0E,
  0x00, 0x07, 0x00, 0x7C, 0x00, 0xC0, 0x00, 0xE0, 0x0F, 0x80, 0x1C, 0x00,
  0x18, 0x01, 0xF0, 0x03, 0x80, 0x07, 0x00, 0x3E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xF8, 0x00, 0xE0, 0x07, 0x00, 0x1F,
  0x00, 0x0E, 0x00, 0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x7C, 0x00,
  0x38, 0x07, 0x00, 0x0F, 0x80, 0x03, 0x80, 0xC0, 0x01, 0xF0, 0x00, 0x70,
  0x38, 0x00, 0x3E, 0x00, 0x06, 0x07, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0xC0,
  0x00, 0xF8, 0x00, 0x1C, 0x38, 0x00, 0x1F, 0x00, 0x01, 0xC7, 0x00, 0x03,
  0xE0, 0x00, 0x39, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x38, 0x00, 0x0F, 0x80,
  0x00, 0x76, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x03,
  0xC0, 0x07, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x03,
  0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x03, 0x00, 0x07, 0xF0, 0x60, 0x00, 0x1F, 0x0C, 0x00,
  0x00, 0xF1, 0x80, 0x00, 0x0F, 0x30, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x30,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x1E, 0x18, 0x00, 0x07,
  0x83, 0x00, 0x0F, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0xFF, 0x01, 0x80, 0x00, 0x7C,
  0x0C, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x0E, 0x18,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x03,
  0xC0, 0xC0, 0x00, 0x3C, 0x06, 0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x07, 0x00, 0x18, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xE0, 0x06, 0x00, 0x07,
  0x80, 0x30, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xF0, 0x0C, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x3C, 0x60, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x07,
  0x98, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0xF6, 0x00, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0x0E, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFE,
  0xFF, 0xE0, 0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x43, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE0, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x38,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x1C, 0x07,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x81, 0x80, 0x00,
  0xE0, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x07,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0x70, 0x0C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0x80, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x01,
  0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x07, 0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x0E, 0x00,
  0xE0, 0x03, 0x80, 0x38, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x00,
  0x1C, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x60, 0x38, 0x00,
  0x18, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x70, 0x30, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0x03, 0x07, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x86, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x06, 0x38, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x73, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0x70, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xF0, 0x07, 0xC0,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFC, 0x70, 0x7E, 0x00, 0x38, 0xF8, 0x00, 0x1C, 0xF0, 0x00, 0x0E, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0x60, 0x00, 0x0D, 0xB8, 0x00, 0x06, 0xDC, 0x00, 0x06,
  0x67, 0x00, 0x06, 0x31, 0xE0, 0x0F, 0x18, 0x7F, 0xFE, 0x0C, 0x1F, 0xFE,
  0x06, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x1F, 0xC0, 0x0E, 0x0F, 0xFF, 0x80, 0xE1, 0xFF, 0xFC, 0x0E, 0x3C,
  0x01, 0xF0, 0xE7, 0x00, 0x07, 0x0E, 0xE0, 0x00, 0x38, 0xFC, 0x00, 0x01,
  0xCD, 0x80, 0x00, 0x1C, 0xD8, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x6F, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x1C, 0xD8, 0x00, 0x01, 0xCD, 0xC0, 0x00, 0x38, 0xCE,
  0x00, 0x07, 0x8C, 0x70, 0x00, 0xF0, 0xC3, 0xC0, 0x3E, 0x0C, 0x1F, 0xFF,
  0xC0, 0xC0, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x03, 0xF0, 0x07, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x01, 0x03, 0xE0, 0x07, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x1F, 0x80, 0x30, 0x0F, 0xFF, 0x03, 0x01,
  0xFF, 0xFC, 0x30, 0x7C, 0x01, 0xE3, 0x0F, 0x00, 0x07, 0x30, 0xE0, 0x00,
  0x33, 0x1C, 0x00, 0x01, 0xB3, 0xC0, 0x00, 0x1B, 0x38, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xB1,
  0xC0, 0x00, 0x1B, 0x1E, 0x00, 0x03, 0x30, 0xF0, 0x00, 0x73, 0x07, 0xC0,
  0x1E, 0x30, 0x3F, 0xFF, 0x83, 0x00, 0xFF, 0xF0, 0x30, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xE0,
  0x1F, 0x00, 0x70, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x03, 0x38, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x60, 0x3E, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0x1E, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x03, 0x03,
  0xFF, 0xFC, 0x30, 0x7C, 0x01, 0xE3, 0x0F, 0x00, 0x07, 0x30, 0xE0, 0x00,
  0x3B, 0x1C, 0x00, 0x01, 0xB3, 0x80, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xB1,
  0xC0, 0x00, 0x3B, 0x1E, 0x00, 0x03, 0x30, 0xF0, 0x00, 0xE3, 0x07, 0xC0,
  0x1C, 0x30, 0x3F, 0xFF, 0x83, 0x00, 0xFF, 0xF0, 0x30, 0x01, 0xF0, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC2, 0x00, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x83, 0xF8, 0x07,
  0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x1F, 0x80, 0x38, 0x3F, 0xFC, 0x0E, 0x1F, 0xFF, 0xC3, 0x8F, 0x00,
  0xF8, 0xE7, 0x00, 0x0F, 0x3B, 0x80, 0x01, 0xCF, 0xC0, 0x00, 0x3B, 0x60,
  0x00, 0x0E, 0xF0, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0x77, 0xFF, 0xF7, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE0, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x87, 0x8F, 0xF0, 0xFE, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xC0,
  0xE0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x00,
  0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xE0, 0x00,
  0xE1, 0xE0, 0x00, 0xE1, 0xE0, 0x00, 0xE3, 0xF0, 0x00, 0xE7, 0x70, 0x00,
  0xEE, 0x38, 0x00, 0xFC, 0x3C, 0x00, 0xF8, 0x1C, 0x00, 0xF0, 0x0E, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80,
  0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x06,
  0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x30, 0xFF, 0xFC, 0x07, 0xFF, 0xE1, 0x8F,
  0x00, 0xF0, 0x78, 0x07, 0x8C, 0xE0, 0x03, 0xC7, 0x00, 0x1E, 0x66, 0x00,
  0x0E, 0x70, 0x00, 0x73, 0x60, 0x00, 0x33, 0x00, 0x01, 0xDB, 0x00, 0x01,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x77, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xB8, 0x00, 0x01, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0xC0, 0x30, 0x1F, 0xFE, 0x0C, 0x1F, 0xFF, 0xC3, 0x0F, 0x00, 0x78, 0xC7,
  0x00, 0x0F, 0x33, 0x80, 0x01, 0xCD, 0xC0, 0x00, 0x3B, 0x60, 0x00, 0x0E,
  0xF0, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0x78, 0x07,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x03, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x1C, 0x3C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xF0,
  0x0E, 0x00, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x0C, 0x07, 0xFF,
  0x80, 0xC1, 0xFF, 0xFC, 0x0C, 0x3C, 0x01, 0xF0, 0xC7, 0x00, 0x07, 0x8C,
  0xE0, 0x00, 0x38, 0xCC, 0x00, 0x01, 0xCD, 0x80, 0x00, 0x1C, 0xD8, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x6F,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x80, 0x00, 0x1C, 0xF8, 0x00,
  0x01, 0xCE, 0xC0, 0x00, 0x3C, 0xEE, 0x00, 0x07, 0x8E, 0x70, 0x00, 0xF0,
  0xE3, 0xC0, 0x3E, 0x0E, 0x1F, 0xFF, 0xC0, 0xE0, 0x7F, 0xF0, 0x0E, 0x00,
  0xF8, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xFF, 0x03, 0x03, 0xFF, 0xFC, 0x30, 0x7C, 0x01, 0xE3,
  0x0F, 0x00, 0x07, 0x31, 0xE0, 0x00, 0x33, 0x1C, 0x00, 0x01, 0xB3, 0x80,
  0x00, 0x1B, 0x38, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x1B, 0x38, 0x00, 0x01, 0xB3, 0xC0, 0x00, 0x3B, 0x1E, 0x00, 0x07,
  0x30, 0xF0, 0x00, 0xE3, 0x07, 0xC0, 0x3C, 0x30, 0x3F, 0xFF, 0x83, 0x00,
  0xFF, 0xE0, 0x30, 0x01, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x1F, 0x30, 0x3F, 0xFC, 0x1F, 0xFB, 0x0F, 0x02, 0xC7,
  0x00, 0x33, 0x80, 0x0C, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0xF0, 0x01, 0xE3, 0xC0, 0x00, 0x4F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x76, 0x00,
  0x01, 0xEF, 0x80, 0x0F, 0x9F, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x40, 0x7F, 0xF0, 0x0F, 0xFC, 0x00,
  0x78, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xB0, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xFB, 0x80, 0x00,
  0x3F, 0x38, 0x00, 0x06, 0xE7, 0x80, 0x01, 0x9C, 0x78, 0x00, 0x73, 0x8F,
  0x80, 0x3C, 0x70, 0x7F, 0xFF, 0x0E, 0x07, 0xFF, 0x81, 0xC0, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38,
  0x0C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x18, 0x01, 0xC0, 0x01,
  0xC0, 0x18, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x77, 0x00, 0x00, 0xF8, 0x00, 0x06,
  0x70, 0x00, 0x0D, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xD8, 0x00, 0x0E, 0x38,
  0x00, 0x1D, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0x9C, 0x00, 0x0C, 0x38, 0x00,
  0x18, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0x1C, 0x00, 0x70, 0x60,
  0x03, 0x80, 0xC0, 0x07, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x70, 0x03,
  0x80, 0xE0, 0x06, 0x03, 0x00, 0x30, 0x0E, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0x60, 0x0E, 0x03, 0x80, 0x70, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0x70,
  0x1C, 0x01, 0x80, 0x60, 0x07, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x30, 0x1C,
  0x01, 0xC0, 0xE0, 0x03, 0x81, 0x80, 0x0C, 0x0E, 0x00, 0x38, 0x38, 0x00,
  0xE0, 0xC0, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x18, 0x30, 0x00, 0xE1,
  0xC0, 0x01, 0xC7, 0x00, 0x06, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0x80,
  0x01, 0xC7, 0x00, 0x07, 0x38, 0x00, 0x0C, 0x60, 0x00, 0x73, 0x80, 0x00,
  0xEE, 0x00, 0x03, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x00, 0x00, 0xEC,
  0x00, 0x03, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70,
  0x1C, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x38, 0x00, 0x70, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07,
  0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x78, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x03,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x0C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x08, 0x3C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xE0,
  0x03, 0xFC, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x13, 0xFF, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x01, 0xFF, 0xFA, 0x00, 0x01, 0xFF, 0xC8, 0x00, 0x01, 0xFC, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 4, 52, 16, 6, -51 },
  { 27, 14, 18, 24, 5, -51 },
  { 59, 37, 51, 41, 2, -51 },
  { 295, 28, 59, 37, 4, -55 },
  { 502, 44, 53, 52, 4, -52 },
  { 794, 38, 53, 43, 4, -52 },
  { 1046, 3, 18, 13, 5, -51 },
  { 1053, 14, 62, 19, 3, -51 },
  { 1162, 13, 62, 19, 3, -51 },
  { 1263, 26, 26, 34, 4, -55 },
  { 1348, 30, 33, 37, 3, -42 },
  { 1472, 7, 17, 14, 3, -8 },
  { 1487, 16, 3, 22, 3, -21 },
  { 1493, 5, 6, 15, 5, -5 },
  { 1497, 22, 51, 24, 1, -51 },
  { 1638, 29, 53, 37, 4, -52 },
  { 1831, 16, 51, 37, 6, -51 },
  { 1933, 28, 52, 37, 4, -52 },
  { 2115, 29, 53, 37, 3, -52 },
  { 2308, 34, 52, 37, 2, -52 },
  { 2529, 28, 52, 37, 5, -51 },
  { 2711, 29, 53, 37, 4, -52 },
  { 2904, 29, 51, 37, 4, -51 },
  { 3089, 29, 53, 37, 4, -52 },
  { 3282, 28, 53, 37, 4, -52 },
  { 3468, 5, 40, 15, 5, -39 },
  { 3493, 7, 48, 15, 3, -39 },
  { 3535, 30, 32, 37, 3, -42 },
  { 3655, 30, 17, 37, 3, -34 },
  { 3719, 30, 32, 37, 3, -42 },
  { 3839, 22, 53, 26, 2, -52 },
  { 3985, 49, 58, 56, 4, -51 },
  { 4341, 37, 51, 37, 0, -51 },
  { 4577, 29, 51, 40, 7, -51 },
  { 4762, 33, 53, 39, 4, -52 },
  { 4981, 33, 51, 45, 7, -51 },
  { 5192, 24, 51, 35, 7, -51 },
  { 5345, 24, 51, 32, 7, -51 },
  { 5498, 38, 53, 47, 4, -52 },
  { 5750, 32, 51, 46, 7, -51 },
  { 5954, 12, 51, 20, 4, -51 },
  { 6031, 15, 64, 16, -5, -51 },
  { 6151, 29, 51, 36, 7, -51 },
  { 6336, 24, 51, 32, 7, -51 },
  { 6489, 43, 51, 56, 7, -51 },
  { 6764, 32, 51, 46, 7, -51 },
  { 6968, 40, 53, 48, 4, -52 },
  { 7233, 27, 51, 37, 7, -51 },
  { 7406, 40, 64, 48, 4, -52 },
  { 7726, 29, 51, 38, 7, -51 },
  { 7911, 28, 53, 35, 4, -52 },
  { 8097, 32, 51, 33, 0, -51 },
  { 8301, 34, 52, 46, 6, -51 },
  { 8522, 36, 51, 36, 0, -51 },
  { 8752, 55, 51, 58, 1, -51 },
  { 9103, 33, 51, 33, 0, -51 },
  { 9314, 32, 51, 32, 0, -51 },
  { 9518, 31, 51, 35, 2, -51 },
  { 9716, 14, 62, 23, 6, -51 },
  { 9825, 22, 51, 24, 1, -51 },
  { 9966, 14, 62, 23, 2, -51 },
  { 10075, 32, 30, 37, 2, -52 },
  { 10195, 29, 3, 29, 0, 6 },
  { 10206, 12, 11, 18, 3, -55 },
  { 10223, 25, 40, 34, 3, -39 },
  { 10348, 28, 56, 38, 6, -55 },
  { 10544, 24, 40, 30, 4, -39 },
  { 10664, 28, 56, 38, 4, -55 },
  { 10860, 27, 40, 35, 4, -39 },
  { 10995, 21, 55, 19, 1, -55 },
  { 11140, 28, 56, 38, 4, -39 },
  { 11336, 26, 55, 38, 6, -55 },
  { 11515, 5, 52, 15, 5, -52 },
  { 11548, 12, 69, 15, -2, -52 },
  { 11652, 24, 55, 30, 6, -55 },
  { 11817, 3, 55, 15, 6, -55 },
  { 11838, 45, 39, 56, 6, -39 },
  { 12058, 26, 39, 38, 6, -39 },
  { 12185, 29, 40, 37, 4, -39 },
  { 12330, 28, 56, 38, 6, -39 },
  { 12526, 28, 56, 38, 4, -39 },
  { 12722, 18, 39, 25, 6, -39 },
  { 12810, 23, 40, 29, 3, -39 },
  { 12925, 18, 48, 21, 1, -47 },
  { 13033, 27, 39, 38, 5, -38 },
  { 13165, 28, 38, 29, 0, -38 },
  { 13298, 44, 38, 46, 1, -38 },
  { 13507, 27, 38, 31, 2, -38 },
  { 13636, 29, 55, 29, 0, -38 },
  { 13836, 22, 38, 28, 3, -38 },
  { 13941, 19, 62, 25, 3, -51 },
  { 14089, 3, 73, 35, 16, -55 },
  { 14117, 19, 62, 25, 3, -51 },
  { 14265, 30, 7, 37, 3, -29 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight72pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT72PT7B_H_
