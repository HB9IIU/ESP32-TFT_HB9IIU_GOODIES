#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT36PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x02, 0xF0, 0xC2, 0x85, 0x0A, 0x14,
  0x28, 0x50, 0xA1, 0x42, 0x84, 0x01, 0x02, 0x00, 0x20, 0x40, 0x04, 0x08,
  0x00, 0x81, 0x00, 0x30, 0x20, 0x04, 0x0C, 0x00, 0x81, 0x00, 0x10, 0x20,
  0x7F, 0xFF, 0xE0, 0x40, 0x80, 0x18, 0x10, 0x02, 0x06, 0x00, 0x40, 0x80,
  0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0x40, 0x0C, 0x08, 0x1F, 0xFF, 0xF0,
  0x20, 0x40, 0x04, 0x08, 0x00, 0x81, 0x00, 0x10, 0x20, 0x06, 0x04, 0x00,
  0xC1, 0x80, 0x10, 0x20, 0x02, 0x04, 0x00, 0x02, 0x00, 0x08, 0x01, 0xFE,
  0x0C, 0x8E, 0x62, 0x03, 0x08, 0x08, 0x20, 0x20, 0x80, 0x82, 0x03, 0x08,
  0x0C, 0x20, 0x18, 0x80, 0x3A, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x98, 0x02,
  0x38, 0x08, 0x20, 0x20, 0xC0, 0x83, 0x02, 0x0C, 0x08, 0x30, 0x20, 0x80,
  0x86, 0xE2, 0x71, 0xFF, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x3C, 0x00,
  0xC1, 0x88, 0x02, 0x04, 0x10, 0x18, 0x30, 0x40, 0x40, 0x81, 0x83, 0x02,
  0x06, 0x08, 0x08, 0x08, 0x20, 0x20, 0x21, 0x00, 0x80, 0x84, 0x02, 0x02,
  0x20, 0x08, 0x18, 0x8E, 0x20, 0x64, 0x6E, 0xC1, 0x13, 0x09, 0x04, 0xC8,
  0x36, 0x22, 0x60, 0x4F, 0x19, 0x81, 0x00, 0x44, 0x04, 0x03, 0x10, 0x10,
  0x08, 0x40, 0x40, 0x61, 0x01, 0x01, 0x06, 0x04, 0x0C, 0x18, 0x10, 0x20,
  0x20, 0xC1, 0x80, 0x82, 0x04, 0x03, 0x18, 0x30, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0x8C, 0x00, 0x40, 0xC0, 0x18, 0x08, 0x03, 0x01, 0x00, 0x60, 0x20,
  0x0C, 0x04, 0x00, 0x81, 0x80, 0x18, 0x20, 0x01, 0x0C, 0x00, 0x33, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x32, 0x00, 0x0C, 0x20, 0x13, 0x06, 0x06,
  0xC0, 0x60, 0xD0, 0x06, 0x12, 0x00, 0x66, 0x40, 0x04, 0x88, 0x00, 0x71,
  0x00, 0x0C, 0x30, 0x01, 0xC3, 0x00, 0xCC, 0x30, 0x30, 0xC3, 0xFC, 0x0C,
  0xD5, 0x55, 0x50, 0x04, 0x21, 0x84, 0x30, 0x86, 0x10, 0x43, 0x0C, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0x0C, 0x10, 0x41, 0x82, 0x0C,
  0x10, 0x60, 0x81, 0xC0, 0xC0, 0x81, 0x81, 0x03, 0x02, 0x06, 0x0C, 0x08,
  0x10, 0x30, 0x60, 0xC0, 0x81, 0x02, 0x0C, 0x18, 0x30, 0x60, 0x81, 0x06,
  0x0C, 0x10, 0x60, 0x83, 0x04, 0x18, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x0C, 0x21, 0xBD, 0x78, 0x1C, 0x00, 0xA0, 0x0D, 0x80, 0x44, 0x04,
  0x10, 0x60, 0xC1, 0x02, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0xFF, 0xFE, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x33, 0x22, 0x66, 0x44, 0xC0, 0xFF, 0x80, 0xBC, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18,
  0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x00, 0x0F, 0xC0, 0x71,
  0x83, 0x03, 0x08, 0x06, 0x60, 0x09, 0x00, 0x24, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x50, 0x03, 0x40, 0x0D, 0x80, 0x22,
  0x01, 0x8C, 0x04, 0x18, 0x60, 0x3F, 0x00, 0x03, 0x07, 0x0F, 0x1B, 0x63,
  0xC3, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x1F, 0xC1, 0xE3,
  0x8C, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0xFF, 0xF0, 0x1F, 0xC1, 0xC1, 0x8C, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x03, 0x00, 0x38, 0x1F, 0x00, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x06, 0xC0, 0x71, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x05, 0x80, 0x04, 0xC0, 0x06, 0x60, 0x02, 0x30, 0x02, 0x18,
  0x03, 0x0C, 0x01, 0x06, 0x01, 0x83, 0x01, 0x81, 0x80, 0x80, 0xC0, 0xC0,
  0x60, 0x40, 0x30, 0x40, 0x18, 0x60, 0x0C, 0x3F, 0xFF, 0xE0, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x3F, 0xF8, 0xFF, 0xE2, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x1F, 0xF8, 0x40, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0xC0, 0x71, 0xFF, 0x00, 0x03,
  0xF8, 0x1C, 0x20, 0xC0, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x3C, 0x37, 0xBC, 0xF0, 0x1A, 0x80, 0x3C,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x50, 0x01, 0x40, 0x05,
  0x80, 0x16, 0x00, 0xCC, 0x06, 0x18, 0x30, 0x3F, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x00, 0x0F, 0xC0, 0xE1, 0xC2, 0x01,
  0x98, 0x02, 0x40, 0x0D, 0x00, 0x34, 0x00, 0xD0, 0x02, 0x60, 0x18, 0xC0,
  0x41, 0x86, 0x03, 0xB0, 0x07, 0x80, 0x33, 0x83, 0x03, 0x18, 0x06, 0x40,
  0x0F, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0xD8,
  0x06, 0x30, 0x30, 0x7F, 0x80, 0x0F, 0xC0, 0xE1, 0x86, 0x03, 0x10, 0x06,
  0xC0, 0x0A, 0x00, 0x28, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xF0, 0x03, 0x40, 0x1D, 0x80, 0x53, 0x06, 0x47, 0xF1, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00,
  0xC1, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xBC, 0x33, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x32, 0x26, 0x64, 0x48, 0x00, 0x02, 0x00, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x40,
  0x00, 0x3F, 0x1C, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0x00, 0x70, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x30, 0x00, 0x02, 0x20, 0x00,
  0x02, 0x60, 0x3F, 0x83, 0x40, 0x40, 0x81, 0xC0, 0x80, 0x81, 0xC1, 0x80,
  0x81, 0x81, 0x00, 0x81, 0x81, 0x00, 0x81, 0x81, 0x00, 0x81, 0x83, 0x01,
  0x81, 0x81, 0x01, 0x81, 0x81, 0x01, 0x81, 0x81, 0x01, 0x83, 0xC1, 0x82,
  0x82, 0xC0, 0xC6, 0xC4, 0x40, 0x78, 0x78, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x02, 0x80, 0x00,
  0x50, 0x00, 0x1B, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x18, 0xC0, 0x02,
  0x08, 0x00, 0x41, 0x00, 0x18, 0x30, 0x02, 0x06, 0x00, 0x40, 0x40, 0x18,
  0x0C, 0x02, 0x01, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x02, 0x00, 0x60, 0x40,
  0x04, 0x18, 0x00, 0x82, 0x00, 0x18, 0x40, 0x01, 0x18, 0x00, 0x22, 0x00,
  0x06, 0xC0, 0x00, 0x58, 0x00, 0x0C, 0xFF, 0x81, 0xFF, 0xE3, 0x00, 0x66,
  0x00, 0x6C, 0x00, 0x58, 0x00, 0xB0, 0x01, 0xE0, 0x02, 0xC0, 0x05, 0x80,
  0x1B, 0x00, 0x26, 0x01, 0x8F, 0xFC, 0x18, 0x07, 0x30, 0x03, 0x60, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0x60, 0x06, 0xC0, 0x79, 0xFF, 0xC0, 0x01, 0xFE, 0x03, 0xC1, 0xC3,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x06, 0x01,
  0x01, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xF8, 0x30, 0x06, 0x18, 0x01, 0x8C,
  0x00, 0x66, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x02, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x58, 0x00, 0x2C, 0x00, 0x36,
  0x00, 0x33, 0x00, 0x11, 0x80, 0x38, 0xC0, 0xF0, 0x7F, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x7F, 0xFB, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x70, 0x7C, 0x38, 0x01, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x3F, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x68, 0x00, 0x0D, 0x00, 0x01, 0xB0, 0x00,
  0x32, 0x00, 0x06, 0x60, 0x00, 0xC6, 0x00, 0x18, 0x60, 0x03, 0x07, 0x00,
  0xE0, 0x3F, 0xF0, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xFC, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x33, 0xF0, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0xFC, 0xC0,
  0x07, 0x80, 0x1B, 0x00, 0x66, 0x01, 0x8C, 0x02, 0x18, 0x0C, 0x30, 0x30,
  0x60, 0xC0, 0xC3, 0x01, 0x8C, 0x03, 0x10, 0x06, 0x60, 0x0D, 0xE0, 0x1E,
  0xC0, 0x38, 0xC0, 0x60, 0x80, 0xC1, 0x81, 0x81, 0x83, 0x01, 0x06, 0x03,
  0x0C, 0x03, 0x18, 0x02, 0x30, 0x06, 0x60, 0x06, 0xC0, 0x05, 0x80, 0x0C,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0x7C,
  0x00, 0x07, 0xD0, 0x00, 0x3F, 0x40, 0x00, 0xBD, 0x80, 0x06, 0xF2, 0x00,
  0x13, 0xC8, 0x00, 0x4F, 0x30, 0x03, 0x3C, 0x40, 0x08, 0xF1, 0x80, 0x23,
  0xC6, 0x01, 0x8F, 0x08, 0x04, 0x3C, 0x30, 0x10, 0xF0, 0x40, 0xC3, 0xC1,
  0x02, 0x0F, 0x06, 0x18, 0x3C, 0x08, 0x40, 0xF0, 0x21, 0x03, 0xC0, 0xCC,
  0x0F, 0x01, 0x20, 0x3C, 0x06, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x30, 0x0F,
  0x00, 0xC0, 0x30, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3D,
  0x00, 0x1E, 0xC0, 0x0F, 0x20, 0x07, 0x98, 0x03, 0xC6, 0x01, 0xE1, 0x00,
  0xF0, 0xC0, 0x78, 0x20, 0x3C, 0x18, 0x1E, 0x06, 0x0F, 0x01, 0x07, 0x80,
  0xC3, 0xC0, 0x21, 0xE0, 0x18, 0xF0, 0x04, 0x78, 0x03, 0x3C, 0x00, 0xDE,
  0x00, 0x2F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xC0, 0x01,
  0xFC, 0x00, 0x70, 0xF0, 0x0C, 0x01, 0x81, 0x00, 0x0C, 0x30, 0x00, 0x46,
  0x00, 0x06, 0x60, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x26, 0x00,
  0x02, 0x60, 0x00, 0x62, 0x00, 0x04, 0x30, 0x00, 0xC1, 0x80, 0x18, 0x0E,
  0x07, 0x00, 0x3F, 0xC0, 0xFE, 0x03, 0xFF, 0x8C, 0x03, 0x30, 0x06, 0xC0,
  0x0B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xB0,
  0x06, 0xC0, 0x13, 0x03, 0x8F, 0xFC, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x70, 0xF0, 0x0C, 0x01, 0x81, 0x00, 0x0C,
  0x30, 0x00, 0x46, 0x00, 0x06, 0x60, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x40,
  0x00, 0x26, 0x00, 0x02, 0x60, 0x00, 0x62, 0x00, 0x04, 0x30, 0x00, 0xC1,
  0x80, 0x18, 0x0E, 0x07, 0x00, 0x3F, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0xFF, 0x01,
  0xFF, 0xC3, 0x00, 0xC6, 0x00, 0xCC, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60,
  0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x26, 0x00, 0xCC, 0x03, 0x1F, 0xF8,
  0x3F, 0xE0, 0x60, 0x40, 0xC0, 0xC1, 0x80, 0x83, 0x01, 0x86, 0x01, 0x0C,
  0x03, 0x18, 0x03, 0x30, 0x02, 0x60, 0x06, 0xC0, 0x05, 0x80, 0x0C, 0x0F,
  0xF0, 0xE0, 0xE6, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x06, 0xC0, 0x73, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x12, 0x00, 0x09,
  0x80, 0x0C, 0x60, 0x0C, 0x18, 0x0C, 0x07, 0xFC, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x34, 0x00, 0x09, 0x00, 0x02, 0x60, 0x01, 0x88, 0x00, 0x42, 0x00,
  0x10, 0xC0, 0x0C, 0x10, 0x02, 0x04, 0x00, 0x81, 0x80, 0x60, 0x20, 0x10,
  0x08, 0x04, 0x03, 0x03, 0x00, 0x40, 0x80, 0x10, 0x20, 0x06, 0x18, 0x00,
  0x86, 0x00, 0x21, 0x00, 0x0C, 0xC0, 0x01, 0x30, 0x00, 0x48, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30,
  0x01, 0x80, 0x0F, 0x00, 0x38, 0x01, 0xA0, 0x05, 0x00, 0x24, 0x00, 0xA0,
  0x04, 0x80, 0x34, 0x01, 0x98, 0x04, 0xC0, 0x31, 0x00, 0x98, 0x04, 0x20,
  0x11, 0x00, 0x84, 0x06, 0x20, 0x30, 0xC0, 0x86, 0x06, 0x08, 0x10, 0xC0,
  0x81, 0x02, 0x08, 0x10, 0x20, 0xC1, 0x06, 0x06, 0x10, 0x30, 0xC0, 0x42,
  0x06, 0x10, 0x08, 0x40, 0x42, 0x01, 0x18, 0x08, 0xC0, 0x33, 0x01, 0x98,
  0x06, 0x40, 0x32, 0x00, 0x48, 0x02, 0x40, 0x0B, 0x00, 0x58, 0x01, 0xE0,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x60, 0x03, 0x20, 0x02, 0x30, 0x06, 0x10, 0x04, 0x18, 0x0C, 0x08, 0x08,
  0x0C, 0x18, 0x04, 0x10, 0x06, 0x30, 0x02, 0x60, 0x03, 0x40, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x30,
  0x0C, 0x10, 0x08, 0x18, 0x18, 0x08, 0x10, 0x0C, 0x30, 0x06, 0x60, 0x02,
  0x40, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x03, 0x60, 0x02, 0x60, 0x06,
  0x20, 0x04, 0x30, 0x0C, 0x10, 0x08, 0x18, 0x18, 0x08, 0x10, 0x0C, 0x30,
  0x04, 0x20, 0x06, 0x60, 0x02, 0x40, 0x03, 0x40, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x7F, 0xFE, 0xFF, 0xFC,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x3F,
  0xFF, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x0C, 0xFF, 0xFC, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x7F, 0xFF, 0x00, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x03,
  0x40, 0x02, 0x20, 0x04, 0x20, 0x04, 0x10, 0x08, 0x10, 0x08, 0x08, 0x10,
  0x08, 0x30, 0x04, 0x20, 0x04, 0x60, 0x02, 0x40, 0x02, 0xC0, 0x03, 0xFF,
  0xFE, 0xC1, 0x83, 0x04, 0x08, 0x10, 0x3F, 0xC6, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x07, 0xF3, 0xE1, 0x60, 0x1C, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x56, 0x0D, 0x3F, 0x10, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x8F, 0xE2, 0x40, 0xCA, 0x01, 0xB0, 0x02, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x02, 0xA0, 0x1A, 0xC0, 0xC8, 0xFE, 0x00, 0x0F,
  0xF1, 0x81, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x81, 0x0F, 0xF0, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x0F, 0xC4, 0xE0, 0xD2, 0x01, 0x58,
  0x03, 0x40, 0x0F, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x14, 0x00, 0xD0, 0x03, 0x60, 0x14,
  0xC0, 0xD1, 0xFC, 0x40, 0x0F, 0xC0, 0xE0, 0xC2, 0x01, 0x18, 0x06, 0x40,
  0x0B, 0x00, 0x2C, 0x00, 0xA0, 0x03, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20,
  0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x60, 0x60,
  0xFF, 0x00, 0x00, 0x80, 0xFC, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x1F, 0xF0, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x0F, 0xE4, 0xC0, 0xD2, 0x01, 0x58, 0x03,
  0x40, 0x0F, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0xC0, 0x07, 0x00, 0x34, 0x00, 0xD0, 0x03, 0x60, 0x14, 0xC0,
  0x91, 0xFC, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x09, 0x00, 0xC7, 0xFE, 0x01, 0xC0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x8F, 0xE4, 0x81, 0xA8, 0x05,
  0x80, 0x3C, 0x01, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0xF8, 0x02, 0xAA, 0xAA, 0xAA, 0xAA, 0xA0, 0x0C, 0x30, 0x80,
  0x00, 0x00, 0x02, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x1B, 0xCC, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x38, 0x04, 0x80, 0xC8, 0x18, 0x83, 0x08, 0x20, 0x84, 0x08, 0x80,
  0x9C, 0x0B, 0x40, 0xA6, 0x0C, 0x30, 0x81, 0x08, 0x18, 0x80, 0x88, 0x0C,
  0x80, 0x68, 0x02, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xE0, 0x9F, 0xC3, 0xF2,
  0xC1, 0x90, 0x6A, 0x02, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x8F, 0xE4, 0x81, 0xA8, 0x05, 0x80, 0x3C, 0x01, 0xE0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x0F, 0xE0, 0x70,
  0x60, 0x80, 0x63, 0x00, 0x64, 0x00, 0x58, 0x00, 0xB0, 0x01, 0x40, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x58, 0x00, 0x90,
  0x01, 0x30, 0x06, 0x20, 0x18, 0x70, 0x60, 0x3F, 0x80, 0x8F, 0xE2, 0x60,
  0xCA, 0x01, 0xB8, 0x02, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF8,
  0x02, 0xA0, 0x1A, 0x60, 0xC8, 0xFE, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xC4, 0xE0,
  0xD2, 0x01, 0x58, 0x03, 0x40, 0x0F, 0x00, 0x3C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x3C, 0x00, 0xD0,
  0x03, 0x60, 0x14, 0xC0, 0x91, 0xFC, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x8F, 0xC8, 0x28,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x00, 0x1F, 0xF3, 0x03, 0x60, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x60, 0x03, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xC0,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x3C, 0x06, 0x7F, 0xC0,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x07, 0xFC, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x80, 0x40, 0x3F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x78, 0x05, 0xC0, 0x2B, 0x06, 0x4F, 0xE2, 0xC0, 0x05,
  0x00, 0x34, 0x00, 0x98, 0x02, 0x20, 0x18, 0x80, 0x43, 0x01, 0x04, 0x0C,
  0x10, 0x20, 0x60, 0x80, 0x86, 0x02, 0x10, 0x0C, 0x40, 0x13, 0x00, 0x48,
  0x01, 0xA0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x06, 0x80,
  0x30, 0x09, 0x80, 0xE0, 0x13, 0x01, 0x40, 0x62, 0x02, 0xC0, 0x84, 0x0C,
  0x81, 0x0C, 0x19, 0x02, 0x18, 0x23, 0x0C, 0x10, 0x46, 0x10, 0x21, 0x84,
  0x20, 0x62, 0x08, 0x40, 0x44, 0x19, 0x80, 0x98, 0x12, 0x01, 0x30, 0x24,
  0x03, 0x40, 0x48, 0x02, 0x80, 0xF0, 0x07, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x03, 0x00, 0xC0, 0x19, 0x80, 0x42, 0x03, 0x0C, 0x08, 0x10, 0x40,
  0x23, 0x00, 0xC8, 0x01, 0x60, 0x07, 0x00, 0x0C, 0x00, 0x70, 0x03, 0x60,
  0x08, 0xC0, 0x61, 0x01, 0x06, 0x08, 0x08, 0x60, 0x11, 0x00, 0x6C, 0x00,
  0xC0, 0xC0, 0x05, 0x00, 0x36, 0x00, 0xD8, 0x02, 0x20, 0x18, 0xC0, 0x63,
  0x01, 0x04, 0x0C, 0x18, 0x20, 0x60, 0x80, 0x86, 0x03, 0x10, 0x04, 0x40,
  0x13, 0x00, 0x48, 0x00, 0xA0, 0x03, 0x80, 0x0C, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x0F, 0x80,
  0x38, 0x00, 0x7F, 0xF0, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x04, 0x00, 0xFF, 0xF0, 0x00, 0xC0, 0xF0, 0x60, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02,
  0x01, 0x83, 0xC0, 0xF0, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x3C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x3E, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x20, 0x07,
  0x01, 0xC0, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x03, 0x0F, 0x83, 0x00, 0x7E, 0x03, 0x07, 0x1E,
  0x03, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 26, 8, 3, -26 },
  { 8, 7, 10, 12, 2, -26 },
  { 17, 19, 26, 20, 1, -26 },
  { 79, 14, 29, 18, 2, -27 },
  { 130, 22, 26, 26, 2, -26 },
  { 202, 19, 26, 21, 2, -26 },
  { 264, 2, 10, 6, 2, -26 },
  { 267, 6, 32, 10, 2, -26 },
  { 291, 7, 32, 10, 1, -26 },
  { 319, 13, 13, 17, 2, -27 },
  { 341, 15, 17, 18, 2, -21 },
  { 373, 4, 9, 7, 1, -4 },
  { 378, 9, 1, 11, 1, -10 },
  { 380, 2, 3, 8, 3, -3 },
  { 381, 11, 26, 12, 1, -26 },
  { 417, 14, 26, 18, 2, -26 },
  { 463, 8, 26, 18, 3, -26 },
  { 489, 14, 26, 18, 2, -26 },
  { 535, 14, 26, 18, 2, -26 },
  { 581, 17, 26, 18, 1, -26 },
  { 637, 14, 26, 18, 2, -26 },
  { 683, 14, 26, 18, 2, -26 },
  { 729, 14, 26, 18, 2, -26 },
  { 775, 14, 26, 18, 2, -26 },
  { 821, 14, 26, 18, 2, -26 },
  { 867, 2, 19, 8, 3, -19 },
  { 872, 4, 24, 8, 1, -19 },
  { 884, 15, 16, 18, 2, -21 },
  { 914, 15, 9, 18, 2, -17 },
  { 931, 15, 16, 18, 2, -21 },
  { 961, 11, 26, 13, 1, -26 },
  { 997, 24, 29, 28, 2, -26 },
  { 1084, 19, 26, 19, 0, -26 },
  { 1146, 15, 26, 20, 3, -26 },
  { 1195, 17, 26, 20, 2, -26 },
  { 1251, 17, 26, 22, 3, -26 },
  { 1307, 13, 26, 18, 3, -26 },
  { 1350, 13, 26, 16, 3, -26 },
  { 1393, 19, 26, 23, 2, -26 },
  { 1455, 16, 26, 23, 3, -26 },
  { 1507, 6, 26, 10, 2, -26 },
  { 1527, 8, 32, 8, -3, -26 },
  { 1559, 15, 26, 18, 3, -26 },
  { 1608, 12, 26, 16, 3, -26 },
  { 1647, 22, 26, 28, 3, -26 },
  { 1719, 17, 26, 23, 3, -26 },
  { 1775, 20, 26, 24, 2, -26 },
  { 1840, 14, 26, 19, 3, -26 },
  { 1886, 20, 32, 24, 2, -26 },
  { 1966, 15, 26, 19, 3, -26 },
  { 2015, 14, 26, 18, 2, -26 },
  { 2061, 16, 26, 16, 0, -26 },
  { 2113, 17, 26, 23, 3, -26 },
  { 2169, 18, 26, 18, 0, -26 },
  { 2228, 27, 26, 29, 1, -26 },
  { 2316, 16, 26, 17, 0, -26 },
  { 2368, 16, 26, 16, 0, -26 },
  { 2420, 15, 26, 18, 1, -26 },
  { 2469, 7, 32, 11, 3, -26 },
  { 2497, 11, 26, 12, 1, -26 },
  { 2533, 7, 32, 11, 1, -26 },
  { 2561, 16, 15, 18, 1, -26 },
  { 2591, 15, 1, 14, 0, 3 },
  { 2593, 6, 6, 9, 1, -28 },
  { 2598, 12, 19, 17, 2, -19 },
  { 2627, 14, 27, 19, 3, -27 },
  { 2675, 12, 19, 15, 2, -19 },
  { 2704, 14, 27, 19, 2, -27 },
  { 2752, 14, 19, 18, 2, -19 },
  { 2786, 11, 28, 9, 0, -28 },
  { 2825, 14, 28, 19, 2, -19 },
  { 2874, 13, 27, 19, 3, -27 },
  { 2918, 2, 26, 7, 3, -26 },
  { 2925, 6, 35, 7, -1, -26 },
  { 2952, 12, 27, 15, 3, -27 },
  { 2993, 1, 27, 7, 3, -27 },
  { 2997, 22, 19, 28, 3, -19 },
  { 3050, 13, 19, 19, 3, -19 },
  { 3081, 15, 19, 19, 2, -19 },
  { 3117, 14, 27, 19, 3, -19 },
  { 3165, 14, 27, 19, 2, -19 },
  { 3213, 9, 19, 12, 3, -19 },
  { 3235, 12, 19, 15, 1, -19 },
  { 3264, 9, 24, 10, 1, -24 },
  { 3291, 13, 19, 19, 3, -19 },
  { 3322, 14, 19, 14, 0, -19 },
  { 3356, 23, 19, 23, 0, -19 },
  { 3411, 14, 19, 15, 1, -19 },
  { 3445, 14, 28, 14, 0, -19 },
  { 3494, 12, 19, 14, 1, -19 },
  { 3523, 10, 32, 12, 1, -26 },
  { 3563, 1, 36, 17, 8, -27 },
  { 3568, 10, 32, 12, 1, -26 },
  { 3608, 15, 3, 18, 2, -14 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight36pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT36PT7B_H_
