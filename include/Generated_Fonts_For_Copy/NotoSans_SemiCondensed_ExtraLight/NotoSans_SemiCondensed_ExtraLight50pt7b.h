#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT50PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF6, 0xDB, 0x6D, 0xB6, 0xDB, 0x69, 0x24, 0x92, 0x49, 0x00,
  0x00, 0x5F, 0xF0, 0xE0, 0xF8, 0x36, 0x0D, 0x03, 0x40, 0xD0, 0x34, 0x0D,
  0x03, 0x40, 0xD0, 0x34, 0x0D, 0x03, 0x40, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x0C, 0x03, 0x00, 0x03, 0x00, 0x80, 0x00, 0x80, 0x20, 0x00, 0x20, 0x18,
  0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60,
  0x10, 0x00, 0x10, 0x04, 0x00, 0x04, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xC0, 0x30, 0x0C, 0x00, 0x0C, 0x02, 0x00, 0x02, 0x00, 0x80,
  0x00, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01,
  0x80, 0x01, 0x80, 0x60, 0x00, 0x40, 0x10, 0x00, 0x10, 0x04, 0x03, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00,
  0x0C, 0x02, 0x00, 0x02, 0x00, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18,
  0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x40, 0x00, 0x40,
  0x10, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x01, 0xFE, 0x01, 0xFF, 0xFC, 0x71, 0x87, 0x1C, 0x30, 0x23, 0x06, 0x00,
  0xC0, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x01,
  0x81, 0x80, 0x30, 0x30, 0x03, 0x06, 0x00, 0x70, 0xC0, 0x07, 0x98, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xBC, 0x00, 0x31, 0xC0,
  0x06, 0x1C, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x06, 0x00, 0xC0, 0xD0,
  0x18, 0x33, 0x83, 0x1C, 0x7F, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0x00, 0x73,
  0x80, 0x06, 0x01, 0x83, 0x80, 0x08, 0x03, 0x03, 0x00, 0x30, 0x0C, 0x02,
  0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18,
  0x0C, 0x00, 0x80, 0x30, 0x18, 0x01, 0x00, 0x60, 0x60, 0x02, 0x00, 0xC0,
  0xC0, 0x04, 0x01, 0x83, 0x00, 0x08, 0x03, 0x06, 0x00, 0x10, 0x06, 0x18,
  0x00, 0x30, 0x0C, 0x30, 0xF0, 0x60, 0x18, 0xC3, 0xF8, 0xC0, 0x31, 0x8C,
  0x19, 0x80, 0xC6, 0x30, 0x31, 0x81, 0x8C, 0x60, 0x33, 0x06, 0x10, 0x80,
  0x63, 0x9C, 0x63, 0x00, 0xC3, 0xF0, 0x86, 0x00, 0x80, 0x03, 0x0C, 0x01,
  0x00, 0x04, 0x18, 0x03, 0x00, 0x18, 0x30, 0x06, 0x00, 0x30, 0x60, 0x0C,
  0x00, 0xC0, 0xC0, 0x18, 0x01, 0x81, 0x80, 0x30, 0x06, 0x03, 0x00, 0x40,
  0x0C, 0x06, 0x01, 0x80, 0x30, 0x04, 0x03, 0x00, 0x60, 0x0C, 0x06, 0x01,
  0x80, 0x18, 0x0C, 0x03, 0x00, 0x18, 0x30, 0x0C, 0x00, 0x38, 0xC0, 0x18,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00,
  0x18, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00,
  0xC0, 0x01, 0x80, 0x18, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x70, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x80, 0xC0, 0x0C, 0x60, 0x1C, 0x01, 0x1C, 0x01, 0xC0,
  0x63, 0x00, 0x1C, 0x0C, 0x60, 0x01, 0x81, 0x8C, 0x00, 0x18, 0x63, 0x00,
  0x01, 0x8C, 0x20, 0x00, 0x1B, 0x06, 0x00, 0x03, 0xE0, 0xC0, 0x00, 0x38,
  0x18, 0x00, 0x07, 0x03, 0x80, 0x01, 0xB0, 0x30, 0x00, 0x63, 0x03, 0x80,
  0x38, 0x70, 0x3C, 0x3E, 0x07, 0x03, 0xFF, 0x00, 0x70, 0x06, 0x00, 0x00,
  0xFD, 0xA4, 0x92, 0x49, 0x24, 0x01, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x30, 0x07,
  0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01,
  0x80, 0x60, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06,
  0x03, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x0C, 0x0C, 0x0F, 0xE3, 0x1F, 0x3E, 0xFE, 0x00, 0xFC,
  0x00, 0x1C, 0x00, 0x05, 0x80, 0x03, 0x30, 0x01, 0x86, 0x00, 0xC1, 0x80,
  0x30, 0x30, 0x38, 0x06, 0x04, 0x01, 0x80, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x19, 0xCC, 0x63, 0x19,
  0x8C, 0x63, 0x31, 0x80, 0xFF, 0xE0, 0x5F, 0xF0, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0C, 0x07, 0x01,
  0x80, 0x38, 0x30, 0x01, 0x83, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x04,
  0x60, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x2C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x66,
  0x00, 0x06, 0x60, 0x00, 0x46, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x18,
  0x18, 0x01, 0x81, 0xC0, 0x30, 0x0F, 0x9E, 0x00, 0x3F, 0xC0, 0x00, 0x60,
  0x1C, 0x0F, 0x83, 0xB0, 0xE6, 0x38, 0xDC, 0x1F, 0x03, 0x40, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x38, 0x03, 0x87, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x78,
  0x03, 0x8E, 0x00, 0x1C, 0x40, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x7E,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xCC, 0x00, 0x3C, 0xFC, 0x0F, 0x03, 0xFF, 0xE0,
  0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0,
  0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x30, 0x00, 0xC0,
  0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xC0, 0x7E, 0x1F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x8C, 0x00, 0x70, 0xF8, 0x3E, 0x03, 0xFF, 0x80, 0x01, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC1,
  0xFC, 0x0C, 0x7F, 0xF0, 0xCE, 0x03, 0x8D, 0x80, 0x0C, 0xF0, 0x00, 0xEE,
  0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00,
  0x36, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0E, 0x18, 0x00, 0xC1, 0xC0,
  0x18, 0x0F, 0x0F, 0x00, 0x3F, 0xE0, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xF0, 0x1C, 0x03, 0x83, 0x00, 0x1C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60,
  0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0xC6,
  0x00, 0x0C, 0x30, 0x01, 0x81, 0x80, 0x38, 0x0E, 0x07, 0x00, 0x71, 0xC0,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0x1C, 0x01, 0xC0, 0x70, 0x38, 0x03,
  0x87, 0x00, 0x1C, 0x60, 0x00, 0xEC, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x06, 0xC0,
  0x00, 0x6E, 0x00, 0x06, 0x60, 0x00, 0xC3, 0x80, 0x18, 0x1E, 0x0F, 0x00,
  0x7F, 0xE0, 0x00, 0x40, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x1C, 0x03,
  0x81, 0x80, 0x18, 0x30, 0x00, 0xC7, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00,
  0x06, 0x60, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x73,
  0x00, 0x07, 0x30, 0x00, 0xB1, 0xC0, 0x3B, 0x0F, 0x1F, 0x30, 0x7F, 0xC3,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x30, 0x3C, 0x03, 0xFF, 0x00, 0x03,
  0x00, 0x00, 0xDF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0xFF,
  0x80, 0x11, 0xCE, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0xE6, 0x31, 0x8C, 0xC6, 0x31, 0x18, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xF8, 0x60, 0x1C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x02, 0x00,
  0x31, 0x80, 0x0F, 0xFC, 0x06, 0x60, 0x0E, 0x07, 0x01, 0x98, 0x07, 0x00,
  0x80, 0x6C, 0x01, 0x80, 0x20, 0x1B, 0x00, 0xC0, 0x08, 0x02, 0xC0, 0x30,
  0x06, 0x00, 0xF0, 0x18, 0x01, 0x80, 0x3C, 0x06, 0x00, 0x60, 0x0F, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x60, 0x06, 0x00, 0xE0, 0x18, 0x01, 0x80, 0x28,
  0x06, 0x00, 0x60, 0x1A, 0x01, 0x80, 0x18, 0x06, 0xC0, 0x60, 0x06, 0x01,
  0xB0, 0x18, 0x03, 0x80, 0x6C, 0x03, 0x00, 0xA0, 0x33, 0x00, 0xC0, 0x6C,
  0x0C, 0xC0, 0x1C, 0x71, 0x8E, 0x18, 0x03, 0xF8, 0x7F, 0x06, 0x00, 0x10,
  0x02, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x04, 0x08, 0x00, 0x03, 0x03, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x20, 0x10, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01,
  0x80, 0x01, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xC0,
  0x0F, 0x8C, 0x00, 0x1C, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x01, 0xCC, 0x00, 0x38, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0xC0, 0x0F, 0x8C, 0x00, 0x1C, 0xC0, 0x00, 0xEC, 0x00,
  0x06, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x01, 0xCC, 0x00, 0x38, 0xFF, 0xFF, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFC, 0x0F, 0x00, 0x30, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x08, 0x07, 0xC1, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x03, 0x00, 0x3E, 0x06, 0x00, 0x1E, 0x0C, 0x00,
  0x0E, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0xC0, 0x00,
  0x19, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0D, 0x80,
  0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00,
  0x06, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x70, 0xC0, 0x01, 0xC1, 0x80, 0x1F,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xB0, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xEC, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x1E, 0x00, 0x38, 0x0E, 0x00, 0x02, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03,
  0x30, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0C, 0x38, 0x00,
  0x03, 0x07, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x70, 0x1F, 0xC3, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC3,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x07,
  0x9F, 0xF0, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x3A,
  0x0E, 0x7F, 0x87, 0xC0, 0xC0, 0x00, 0x7C, 0x00, 0x0E, 0xC0, 0x00, 0xCC,
  0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x70, 0xC0, 0x0E, 0x0C, 0x01, 0xC0,
  0xC0, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x0E, 0x00, 0xC1, 0xC0,
  0x0C, 0x38, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0xCF, 0x00, 0x0D, 0xB0,
  0x00, 0xF1, 0x80, 0x0F, 0x1C, 0x00, 0xE0, 0xC0, 0x0C, 0x06, 0x00, 0xC0,
  0x70, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x01, 0xC0, 0xC0, 0x0C, 0x0C,
  0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x8C, 0x00, 0x18,
  0xC0, 0x00, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xEC, 0x00, 0x00, 0x1B, 0xB0, 0x00, 0x00, 0x6E, 0xC0, 0x00,
  0x01, 0xBD, 0x80, 0x00, 0x0C, 0xF6, 0x00, 0x00, 0x33, 0xCC, 0x00, 0x00,
  0xCF, 0x30, 0x00, 0x06, 0x3C, 0xC0, 0x00, 0x18, 0xF1, 0x80, 0x00, 0x43,
  0xC6, 0x00, 0x03, 0x0F, 0x18, 0x00, 0x0C, 0x3C, 0x30, 0x00, 0x60, 0xF0,
  0xC0, 0x01, 0x83, 0xC3, 0x00, 0x06, 0x0F, 0x06, 0x00, 0x30, 0x3C, 0x18,
  0x00, 0xC0, 0xF0, 0x30, 0x02, 0x03, 0xC0, 0xC0, 0x18, 0x0F, 0x03, 0x00,
  0x60, 0x3C, 0x06, 0x03, 0x00, 0xF0, 0x18, 0x0C, 0x03, 0xC0, 0x60, 0x30,
  0x0F, 0x00, 0xC1, 0x80, 0x3C, 0x03, 0x06, 0x00, 0xF0, 0x0C, 0x18, 0x03,
  0xC0, 0x18, 0xC0, 0x0F, 0x00, 0x63, 0x00, 0x3C, 0x00, 0xC8, 0x00, 0xF0,
  0x03, 0x60, 0x03, 0xC0, 0x0D, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0xE0, 0x00, 0x39, 0x80,
  0x00, 0xE3, 0x00, 0x03, 0xCC, 0x00, 0x0F, 0x18, 0x00, 0x3C, 0x70, 0x00,
  0xF0, 0xC0, 0x03, 0xC1, 0x80, 0x0F, 0x06, 0x00, 0x3C, 0x0C, 0x00, 0xF0,
  0x38, 0x03, 0xC0, 0x60, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x06,
  0x03, 0xC0, 0x1C, 0x0F, 0x00, 0x30, 0x3C, 0x00, 0xE0, 0xF0, 0x01, 0x83,
  0xC0, 0x03, 0x0F, 0x00, 0x0C, 0x3C, 0x00, 0x18, 0xF0, 0x00, 0x73, 0xC0,
  0x00, 0xCF, 0x00, 0x01, 0xBC, 0x00, 0x06, 0x70, 0x00, 0x0D, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x00, 0xE0, 0x0C,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x30, 0x0E, 0x00, 0x06, 0x00, 0x78, 0x01, 0xC0, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x0C,
  0x01, 0xE3, 0x00, 0x1C, 0xC0, 0x01, 0xB0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x01, 0xCC,
  0x01, 0xE3, 0xFF, 0xF0, 0xFF, 0xE0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0x80, 0x1C, 0x00, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x38, 0x38, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x00,
  0x78, 0x01, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x05,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xC0,
  0x1F, 0x0C, 0x00, 0x38, 0xC0, 0x01, 0x8C, 0x00, 0x1C, 0xC0, 0x00, 0xCC,
  0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C,
  0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0xCC, 0x00, 0x18, 0xC0, 0x03,
  0x0C, 0x00, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xC0, 0x70, 0x0C, 0x03,
  0x00, 0xC0, 0x38, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0,
  0x06, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x38, 0xC0, 0x01, 0x8C,
  0x00, 0x1C, 0xC0, 0x00, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00, 0x03,
  0x01, 0xFF, 0x80, 0x7F, 0xFE, 0x1E, 0x00, 0x63, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xCC, 0x00,
  0x3C, 0xFE, 0x1F, 0x03, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xDC, 0x00, 0x03, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x3C,
  0x00, 0xE0, 0x1F, 0x0F, 0x80, 0x1F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x01, 0x80, 0x03,
  0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x60,
  0x0C, 0x00, 0x10, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x01, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xC0,
  0x00, 0x36, 0x00, 0x07, 0x00, 0x00, 0xD8, 0x00, 0x1E, 0x00, 0x06, 0x60,
  0x00, 0x78, 0x00, 0x19, 0x80, 0x01, 0x60, 0x00, 0x63, 0x00, 0x0C, 0x80,
  0x01, 0x8C, 0x00, 0x33, 0x00, 0x0C, 0x30, 0x00, 0xCC, 0x00, 0x30, 0xC0,
  0x03, 0x30, 0x00, 0xC1, 0x80, 0x18, 0x40, 0x07, 0x06, 0x00, 0x61, 0x80,
  0x18, 0x18, 0x01, 0x86, 0x00, 0x60, 0x60, 0x06, 0x18, 0x01, 0x80, 0xC0,
  0x30, 0x20, 0x0E, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x0C, 0x03, 0x00, 0x60, 0x60, 0x10, 0x1C, 0x01, 0x81,
  0x80, 0x60, 0x60, 0x06, 0x06, 0x01, 0x81, 0x80, 0x18, 0x18, 0x06, 0x06,
  0x00, 0x30, 0xC0, 0x08, 0x30, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0xC3, 0x00, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0x19, 0x80, 0x04, 0x60,
  0x00, 0x66, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x66, 0x00, 0x06, 0x60,
  0x01, 0x98, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x06, 0x00, 0x70, 0x00, 0x0C, 0x60, 0x00,
  0x38, 0xE0, 0x00, 0x60, 0xC0, 0x01, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x00,
  0x06, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x70, 0x00, 0x18, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x31,
  0xC0, 0x00, 0xC1, 0x80, 0x01, 0x81, 0x80, 0x06, 0x03, 0x00, 0x1C, 0x03,
  0x00, 0x30, 0x06, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x31, 0x80, 0x00, 0x37,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x01, 0x9C,
  0x00, 0x06, 0x30, 0x00, 0x38, 0xE0, 0x00, 0xC1, 0x80, 0x07, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60,
  0x03, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x61, 0x80, 0x00,
  0xC6, 0x00, 0x03, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0xFF, 0xFF, 0xF0, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x1F, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x16, 0x00, 0x00, 0xCC, 0x00, 0x02, 0x30, 0x00, 0x18, 0x60, 0x00, 0xC1,
  0x80, 0x03, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x06, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00,
  0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x03, 0xF8, 0x07, 0xFF, 0x83, 0x80, 0x70, 0x40, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xFF, 0xC1, 0xFC, 0x31, 0xE0, 0x0C,
  0xE0, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3D, 0x80, 0x1B, 0x70, 0x0C, 0xCE, 0x0E,
  0x31, 0xFF, 0x0C, 0x04, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x1F, 0xC0, 0xC7,
  0xFF, 0x0C, 0xE0, 0x38, 0xD8, 0x01, 0xCD, 0x00, 0x0C, 0xF0, 0x00, 0xEE,
  0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00,
  0x06, 0xE0, 0x00, 0xEF, 0x00, 0x0C, 0xD0, 0x01, 0xCD, 0x80, 0x38, 0xCF,
  0x0F, 0x0C, 0x3F, 0xC0, 0x00, 0x40, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0xC3,
  0x80, 0x43, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0xC3, 0x80, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x1F,
  0x83, 0x07, 0xFE, 0x31, 0xC0, 0x73, 0x38, 0x01, 0xB3, 0x00, 0x0B, 0x60,
  0x00, 0xF6, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x60, 0x00, 0xF6, 0x00, 0x0B, 0x30, 0x01, 0xB3, 0x80,
  0x33, 0x1E, 0x0E, 0x30, 0x7F, 0xC3, 0x00, 0x40, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xC0, 0x70, 0x1C, 0x0C, 0x01, 0x83, 0x00, 0x18, 0xC0, 0x01, 0x98,
  0x00, 0x33, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x0B, 0x00, 0x01, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x41, 0xE0, 0xF8, 0x0F,
  0xFC, 0x00, 0x10, 0x00, 0x01, 0xFE, 0x07, 0xB8, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x0F, 0xFE, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xC4, 0x70, 0x1C, 0x9C,
  0x00, 0xD3, 0x00, 0x0A, 0xC0, 0x01, 0xD8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x06, 0xC0, 0x01, 0xD8, 0x00, 0x29, 0x80,
  0x0D, 0x38, 0x03, 0x23, 0xC1, 0xC4, 0x1F, 0xF0, 0x80, 0x60, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x20, 0x00, 0xE7, 0x00, 0x78, 0xFF, 0xFC, 0x03, 0xFE,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x07, 0xE0, 0xC7, 0xFE, 0x33, 0x81, 0xCD, 0x80, 0x1B, 0xC0,
  0x06, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x30, 0xDF, 0x80, 0x00, 0x03, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x03, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x33, 0xF9, 0xF0, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x76, 0x00, 0x73, 0x00, 0x31, 0x80, 0x30, 0xC0, 0x30, 0x60,
  0x30, 0x30, 0x38, 0x18, 0x18, 0x0C, 0x18, 0x06, 0x18, 0x03, 0x1C, 0x01,
  0x9E, 0x00, 0xCD, 0x80, 0x6C, 0xC0, 0x3C, 0x30, 0x1C, 0x1C, 0x0C, 0x06,
  0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x30, 0xC0, 0x0C, 0x60, 0x06, 0x30,
  0x01, 0x98, 0x00, 0xEC, 0x00, 0x36, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xE1, 0x8F, 0xF8,
  0x3F, 0xE3, 0x30, 0x38, 0xC0, 0xE6, 0xC0, 0x33, 0x00, 0x6F, 0x00, 0x3C,
  0x00, 0xDC, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0xC0,
  0x03, 0xC0, 0x01, 0x80, 0x07, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x06, 0x00,
  0x1E, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x78, 0x00, 0x30, 0x00,
  0xF0, 0x00, 0x60, 0x01, 0xE0, 0x00, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x07,
  0x80, 0x03, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x3C,
  0x00, 0x18, 0x00, 0x78, 0x00, 0x30, 0x00, 0xF0, 0x00, 0x60, 0x01, 0xE0,
  0x00, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x07, 0x80, 0x03, 0x00, 0x0F, 0x00,
  0x06, 0x00, 0x18, 0x01, 0xF8, 0x31, 0xFF, 0x8C, 0xE0, 0x73, 0x60, 0x06,
  0xD0, 0x01, 0xB8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0C, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1E, 0x03, 0x83,
  0x80, 0x1C, 0x30, 0x00, 0xC6, 0x00, 0x06, 0x60, 0x00, 0x6E, 0x00, 0x06,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x60, 0x00, 0x66, 0x00, 0x06, 0x70,
  0x00, 0xE3, 0x00, 0x0C, 0x1C, 0x03, 0x80, 0xF0, 0xF0, 0x07, 0xFE, 0x00,
  0x06, 0x00, 0x01, 0xFC, 0x0C, 0x7F, 0xF0, 0xCE, 0x03, 0x8D, 0x80, 0x1C,
  0xD0, 0x00, 0xCF, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xF0, 0x00, 0xCD,
  0x80, 0x1C, 0xDC, 0x03, 0x8C, 0xF0, 0xF0, 0xC3, 0xFE, 0x0C, 0x06, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xC4, 0x70, 0x1C, 0x9C,
  0x00, 0xD3, 0x00, 0x0A, 0xC0, 0x01, 0xD8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x01, 0xD8, 0x00, 0x29, 0x80,
  0x0D, 0x38, 0x03, 0x23, 0xC1, 0xCC, 0x1F, 0xF1, 0x80, 0x20, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x01, 0xFC, 0x7F, 0xCE, 0x0D, 0x80, 0xD0, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0xF8, 0x1F, 0xFF, 0x38, 0x06,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x06, 0xF8, 0x3C, 0x7F, 0xF8,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x0F, 0xFF, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C,
  0x00, 0xE1, 0x07, 0xF0, 0x08, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xF6, 0x00, 0x2D, 0xC0, 0x3B, 0x3E,
  0x3C, 0xC7, 0xFC, 0x30, 0x10, 0x00, 0xC0, 0x00, 0x76, 0x00, 0x06, 0x60,
  0x00, 0x66, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01, 0x81,
  0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x19,
  0x00, 0x00, 0xB0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xD8, 0x01,
  0xA0, 0x02, 0x60, 0x06, 0xC0, 0x19, 0x80, 0x13, 0x00, 0x66, 0x00, 0xCC,
  0x01, 0x8C, 0x03, 0x18, 0x04, 0x30, 0x0C, 0x60, 0x30, 0xC0, 0x61, 0x80,
  0xC1, 0x01, 0x86, 0x03, 0x06, 0x06, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x60,
  0x60, 0xC0, 0xC1, 0x80, 0xC3, 0x01, 0x06, 0x03, 0x0C, 0x06, 0x10, 0x0C,
  0x60, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x90,
  0x03, 0x20, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x16, 0x00, 0x2C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0xE6, 0x00, 0x38, 0xE0, 0x06, 0x0C, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0x0C, 0x01, 0x83, 0x80, 0x38, 0x60, 0x03, 0x18, 0x00, 0x33,
  0x00, 0x06, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x6C,
  0x00, 0x0C, 0xC0, 0x03, 0x18, 0x00, 0xC1, 0x80, 0x18, 0x18, 0x06, 0x03,
  0x01, 0xC0, 0x30, 0x30, 0x07, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x60, 0x00,
  0xDC, 0x00, 0x0C, 0xE0, 0x00, 0x36, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00,
  0x06, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x18, 0x18,
  0x01, 0x80, 0xC0, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00,
  0x60, 0x60, 0x06, 0x06, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0,
  0x01, 0x8C, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x0D, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x07, 0xC0, 0x70, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x01, 0xC0, 0x7C, 0x03, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0x3E, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x01, 0xF0, 0x07, 0xC0,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x0F, 0xC0, 0x3C, 0x00,
  0x1F, 0x80, 0x0B, 0xFF, 0x00, 0x78, 0x1E, 0x0F, 0x00, 0x3F, 0xE0, 0x00,
  0x1C, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 36, 11, 4, -36 },
  { 15, 10, 13, 16, 3, -36 },
  { 32, 26, 36, 28, 1, -36 },
  { 149, 19, 41, 25, 3, -38 },
  { 247, 31, 37, 36, 3, -36 },
  { 391, 27, 37, 30, 2, -36 },
  { 516, 3, 13, 9, 3, -36 },
  { 521, 10, 44, 13, 2, -36 },
  { 576, 9, 44, 13, 2, -36 },
  { 626, 18, 18, 24, 3, -38 },
  { 667, 21, 23, 26, 2, -29 },
  { 728, 5, 12, 10, 2, -6 },
  { 736, 11, 1, 15, 2, -14 },
  { 738, 3, 4, 11, 4, -4 },
  { 740, 15, 36, 17, 1, -36 },
  { 808, 20, 36, 25, 3, -36 },
  { 898, 11, 36, 25, 4, -36 },
  { 948, 20, 36, 25, 2, -36 },
  { 1038, 20, 37, 25, 2, -36 },
  { 1131, 24, 36, 25, 1, -36 },
  { 1239, 20, 37, 25, 3, -36 },
  { 1332, 20, 37, 25, 3, -36 },
  { 1425, 21, 36, 25, 2, -36 },
  { 1520, 20, 37, 25, 3, -36 },
  { 1613, 20, 37, 25, 2, -36 },
  { 1706, 3, 27, 11, 4, -27 },
  { 1717, 5, 33, 11, 2, -27 },
  { 1738, 21, 22, 26, 2, -29 },
  { 1796, 21, 12, 26, 2, -24 },
  { 1828, 21, 22, 26, 2, -29 },
  { 1886, 16, 36, 18, 1, -36 },
  { 1958, 34, 41, 39, 3, -36 },
  { 2133, 26, 36, 26, 0, -36 },
  { 2250, 20, 36, 28, 5, -36 },
  { 2340, 23, 37, 27, 3, -36 },
  { 2447, 23, 36, 31, 5, -36 },
  { 2551, 17, 36, 25, 5, -36 },
  { 2628, 17, 36, 22, 5, -36 },
  { 2705, 26, 37, 33, 3, -36 },
  { 2826, 22, 36, 32, 5, -36 },
  { 2925, 9, 36, 14, 2, -36 },
  { 2966, 11, 45, 11, -4, -36 },
  { 3028, 20, 36, 25, 5, -36 },
  { 3118, 17, 36, 23, 5, -36 },
  { 3195, 30, 36, 39, 5, -36 },
  { 3330, 22, 36, 32, 5, -36 },
  { 3429, 28, 37, 34, 3, -36 },
  { 3559, 18, 36, 26, 5, -36 },
  { 3640, 28, 45, 34, 3, -36 },
  { 3798, 20, 36, 26, 5, -36 },
  { 3888, 20, 37, 24, 2, -36 },
  { 3981, 22, 36, 23, 0, -36 },
  { 4080, 23, 37, 32, 4, -36 },
  { 4187, 25, 36, 25, 0, -36 },
  { 4300, 38, 36, 40, 1, -36 },
  { 4471, 23, 36, 23, 0, -36 },
  { 4575, 22, 36, 22, 0, -36 },
  { 4674, 21, 36, 24, 2, -36 },
  { 4769, 10, 44, 16, 4, -36 },
  { 4824, 15, 36, 17, 1, -36 },
  { 4892, 10, 44, 16, 1, -36 },
  { 4947, 22, 21, 26, 2, -36 },
  { 5005, 20, 2, 20, 0, 4 },
  { 5010, 8, 8, 12, 2, -38 },
  { 5018, 18, 28, 23, 2, -27 },
  { 5081, 20, 39, 27, 4, -38 },
  { 5179, 17, 28, 21, 3, -27 },
  { 5239, 20, 39, 27, 3, -38 },
  { 5337, 19, 28, 24, 3, -27 },
  { 5404, 15, 38, 13, 1, -38 },
  { 5476, 19, 39, 27, 3, -27 },
  { 5569, 18, 38, 26, 4, -38 },
  { 5655, 3, 36, 10, 4, -36 },
  { 5669, 9, 48, 10, -2, -36 },
  { 5723, 17, 38, 21, 4, -38 },
  { 5804, 2, 38, 10, 4, -38 },
  { 5814, 31, 27, 39, 4, -27 },
  { 5919, 18, 27, 26, 4, -27 },
  { 5980, 20, 28, 26, 3, -27 },
  { 6050, 20, 39, 27, 4, -27 },
  { 6148, 19, 39, 27, 3, -27 },
  { 6241, 12, 27, 17, 4, -27 },
  { 6282, 16, 28, 20, 2, -27 },
  { 6338, 12, 34, 14, 1, -33 },
  { 6389, 18, 27, 26, 4, -26 },
  { 6450, 20, 26, 20, 0, -26 },
  { 6515, 30, 26, 32, 1, -26 },
  { 6613, 19, 26, 21, 1, -26 },
  { 6675, 20, 38, 20, 0, -26 },
  { 6770, 16, 26, 19, 2, -26 },
  { 6822, 13, 44, 17, 2, -36 },
  { 6894, 2, 50, 24, 11, -38 },
  { 6907, 14, 44, 17, 2, -36 },
  { 6984, 21, 5, 26, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight50pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT50PT7B_H_
