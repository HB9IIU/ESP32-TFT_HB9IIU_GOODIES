#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT29PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight29pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x03, 0xC0, 0x8E, 0x38, 0xA2, 0x8A, 0x28,
  0xA2, 0x06, 0x10, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x41, 0x00, 0x84,
  0x03, 0x08, 0x3F, 0xFF, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x42, 0x00,
  0x84, 0x1F, 0xFF, 0x84, 0x10, 0x08, 0x20, 0x10, 0x40, 0x21, 0x00, 0x42,
  0x01, 0x04, 0x02, 0x08, 0x00, 0x08, 0x01, 0x00, 0xFE, 0x24, 0x28, 0x81,
  0x10, 0x22, 0x04, 0x40, 0x88, 0x09, 0x00, 0xE0, 0x06, 0x00, 0xB0, 0x11,
  0x82, 0x10, 0x41, 0x08, 0x21, 0x0C, 0x21, 0x44, 0x6F, 0xF0, 0x10, 0x02,
  0x00, 0x40, 0x78, 0x04, 0x22, 0x04, 0x21, 0x02, 0x10, 0xC2, 0x08, 0x21,
  0x04, 0x11, 0x02, 0x08, 0x81, 0x04, 0xC0, 0x82, 0x46, 0x43, 0x2C, 0xA1,
  0x24, 0x29, 0x92, 0x17, 0x92, 0x08, 0x09, 0x04, 0x08, 0x82, 0x04, 0x41,
  0x04, 0x20, 0x82, 0x10, 0x42, 0x04, 0x21, 0x02, 0x31, 0x00, 0xF0, 0x0F,
  0x80, 0x18, 0xC0, 0x10, 0x40, 0x30, 0x40, 0x20, 0x40, 0x10, 0x40, 0x10,
  0x40, 0x18, 0x80, 0x09, 0x00, 0x06, 0x00, 0x1A, 0x00, 0x33, 0x00, 0x61,
  0x82, 0x40, 0xC2, 0x40, 0x44, 0xC0, 0x24, 0xC0, 0x18, 0x40, 0x18, 0x40,
  0x3C, 0x20, 0x66, 0x1F, 0x83, 0xFF, 0x0C, 0x21, 0x0C, 0x20, 0x84, 0x10,
  0x41, 0x0C, 0x20, 0x82, 0x08, 0x30, 0x41, 0x04, 0x10, 0x20, 0x83, 0x04,
  0x08, 0x30, 0x82, 0x08, 0x41, 0x08, 0x41, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x21, 0x08, 0x8C, 0x44, 0x00, 0x08, 0x02, 0x00, 0x82, 0x21,
  0xE9, 0xC7, 0x80, 0xC0, 0x48, 0x23, 0x18, 0x60, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0xFF, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x2D, 0x25, 0x20, 0xFE, 0xF0, 0x00, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80,
  0x80, 0x40, 0x20, 0x20, 0x10, 0x18, 0x08, 0x0C, 0x00, 0x1F, 0x06, 0x31,
  0x03, 0x20, 0x28, 0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x48, 0x09, 0x01, 0x10,
  0x41, 0xF0, 0x0C, 0x73, 0x51, 0x84, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x1F, 0x06, 0x0C, 0x40, 0x40, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08,
  0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0xFF, 0xF0, 0x1F, 0x86, 0x0C, 0xC0, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x18, 0x1F, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x28, 0x04, 0x7F, 0x80, 0x00, 0x40,
  0x06, 0x00, 0x70, 0x02, 0x80, 0x24, 0x01, 0x20, 0x11, 0x01, 0x08, 0x08,
  0x40, 0x82, 0x0C, 0x10, 0x40, 0x84, 0x04, 0x60, 0x22, 0x01, 0x1F, 0xFF,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x7F, 0xC8, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x1F, 0xF0, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x40,
  0x4F, 0xF0, 0x07, 0xC3, 0x00, 0xC0, 0x30, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x00, 0x87, 0x16, 0x33, 0x01, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x28, 0x05, 0x01, 0x10, 0x61, 0xF8, 0xFF, 0xF0, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x18, 0x00, 0x1F, 0x0C, 0x11, 0x01, 0x40, 0x28, 0x07, 0x00, 0xF0,
  0x12, 0x06, 0x31, 0x83, 0xC0, 0x78, 0x10, 0xC4, 0x05, 0x00, 0xE0, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0xA0, 0x63, 0xF8, 0x0F, 0x03, 0x0C, 0x60,
  0x64, 0x02, 0x40, 0x2C, 0x01, 0xC0, 0x1C, 0x01, 0x40, 0x14, 0x03, 0x60,
  0x33, 0x0D, 0x1F, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00,
  0xC0, 0x18, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x2D, 0x80, 0x00, 0x00,
  0x00, 0xDA, 0x4A, 0x40, 0x00, 0x10, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x10,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x00, 0x80, 0x00, 0x7C, 0x41, 0x80, 0x40, 0x30,
  0x08, 0x04, 0x04, 0x02, 0x03, 0x03, 0x03, 0x03, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x00, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x70, 0x00, 0xE1, 0xC0,
  0x20, 0x0C, 0x08, 0x00, 0x42, 0x00, 0x0C, 0x80, 0x00, 0x90, 0x3E, 0x1C,
  0x08, 0x41, 0x82, 0x08, 0x30, 0x81, 0x06, 0x10, 0x20, 0xC2, 0x04, 0x18,
  0x40, 0x83, 0x08, 0x10, 0x61, 0x02, 0x0C, 0x20, 0xC2, 0x82, 0x24, 0xD0,
  0x38, 0x71, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x87, 0x00, 0x0F, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0A, 0x00, 0x14, 0x00,
  0x24, 0x00, 0x88, 0x01, 0x10, 0x02, 0x30, 0x08, 0x20, 0x10, 0x40, 0x20,
  0xC0, 0x80, 0x81, 0xFF, 0x02, 0x03, 0x08, 0x02, 0x10, 0x04, 0x20, 0x0C,
  0x80, 0x09, 0x00, 0x16, 0x00, 0x38, 0x00, 0x20, 0xFE, 0x08, 0x3C, 0x80,
  0x48, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x06, 0x80, 0x48, 0x38, 0xFF,
  0x88, 0x04, 0x80, 0x28, 0x02, 0x80, 0x38, 0x03, 0x80, 0x38, 0x02, 0x80,
  0x68, 0x0C, 0xFF, 0x00, 0x07, 0xF0, 0x60, 0xCC, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x10, 0xFF, 0x80, 0xFC, 0x04, 0x1C, 0x20, 0x19, 0x00, 0x68, 0x01, 0x40,
  0x0A, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x02, 0x80, 0x14, 0x01, 0xA0, 0x19, 0x03, 0x8F,
  0xE0, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x0F, 0xFA, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFE, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x03, 0xF8, 0x18, 0x1C,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x07, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xE0, 0x01, 0x40, 0x02, 0xC0, 0x04, 0xC0, 0x08, 0xC0, 0x30, 0x7F, 0xC0,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFF, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0xF9,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x6F,
  0x80, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x43, 0x0B, 0xC0, 0x80, 0x28, 0x04,
  0x80, 0xC8, 0x18, 0x83, 0x08, 0x20, 0x84, 0x08, 0x80, 0x98, 0x0B, 0x00,
  0xA8, 0x0C, 0xC0, 0x84, 0x08, 0x60, 0x83, 0x08, 0x10, 0x81, 0x88, 0x08,
  0x80, 0x48, 0x06, 0x80, 0x30, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x0F, 0xF8, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x5A, 0x00, 0x2D, 0x00, 0x36, 0xC0, 0x13, 0x20, 0x09, 0x90, 0x08,
  0xC4, 0x04, 0x62, 0x02, 0x31, 0x02, 0x18, 0x41, 0x0C, 0x21, 0x86, 0x18,
  0x83, 0x04, 0x41, 0x82, 0x60, 0xC1, 0xA0, 0x60, 0x50, 0x30, 0x30, 0x18,
  0x08, 0x08, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1A, 0x00, 0xC8, 0x06,
  0x60, 0x31, 0x01, 0x8C, 0x0C, 0x20, 0x60, 0x83, 0x04, 0x18, 0x10, 0xC0,
  0xC6, 0x02, 0x30, 0x19, 0x80, 0x4C, 0x01, 0x60, 0x0F, 0x00, 0x38, 0x01,
  0x80, 0x07, 0xE0, 0x18, 0x30, 0x30, 0x08, 0x60, 0x04, 0x40, 0x06, 0xC0,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0xC0, 0x02, 0x40, 0x02, 0x40,
  0x04, 0x20, 0x0C, 0x18, 0x18, 0x0F, 0xE0, 0xFC, 0x10, 0xF2, 0x03, 0x40,
  0x28, 0x05, 0x00, 0xE0, 0x1C, 0x02, 0x80, 0x50, 0x1A, 0x06, 0x7F, 0x88,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00,
  0x07, 0xE0, 0x18, 0x38, 0x30, 0x0C, 0x60, 0x04, 0x40, 0x06, 0xC0, 0x02,
  0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0xC0, 0x02, 0x40, 0x02, 0x40, 0x04,
  0x20, 0x0C, 0x18, 0x18, 0x0F, 0xE0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0xFC, 0x08, 0x78, 0x80, 0xC8, 0x04, 0x80, 0x48,
  0x06, 0x80, 0x68, 0x04, 0x80, 0x48, 0x0C, 0x81, 0x8F, 0xE0, 0x82, 0x08,
  0x20, 0x81, 0x08, 0x18, 0x80, 0x88, 0x0C, 0x80, 0x48, 0x06, 0x80, 0x30,
  0x0F, 0xC3, 0x02, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x28, 0x04, 0x7F, 0x80, 0xFF, 0xF8, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x14, 0x00, 0x50, 0x01, 0x40,
  0x0D, 0x00, 0x22, 0x01, 0x8C, 0x0C, 0x0F, 0xE0, 0x80, 0x07, 0x80, 0x09,
  0x00, 0x12, 0x00, 0x66, 0x00, 0x84, 0x01, 0x08, 0x06, 0x10, 0x08, 0x10,
  0x10, 0x20, 0x60, 0x40, 0x80, 0x41, 0x00, 0x86, 0x01, 0x08, 0x01, 0x10,
  0x02, 0x60, 0x04, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x80, 0x20, 0x0E, 0x00, 0x80, 0x28, 0x05, 0x00, 0xB0, 0x14, 0x02, 0x40,
  0x50, 0x19, 0x01, 0x40, 0x44, 0x0C, 0x81, 0x18, 0x22, 0x04, 0x20, 0x88,
  0x30, 0x82, 0x20, 0x82, 0x18, 0x42, 0x0C, 0x41, 0x08, 0x11, 0x04, 0x60,
  0x44, 0x11, 0x01, 0x30, 0x24, 0x06, 0x80, 0x90, 0x0A, 0x02, 0xC0, 0x28,
  0x0A, 0x00, 0xA0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x01, 0x80, 0x40, 0x0B,
  0x00, 0x88, 0x0C, 0x60, 0x41, 0x06, 0x04, 0x20, 0x23, 0x00, 0x90, 0x05,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x58, 0x04, 0x40, 0x21, 0x02, 0x08,
  0x10, 0x21, 0x01, 0x18, 0x04, 0x80, 0x2C, 0x00, 0x80, 0x80, 0x0A, 0x00,
  0x90, 0x04, 0x40, 0x62, 0x02, 0x18, 0x30, 0x41, 0x03, 0x18, 0x08, 0x80,
  0x44, 0x01, 0x40, 0x0A, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x7F, 0xF0, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0xFF, 0xF0, 0xFF, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xF0,
  0xC0, 0x20, 0x10, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x18, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x30, 0x08, 0x04, 0x03, 0x00, 0x80, 0x40, 0x10, 0x08,
  0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x07, 0xF0, 0x02, 0x00, 0x38, 0x01,
  0x40, 0x1B, 0x00, 0x88, 0x0C, 0x60, 0x41, 0x04, 0x0C, 0x20, 0x22, 0x01,
  0x90, 0x05, 0x00, 0x20, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0x06, 0x0E, 0x60,
  0x0C, 0x01, 0x00, 0x40, 0x10, 0x04, 0x1F, 0x38, 0x58, 0x14, 0x06, 0x01,
  0x80, 0x70, 0x34, 0x1C, 0xF9, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x87, 0x09, 0x9C, 0xA0, 0x6C, 0x02, 0xC0, 0x2C, 0x03, 0xC0,
  0x1C, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x2A, 0x02, 0xA0,
  0x49, 0xF8, 0x07, 0x1C, 0xD8, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x02, 0x01, 0x80, 0x3F, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x43, 0x09, 0xDD, 0x40, 0xB8, 0x0E, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xE0, 0x36,
  0x0A, 0x7E, 0x40, 0x04, 0x07, 0x71, 0x02, 0x20, 0x28, 0x05, 0x00, 0xA0,
  0x1F, 0xFF, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x18, 0x10,
  0xFE, 0x0F, 0x84, 0x04, 0x02, 0x01, 0x00, 0x80, 0x41, 0xFC, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x0C, 0x06, 0x35, 0x03, 0xE0, 0x38, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x80, 0xD8, 0x29, 0xF9,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x05, 0x83, 0x0F, 0xC0, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0xC4, 0xCC, 0xA0, 0x58, 0x0F,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x18,
  0xC0, 0x00, 0x00, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0x85, 0xC0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x06, 0x02, 0x81, 0x20, 0x88, 0x62, 0x10, 0x88, 0x26, 0x0A, 0xC3,
  0x10, 0xC2, 0x20, 0x88, 0x12, 0x06, 0x80, 0xA0, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x06, 0x06, 0x26, 0xE6, 0x6A, 0x0A, 0x0F, 0x01, 0x81,
  0xC0, 0x40, 0x70, 0x10, 0x18, 0x04, 0x06, 0x01, 0x01, 0x80, 0x40, 0x60,
  0x10, 0x18, 0x04, 0x06, 0x01, 0x01, 0x80, 0x40, 0x60, 0x10, 0x18, 0x04,
  0x06, 0x01, 0x01, 0x03, 0x13, 0x3A, 0x81, 0x60, 0x3C, 0x03, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x06, 0x07, 0x31, 0x01, 0x60, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x80, 0x98, 0x31, 0xFC, 0x06,
  0x09, 0x9C, 0xA0, 0x6A, 0x02, 0xC0, 0x2C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x2A, 0x02, 0xF0, 0x4D, 0xF8, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x07,
  0x75, 0x02, 0xE0, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x07, 0x80, 0xD8, 0x29, 0xF9, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x07, 0x9A, 0xA0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x0C, 0x0C,
  0xE4, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x40, 0x28, 0x1B, 0xFC, 0x10, 0x10, 0x30, 0x30, 0xFF, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x10,
  0x1F, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x01, 0xC0, 0x34, 0x06, 0xC1, 0x4F, 0xC8, 0xC0, 0x28,
  0x05, 0x01, 0x20, 0x22, 0x04, 0x41, 0x08, 0x20, 0x84, 0x11, 0x02, 0x20,
  0x24, 0x05, 0x00, 0xA0, 0x0C, 0x01, 0x00, 0xC0, 0x40, 0x50, 0x28, 0x14,
  0x0A, 0x0D, 0x82, 0x82, 0x21, 0xA0, 0x88, 0x44, 0x22, 0x11, 0x18, 0xC4,
  0x44, 0x12, 0x19, 0x04, 0x82, 0x41, 0x20, 0xB0, 0x78, 0x28, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x40, 0xC0, 0x68, 0x10, 0x86, 0x18, 0x81, 0x30,
  0x14, 0x03, 0x00, 0x60, 0x0A, 0x02, 0x40, 0xC4, 0x10, 0xC4, 0x08, 0x80,
  0xA0, 0x18, 0xC0, 0x34, 0x02, 0x40, 0x62, 0x04, 0x20, 0x42, 0x0C, 0x10,
  0x81, 0x08, 0x11, 0x80, 0x90, 0x09, 0x00, 0xB0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x10, 0x0E, 0x00, 0x7F,
  0x80, 0xC0, 0x40, 0x40, 0x20, 0x20, 0x30, 0x10, 0x18, 0x08, 0x08, 0x04,
  0x04, 0x06, 0x03, 0xFE, 0x01, 0x0E, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0xE0, 0xE0, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x08, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x30,
  0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x07, 0x07,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18, 0x70, 0xC0,
  0x10, 0x06, 0xE1, 0x81, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 21, 6, 2, -21 },
  { 7, 6, 8, 10, 2, -21 },
  { 13, 15, 21, 16, 1, -21 },
  { 53, 11, 24, 15, 2, -22 },
  { 86, 17, 21, 21, 2, -21 },
  { 131, 16, 21, 17, 1, -21 },
  { 173, 1, 8, 5, 2, -21 },
  { 174, 6, 26, 8, 1, -21 },
  { 194, 5, 26, 8, 1, -21 },
  { 211, 10, 10, 14, 2, -22 },
  { 224, 12, 13, 15, 1, -17 },
  { 244, 3, 7, 6, 1, -3 },
  { 247, 7, 1, 9, 1, -8 },
  { 248, 2, 2, 6, 2, -2 },
  { 249, 9, 21, 10, 0, -21 },
  { 273, 11, 21, 15, 2, -21 },
  { 302, 6, 21, 15, 3, -21 },
  { 318, 12, 21, 15, 1, -21 },
  { 350, 12, 21, 15, 1, -21 },
  { 382, 13, 21, 15, 1, -21 },
  { 417, 11, 21, 15, 2, -21 },
  { 446, 11, 21, 15, 2, -21 },
  { 475, 12, 21, 15, 1, -21 },
  { 507, 11, 21, 15, 2, -21 },
  { 536, 12, 21, 15, 1, -21 },
  { 568, 2, 16, 6, 2, -16 },
  { 572, 3, 20, 6, 1, -16 },
  { 580, 12, 13, 15, 1, -17 },
  { 600, 12, 7, 15, 1, -14 },
  { 611, 12, 13, 15, 1, -17 },
  { 631, 9, 21, 11, 1, -21 },
  { 655, 19, 24, 23, 2, -21 },
  { 712, 15, 21, 15, 0, -21 },
  { 752, 12, 21, 16, 3, -21 },
  { 784, 13, 21, 16, 2, -21 },
  { 819, 13, 21, 18, 3, -21 },
  { 854, 10, 21, 14, 3, -21 },
  { 881, 10, 21, 13, 3, -21 },
  { 908, 15, 21, 19, 2, -21 },
  { 948, 13, 21, 18, 3, -21 },
  { 983, 5, 21, 8, 1, -21 },
  { 997, 6, 26, 6, -2, -21 },
  { 1017, 12, 21, 15, 3, -21 },
  { 1049, 9, 21, 13, 3, -21 },
  { 1073, 17, 21, 23, 3, -21 },
  { 1118, 13, 21, 19, 3, -21 },
  { 1153, 16, 21, 19, 2, -21 },
  { 1195, 11, 21, 15, 3, -21 },
  { 1224, 16, 26, 19, 2, -21 },
  { 1276, 12, 21, 15, 3, -21 },
  { 1308, 12, 21, 14, 1, -21 },
  { 1340, 13, 21, 13, 0, -21 },
  { 1375, 14, 21, 18, 2, -21 },
  { 1412, 15, 21, 15, 0, -21 },
  { 1452, 22, 21, 23, 1, -21 },
  { 1510, 13, 21, 13, 0, -21 },
  { 1545, 13, 21, 13, 0, -21 },
  { 1580, 12, 21, 14, 1, -21 },
  { 1612, 6, 26, 9, 2, -21 },
  { 1632, 9, 21, 10, 0, -21 },
  { 1656, 6, 26, 9, 1, -21 },
  { 1676, 13, 12, 15, 1, -21 },
  { 1696, 12, 1, 12, 0, 3 },
  { 1698, 5, 4, 7, 1, -22 },
  { 1701, 10, 16, 14, 1, -16 },
  { 1721, 12, 22, 15, 2, -22 },
  { 1754, 9, 16, 12, 2, -16 },
  { 1772, 11, 22, 15, 2, -22 },
  { 1803, 11, 16, 14, 2, -16 },
  { 1825, 9, 22, 8, 0, -22 },
  { 1850, 11, 23, 15, 2, -16 },
  { 1882, 11, 22, 15, 2, -22 },
  { 1913, 2, 21, 6, 2, -21 },
  { 1919, 5, 28, 6, -1, -21 },
  { 1937, 10, 22, 12, 2, -22 },
  { 1965, 2, 22, 6, 2, -22 },
  { 1971, 18, 16, 23, 2, -16 },
  { 2007, 11, 16, 15, 2, -16 },
  { 2029, 11, 16, 15, 2, -16 },
  { 2051, 12, 23, 15, 2, -16 },
  { 2086, 11, 23, 15, 2, -16 },
  { 2118, 8, 16, 10, 2, -16 },
  { 2134, 10, 16, 12, 1, -16 },
  { 2154, 8, 19, 8, 0, -19 },
  { 2173, 11, 15, 15, 2, -15 },
  { 2194, 11, 15, 11, 0, -15 },
  { 2215, 18, 15, 19, 0, -15 },
  { 2249, 11, 15, 12, 1, -15 },
  { 2270, 12, 22, 12, 0, -15 },
  { 2303, 9, 15, 11, 1, -15 },
  { 2320, 8, 26, 10, 1, -21 },
  { 2346, 1, 29, 14, 6, -22 },
  { 2350, 8, 26, 10, 1, -21 },
  { 2376, 12, 3, 15, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight29pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT29PT7B_H_
