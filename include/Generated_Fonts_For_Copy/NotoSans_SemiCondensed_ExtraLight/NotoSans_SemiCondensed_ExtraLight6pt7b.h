#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT6PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x7B, 0xD0, 0x59, 0x3C, 0xED, 0x77, 0xEA, 0xF0, 0x80,
  0xF8, 0xF8, 0x5E, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x5A, 0xF6, 0xF0,
  0xF0, 0xE5, 0x70, 0xEC, 0xF0, 0x4B, 0x90, 0xD8, 0xF0, 0xDA, 0xF0, 0xE9,
  0x20, 0xEA, 0xF0, 0xF5, 0xB0, 0xA0, 0xB0, 0xEC, 0xFC, 0xF8, 0xD8, 0xFF,
  0xF8, 0x60, 0x57, 0xD0, 0xFF, 0xF2, 0x70, 0xFF, 0xFB, 0xFA, 0xF2, 0xB0,
  0xFF, 0xF0, 0xF8, 0xEB, 0xAB, 0xB7, 0xF0, 0xFF, 0xF9, 0x9F, 0xFA, 0xF9,
  0x9D, 0x20, 0xFB, 0xF8, 0xF0, 0xE9, 0x20, 0xFF, 0xB5, 0x20, 0xAF, 0x74,
  0xA0, 0xAB, 0x50, 0xB9, 0x20, 0xE9, 0x70, 0xF8, 0xA5, 0xF8, 0x54, 0xC0,
  0x80, 0x7C, 0x9A, 0xDE, 0xEC, 0x2E, 0xDE, 0xFB, 0x00, 0x6A, 0x80, 0xF6,
  0xF0, 0x9A, 0xDA, 0xF0, 0xF8, 0x93, 0x6A, 0xF8, 0xFB, 0xB0, 0xF6, 0x80,
  0xF7, 0x80, 0xF7, 0xC0, 0xF7, 0x90, 0xE8, 0xDC, 0xEB, 0xB7, 0x80, 0xF4,
  0xD6, 0xA0, 0xDC, 0xF7, 0xDC, 0xEA, 0x40, 0xFC, 0xD5, 0xC0, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 2, 1, 2, 0, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 3, 4, 4, 0, -4 },
  { 11, 1, 1, 1, 0, -4 },
  { 12, 1, 5, 2, 0, -4 },
  { 13, 1, 5, 2, 0, -4 },
  { 14, 3, 3, 3, 0, -5 },
  { 16, 3, 3, 3, 0, -4 },
  { 18, 1, 2, 1, 0, -1 },
  { 19, 2, 1, 2, 0, -2 },
  { 20, 1, 1, 1, 0, -1 },
  { 21, 2, 4, 2, 0, -4 },
  { 22, 3, 4, 3, 0, -4 },
  { 24, 1, 4, 3, 1, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 3, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 1, 3, 1, 0, -3 },
  { 42, 1, 4, 1, 0, -3 },
  { 43, 3, 2, 3, 0, -3 },
  { 44, 3, 2, 3, 0, -3 },
  { 45, 3, 2, 3, 0, -3 },
  { 46, 2, 4, 2, 0, -4 },
  { 47, 4, 5, 5, 0, -4 },
  { 50, 3, 4, 3, 0, -4 },
  { 52, 2, 4, 3, 1, -4 },
  { 53, 3, 4, 3, 0, -4 },
  { 55, 2, 4, 4, 1, -4 },
  { 56, 2, 4, 3, 1, -4 },
  { 57, 2, 4, 3, 1, -4 },
  { 58, 3, 4, 4, 0, -4 },
  { 60, 2, 4, 4, 1, -4 },
  { 61, 1, 4, 2, 0, -4 },
  { 62, 1, 5, 1, 0, -4 },
  { 63, 2, 4, 3, 1, -4 },
  { 64, 2, 4, 3, 1, -4 },
  { 65, 3, 4, 5, 1, -4 },
  { 67, 2, 4, 4, 1, -4 },
  { 68, 4, 4, 4, 0, -4 },
  { 70, 2, 4, 3, 1, -4 },
  { 71, 4, 5, 4, 0, -4 },
  { 74, 2, 4, 3, 1, -4 },
  { 75, 3, 4, 3, 0, -4 },
  { 77, 3, 4, 3, 0, -4 },
  { 79, 2, 4, 4, 1, -4 },
  { 80, 3, 4, 3, 0, -4 },
  { 82, 5, 4, 5, 0, -4 },
  { 85, 3, 4, 3, 0, -4 },
  { 87, 3, 4, 3, 0, -4 },
  { 89, 3, 4, 3, 0, -4 },
  { 91, 1, 5, 2, 1, -4 },
  { 92, 2, 4, 2, 0, -4 },
  { 93, 1, 5, 2, 0, -4 },
  { 94, 3, 2, 3, 0, -4 },
  { 95, 2, 1, 2, 0, 0 },
  { 96, 1, 1, 1, 0, -5 },
  { 97, 2, 3, 3, 0, -3 },
  { 98, 3, 5, 3, 0, -5 },
  { 100, 2, 3, 3, 0, -3 },
  { 101, 3, 5, 3, 0, -5 },
  { 103, 3, 3, 3, 0, -3 },
  { 105, 2, 5, 2, 0, -5 },
  { 107, 3, 4, 3, 0, -3 },
  { 109, 3, 5, 3, 0, -5 },
  { 111, 1, 4, 1, 0, -4 },
  { 112, 1, 5, 1, 0, -4 },
  { 113, 3, 5, 3, 0, -5 },
  { 115, 1, 5, 1, 0, -5 },
  { 116, 4, 3, 5, 0, -3 },
  { 118, 3, 3, 3, 0, -3 },
  { 120, 3, 3, 3, 0, -3 },
  { 122, 3, 4, 3, 0, -3 },
  { 124, 3, 4, 3, 0, -3 },
  { 126, 2, 3, 2, 0, -3 },
  { 127, 2, 3, 2, 0, -3 },
  { 128, 2, 4, 2, 0, -4 },
  { 129, 3, 3, 3, 0, -3 },
  { 131, 2, 3, 2, 0, -3 },
  { 132, 4, 3, 4, 0, -3 },
  { 134, 2, 3, 3, 0, -3 },
  { 135, 2, 4, 2, 0, -3 },
  { 136, 2, 3, 2, 0, -3 },
  { 137, 2, 5, 2, 0, -4 },
  { 139, 1, 6, 3, 1, -5 },
  { 140, 2, 5, 2, 0, -4 },
  { 142, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight6pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT6PT7B_H_
