#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT31PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight31pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x00, 0xF0, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x04, 0x08, 0x04, 0x10, 0x04,
  0x10, 0x04, 0x10, 0x7F, 0xFF, 0x04, 0x10, 0x08, 0x10, 0x08, 0x20, 0x08,
  0x20, 0x08, 0x20, 0x08, 0x20, 0xFF, 0xFE, 0x10, 0x20, 0x10, 0x40, 0x10,
  0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x30, 0xC0, 0x04, 0x00, 0x40,
  0x0E, 0x03, 0xDE, 0x44, 0x28, 0x40, 0x84, 0x08, 0x40, 0x84, 0x08, 0x40,
  0x44, 0x03, 0x40, 0x1C, 0x00, 0x78, 0x04, 0xC0, 0x46, 0x04, 0x20, 0x43,
  0x04, 0x30, 0x42, 0x04, 0x28, 0x44, 0xFF, 0x80, 0x40, 0x04, 0x00, 0x40,
  0x7C, 0x02, 0x08, 0x80, 0x82, 0x08, 0x10, 0x41, 0x04, 0x08, 0x20, 0x81,
  0x04, 0x20, 0x20, 0x84, 0x04, 0x11, 0x00, 0x82, 0x22, 0x10, 0x48, 0xF2,
  0x09, 0x21, 0x22, 0x6C, 0x27, 0xC9, 0x06, 0x03, 0x20, 0x40, 0x44, 0x08,
  0x18, 0x81, 0x02, 0x10, 0x20, 0x42, 0x04, 0x10, 0x41, 0x82, 0x04, 0x20,
  0x80, 0x84, 0x30, 0x0F, 0x00, 0x1F, 0x80, 0x30, 0xC0, 0x20, 0x40, 0x20,
  0x40, 0x20, 0x40, 0x20, 0x40, 0x20, 0xC0, 0x10, 0x80, 0x19, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x32, 0x00, 0x41, 0x02, 0xC1, 0x82, 0x80, 0xC6, 0x80,
  0x64, 0x80, 0x2C, 0x80, 0x18, 0x80, 0x18, 0xC0, 0x3C, 0x60, 0x66, 0x3F,
  0x83, 0xFF, 0x0C, 0x21, 0x04, 0x20, 0x86, 0x10, 0x41, 0x04, 0x30, 0xC3,
  0x0C, 0x30, 0x41, 0x04, 0x10, 0x60, 0x82, 0x04, 0x10, 0x20, 0x40, 0xC1,
  0x82, 0x0C, 0x10, 0x60, 0x82, 0x08, 0x30, 0xC1, 0x04, 0x10, 0x41, 0x0C,
  0x20, 0x82, 0x08, 0x41, 0x0C, 0x21, 0x0C, 0x00, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x08, 0x43, 0xEB, 0x83, 0x80, 0x50, 0x12, 0x06, 0x21, 0x82, 0x10,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x1F, 0xFF, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x25, 0xA4, 0xA0, 0xFE, 0xF0, 0x01, 0x80, 0x80, 0x40, 0x60, 0x20, 0x10,
  0x10, 0x08, 0x04, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20,
  0x20, 0x10, 0x18, 0x08, 0x04, 0x00, 0x1F, 0x82, 0x0C, 0x60, 0x64, 0x02,
  0xC0, 0x28, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x3C, 0x02, 0x40, 0x26, 0x04,
  0x30, 0xC1, 0xF8, 0x0C, 0x73, 0x51, 0x84, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x3F, 0x8C, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x0F, 0xFF, 0x3F, 0xC7, 0x03, 0x10, 0x0C, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x06, 0x07, 0xC0, 0x01,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x6C, 0x06, 0x3F, 0xE0, 0x00, 0x60, 0x03, 0x80, 0x0A, 0x00, 0x48,
  0x01, 0x20, 0x08, 0x80, 0x62, 0x01, 0x08, 0x08, 0x20, 0x60, 0x81, 0x02,
  0x08, 0x08, 0x60, 0x21, 0x00, 0x88, 0x02, 0x3F, 0xFF, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x7F, 0xE4, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0F, 0xF8, 0x00,
  0xC0, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x20, 0x06, 0x80, 0xC7, 0xF8, 0x0F, 0xE1, 0x80, 0x30, 0x02, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x08, 0x00, 0x87, 0x09, 0xDC, 0xA0, 0x6C, 0x03, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0x40, 0x36, 0x02, 0x30,
  0x41, 0xF8, 0xFF, 0xF0, 0x01, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x3F,
  0x86, 0x04, 0x40, 0x2C, 0x02, 0x80, 0x28, 0x02, 0x40, 0x26, 0x06, 0x30,
  0xC1, 0xF0, 0x0F, 0x03, 0x18, 0x60, 0x4C, 0x02, 0x80, 0x38, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x1C, 0x02, 0x60, 0x63, 0xF8, 0x3F, 0x86, 0x0C, 0xC0,
  0x48, 0x02, 0x80, 0x28, 0x03, 0x80, 0x38, 0x01, 0x80, 0x38, 0x03, 0xC0,
  0x34, 0x05, 0x3F, 0x90, 0x43, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x08, 0x01, 0x87, 0xE0, 0x74, 0x00, 0x00, 0x03, 0xC0, 0x2C, 0x80,
  0x00, 0x00, 0x00, 0x0B, 0x69, 0x28, 0x00, 0x08, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x04, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x40, 0x00, 0xFE, 0x40, 0x80, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x01, 0x80, 0x01, 0xFC, 0x00, 0x38, 0x18, 0x02,
  0x00, 0x30, 0x20, 0x00, 0x82, 0x00, 0x02, 0x30, 0x00, 0x19, 0x01, 0xF0,
  0x58, 0x30, 0x82, 0x81, 0x04, 0x14, 0x10, 0x20, 0xE0, 0x81, 0x03, 0x0C,
  0x08, 0x18, 0x40, 0x40, 0xC2, 0x02, 0x0E, 0x18, 0x10, 0x50, 0x41, 0x82,
  0x82, 0x0E, 0x34, 0x0D, 0x9B, 0x30, 0x10, 0x20, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0xC0, 0x03, 0xF8, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x02, 0x40, 0x02, 0x40, 0x02, 0x60,
  0x04, 0x20, 0x04, 0x20, 0x04, 0x30, 0x08, 0x10, 0x08, 0x10, 0x08, 0x18,
  0x10, 0x08, 0x1F, 0xF8, 0x10, 0x0C, 0x20, 0x04, 0x20, 0x04, 0x20, 0x06,
  0x40, 0x02, 0x40, 0x02, 0xC0, 0x03, 0x80, 0x01, 0xFF, 0x84, 0x03, 0x20,
  0x0D, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x06, 0x80, 0x24, 0x06,
  0x3F, 0xE1, 0x00, 0xC8, 0x03, 0x40, 0x0A, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xA0, 0x05, 0x00, 0x68, 0x0E, 0x7F, 0xC0, 0x07, 0xFC, 0x70, 0x13,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x1C, 0x04, 0x1F, 0xE0, 0xFF,
  0x82, 0x03, 0x88, 0x03, 0x20, 0x06, 0x80, 0x0A, 0x00, 0x38, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x0C, 0x81, 0xC3,
  0xFC, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x0F, 0xFE, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFF, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x07, 0xFE,
  0x0C, 0x03, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x7F, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x60, 0x01, 0x20, 0x01,
  0x30, 0x01, 0x0C, 0x03, 0x07, 0xFE, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0xF9, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x7C, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x3F, 0x90, 0x80, 0x34, 0x01, 0x20,
  0x11, 0x01, 0x08, 0x18, 0x41, 0x82, 0x18, 0x10, 0x80, 0x88, 0x04, 0xC0,
  0x2A, 0x01, 0xD8, 0x0C, 0x60, 0x41, 0x02, 0x0C, 0x10, 0x30, 0x80, 0x84,
  0x06, 0x20, 0x11, 0x00, 0x48, 0x03, 0x40, 0x0C, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0E, 0x80, 0x05, 0xA0, 0x01, 0x64,
  0x00, 0x59, 0x00, 0x26, 0x40, 0x09, 0x88, 0x06, 0x62, 0x01, 0x18, 0xC0,
  0x46, 0x10, 0x31, 0x84, 0x08, 0x61, 0x82, 0x18, 0x21, 0x06, 0x08, 0x41,
  0x81, 0x10, 0x60, 0x48, 0x18, 0x1A, 0x06, 0x03, 0x81, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x68, 0x01, 0xB0, 0x06, 0x40,
  0x18, 0x80, 0x63, 0x01, 0x84, 0x06, 0x18, 0x18, 0x20, 0x60, 0x41, 0x81,
  0x86, 0x02, 0x18, 0x0C, 0x60, 0x11, 0x80, 0x66, 0x00, 0x98, 0x01, 0x60,
  0x07, 0x80, 0x0E, 0x00, 0x30, 0x0F, 0xF8, 0x0C, 0x06, 0x0C, 0x01, 0x8C,
  0x00, 0x44, 0x00, 0x12, 0x00, 0x0B, 0x00, 0x05, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x80, 0x02, 0x40, 0x01, 0x20, 0x01, 0x88, 0x00, 0x86, 0x00, 0xC1,
  0x80, 0xC0, 0x3F, 0x80, 0xFF, 0x08, 0x0C, 0x80, 0x68, 0x02, 0x80, 0x28,
  0x02, 0x80, 0x38, 0x02, 0x80, 0x28, 0x06, 0x80, 0xC8, 0x38, 0xFC, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x0F, 0xF8, 0x0C, 0x06, 0x0C, 0x01, 0x8C, 0x00, 0x44, 0x00, 0x12,
  0x00, 0x0B, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x80, 0x02, 0x40,
  0x01, 0x20, 0x01, 0x88, 0x00, 0x86, 0x00, 0xC1, 0x80, 0xC0, 0x3F, 0x80,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x80, 0xFF,
  0x04, 0x06, 0x20, 0x19, 0x00, 0x48, 0x02, 0x40, 0x1A, 0x00, 0xD0, 0x04,
  0x80, 0x24, 0x03, 0x20, 0x31, 0xFE, 0x08, 0x20, 0x40, 0x82, 0x04, 0x10,
  0x10, 0x80, 0xC4, 0x02, 0x20, 0x19, 0x00, 0x48, 0x03, 0x40, 0x0C, 0x3F,
  0xE6, 0x02, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x06, 0x80, 0xCF, 0xF8, 0xFF, 0xFC, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x3C, 0x00, 0x90, 0x06, 0x30, 0x30,
  0x7F, 0x80, 0x80, 0x03, 0x40, 0x02, 0x40, 0x06, 0x40, 0x04, 0x60, 0x04,
  0x20, 0x0C, 0x20, 0x08, 0x30, 0x08, 0x10, 0x08, 0x10, 0x10, 0x18, 0x10,
  0x08, 0x10, 0x08, 0x20, 0x0C, 0x20, 0x04, 0x20, 0x04, 0x60, 0x06, 0x40,
  0x02, 0x40, 0x02, 0xC0, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x80, 0x10,
  0x03, 0x00, 0x60, 0x07, 0x00, 0xA0, 0x1A, 0x01, 0x40, 0x24, 0x02, 0x80,
  0x48, 0x0D, 0x00, 0x98, 0x13, 0x03, 0x10, 0x22, 0x04, 0x20, 0x44, 0x08,
  0x41, 0x88, 0x10, 0x82, 0x18, 0x60, 0x84, 0x10, 0x81, 0x08, 0x21, 0x02,
  0x30, 0x42, 0x04, 0x40, 0xCC, 0x04, 0x80, 0x90, 0x09, 0x01, 0x20, 0x16,
  0x02, 0x40, 0x28, 0x07, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x00, 0x40, 0x0C, 0x80, 0x23, 0x01, 0x04, 0x0C, 0x18, 0x20, 0x21,
  0x80, 0xC4, 0x01, 0x30, 0x06, 0x80, 0x0E, 0x00, 0x10, 0x00, 0xE0, 0x06,
  0x80, 0x13, 0x00, 0xC4, 0x02, 0x18, 0x10, 0x20, 0x40, 0xC2, 0x01, 0x18,
  0x06, 0x40, 0x0B, 0x00, 0x10, 0xC0, 0x0D, 0x00, 0x26, 0x01, 0x88, 0x04,
  0x20, 0x30, 0x40, 0x81, 0x02, 0x02, 0x10, 0x08, 0x40, 0x12, 0x00, 0x48,
  0x01, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x7F, 0xF8, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x7F, 0xFC, 0xFE, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x0F, 0xC0, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x20, 0x04,
  0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x00, 0x80, 0x20,
  0x0C, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30, 0xFC, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x1F, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x48, 0x01,
  0x20, 0x08, 0x40, 0x21, 0x01, 0x02, 0x04, 0x08, 0x20, 0x10, 0x80, 0x44,
  0x00, 0xB0, 0x03, 0xFF, 0xF8, 0xC2, 0x08, 0x20, 0x80, 0x07, 0x07, 0x38,
  0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x1F, 0xE6, 0x05, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0xD0, 0x1B, 0x05, 0x3F, 0x20, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0xF0, 0xB9, 0xCE, 0x04,
  0xC0, 0x28, 0x02, 0x80, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x38, 0x02, 0x80, 0x2C, 0x06, 0xA0, 0xC9, 0xF8, 0x07, 0x87, 0x32,
  0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x30, 0x04, 0x00, 0xC1, 0x1F, 0xC0, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0xE1, 0x39, 0x96, 0x05, 0x40, 0x3C,
  0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x03, 0xC0, 0x34, 0x03, 0x60, 0x51, 0xF9, 0x06, 0x07, 0x31, 0x81, 0x20,
  0x3C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x80, 0x10, 0x01, 0x81, 0x1F, 0xC0, 0x03, 0xC3, 0x20, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0xFF, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x0F, 0x03, 0x99, 0x60, 0x54, 0x03, 0xC0, 0x38, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x3C, 0x03, 0x40, 0x56,
  0x0D, 0x1F, 0x90, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x80, 0x67,
  0xF8, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x38,
  0xB1, 0x9C, 0x0B, 0x01, 0x40, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xF0, 0x05,
  0x55, 0x55, 0x55, 0x50, 0x18, 0xC0, 0x00, 0x00, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x46, 0x2F, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x81, 0xA0, 0x48,
  0x22, 0x10, 0x8C, 0x26, 0x09, 0x02, 0xE0, 0xC8, 0x21, 0x08, 0x62, 0x08,
  0x81, 0x20, 0x68, 0x0A, 0x03, 0xFF, 0xFF, 0xFF, 0x0E, 0x06, 0x16, 0x63,
  0x33, 0x02, 0x81, 0x60, 0x60, 0x38, 0x0C, 0x07, 0x00, 0x80, 0x60, 0x10,
  0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20,
  0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40,
  0x20, 0x0F, 0x17, 0x33, 0x01, 0x60, 0x28, 0x07, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x07, 0x03, 0x9C, 0x60, 0x64, 0x02, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x03, 0x40, 0x22,
  0x04, 0x1F, 0x80, 0x0F, 0x0B, 0x9C, 0xA0, 0x4C, 0x02, 0x80, 0x28, 0x03,
  0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x28, 0x02,
  0xC0, 0x6A, 0x0C, 0x9F, 0x88, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x0E, 0x03, 0x99, 0x60, 0x54, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x3C, 0x03,
  0x40, 0x56, 0x0D, 0x3F, 0x90, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x0F, 0x7F, 0x86, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x0F, 0x0C, 0x74, 0x01, 0x00, 0x40,
  0x10, 0x06, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0x00, 0x40, 0x10,
  0x06, 0x03, 0x7F, 0x00, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x0F,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x40, 0x34, 0x05, 0x60, 0x93, 0xF1,
  0xC0, 0x14, 0x03, 0x40, 0x26, 0x02, 0x20, 0x62, 0x04, 0x30, 0x41, 0x0C,
  0x10, 0x81, 0x88, 0x09, 0x80, 0x90, 0x09, 0x00, 0x70, 0x06, 0x00, 0x60,
  0xC0, 0x60, 0x28, 0x0C, 0x05, 0x01, 0xC0, 0xB0, 0x68, 0x22, 0x09, 0x04,
  0x41, 0x20, 0x88, 0x26, 0x11, 0x88, 0x44, 0x11, 0x08, 0x82, 0x21, 0x90,
  0x4C, 0x12, 0x05, 0x02, 0x80, 0xA0, 0x50, 0x14, 0x0E, 0x03, 0x00, 0xC0,
  0x20, 0x10, 0xC0, 0x64, 0x04, 0x20, 0xC3, 0x08, 0x11, 0x00, 0xB0, 0x0E,
  0x00, 0x40, 0x0E, 0x00, 0xB0, 0x11, 0x03, 0x18, 0x20, 0x86, 0x04, 0x40,
  0x68, 0x03, 0xC0, 0x14, 0x01, 0x40, 0x22, 0x02, 0x20, 0x22, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x80, 0x88, 0x08, 0x80, 0x90, 0x05, 0x00, 0x50, 0x06,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0xF0,
  0x04, 0x00, 0x7F, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x40, 0x10,
  0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x0C, 0x03, 0xFF, 0x07, 0x0C,
  0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0xE0,
  0x30, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x0C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0x60, 0x1C, 0x10, 0x18, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x18, 0x38, 0x00,
  0x7E, 0x0C, 0x0F, 0xC0, 0x18,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 22, 7, 2, -22 },
  { 7, 6, 8, 10, 2, -22 },
  { 13, 16, 22, 18, 1, -22 },
  { 57, 12, 26, 16, 2, -24 },
  { 96, 19, 22, 22, 2, -22 },
  { 149, 16, 22, 18, 2, -22 },
  { 193, 1, 8, 6, 2, -22 },
  { 194, 6, 27, 8, 1, -22 },
  { 215, 6, 27, 8, 1, -22 },
  { 236, 11, 12, 15, 2, -24 },
  { 253, 13, 14, 16, 1, -18 },
  { 276, 3, 7, 6, 1, -3 },
  { 279, 7, 1, 9, 1, -9 },
  { 280, 2, 2, 7, 2, -2 },
  { 281, 9, 22, 10, 1, -22 },
  { 306, 12, 22, 16, 2, -22 },
  { 339, 6, 22, 16, 3, -22 },
  { 356, 12, 22, 16, 2, -22 },
  { 389, 13, 22, 16, 1, -22 },
  { 425, 14, 22, 16, 1, -22 },
  { 464, 12, 22, 16, 2, -22 },
  { 497, 12, 22, 16, 2, -22 },
  { 530, 12, 22, 16, 2, -22 },
  { 563, 12, 22, 16, 2, -22 },
  { 596, 12, 22, 16, 2, -22 },
  { 629, 2, 17, 7, 2, -17 },
  { 634, 3, 21, 7, 1, -17 },
  { 642, 13, 14, 16, 1, -18 },
  { 665, 13, 8, 16, 1, -15 },
  { 678, 13, 14, 16, 1, -18 },
  { 701, 9, 22, 11, 1, -22 },
  { 726, 21, 25, 24, 2, -22 },
  { 792, 16, 22, 16, 0, -22 },
  { 836, 13, 22, 17, 3, -22 },
  { 872, 14, 22, 17, 2, -22 },
  { 911, 14, 22, 19, 3, -22 },
  { 950, 10, 22, 15, 3, -22 },
  { 978, 10, 22, 14, 3, -22 },
  { 1006, 16, 22, 20, 2, -22 },
  { 1050, 14, 22, 20, 3, -22 },
  { 1089, 5, 22, 8, 2, -22 },
  { 1103, 6, 28, 7, -2, -22 },
  { 1124, 13, 22, 16, 3, -22 },
  { 1160, 10, 22, 14, 3, -22 },
  { 1188, 18, 22, 24, 3, -22 },
  { 1238, 14, 22, 20, 3, -22 },
  { 1277, 17, 22, 21, 2, -22 },
  { 1324, 12, 22, 16, 3, -22 },
  { 1357, 17, 27, 21, 2, -22 },
  { 1415, 13, 22, 16, 3, -22 },
  { 1451, 12, 22, 15, 2, -22 },
  { 1484, 14, 22, 14, 0, -22 },
  { 1523, 14, 22, 20, 3, -22 },
  { 1562, 16, 22, 16, 0, -22 },
  { 1606, 23, 22, 25, 1, -22 },
  { 1670, 14, 22, 14, 0, -22 },
  { 1709, 14, 22, 14, 0, -22 },
  { 1748, 13, 22, 15, 1, -22 },
  { 1784, 6, 27, 10, 3, -22 },
  { 1805, 10, 22, 10, 0, -22 },
  { 1833, 6, 27, 10, 1, -22 },
  { 1854, 14, 12, 16, 1, -22 },
  { 1875, 13, 1, 12, 0, 3 },
  { 1877, 5, 5, 8, 1, -24 },
  { 1881, 11, 17, 15, 1, -17 },
  { 1905, 12, 24, 16, 3, -24 },
  { 1941, 10, 17, 13, 2, -17 },
  { 1963, 12, 24, 16, 2, -24 },
  { 1999, 11, 17, 15, 2, -17 },
  { 2023, 10, 24, 8, 0, -24 },
  { 2053, 12, 24, 16, 2, -17 },
  { 2089, 11, 24, 16, 3, -24 },
  { 2122, 2, 22, 6, 2, -22 },
  { 2128, 5, 29, 6, -1, -22 },
  { 2147, 10, 24, 13, 3, -24 },
  { 2177, 1, 24, 6, 3, -24 },
  { 2180, 19, 17, 24, 3, -17 },
  { 2221, 11, 17, 16, 3, -17 },
  { 2245, 12, 17, 16, 2, -17 },
  { 2271, 12, 24, 16, 3, -17 },
  { 2307, 12, 24, 16, 2, -17 },
  { 2343, 7, 17, 11, 3, -17 },
  { 2358, 10, 17, 13, 1, -17 },
  { 2380, 8, 20, 9, 0, -20 },
  { 2400, 12, 16, 16, 2, -16 },
  { 2424, 12, 16, 12, 0, -16 },
  { 2448, 19, 16, 20, 0, -16 },
  { 2486, 12, 16, 13, 1, -16 },
  { 2510, 12, 24, 12, 0, -16 },
  { 2546, 10, 16, 12, 1, -16 },
  { 2566, 8, 27, 11, 1, -22 },
  { 2593, 1, 32, 15, 7, -24 },
  { 2597, 9, 27, 11, 1, -22 },
  { 2628, 13, 3, 16, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight31pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT31PT7B_H_
