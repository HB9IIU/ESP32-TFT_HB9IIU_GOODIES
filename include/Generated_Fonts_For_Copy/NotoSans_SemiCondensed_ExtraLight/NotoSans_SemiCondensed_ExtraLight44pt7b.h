#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT44PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight44pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xD8, 0x00, 0x07,
  0xD8, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1,
  0x00, 0x40, 0x60, 0x00, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x02, 0x00,
  0x0C, 0x04, 0x00, 0x10, 0x08, 0x00, 0x20, 0x30, 0x00, 0x40, 0x60, 0x01,
  0x80, 0xC0, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x08, 0x04, 0x00, 0x10,
  0x18, 0x00, 0x20, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x80, 0x03, 0x01,
  0x00, 0x04, 0x02, 0x00, 0x08, 0x04, 0x00, 0x10, 0x18, 0x0F, 0xFF, 0xFF,
  0x80, 0xC0, 0x60, 0x01, 0x80, 0x80, 0x02, 0x01, 0x00, 0x04, 0x02, 0x00,
  0x08, 0x0C, 0x00, 0x10, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x40, 0x01,
  0x80, 0x80, 0x02, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0xF8,
  0x01, 0xFF, 0xC3, 0x88, 0x73, 0x84, 0x01, 0x82, 0x00, 0x81, 0x00, 0xC0,
  0x80, 0x60, 0x40, 0x30, 0x20, 0x18, 0x10, 0x06, 0x08, 0x03, 0x84, 0x00,
  0xE2, 0x00, 0x1D, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x2F, 0x00, 0x11,
  0xC0, 0x08, 0x30, 0x04, 0x0C, 0x02, 0x06, 0x01, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x40, 0x20, 0x60, 0x10, 0x30, 0x08, 0x36, 0x04, 0x33, 0xFF, 0xF0,
  0x3F, 0xE0, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0x30, 0xC0, 0x08, 0x06, 0x04, 0x01,
  0x80, 0x60, 0x60, 0x10, 0x04, 0x06, 0x03, 0x00, 0x40, 0x20, 0x20, 0x0C,
  0x02, 0x06, 0x00, 0xC0, 0x20, 0x40, 0x0C, 0x02, 0x0C, 0x00, 0xC0, 0x20,
  0x80, 0x0C, 0x02, 0x18, 0x00, 0xC0, 0x21, 0x80, 0x04, 0x06, 0x30, 0xF8,
  0x40, 0x63, 0x38, 0xC6, 0x06, 0x63, 0x04, 0x60, 0x46, 0x60, 0x63, 0x0C,
  0x46, 0x06, 0x1F, 0x8C, 0x40, 0x20, 0xF0, 0x84, 0x02, 0x00, 0x18, 0x40,
  0x20, 0x01, 0x04, 0x03, 0x00, 0x30, 0x40, 0x30, 0x02, 0x04, 0x03, 0x00,
  0x60, 0x40, 0x30, 0x04, 0x04, 0x02, 0x00, 0xC0, 0x40, 0x20, 0x08, 0x06,
  0x06, 0x01, 0x80, 0x60, 0x60, 0x10, 0x02, 0x04, 0x03, 0x00, 0x30, 0xC0,
  0x30, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x38, 0x30, 0x00,
  0x60, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0x40, 0x06, 0x00, 0x80, 0x0C,
  0x01, 0x00, 0x18, 0x06, 0x00, 0x10, 0x0C, 0x00, 0x30, 0x10, 0x00, 0x20,
  0x60, 0x00, 0x61, 0x80, 0x00, 0x6E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x30, 0xC0, 0x00, 0xC0, 0xC0, 0x13, 0x00, 0xC0,
  0x66, 0x00, 0xC0, 0xC8, 0x00, 0xC1, 0x30, 0x01, 0xC6, 0x60, 0x01, 0x8C,
  0xC0, 0x01, 0xB1, 0x80, 0x01, 0xE3, 0x00, 0x01, 0x83, 0x00, 0x07, 0x86,
  0x00, 0x19, 0x86, 0x00, 0x63, 0x07, 0x07, 0x83, 0x07, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x03, 0x06, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x30, 0x20, 0x60,
  0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x60, 0x20, 0x30, 0x30, 0x18, 0x18,
  0x0C, 0x04, 0x06, 0x03, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x18, 0x08, 0x0C,
  0x0C, 0x04, 0x06, 0x06, 0x06, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18,
  0x18, 0x10, 0x30, 0x60, 0x60, 0xC0, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x03, 0x04, 0x1B, 0xF2, 0x7E, 0x1F, 0xE0, 0x01,
  0xC0, 0x00, 0xA0, 0x00, 0x98, 0x00, 0xC6, 0x00, 0xC1, 0x80, 0x40, 0xC0,
  0x60, 0x30, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x0F, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x33, 0x36, 0x66, 0x64, 0xC8, 0x80, 0xFF, 0xFF, 0xF0, 0x7F,
  0x80, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0xC0, 0xE0, 0x60,
  0x18, 0x30, 0x03, 0x0C, 0x00, 0x42, 0x00, 0x19, 0x80, 0x06, 0x60, 0x00,
  0x98, 0x00, 0x24, 0x00, 0x0D, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0x40, 0x00, 0xD0, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x02, 0x60, 0x01,
  0x98, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0C, 0x18, 0x03, 0x07, 0x01, 0x80,
  0xE1, 0xC0, 0x0F, 0xE0, 0x01, 0x83, 0xC3, 0x63, 0x37, 0x1F, 0x0D, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0xE0, 0x07, 0xFE, 0x07, 0x80, 0xC1, 0x80, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x0F, 0xFE, 0x1C, 0x03, 0x98, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x34, 0x00, 0x33, 0xC0, 0x70, 0x7F, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xB0,
  0x00, 0x0D, 0x80, 0x00, 0xCC, 0x00, 0x04, 0x60, 0x00, 0x63, 0x00, 0x06,
  0x18, 0x00, 0x20, 0xC0, 0x03, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80,
  0x18, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x04, 0x00,
  0xC0, 0x60, 0x06, 0x06, 0x00, 0x30, 0x20, 0x01, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x3F,
  0xFE, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0xFE, 0x03, 0xFF, 0xC1, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC8, 0x00,
  0xC7, 0x81, 0xC1, 0xFF, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x3F, 0xC2, 0x70,
  0x71, 0x60, 0x0C, 0xA0, 0x03, 0x60, 0x00, 0xB0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xD8, 0x00, 0x6C, 0x00, 0x63, 0x00, 0x31, 0xC0, 0x30, 0x70, 0x70, 0x0F,
  0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xC0, 0x60, 0xC0, 0x0C, 0x30, 0x01, 0x98, 0x00,
  0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0x63, 0x00, 0x10,
  0xC0, 0x0C, 0x1C, 0x06, 0x03, 0x87, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x07,
  0x38, 0x03, 0x03, 0x83, 0x80, 0x70, 0xC0, 0x0E, 0x60, 0x01, 0x90, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x34, 0x00, 0x0D,
  0x80, 0x02, 0x60, 0x01, 0x8C, 0x00, 0xC1, 0xC0, 0xE0, 0x1F, 0xF0, 0x03,
  0xE0, 0x03, 0xFE, 0x01, 0x80, 0xC0, 0xC0, 0x18, 0x60, 0x03, 0x18, 0x00,
  0xC4, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x2C, 0x00, 0x0B,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x74, 0x00, 0x1D, 0x80, 0x0F, 0x30,
  0x02, 0xCE, 0x03, 0x31, 0xFF, 0x88, 0x1F, 0x82, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x02, 0x07, 0x00, 0xFF, 0x80, 0x5F,
  0xB0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x27, 0x73, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x33, 0x66, 0x64, 0xCC, 0x88, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x1F, 0x83, 0xFF, 0x84, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18,
  0xC0, 0x1F, 0xE0, 0x26, 0x01, 0xC0, 0x80, 0xD8, 0x0C, 0x02, 0x03, 0x60,
  0x30, 0x08, 0x0D, 0x01, 0x80, 0x20, 0x14, 0x06, 0x00, 0x80, 0x70, 0x10,
  0x06, 0x01, 0xC0, 0xC0, 0x18, 0x07, 0x03, 0x00, 0x60, 0x1C, 0x0C, 0x01,
  0x80, 0xF0, 0x30, 0x06, 0x03, 0xC0, 0x40, 0x18, 0x0F, 0x01, 0x00, 0x60,
  0x24, 0x06, 0x02, 0x81, 0x90, 0x18, 0x1B, 0x04, 0x60, 0x39, 0xC6, 0x71,
  0x80, 0x7E, 0x1F, 0x82, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x04, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0, 0x00, 0x03,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x08, 0x80, 0x00, 0x31, 0x80, 0x00, 0x63,
  0x00, 0x00, 0x82, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x08, 0x08,
  0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x00, 0x80, 0x20, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x3F, 0xFF, 0x80, 0x60, 0x03, 0x00,
  0x80, 0x02, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x08, 0x00, 0x08, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x30, 0x80, 0x00, 0x63, 0x00, 0x00, 0x66, 0x00,
  0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x80, 0xFF, 0xFC, 0x30, 0x07,
  0x8C, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x0B,
  0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0C, 0xC0,
  0x06, 0x30, 0x0F, 0x0F, 0xFF, 0x03, 0x00, 0x78, 0xC0, 0x03, 0x30, 0x00,
  0x6C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x0E, 0xC0,
  0x07, 0x3F, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x07,
  0x80, 0x20, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0xE0,
  0x1F, 0xFC, 0xFF, 0xF8, 0x06, 0x01, 0xF0, 0x30, 0x01, 0xC1, 0x80, 0x03,
  0x0C, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x06, 0xC0,
  0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x2C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x05, 0x80, 0x00, 0x2C, 0x00, 0x03, 0x60, 0x00, 0x1B,
  0x00, 0x00, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00,
  0x61, 0x80, 0x07, 0x0C, 0x00, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x3F, 0xFF, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0xE0, 0x38, 0x01, 0xC3, 0x80, 0x01, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x50, 0x00, 0x01, 0x60, 0x00, 0x05, 0x80, 0x00, 0x13, 0x00, 0x00,
  0x46, 0x00, 0x01, 0x1C, 0x00, 0x04, 0x38, 0x00, 0x10, 0x3E, 0x03, 0xC0,
  0x3F, 0xFC, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xFF, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x77, 0xF3, 0xE0, 0xC0,
  0x01, 0xF0, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x38, 0xC0, 0x0C, 0x30, 0x06,
  0x0C, 0x03, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x70, 0x0C, 0x18, 0x03,
  0x0C, 0x00, 0xC6, 0x00, 0x33, 0x80, 0x0D, 0xB0, 0x03, 0x4C, 0x00, 0xF1,
  0x80, 0x38, 0x70, 0x0C, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x30, 0x0C,
  0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x63,
  0x00, 0x0C, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x17, 0xC0, 0x00, 0x0D, 0xD0, 0x00, 0x03,
  0x76, 0x00, 0x00, 0x9D, 0x80, 0x00, 0x67, 0x30, 0x00, 0x19, 0xCC, 0x00,
  0x04, 0x71, 0x00, 0x03, 0x1C, 0x60, 0x00, 0x87, 0x18, 0x00, 0x61, 0xC2,
  0x00, 0x18, 0x70, 0xC0, 0x04, 0x1C, 0x30, 0x03, 0x07, 0x04, 0x00, 0xC1,
  0xC1, 0x80, 0x20, 0x70, 0x60, 0x18, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x01,
  0x01, 0xC0, 0x40, 0xC0, 0x70, 0x18, 0x20, 0x1C, 0x06, 0x18, 0x07, 0x00,
  0x86, 0x01, 0xC0, 0x31, 0x00, 0x70, 0x0C, 0xC0, 0x1C, 0x01, 0x30, 0x07,
  0x00, 0x68, 0x01, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x04, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xD8,
  0x00, 0x3D, 0x80, 0x03, 0xCC, 0x00, 0x3C, 0x60, 0x03, 0xC6, 0x00, 0x3C,
  0x30, 0x03, 0xC3, 0x00, 0x3C, 0x18, 0x03, 0xC1, 0x80, 0x3C, 0x0C, 0x03,
  0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x30, 0x3C, 0x03, 0x03, 0xC0, 0x18,
  0x3C, 0x00, 0xC3, 0xC0, 0x0C, 0x3C, 0x00, 0x63, 0xC0, 0x06, 0x3C, 0x00,
  0x33, 0xC0, 0x03, 0x3C, 0x00, 0x1B, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x18, 0x00, 0x38, 0x0E, 0x00,
  0x70, 0x07, 0x83, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x60, 0x1E, 0x30,
  0x03, 0x98, 0x00, 0xEC, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x58, 0x00, 0x6C, 0x00, 0x36, 0x00,
  0x33, 0x00, 0x19, 0x80, 0x38, 0xFF, 0xF8, 0x7F, 0xC0, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0x00, 0xE0, 0x0C, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0x40, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x18, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x07, 0x83, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0xFF, 0xF0,
  0x30, 0x0F, 0x0C, 0x00, 0xE3, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x4C,
  0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x13, 0x00,
  0x0C, 0xC0, 0x03, 0x30, 0x01, 0x8C, 0x00, 0xC3, 0x03, 0xE0, 0xFF, 0xE0,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x06, 0x0C,
  0x01, 0x83, 0x00, 0x30, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x33, 0x00,
  0x0C, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x0C, 0x01, 0xF8, 0x07, 0xFF,
  0xC7, 0x00, 0xC6, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x34, 0x00, 0x33,
  0xC0, 0x70, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x34, 0x00, 0x02, 0x60, 0x00, 0x67, 0x00, 0x0C, 0x38, 0x01, 0xC1, 0xE0,
  0x78, 0x07, 0xFE, 0x00, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x26, 0x00, 0x01,
  0x98, 0x00, 0x06, 0x20, 0x00, 0x10, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x04,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x01, 0x80, 0x80, 0x06, 0x03, 0x00,
  0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60,
  0x06, 0x01, 0x80, 0x0C, 0x04, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x01,
  0x02, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x21, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0x30, 0x00, 0x04, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xD0, 0x00, 0x50, 0x00, 0x6C, 0x00, 0x28, 0x00, 0x26, 0x00,
  0x36, 0x00, 0x33, 0x00, 0x1B, 0x00, 0x18, 0x80, 0x0D, 0x80, 0x0C, 0x60,
  0x04, 0x40, 0x04, 0x30, 0x06, 0x30, 0x06, 0x18, 0x03, 0x18, 0x03, 0x04,
  0x01, 0x8C, 0x01, 0x83, 0x00, 0x82, 0x00, 0x81, 0x80, 0xC1, 0x80, 0xC0,
  0xC0, 0x60, 0xC0, 0x60, 0x20, 0x30, 0x60, 0x30, 0x18, 0x10, 0x10, 0x10,
  0x0C, 0x18, 0x0C, 0x18, 0x06, 0x0C, 0x06, 0x0C, 0x01, 0x06, 0x03, 0x06,
  0x00, 0xC2, 0x00, 0x82, 0x00, 0x63, 0x00, 0x63, 0x00, 0x31, 0x80, 0x31,
  0x80, 0x08, 0xC0, 0x18, 0xC0, 0x06, 0x40, 0x04, 0x40, 0x03, 0x60, 0x03,
  0x60, 0x01, 0xB0, 0x01, 0xB0, 0x00, 0x58, 0x00, 0xD8, 0x00, 0x28, 0x00,
  0x28, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x73, 0x00, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x08,
  0x0C, 0x01, 0x80, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x60, 0x60, 0x03, 0x06,
  0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00, 0x09, 0x80, 0x00, 0xD8, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x09, 0x80, 0x01,
  0x88, 0x00, 0x10, 0xC0, 0x03, 0x04, 0x00, 0x60, 0x60, 0x06, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x01, 0x81, 0x80, 0x18, 0x10, 0x00, 0xC3, 0x00, 0x0C,
  0x60, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x76, 0x00,
  0x06, 0x60, 0x00, 0x43, 0x00, 0x0C, 0x30, 0x00, 0x81, 0x80, 0x18, 0x18,
  0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x60, 0x06, 0x06, 0x00,
  0x20, 0xC0, 0x03, 0x0C, 0x00, 0x11, 0x80, 0x01, 0x98, 0x00, 0x19, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0F, 0xFF, 0xFC, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0xFF, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xFF, 0xFC, 0x00, 0x20, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0D, 0x80, 0x00, 0x98, 0x00, 0x18, 0xC0,
  0x01, 0x0C, 0x00, 0x30, 0x60, 0x02, 0x06, 0x00, 0x60, 0x30, 0x04, 0x03,
  0x00, 0xC0, 0x10, 0x08, 0x01, 0x81, 0x80, 0x08, 0x10, 0x00, 0xC3, 0x00,
  0x04, 0x20, 0x00, 0x6E, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xC1, 0xC1, 0x81,
  0x81, 0x81, 0x81, 0x80, 0x01, 0xE0, 0x3F, 0xF0, 0xC0, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x1F, 0xF1, 0xE0, 0x26, 0x00, 0x58, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xAC, 0x03, 0x5C, 0x1C, 0x8F,
  0xE1, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0xF0, 0x23, 0xFE,
  0x13, 0x01, 0x8B, 0x00, 0x65, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x02, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x58, 0x00,
  0x6C, 0x00, 0x35, 0x00, 0x32, 0xC0, 0x39, 0x38, 0x38, 0x8F, 0xF0, 0x00,
  0x00, 0x78, 0x0F, 0xFC, 0x38, 0x08, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x81, 0x83, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x78, 0x30, 0x7F, 0x8C, 0x70, 0x3B,
  0x18, 0x02, 0xCC, 0x00, 0x72, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x00, 0xD0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xD0, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x07,
  0x60, 0x01, 0xCC, 0x00, 0xF1, 0x80, 0x6C, 0x78, 0x33, 0x07, 0xF8, 0xC0,
  0x00, 0xE0, 0x03, 0xFC, 0x03, 0x03, 0x83, 0x00, 0xC3, 0x00, 0x31, 0x00,
  0x19, 0x80, 0x06, 0xC0, 0x03, 0x40, 0x01, 0xA0, 0x00, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x04, 0x38,
  0x1C, 0x0F, 0xFC, 0x00, 0x70, 0x0F, 0xF0, 0x30, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x3F, 0xF8,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0x31, 0xC0, 0x6C, 0x60, 0x0B,
  0x30, 0x01, 0xC8, 0x00, 0x76, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x40, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x1D, 0x80, 0x07,
  0x30, 0x03, 0xC6, 0x01, 0xB1, 0xE0, 0xCC, 0x1F, 0xE3, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x19, 0x00, 0x0C, 0x30, 0x0E, 0x0F, 0xFF, 0x00, 0x0C, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x83, 0xE0, 0x8F, 0xF8, 0x98, 0x1C, 0xB0, 0x0E,
  0xA0, 0x06, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x5F, 0x80, 0x00, 0x09, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x49, 0x24, 0x92, 0x02, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06, 0x0E, 0xFC, 0x30, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x0A, 0x00, 0x64, 0x01, 0x88, 0x03, 0x10,
  0x0C, 0x20, 0x30, 0x40, 0xC0, 0x83, 0x01, 0x06, 0x02, 0x18, 0x04, 0x60,
  0x09, 0xE0, 0x16, 0x40, 0x28, 0xC0, 0x60, 0xC0, 0xC1, 0x81, 0x01, 0x82,
  0x01, 0x84, 0x03, 0x08, 0x03, 0x10, 0x06, 0x20, 0x06, 0x40, 0x06, 0x80,
  0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x1C, 0x11, 0xFE, 0x1F,
  0xE2, 0x60, 0xE6, 0x06, 0x50, 0x0D, 0x80, 0x6E, 0x00, 0xA0, 0x05, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0x00, 0x1E, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x01, 0xC0, 0x8F, 0xF8, 0x98, 0x1C, 0xB0, 0x06, 0xA0,
  0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x01, 0xE0, 0x01, 0xFF, 0x00, 0xC0, 0x60, 0x60, 0x0C,
  0x30, 0x01, 0x88, 0x00, 0x66, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x05, 0x00, 0x01, 0x40, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0C, 0xC0, 0x06,
  0x30, 0x01, 0x86, 0x00, 0xC0, 0xE0, 0xE0, 0x1F, 0xF0, 0x01, 0xE0, 0x47,
  0xFC, 0x26, 0x03, 0x16, 0x00, 0xCA, 0x00, 0x37, 0x00, 0x1B, 0x00, 0x05,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xB0,
  0x00, 0xDC, 0x00, 0x6A, 0x00, 0x65, 0x80, 0x72, 0x70, 0x71, 0x0F, 0xE0,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0xE0,
  0x01, 0xFE, 0x31, 0xC0, 0xEC, 0x60, 0x0B, 0x30, 0x01, 0xD8, 0x00, 0x76,
  0x00, 0x1D, 0x80, 0x03, 0x40, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x40, 0x00,
  0xD8, 0x00, 0x76, 0x00, 0x1D, 0x80, 0x07, 0x30, 0x03, 0xCE, 0x01, 0xB1,
  0xE1, 0xCC, 0x1F, 0xE3, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x03, 0xA3, 0xF9, 0x82, 0xC0, 0xA0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x03, 0xC0, 0x7F,
  0xF7, 0x00, 0x98, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x6E,
  0x07, 0x1F, 0xF8, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x3F,
  0xF8, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x03, 0x00, 0x60, 0x06, 0x10, 0xFE, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x07, 0x60, 0x05, 0x70,
  0x0D, 0x38, 0x39, 0x1F, 0xE1, 0xC0, 0x01, 0xA0, 0x00, 0xD8, 0x00, 0x4C,
  0x00, 0x62, 0x00, 0x31, 0x80, 0x10, 0xC0, 0x18, 0x20, 0x0C, 0x18, 0x04,
  0x0C, 0x06, 0x02, 0x03, 0x01, 0x81, 0x00, 0xC1, 0x80, 0x20, 0xC0, 0x18,
  0x40, 0x0C, 0x60, 0x02, 0x30, 0x01, 0x90, 0x00, 0xD8, 0x00, 0x2C, 0x00,
  0x14, 0x00, 0x0E, 0x00, 0x03, 0x00, 0xC0, 0x0C, 0x00, 0x78, 0x01, 0xC0,
  0x0B, 0x00, 0x38, 0x03, 0x20, 0x0D, 0x00, 0x66, 0x01, 0xB0, 0x08, 0xC0,
  0x26, 0x01, 0x18, 0x04, 0xC0, 0x61, 0x01, 0x88, 0x0C, 0x30, 0x31, 0x81,
  0x06, 0x04, 0x30, 0x20, 0xC1, 0x82, 0x0C, 0x08, 0x30, 0x61, 0x81, 0x84,
  0x0C, 0x20, 0x30, 0x81, 0x84, 0x06, 0x30, 0x11, 0x80, 0x46, 0x03, 0x30,
  0x0C, 0x80, 0x64, 0x01, 0xB0, 0x04, 0x80, 0x16, 0x00, 0xB0, 0x02, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0xE0, 0x03, 0x30, 0x03, 0x0C, 0x01, 0x83, 0x01, 0x81, 0x80, 0xC0, 0x60,
  0xC0, 0x10, 0xC0, 0x0C, 0x60, 0x03, 0x60, 0x01, 0xA0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x34, 0x00, 0x1B, 0x00, 0x18, 0xC0, 0x08, 0x60, 0x0C, 0x18,
  0x0C, 0x04, 0x06, 0x03, 0x06, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x1B, 0x00,
  0x06, 0xC0, 0x00, 0xD8, 0x00, 0x66, 0x00, 0x18, 0x80, 0x04, 0x30, 0x03,
  0x0C, 0x00, 0xC1, 0x00, 0x20, 0x60, 0x18, 0x18, 0x06, 0x02, 0x01, 0x00,
  0xC0, 0xC0, 0x30, 0x30, 0x04, 0x08, 0x01, 0x86, 0x00, 0x61, 0x80, 0x08,
  0x40, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x12, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xE0, 0x70, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x07, 0x03,
  0x80, 0x78, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x3E, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x38, 0x00, 0xF0, 0x1F, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0xF8, 0x0E, 0x00, 0x0C, 0x00, 0x1F, 0xE0, 0x1C,
  0x0E, 0x0E, 0x00, 0xFE, 0x00, 0x04, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 31, 10, 3, -31 },
  { 13, 8, 11, 14, 3, -31 },
  { 24, 23, 31, 25, 1, -31 },
  { 114, 17, 36, 22, 2, -33 },
  { 191, 28, 32, 32, 2, -32 },
  { 303, 23, 32, 26, 2, -32 },
  { 395, 2, 11, 8, 3, -31 },
  { 398, 8, 38, 12, 2, -31 },
  { 436, 8, 38, 12, 2, -31 },
  { 474, 17, 15, 21, 2, -33 },
  { 506, 18, 21, 22, 2, -26 },
  { 554, 4, 11, 9, 2, -5 },
  { 560, 10, 2, 13, 2, -13 },
  { 563, 3, 3, 9, 3, -3 },
  { 565, 13, 31, 15, 1, -31 },
  { 616, 18, 32, 22, 2, -32 },
  { 688, 9, 31, 22, 4, -31 },
  { 723, 18, 32, 22, 2, -32 },
  { 795, 17, 32, 22, 2, -32 },
  { 863, 21, 32, 22, 1, -32 },
  { 947, 17, 31, 22, 3, -31 },
  { 1013, 17, 32, 22, 3, -32 },
  { 1081, 18, 31, 22, 2, -31 },
  { 1151, 18, 32, 22, 2, -32 },
  { 1223, 18, 32, 22, 2, -32 },
  { 1295, 3, 24, 9, 3, -24 },
  { 1304, 4, 30, 9, 2, -24 },
  { 1319, 18, 20, 22, 2, -26 },
  { 1364, 18, 11, 22, 2, -21 },
  { 1389, 18, 20, 22, 2, -26 },
  { 1434, 14, 32, 16, 1, -32 },
  { 1490, 30, 35, 34, 2, -31 },
  { 1622, 23, 31, 23, 0, -31 },
  { 1712, 18, 31, 24, 4, -31 },
  { 1782, 20, 32, 24, 3, -32 },
  { 1862, 21, 31, 27, 4, -31 },
  { 1944, 15, 31, 22, 4, -31 },
  { 2003, 15, 31, 20, 4, -31 },
  { 2062, 22, 32, 29, 3, -32 },
  { 2150, 20, 31, 28, 4, -31 },
  { 2228, 8, 31, 12, 2, -31 },
  { 2259, 9, 39, 10, -3, -31 },
  { 2303, 18, 31, 22, 4, -31 },
  { 2373, 15, 31, 20, 4, -31 },
  { 2432, 26, 31, 34, 4, -31 },
  { 2533, 20, 31, 28, 4, -31 },
  { 2611, 24, 32, 30, 3, -32 },
  { 2707, 17, 31, 23, 4, -31 },
  { 2773, 24, 39, 30, 3, -32 },
  { 2890, 18, 31, 23, 4, -31 },
  { 2960, 17, 32, 22, 2, -32 },
  { 3028, 20, 31, 20, 0, -31 },
  { 3106, 20, 31, 28, 4, -31 },
  { 3184, 22, 31, 22, 0, -31 },
  { 3270, 33, 31, 35, 1, -31 },
  { 3398, 20, 31, 20, 0, -31 },
  { 3476, 20, 31, 20, 0, -31 },
  { 3554, 19, 31, 21, 1, -31 },
  { 3628, 9, 38, 14, 4, -31 },
  { 3671, 13, 31, 15, 1, -31 },
  { 3722, 9, 38, 14, 1, -31 },
  { 3765, 20, 18, 22, 1, -32 },
  { 3810, 18, 1, 18, 0, 4 },
  { 3813, 7, 7, 11, 2, -34 },
  { 3820, 15, 24, 21, 2, -24 },
  { 3865, 17, 33, 23, 4, -33 },
  { 3936, 15, 24, 18, 2, -24 },
  { 3981, 18, 33, 23, 2, -33 },
  { 4056, 17, 24, 21, 2, -24 },
  { 4107, 14, 34, 12, 0, -34 },
  { 4167, 18, 35, 23, 2, -24 },
  { 4246, 16, 33, 23, 4, -33 },
  { 4312, 3, 32, 9, 3, -32 },
  { 4324, 8, 43, 9, -2, -32 },
  { 4367, 15, 33, 19, 4, -33 },
  { 4429, 1, 33, 9, 4, -33 },
  { 4434, 27, 24, 34, 4, -24 },
  { 4515, 16, 24, 23, 4, -24 },
  { 4563, 18, 24, 23, 2, -24 },
  { 4617, 17, 34, 23, 4, -24 },
  { 4690, 18, 34, 23, 2, -24 },
  { 4767, 10, 24, 15, 4, -24 },
  { 4797, 14, 24, 18, 2, -24 },
  { 4839, 11, 29, 13, 1, -29 },
  { 4879, 16, 23, 23, 3, -23 },
  { 4925, 17, 23, 17, 0, -23 },
  { 4974, 27, 23, 28, 1, -23 },
  { 5052, 17, 23, 19, 1, -23 },
  { 5101, 18, 34, 18, 0, -23 },
  { 5178, 14, 23, 17, 2, -23 },
  { 5219, 11, 38, 15, 2, -31 },
  { 5272, 1, 45, 21, 10, -34 },
  { 5278, 12, 38, 15, 2, -31 },
  { 5335, 18, 5, 22, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight44pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT44PT7B_H_
