#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT64PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight64pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x02, 0xFF, 0xFF,
  0x20, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x76, 0x03, 0x30, 0x19, 0x80,
  0xCC, 0x06, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x19,
  0x80, 0xCC, 0x06, 0x60, 0x30, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0,
  0x0E, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x80, 0x18, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x30, 0x03, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xE0, 0x06, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x38, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x3E, 0x30, 0x3C, 0x3C, 0x18, 0x02, 0x1C, 0x0C, 0x00, 0x1C, 0x06,
  0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x03, 0x80,
  0x60, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x1C,
  0x06, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0xC0, 0x00,
  0x3C, 0x60, 0x00, 0x0F, 0xB0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0x8F, 0x80, 0x00, 0xC1,
  0xE0, 0x00, 0x60, 0x78, 0x00, 0x30, 0x0E, 0x00, 0x18, 0x07, 0x00, 0x0C,
  0x01, 0xC0, 0x06, 0x00, 0xE0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x0E, 0x00, 0x30, 0x07, 0x00, 0x18, 0x03, 0x00,
  0x0C, 0x03, 0x80, 0x06, 0x01, 0x98, 0x03, 0x03, 0xCF, 0x81, 0x87, 0xC7,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0x00, 0x1C,
  0x1C, 0x00, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x0E, 0x00, 0x30, 0x06, 0x00,
  0x0C, 0x00, 0x70, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0x60, 0x03,
  0x00, 0x70, 0x00, 0x60, 0x03, 0x00, 0x60, 0x00, 0xE0, 0x03, 0x00, 0x60,
  0x00, 0xE0, 0x03, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x00, 0xE0,
  0x03, 0x01, 0x80, 0x00, 0xE0, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x03, 0x03,
  0x00, 0x00, 0x60, 0x03, 0x03, 0x00, 0x00, 0x60, 0x03, 0x07, 0x07, 0xE0,
  0x60, 0x03, 0x06, 0x0F, 0xF0, 0x60, 0x07, 0x0E, 0x1C, 0x38, 0x60, 0x07,
  0x0C, 0x38, 0x1C, 0x70, 0x06, 0x1C, 0x30, 0x0C, 0x30, 0x0E, 0x18, 0x60,
  0x0E, 0x38, 0x0C, 0x38, 0x60, 0x06, 0x1C, 0x1C, 0x30, 0x60, 0x06, 0x0F,
  0xF8, 0x70, 0xE0, 0x07, 0x07, 0xF0, 0x60, 0xC0, 0x07, 0x00, 0x00, 0xE0,
  0xC0, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x03,
  0x00, 0x01, 0x80, 0xC0, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x03, 0x00, 0x03,
  0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x06, 0x00, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x30, 0x00, 0x30, 0x0C,
  0x00, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x00, 0x1E, 0x78, 0x00, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x03, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x78, 0x00,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xE1, 0xC0,
  0x1C, 0x00, 0x30, 0xE0, 0x03, 0x80, 0x0C, 0x30, 0x00, 0xE0, 0x07, 0x1C,
  0x00, 0x1C, 0x01, 0xC6, 0x00, 0x03, 0x80, 0x63, 0x80, 0x00, 0x70, 0x38,
  0xE0, 0x00, 0x0E, 0x0C, 0x38, 0x00, 0x01, 0xC7, 0x0E, 0x00, 0x00, 0x71,
  0xC3, 0x80, 0x00, 0x0E, 0xE0, 0xE0, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x00,
  0x3C, 0x06, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x70, 0x00,
  0x03, 0xB8, 0x0E, 0x00, 0x01, 0xC7, 0x01, 0xC0, 0x01, 0xE0, 0xE0, 0x3C,
  0x01, 0xF0, 0x1C, 0x07, 0xFF, 0xF8, 0x03, 0x80, 0xFF, 0xF8, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x00, 0xFF, 0xF6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x00,
  0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70,
  0x03, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x18, 0x03, 0xF8, 0x18, 0x1F, 0x7F, 0x18, 0xFE, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x66, 0x00, 0x00,
  0xE3, 0x00, 0x01, 0xC1, 0x80, 0x01, 0x81, 0xC0, 0x03, 0x80, 0xE0, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x1C,
  0x70, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x60, 0xC3, 0x86, 0x0C, 0x38, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x4F, 0xFF, 0xF4, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3C, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x0E, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x0E, 0x70, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x70, 0x70, 0x00, 0x18, 0x0C, 0x00, 0x0E,
  0x03, 0x80, 0x03, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x01, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x03, 0xC0,
  0x3E, 0x03, 0xB0, 0x39, 0x87, 0x8C, 0x78, 0x67, 0x83, 0x70, 0x1F, 0x00,
  0xD0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x07, 0xC0, 0x3C, 0x0F, 0x80, 0x07, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x0F, 0xC0, 0x3E, 0x0F, 0x00, 0x07, 0x8E,
  0x00, 0x01, 0xE2, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x20, 0x00,
  0x07, 0x1F, 0x00, 0x0F, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x60, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xC0, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3E,
  0x00, 0x80, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x1F, 0xF0, 0x1C, 0x3F, 0xFE, 0x0C, 0x7C, 0x07, 0x86, 0x70, 0x00,
  0xE3, 0x30, 0x00, 0x39, 0xB0, 0x00, 0x0C, 0xF0, 0x00, 0x07, 0x78, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x18, 0x00, 0x06,
  0x0E, 0x00, 0x07, 0x03, 0x80, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x78, 0x07, 0xC0, 0x38,
  0x00, 0x78, 0x1C, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x70, 0x70, 0x00, 0x18, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x07, 0x80, 0x07, 0x87, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xC0, 0xF0, 0x03, 0xC0,
  0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x19, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0x30,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x78, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x1C,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C,
  0x60, 0x00, 0x07, 0x18, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x0E, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xF3, 0x00, 0x00,
  0x7C, 0xE0, 0x00, 0x37, 0x1C, 0x00, 0x39, 0x83, 0xC0, 0x1C, 0x60, 0x7F,
  0xFE, 0x18, 0x07, 0xFE, 0x06, 0x00, 0x10, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF,
  0x40, 0x1E, 0x3C, 0x78, 0xF0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x06, 0x1C, 0x30,
  0x61, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0xC3, 0xC0, 0x3E, 0x60, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x3C, 0x00, 0x0C,
  0x18, 0x00, 0x1F, 0xFE, 0x00, 0xE3, 0x80, 0x07, 0xE3, 0xE0, 0x0E, 0x30,
  0x00, 0xE0, 0x06, 0x00, 0x63, 0x00, 0x1C, 0x00, 0x60, 0x06, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x67, 0x00, 0x30, 0x00, 0xE0, 0x07, 0x60, 0x07, 0x00,
  0x0E, 0x00, 0x76, 0x00, 0x60, 0x00, 0xE0, 0x07, 0x60, 0x06, 0x00, 0x0E,
  0x00, 0x36, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0xE0, 0x0E, 0x00, 0x0E, 0x00,
  0x3E, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0xE0, 0x0E, 0x00, 0x0C, 0x00, 0x7E,
  0x00, 0xC0, 0x00, 0xC0, 0x07, 0xE0, 0x0C, 0x00, 0x0C, 0x00, 0x6E, 0x00,
  0xC0, 0x00, 0xC0, 0x06, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0x66, 0x00, 0xE0,
  0x01, 0xC0, 0x06, 0x60, 0x06, 0x00, 0x1C, 0x00, 0xE6, 0x00, 0x60, 0x03,
  0x60, 0x0C, 0x60, 0x07, 0x00, 0x36, 0x01, 0xC7, 0x00, 0x38, 0x06, 0x70,
  0x38, 0x70, 0x01, 0xE1, 0xC3, 0x87, 0x03, 0x00, 0x0F, 0xF8, 0x1F, 0xE0,
  0x30, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1C, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x83, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x30, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xF0, 0xC0, 0x01, 0xF8, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0x00, 0x03, 0xE0, 0xC0, 0x00, 0x1E,
  0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x03, 0xCC, 0x00, 0x01, 0xE3, 0x00,
  0x07, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x3E, 0x01, 0xE0, 0x00, 0x20,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x30,
  0x00, 0x1F, 0x00, 0xC0, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x1E, 0x0C, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x07, 0x30,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x78, 0x0C, 0x00, 0x07, 0xC0, 0x30, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xB0, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0xE0,
  0x1E, 0x00, 0x00, 0x10, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x0C, 0x78, 0x00, 0x00, 0x06,
  0x1C, 0x00, 0x00, 0x03, 0x07, 0x80, 0x00, 0x01, 0x81, 0xE0, 0x00, 0x00,
  0xC0, 0x7C, 0x00, 0x00, 0x60, 0x1F, 0x80, 0x01, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0xFF, 0xFF, 0xFC, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC8, 0x1E,
  0x3F, 0xF8, 0xFF, 0x80, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x0F, 0x0C,
  0x00, 0x03, 0x83, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x70,
  0x0C, 0x00, 0x38, 0x03, 0x00, 0x1E, 0x00, 0xC0, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x30,
  0x3C, 0x00, 0x0C, 0x1E, 0x00, 0x03, 0x07, 0x00, 0x00, 0xC3, 0xC0, 0x00,
  0x31, 0xF8, 0x00, 0x0C, 0xEE, 0x00, 0x03, 0x71, 0xC0, 0x00, 0xD8, 0x38,
  0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xC0,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x0E, 0x00,
  0xC0, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xD8, 0x00, 0x00, 0x00, 0x6F, 0x70, 0x00, 0x00, 0x01, 0xBD, 0xC0, 0x00,
  0x00, 0x0E, 0xF3, 0x00, 0x00, 0x00, 0x33, 0xCE, 0x00, 0x00, 0x01, 0xCF,
  0x38, 0x00, 0x00, 0x07, 0x3C, 0x60, 0x00, 0x00, 0x18, 0xF1, 0xC0, 0x00,
  0x00, 0xE3, 0xC3, 0x00, 0x00, 0x03, 0x0F, 0x0C, 0x00, 0x00, 0x0C, 0x3C,
  0x38, 0x00, 0x00, 0x70, 0xF0, 0x60, 0x00, 0x01, 0x83, 0xC1, 0xC0, 0x00,
  0x06, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x3C, 0x0C, 0x00, 0x00, 0xC0, 0xF0,
  0x38, 0x00, 0x07, 0x03, 0xC0, 0xE0, 0x00, 0x1C, 0x0F, 0x01, 0x80, 0x00,
  0x60, 0x3C, 0x07, 0x00, 0x03, 0x80, 0xF0, 0x0C, 0x00, 0x0C, 0x03, 0xC0,
  0x38, 0x00, 0x30, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0x3C, 0x01, 0x80, 0x06,
  0x00, 0xF0, 0x07, 0x00, 0x18, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x30, 0x03, 0x00, 0x3C, 0x00, 0xE0, 0x1C, 0x00, 0xF0, 0x01, 0x80, 0x60,
  0x03, 0xC0, 0x06, 0x01, 0x80, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x3C, 0x00,
  0x30, 0x30, 0x00, 0xF0, 0x00, 0xE0, 0xC0, 0x03, 0xC0, 0x03, 0x87, 0x00,
  0x0F, 0x00, 0x06, 0x18, 0x00, 0x3C, 0x00, 0x1C, 0xE0, 0x00, 0xF0, 0x00,
  0x73, 0x80, 0x03, 0xC0, 0x00, 0xCC, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x79, 0xC0, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07,
  0x87, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x78, 0x0C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0xF0, 0x0E, 0x00, 0x07, 0x80, 0x38, 0x00, 0x3C, 0x00, 0xC0, 0x01,
  0xE0, 0x07, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x03, 0x80, 0x1E, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x70, 0x07, 0x80, 0x01,
  0x80, 0x3C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x18, 0x1E, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x03, 0x8F, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x70, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0xF8, 0xC0, 0x00, 0x3C,
  0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x1C,
  0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x78, 0xC0, 0x01, 0xF0, 0xC0, 0x7F, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x0E, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x07,
  0x18, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0x00,
  0x03, 0xE0, 0xC0, 0x00, 0x3C, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x0E,
  0x0C, 0x00, 0x0F, 0x03, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x80, 0x30,
  0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0,
  0x30, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x38, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x0E, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x01, 0xF0, 0x07, 0xC3, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x20, 0x00, 0x0F, 0x1E, 0x00, 0x1F,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x1C, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x60, 0x07, 0x00,
  0x00, 0xE0, 0x03, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x71, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x18, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x0C, 0x38,
  0x00, 0x07, 0x70, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x07, 0x06,
  0x00, 0x01, 0x8C, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC7, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xE0,
  0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x30,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x1C,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x00, 0xE0, 0x03, 0x01, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x18, 0x01, 0x80, 0x30, 0x03,
  0x80, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0x70, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x70,
  0x18, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x0C,
  0x0E, 0x00, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x03,
  0x83, 0x00, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x61, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x0E, 0x30, 0x00,
  0x1C, 0x60, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x01, 0x98, 0x00,
  0x03, 0x38, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x70, 0x03, 0x80, 0x01, 0x80, 0x18, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x60, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x18, 0x01, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x70, 0x00, 0x38, 0x03,
  0x80, 0x00, 0xC0, 0x18, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0C, 0x01, 0x80,
  0x01, 0xC0, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0x60, 0x07, 0x00, 0x07, 0x00, 0x60, 0x00, 0x30, 0x0E, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x08, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0x80, 0x3C, 0x18, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xB0, 0xF8,
  0x00, 0xC7, 0x80, 0x03, 0x38, 0x00, 0x0D, 0xC0, 0x00, 0x36, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xB6, 0x00, 0x06, 0xDC, 0x00,
  0x33, 0x38, 0x03, 0x8C, 0x7E, 0xFC, 0x30, 0xFF, 0xE0, 0xC0, 0x38, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0xE0,
  0x03, 0x83, 0xFF, 0x80, 0xE1, 0xFF, 0xF0, 0x39, 0xE0, 0x1E, 0x0E, 0xE0,
  0x01, 0xC3, 0xB0, 0x00, 0x38, 0xF8, 0x00, 0x06, 0x3E, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x33, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xF0, 0x00,
  0x03, 0x3C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x73, 0xE0, 0x00, 0x38, 0xDC,
  0x00, 0x0E, 0x33, 0x80, 0x07, 0x0C, 0x70, 0x07, 0x83, 0x0F, 0xFF, 0xC0,
  0xC1, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x00, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0xF8, 0x03, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x0C, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x40, 0x1C, 0x03,
  0xFF, 0x07, 0x03, 0xFF, 0xF1, 0xC1, 0xE0, 0x0E, 0x70, 0xF0, 0x01, 0xDC,
  0x38, 0x00, 0x37, 0x1C, 0x00, 0x06, 0xCE, 0x00, 0x00, 0xB3, 0x80, 0x00,
  0x3C, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xCC,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x2C, 0xE0, 0x00, 0x1B, 0x1C, 0x00, 0x0C,
  0xC3, 0x80, 0x07, 0x30, 0x78, 0x03, 0x8C, 0x0F, 0xFF, 0xC3, 0x01, 0xFF,
  0xC0, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x01, 0xC0, 0x70, 0x00, 0xE0,
  0x70, 0x00, 0x38, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x18, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x66, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x02, 0x07, 0xC0, 0x0F,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x0F, 0xFC, 0x03, 0xC1, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0xF0,
  0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F,
  0xF0, 0x30, 0x3F, 0xFF, 0x0C, 0x1E, 0x00, 0xE3, 0x0F, 0x00, 0x1D, 0xC7,
  0x80, 0x03, 0xF1, 0xC0, 0x00, 0x7C, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03,
  0xCC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x60, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x07, 0x60, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3C, 0xC0,
  0x00, 0x0F, 0x38, 0x00, 0x03, 0xC6, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0xDC,
  0x38, 0x00, 0x77, 0x07, 0x80, 0x39, 0xC0, 0xFF, 0xFC, 0x70, 0x1F, 0xFC,
  0x1C, 0x00, 0x78, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC3, 0x00, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x01, 0x00, 0x70, 0x7F, 0xE0,
  0xE3, 0xFF, 0xF1, 0xCF, 0x00, 0xF3, 0xB8, 0x00, 0xF7, 0x60, 0x00, 0xEF,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x06, 0xEF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x01, 0xC0,
  0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x1E, 0x7F, 0x8F, 0xE0, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x73, 0x80, 0x03, 0x8E,
  0x00, 0x1C, 0x38, 0x00, 0x60, 0xE0, 0x03, 0x83, 0x80, 0x1C, 0x0E, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x00,
  0x38, 0x38, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x3E, 0x00, 0x39,
  0xB8, 0x00, 0xEE, 0x70, 0x03, 0xF0, 0xC0, 0x0F, 0x83, 0x80, 0x3C, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x0E, 0x00, 0x60, 0x38, 0x01, 0xC0,
  0xE0, 0x03, 0x83, 0x80, 0x06, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xE0,
  0x00, 0xE3, 0x80, 0x01, 0xCE, 0x00, 0x03, 0x38, 0x00, 0x0E, 0xE0, 0x00,
  0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x02,
  0x00, 0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0xC3, 0xFF, 0xC0, 0xFF, 0xF8, 0xC7,
  0x01, 0xE1, 0xE0, 0x3C, 0xCC, 0x00, 0x73, 0x80, 0x1C, 0xD8, 0x00, 0x73,
  0x00, 0x0E, 0xD8, 0x00, 0x36, 0x00, 0x06, 0xF0, 0x00, 0x3E, 0x00, 0x06,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x04, 0x01, 0x81, 0xFF, 0x83, 0x07, 0xFF, 0xC6,
  0x3C, 0x03, 0xCC, 0xE0, 0x03, 0xD9, 0x80, 0x03, 0xB6, 0x00, 0x03, 0xE8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x18, 0x00, 0x04, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00,
  0xE0, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x38, 0x38, 0x00,
  0x06, 0x03, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x30, 0x3F, 0xF0, 0x0C, 0x1F, 0xFF, 0x03, 0x0E, 0x01, 0xE0, 0xC6,
  0x00, 0x1C, 0x33, 0x00, 0x03, 0x8D, 0x80, 0x00, 0x73, 0x60, 0x00, 0x1C,
  0xF0, 0x00, 0x03, 0x3C, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x0C, 0xF8, 0x00, 0x07, 0x3E, 0x00, 0x03, 0x8E,
  0xC0, 0x00, 0xE3, 0xB8, 0x00, 0x70, 0xE7, 0x80, 0x78, 0x38, 0xFF, 0xFC,
  0x0E, 0x0F, 0xFC, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF0, 0x30,
  0x3F, 0xFF, 0x0C, 0x1E, 0x01, 0xE3, 0x0F, 0x00, 0x1C, 0xC7, 0x80, 0x03,
  0x71, 0xC0, 0x00, 0x7C, 0xE0, 0x00, 0x1F, 0x38, 0x00, 0x03, 0xCC, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x60,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x0F,
  0x38, 0x00, 0x07, 0xCE, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0xDC, 0x38, 0x00,
  0x67, 0x0F, 0x80, 0x79, 0xC0, 0xFF, 0xFC, 0x70, 0x1F, 0xFC, 0x1C, 0x00,
  0xF8, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0xC0, 0xFF, 0xC3, 0xFF, 0xC7, 0x81, 0xCE, 0x00, 0xCC, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x1F,
  0xFF, 0x03, 0xFF, 0xFE, 0x3C, 0x00, 0xE3, 0xC0, 0x01, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x0E, 0xF0, 0x01, 0xE7, 0xFF,
  0xFE, 0x07, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x38, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xF6, 0x00, 0x03, 0x6E, 0x00, 0x06, 0xCE,
  0x00, 0x19, 0x9E, 0x00, 0xE3, 0x1F, 0xFF, 0x86, 0x0F, 0xFC, 0x0C, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x71, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x18,
  0x30, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x06, 0x03, 0x00, 0x07,
  0x01, 0x80, 0x03, 0x00, 0xE0, 0x01, 0x80, 0x30, 0x01, 0xC0, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x70, 0x01, 0x80, 0x30, 0x00, 0xE0,
  0x18, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x03,
  0x07, 0x00, 0x01, 0x83, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x31, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x70, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x80,
  0x00, 0xF0, 0x00, 0x3B, 0x00, 0x01, 0xE0, 0x00, 0x67, 0x00, 0x07, 0xC0,
  0x00, 0xCE, 0x00, 0x0D, 0xC0, 0x03, 0x9C, 0x00, 0x19, 0x80, 0x07, 0x18,
  0x00, 0x73, 0x00, 0x0C, 0x38, 0x00, 0xE6, 0x00, 0x18, 0x70, 0x01, 0x8E,
  0x00, 0x70, 0x60, 0x03, 0x0C, 0x00, 0xE0, 0xC0, 0x0E, 0x18, 0x01, 0x81,
  0xC0, 0x18, 0x38, 0x03, 0x03, 0x80, 0x30, 0x70, 0x0E, 0x03, 0x00, 0xE0,
  0x60, 0x1C, 0x06, 0x01, 0xC0, 0xC0, 0x30, 0x0E, 0x03, 0x01, 0xC0, 0x60,
  0x1C, 0x06, 0x01, 0x81, 0xC0, 0x18, 0x1C, 0x03, 0x03, 0x80, 0x30, 0x30,
  0x07, 0x06, 0x00, 0x70, 0x60, 0x0E, 0x0C, 0x00, 0xE1, 0xC0, 0x0C, 0x38,
  0x00, 0xC3, 0x80, 0x18, 0x70, 0x01, 0x86, 0x00, 0x38, 0xC0, 0x03, 0x8C,
  0x00, 0x31, 0x80, 0x03, 0x38, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0xCE,
  0x00, 0x0C, 0xC0, 0x01, 0xD8, 0x00, 0x1D, 0x80, 0x01, 0xB0, 0x00, 0x1F,
  0x00, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x83, 0x80, 0x01, 0x80,
  0xC0, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0xE0,
  0x03, 0x80, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x30,
  0x00, 0x06, 0x38, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0E,
  0xE0, 0x00, 0x06, 0x38, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x07, 0x00, 0x03,
  0x81, 0x80, 0x03, 0x80, 0xE0, 0x01, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x01,
  0xC0, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x0C, 0x70, 0x00, 0x07, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x67, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18,
  0x1C, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x38, 0x00,
  0x70, 0x06, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x70, 0x03, 0x80, 0x0C,
  0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0xE0, 0x1C, 0x00, 0x18, 0x06, 0x00,
  0x06, 0x01, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x07,
  0x38, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00,
  0xF8, 0x03, 0xF8, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x05, 0xFF, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x00, 0x7F, 0xFD, 0x00,
  0x03, 0xFE, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 47, 14, 5, -46 },
  { 25, 13, 17, 21, 4, -46 },
  { 53, 33, 46, 36, 2, -46 },
  { 243, 25, 53, 33, 3, -49 },
  { 409, 40, 47, 46, 3, -46 },
  { 644, 34, 47, 38, 3, -46 },
  { 844, 3, 17, 11, 4, -46 },
  { 851, 12, 56, 17, 3, -46 },
  { 935, 12, 56, 17, 2, -46 },
  { 1019, 24, 23, 31, 3, -49 },
  { 1088, 27, 29, 33, 3, -37 },
  { 1186, 7, 15, 12, 2, -7 },
  { 1200, 15, 3, 19, 2, -19 },
  { 1206, 4, 6, 14, 5, -5 },
  { 1209, 19, 46, 21, 1, -46 },
  { 1319, 26, 47, 33, 3, -46 },
  { 1472, 13, 46, 33, 6, -46 },
  { 1547, 25, 46, 33, 3, -46 },
  { 1691, 25, 47, 33, 3, -46 },
  { 1838, 31, 46, 33, 1, -46 },
  { 2017, 25, 47, 33, 4, -46 },
  { 2164, 25, 47, 33, 4, -46 },
  { 2311, 26, 46, 33, 3, -46 },
  { 2461, 26, 47, 33, 3, -46 },
  { 2614, 26, 47, 33, 3, -46 },
  { 2767, 4, 35, 14, 5, -34 },
  { 2785, 7, 42, 14, 2, -34 },
  { 2822, 27, 28, 33, 3, -37 },
  { 2917, 27, 15, 33, 3, -30 },
  { 2968, 27, 28, 33, 3, -37 },
  { 3063, 19, 47, 23, 2, -46 },
  { 3175, 44, 52, 50, 3, -46 },
  { 3461, 33, 46, 33, 0, -46 },
  { 3651, 26, 46, 35, 6, -46 },
  { 3801, 29, 47, 35, 4, -46 },
  { 3972, 30, 46, 40, 6, -46 },
  { 4145, 22, 46, 31, 6, -46 },
  { 4272, 22, 46, 29, 6, -46 },
  { 4399, 33, 47, 42, 4, -46 },
  { 4593, 29, 46, 41, 6, -46 },
  { 4760, 11, 46, 17, 3, -46 },
  { 4824, 14, 57, 14, -5, -46 },
  { 4924, 26, 46, 32, 6, -46 },
  { 5074, 22, 46, 29, 6, -46 },
  { 5201, 38, 46, 50, 6, -46 },
  { 5420, 29, 46, 41, 6, -46 },
  { 5587, 35, 47, 43, 4, -46 },
  { 5793, 24, 46, 33, 6, -46 },
  { 5931, 35, 57, 43, 4, -46 },
  { 6181, 26, 46, 34, 6, -46 },
  { 6331, 25, 47, 31, 3, -46 },
  { 6478, 29, 46, 29, 0, -46 },
  { 6645, 30, 47, 41, 5, -46 },
  { 6822, 32, 46, 32, 0, -46 },
  { 7006, 49, 46, 51, 1, -46 },
  { 7288, 29, 46, 29, 0, -46 },
  { 7455, 29, 46, 29, 0, -46 },
  { 7622, 27, 46, 31, 2, -46 },
  { 7778, 13, 56, 20, 5, -46 },
  { 7869, 19, 46, 21, 1, -46 },
  { 7979, 13, 56, 20, 2, -46 },
  { 8070, 28, 26, 33, 2, -46 },
  { 8161, 26, 2, 26, 0, 6 },
  { 8168, 10, 10, 16, 3, -49 },
  { 8181, 22, 36, 30, 3, -35 },
  { 8280, 26, 50, 34, 5, -49 },
  { 8443, 22, 36, 27, 3, -35 },
  { 8542, 26, 50, 34, 3, -49 },
  { 8705, 25, 36, 31, 3, -35 },
  { 8818, 19, 49, 17, 1, -49 },
  { 8935, 26, 50, 34, 3, -35 },
  { 9098, 23, 49, 33, 5, -49 },
  { 9239, 4, 46, 13, 5, -46 },
  { 9262, 11, 61, 13, -2, -46 },
  { 9346, 22, 49, 27, 5, -49 },
  { 9481, 3, 49, 13, 5, -49 },
  { 9500, 40, 35, 50, 5, -35 },
  { 9675, 23, 35, 33, 5, -35 },
  { 9776, 27, 36, 33, 3, -35 },
  { 9898, 26, 50, 34, 5, -35 },
  { 10061, 26, 50, 34, 3, -35 },
  { 10224, 16, 34, 22, 5, -34 },
  { 10292, 21, 36, 26, 2, -35 },
  { 10387, 16, 43, 18, 1, -42 },
  { 10473, 23, 35, 33, 5, -34 },
  { 10574, 25, 34, 25, 0, -34 },
  { 10681, 39, 34, 41, 1, -34 },
  { 10847, 25, 34, 27, 1, -34 },
  { 10954, 26, 49, 26, 0, -34 },
  { 11114, 21, 34, 25, 2, -34 },
  { 11204, 18, 56, 22, 2, -46 },
  { 11330, 2, 65, 31, 14, -49 },
  { 11347, 17, 56, 22, 3, -46 },
  { 11466, 27, 6, 33, 3, -26 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight64pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT64PT7B_H_
