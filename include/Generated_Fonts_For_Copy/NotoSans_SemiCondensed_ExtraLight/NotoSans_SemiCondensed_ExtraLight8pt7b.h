#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT8PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight8pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0xC0, 0x55, 0xF6, 0xF6, 0x6C, 0xC2, 0x5E, 0xCD, 0xAA, 0xB3,
  0xAC, 0x62, 0x99, 0x59, 0x7C, 0xC0, 0x6A, 0xA4, 0x95, 0x58, 0x5D, 0x80,
  0x22, 0xF2, 0xC0, 0xC0, 0x80, 0x29, 0x29, 0x00, 0x69, 0x99, 0x96, 0xFC,
  0x61, 0x12, 0x4F, 0xE1, 0x25, 0x1E, 0x22, 0x6A, 0xF2, 0x68, 0xE1, 0x1E,
  0x68, 0xE9, 0x97, 0xF1, 0x22, 0x44, 0x69, 0x66, 0x9F, 0x69, 0x97, 0x16,
  0x10, 0x18, 0x16, 0xC3, 0xFF, 0x86, 0x3C, 0xC4, 0xA4, 0x80, 0x39, 0x1B,
  0xEB, 0xBE, 0x07, 0x00, 0x22, 0x6F, 0x99, 0xD6, 0xFB, 0xC0, 0x78, 0x88,
  0x87, 0xD6, 0xDB, 0xC0, 0xEB, 0xB0, 0xEB, 0xA0, 0x3A, 0x21, 0x38, 0xBC,
  0xB6, 0xFB, 0x40, 0xD5, 0x70, 0x55, 0x5C, 0xBA, 0x4D, 0x40, 0xAA, 0xB0,
  0x8C, 0x67, 0x3E, 0xE4, 0xB6, 0xFB, 0x40, 0x74, 0x63, 0x18, 0xB8, 0xD6,
  0xE9, 0x00, 0x74, 0x63, 0x18, 0xB8, 0x40, 0xD6, 0xEB, 0x40, 0x68, 0xC2,
  0x1E, 0xF4, 0x44, 0x44, 0xB6, 0xDB, 0xC0, 0x99, 0x96, 0x64, 0x96, 0x5B,
  0x5D, 0x49, 0x20, 0x96, 0x44, 0x69, 0x9A, 0x64, 0x44, 0xF2, 0x24, 0x4F,
  0xFE, 0x91, 0x24, 0x40, 0xD5, 0x5C, 0x26, 0x99, 0xE0, 0xC0, 0x6E, 0xF0,
  0x9A, 0xDB, 0xC0, 0xF2, 0x30, 0x17, 0x99, 0x9F, 0xFE, 0x30, 0x7A, 0xA0,
  0xF9, 0x9F, 0x1E, 0x9A, 0xDB, 0x40, 0xBC, 0xBF, 0xAE, 0xB0, 0xFC, 0xFD,
  0x6B, 0x50, 0xF6, 0xD0, 0xF9, 0x97, 0xF6, 0xF9, 0x00, 0xF9, 0x9F, 0x11,
  0xEA, 0xF8, 0xF0, 0xEA, 0xC0, 0xB6, 0xF0, 0xB5, 0x20, 0xAD, 0x74, 0xA0,
  0xA9, 0x50, 0xB5, 0x25, 0x80, 0xE9, 0x70, 0x57, 0x54, 0xFF, 0x95, 0x5C,
  0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 1, 2, 3, 1, -6 },
  { 3, 4, 6, 5, 0, -6 },
  { 6, 4, 6, 4, 0, -6 },
  { 9, 5, 6, 6, 0, -6 },
  { 13, 5, 6, 5, 0, -6 },
  { 17, 1, 2, 1, 0, -6 },
  { 18, 2, 7, 2, 0, -6 },
  { 20, 2, 7, 2, 0, -6 },
  { 22, 3, 3, 4, 0, -6 },
  { 24, 4, 4, 4, 0, -5 },
  { 26, 1, 2, 2, 0, -1 },
  { 27, 2, 1, 2, 0, -3 },
  { 28, 1, 1, 2, 0, -1 },
  { 29, 3, 6, 3, 0, -6 },
  { 32, 4, 6, 4, 0, -6 },
  { 35, 1, 6, 4, 1, -6 },
  { 36, 4, 6, 4, 0, -6 },
  { 39, 4, 6, 4, 0, -6 },
  { 42, 4, 6, 4, 0, -6 },
  { 45, 4, 6, 4, 0, -6 },
  { 48, 4, 6, 4, 0, -6 },
  { 51, 4, 6, 4, 0, -6 },
  { 54, 4, 6, 4, 0, -6 },
  { 57, 4, 6, 4, 0, -6 },
  { 60, 1, 4, 2, 0, -4 },
  { 61, 1, 5, 2, 0, -4 },
  { 62, 4, 4, 4, 0, -5 },
  { 64, 4, 2, 4, 0, -4 },
  { 65, 4, 4, 4, 0, -5 },
  { 67, 3, 6, 3, 0, -6 },
  { 70, 6, 7, 6, 0, -6 },
  { 76, 4, 6, 4, 0, -6 },
  { 79, 3, 6, 4, 1, -6 },
  { 82, 4, 6, 4, 0, -6 },
  { 85, 3, 6, 5, 1, -6 },
  { 88, 2, 6, 4, 1, -6 },
  { 90, 2, 6, 4, 1, -6 },
  { 92, 5, 6, 5, 0, -6 },
  { 96, 3, 6, 5, 1, -6 },
  { 99, 2, 6, 2, 0, -6 },
  { 101, 2, 7, 2, -1, -6 },
  { 103, 3, 6, 4, 1, -6 },
  { 106, 2, 6, 4, 1, -6 },
  { 108, 5, 6, 6, 1, -6 },
  { 112, 3, 6, 5, 1, -6 },
  { 115, 5, 6, 5, 0, -6 },
  { 119, 3, 6, 4, 1, -6 },
  { 122, 5, 7, 5, 0, -6 },
  { 127, 3, 6, 4, 1, -6 },
  { 130, 4, 6, 4, 0, -6 },
  { 133, 4, 6, 4, 0, -6 },
  { 136, 3, 6, 5, 1, -6 },
  { 139, 4, 6, 4, 0, -6 },
  { 142, 6, 6, 6, 0, -6 },
  { 147, 4, 6, 4, 0, -6 },
  { 150, 4, 6, 4, 0, -6 },
  { 153, 4, 6, 4, 0, -6 },
  { 156, 1, 7, 3, 1, -6 },
  { 157, 3, 6, 3, 0, -6 },
  { 160, 2, 7, 3, 0, -6 },
  { 162, 4, 4, 4, 0, -6 },
  { 164, 3, 1, 3, 0, 0 },
  { 165, 2, 1, 2, 0, -6 },
  { 166, 3, 4, 4, 0, -4 },
  { 168, 3, 6, 4, 1, -6 },
  { 171, 3, 4, 3, 0, -4 },
  { 173, 4, 6, 4, 0, -6 },
  { 176, 3, 4, 4, 0, -4 },
  { 178, 2, 6, 2, 0, -6 },
  { 180, 4, 6, 4, 0, -4 },
  { 183, 3, 6, 4, 1, -6 },
  { 186, 1, 6, 2, 0, -6 },
  { 187, 1, 8, 2, 0, -6 },
  { 188, 2, 6, 3, 1, -6 },
  { 190, 1, 6, 2, 0, -6 },
  { 191, 5, 4, 6, 1, -4 },
  { 194, 3, 4, 4, 1, -4 },
  { 196, 4, 4, 4, 0, -4 },
  { 198, 3, 6, 4, 1, -4 },
  { 201, 4, 6, 4, 0, -4 },
  { 204, 2, 4, 3, 1, -4 },
  { 205, 3, 4, 3, 0, -4 },
  { 207, 2, 5, 2, 0, -5 },
  { 209, 3, 4, 4, 1, -4 },
  { 211, 3, 4, 3, 0, -4 },
  { 213, 5, 4, 5, 0, -4 },
  { 216, 3, 4, 3, 0, -4 },
  { 218, 3, 6, 3, 0, -4 },
  { 221, 3, 4, 3, 0, -4 },
  { 223, 2, 7, 3, 0, -6 },
  { 225, 1, 8, 4, 1, -6 },
  { 226, 2, 7, 3, 0, -6 },
  { 228, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight8pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT8PT7B_H_
