#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT37PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x87, 0x0E, 0x1C, 0x28,
  0x50, 0xA1, 0x42, 0x84, 0x01, 0x83, 0x00, 0x20, 0x60, 0x04, 0x08, 0x00,
  0x81, 0x00, 0x10, 0x20, 0x06, 0x04, 0x00, 0x81, 0x80, 0x10, 0x30, 0x7F,
  0xFF, 0xE0, 0x40, 0x80, 0x08, 0x10, 0x03, 0x02, 0x00, 0x40, 0x40, 0x08,
  0x18, 0x01, 0x02, 0x00, 0x20, 0x40, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x20,
  0x20, 0x04, 0x0C, 0x00, 0x81, 0x00, 0x10, 0x20, 0x02, 0x04, 0x00, 0xC0,
  0x80, 0x18, 0x10, 0x02, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0xFC, 0x0F,
  0xFE, 0x63, 0x09, 0x0C, 0x0C, 0x30, 0x20, 0xC0, 0x83, 0x02, 0x0C, 0x0C,
  0x30, 0x18, 0xC0, 0x33, 0x00, 0x7C, 0x00, 0x70, 0x00, 0xF8, 0x03, 0x30,
  0x0C, 0x60, 0x30, 0xC0, 0xC1, 0x03, 0x04, 0x0C, 0x10, 0x30, 0x40, 0xC3,
  0x03, 0x1B, 0x8D, 0xC7, 0xFC, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x00, 0x6C, 0x00, 0x81, 0x84, 0x02, 0x02, 0x0C, 0x04, 0x0C, 0x18,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0xC0, 0x40, 0x41, 0x00, 0x80, 0x86,
  0x01, 0x01, 0x08, 0x02, 0x02, 0x30, 0x04, 0x04, 0x47, 0x8C, 0x19, 0x98,
  0x88, 0x32, 0x60, 0x98, 0x4C, 0x81, 0x1B, 0x11, 0x03, 0x1C, 0x62, 0x06,
  0x00, 0x84, 0x0C, 0x03, 0x08, 0x08, 0x04, 0x10, 0x10, 0x08, 0x20, 0x60,
  0x20, 0x40, 0xC0, 0x40, 0x81, 0x81, 0x01, 0x02, 0x02, 0x03, 0x04, 0x0C,
  0x02, 0x18, 0x30, 0x03, 0xE0, 0x03, 0x80, 0x01, 0xDC, 0x00, 0x60, 0xC0,
  0x08, 0x08, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x00, 0x80, 0x80,
  0x10, 0x30, 0x03, 0x04, 0x00, 0x31, 0x80, 0x02, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x06, 0x60, 0x01, 0x06, 0x03, 0x40, 0x60, 0x58, 0x04, 0x0A,
  0x00, 0x43, 0x40, 0x0C, 0x48, 0x00, 0xD9, 0x00, 0x0E, 0x30, 0x00, 0xC6,
  0x00, 0x38, 0x60, 0x0C, 0x86, 0x07, 0x18, 0x7F, 0x81, 0x80, 0xFF, 0x80,
  0x0E, 0x10, 0x41, 0x82, 0x04, 0x18, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x18, 0x30, 0x20, 0x40, 0xC0, 0x81,
  0x81, 0x03, 0x03, 0x03, 0xE0, 0x40, 0xC0, 0x81, 0x81, 0x03, 0x06, 0x04,
  0x0C, 0x18, 0x30, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x30, 0x60, 0xC1,
  0x02, 0x0C, 0x10, 0x20, 0xC1, 0x06, 0x18, 0x60, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x82, 0x0B, 0xC8, 0xF1, 0xFC, 0x00, 0xC0, 0x05, 0x80,
  0x32, 0x01, 0x84, 0x04, 0x18, 0x30, 0x30, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x33, 0x32, 0x26, 0x44, 0xC0, 0xFF, 0xFF,
  0xC0, 0xBC, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0,
  0x10, 0x00, 0x03, 0x80, 0x1F, 0xC0, 0x40, 0xC1, 0x80, 0xC6, 0x00, 0x8C,
  0x01, 0x90, 0x01, 0x20, 0x02, 0xC0, 0x05, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x16, 0x00, 0x24, 0x00, 0x48, 0x01, 0x98, 0x03, 0x10, 0x04, 0x30,
  0x18, 0x30, 0x60, 0x3F, 0x80, 0x03, 0x0D, 0x19, 0x31, 0xE1, 0x41, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x07, 0x80, 0xFF, 0x8E, 0x03,
  0x10, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0x80, 0xFF, 0x8E, 0x03,
  0x20, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x0C, 0x01, 0xC0, 0x7F, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x1B, 0x00, 0xC7, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x05, 0x00, 0x06, 0x80, 0x06, 0x40, 0x02, 0x20, 0x03, 0x10,
  0x01, 0x08, 0x01, 0x04, 0x01, 0x82, 0x00, 0x81, 0x00, 0x80, 0x80, 0xC0,
  0x40, 0x40, 0x20, 0x60, 0x10, 0x60, 0x08, 0x20, 0x04, 0x30, 0x02, 0x1F,
  0xFF, 0xF0, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x3F, 0xF8, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x3F, 0x03, 0xEF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x40, 0x0C, 0xE0, 0x70, 0xFF, 0x80, 0x00, 0xF8, 0x0F, 0xF0, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x3F, 0x0D, 0x81, 0x9E, 0x01, 0xB8, 0x01, 0x60, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x34, 0x00, 0x68, 0x00, 0xD8,
  0x01, 0x10, 0x06, 0x30, 0x08, 0x30, 0x70, 0x3F, 0x80, 0xFF, 0xFE, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x07, 0xC0,
  0x3F, 0xE0, 0xC0, 0x63, 0x00, 0x44, 0x00, 0xC8, 0x00, 0x90, 0x01, 0x20,
  0x06, 0x60, 0x0C, 0x40, 0x10, 0xC0, 0xC0, 0xE3, 0x00, 0x7C, 0x00, 0xF8,
  0x06, 0x18, 0x18, 0x0C, 0x60, 0x0D, 0x80, 0x0B, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xF0, 0x01, 0xA0, 0x02, 0x60, 0x0C, 0x60, 0x70, 0x7F,
  0x80, 0x07, 0x80, 0x3F, 0xC0, 0xC0, 0xC3, 0x00, 0xC4, 0x00, 0x98, 0x01,
  0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x16, 0x00, 0x3C,
  0x00, 0xE8, 0x01, 0xD8, 0x0D, 0x1E, 0x72, 0x0F, 0x84, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x81, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x2F, 0x33, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0x22, 0x66, 0x44, 0xC0, 0x00, 0x06,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x1E, 0x1F, 0xF2, 0x03, 0x00, 0x30, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x03, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xC0, 0x38, 0x01,
  0x80, 0x06, 0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0x61, 0x80, 0x00, 0x10,
  0x80, 0x00, 0x0C, 0xC0, 0x3F, 0x02, 0x40, 0x70, 0xC1, 0xA0, 0x60, 0x60,
  0xF0, 0x20, 0x30, 0x38, 0x30, 0x10, 0x18, 0x10, 0x08, 0x0C, 0x08, 0x04,
  0x06, 0x04, 0x02, 0x03, 0x02, 0x01, 0x03, 0x81, 0x00, 0x81, 0xC0, 0x80,
  0xC0, 0xE0, 0x60, 0x60, 0x58, 0x10, 0x78, 0x64, 0x0E, 0x66, 0x62, 0x03,
  0xE1, 0xE1, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x02, 0x80, 0x00, 0x58,
  0x00, 0x19, 0x00, 0x02, 0x20, 0x00, 0x46, 0x00, 0x18, 0x40, 0x02, 0x08,
  0x00, 0x41, 0x80, 0x18, 0x10, 0x02, 0x02, 0x00, 0x40, 0x60, 0x18, 0x04,
  0x02, 0x00, 0x80, 0x7F, 0xF8, 0x18, 0x01, 0x02, 0x00, 0x20, 0x40, 0x06,
  0x18, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x98, 0x00, 0x32, 0x00, 0x02,
  0xC0, 0x00, 0x78, 0x00, 0x0C, 0xFF, 0xF0, 0xC0, 0x18, 0xC0, 0x0C, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x0C, 0xC0, 0x18, 0xFF, 0xF0, 0xFF, 0xF0, 0xC0, 0x1C, 0xC0, 0x06, 0xC0,
  0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0,
  0x02, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x78, 0xFF, 0xE0, 0x00, 0x7C, 0x01,
  0xFF, 0xC1, 0x80, 0x21, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0xC0, 0xFF, 0xC0, 0xFF, 0xF0, 0x30, 0x0E, 0x0C,
  0x00, 0xE3, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x00, 0x4C, 0x00, 0x1B, 0x00,
  0x02, 0xC0, 0x00, 0xB0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xB0, 0x00, 0x2C,
  0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x63, 0x00,
  0x70, 0xC0, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0xFF, 0xEF, 0xFF, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xFF,
  0xC0, 0xFF, 0xFE, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFB,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F,
  0xFC, 0x18, 0x01, 0x86, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x07, 0xFE, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x16, 0x00, 0x02, 0x40, 0x00,
  0x4C, 0x00, 0x08, 0xC0, 0x01, 0x0C, 0x00, 0x20, 0xE0, 0x1C, 0x07, 0xFF,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x40, 0xFC, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x33, 0xF0, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x03, 0x02, 0x06,
  0xFC, 0x30, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x60,
  0xC0, 0x40, 0xC0, 0xC0, 0xC1, 0x80, 0xC3, 0x00, 0xC6, 0x00, 0xCC, 0x00,
  0xCC, 0x00, 0xD6, 0x00, 0xF3, 0x00, 0xE1, 0x00, 0xC1, 0x80, 0xC0, 0xC0,
  0xC0, 0x40, 0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x08,
  0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xFF,
  0xC0, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x80, 0x00,
  0xBD, 0x00, 0x01, 0x7B, 0x00, 0x06, 0xF2, 0x00, 0x09, 0xE4, 0x00, 0x13,
  0xCC, 0x00, 0x67, 0x88, 0x00, 0x8F, 0x18, 0x03, 0x1E, 0x30, 0x04, 0x3C,
  0x20, 0x08, 0x78, 0x60, 0x30, 0xF0, 0x40, 0x41, 0xE0, 0x80, 0x83, 0xC1,
  0x83, 0x07, 0x81, 0x04, 0x0F, 0x03, 0x18, 0x1E, 0x06, 0x30, 0x3C, 0x04,
  0x40, 0x78, 0x0D, 0x80, 0xF0, 0x1A, 0x01, 0xE0, 0x14, 0x03, 0xC0, 0x38,
  0x07, 0x80, 0x20, 0x0C, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3A, 0x00,
  0x1D, 0x80, 0x0E, 0x40, 0x07, 0x30, 0x03, 0x8C, 0x01, 0xC2, 0x00, 0xE1,
  0x80, 0x70, 0x40, 0x38, 0x30, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x01, 0x83,
  0x80, 0x41, 0xC0, 0x30, 0xE0, 0x08, 0x70, 0x06, 0x38, 0x01, 0x9C, 0x00,
  0x4E, 0x00, 0x37, 0x00, 0x0B, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0x00, 0x60, 0x30, 0x01, 0x83, 0x00,
  0x06, 0x10, 0x00, 0x31, 0x80, 0x00, 0x8C, 0x00, 0x06, 0x40, 0x00, 0x12,
  0x00, 0x00, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x90,
  0x00, 0x04, 0x80, 0x00, 0x66, 0x00, 0x03, 0x10, 0x00, 0x10, 0xC0, 0x01,
  0x82, 0x00, 0x18, 0x1C, 0x01, 0x80, 0x30, 0x18, 0x00, 0xFF, 0x80, 0xFF,
  0xE3, 0x00, 0xCC, 0x01, 0xB0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x02, 0xC0, 0x3B, 0x07, 0x8F,
  0xF8, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x3F, 0xF8, 0x03, 0x00, 0x60, 0x30, 0x01, 0x83, 0x00, 0x06, 0x10, 0x00,
  0x31, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x40, 0x00, 0x12, 0x00, 0x00, 0xB0,
  0x00, 0x05, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80,
  0x00, 0x66, 0x00, 0x03, 0x10, 0x00, 0x10, 0xC0, 0x01, 0x82, 0x00, 0x18,
  0x1C, 0x01, 0x80, 0x30, 0x18, 0x00, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0xC0,
  0xFF, 0xE0, 0xC0, 0x38, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x04, 0xC0, 0x04,
  0xC0, 0x04, 0xC0, 0x04, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18,
  0xC0, 0x70, 0xFF, 0xC0, 0xC0, 0x80, 0xC0, 0xC0, 0xC0, 0x40, 0xC0, 0x60,
  0xC0, 0x20, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x04,
  0xC0, 0x06, 0xC0, 0x03, 0x07, 0xE0, 0x7F, 0xF3, 0x00, 0x58, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x1B,
  0x01, 0xCF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x14, 0x00, 0x1A, 0x00, 0x0D, 0x80,
  0x0C, 0x60, 0x06, 0x1C, 0x0E, 0x07, 0xFC, 0x00, 0xC0, 0x00, 0x68, 0x00,
  0x19, 0x00, 0x03, 0x30, 0x00, 0x42, 0x00, 0x18, 0x40, 0x03, 0x0C, 0x00,
  0x40, 0x80, 0x08, 0x10, 0x03, 0x03, 0x00, 0x40, 0x20, 0x08, 0x04, 0x03,
  0x00, 0xC0, 0x40, 0x18, 0x08, 0x01, 0x03, 0x00, 0x30, 0x40, 0x06, 0x08,
  0x00, 0x43, 0x00, 0x0C, 0x40, 0x01, 0x88, 0x00, 0x13, 0x00, 0x03, 0x40,
  0x00, 0x68, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x80, 0x06,
  0x00, 0x3C, 0x00, 0x60, 0x02, 0xC0, 0x0E, 0x00, 0x24, 0x00, 0xA0, 0x06,
  0x40, 0x0B, 0x00, 0x66, 0x00, 0x90, 0x04, 0x60, 0x19, 0x00, 0x42, 0x01,
  0x10, 0x0C, 0x20, 0x11, 0x80, 0xC3, 0x01, 0x08, 0x08, 0x30, 0x30, 0x80,
  0x81, 0x02, 0x08, 0x18, 0x10, 0x20, 0xC1, 0x81, 0x82, 0x04, 0x10, 0x18,
  0x60, 0x41, 0x00, 0x84, 0x04, 0x30, 0x08, 0x40, 0x63, 0x00, 0xC4, 0x02,
  0x20, 0x0C, 0xC0, 0x22, 0x00, 0x48, 0x02, 0x60, 0x04, 0x80, 0x36, 0x00,
  0x68, 0x01, 0x40, 0x07, 0x80, 0x14, 0x00, 0x38, 0x01, 0x40, 0x03, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x80, 0x60, 0x03, 0x18, 0x01, 0x0C, 0x01, 0x83,
  0x00, 0x80, 0x80, 0xC0, 0x60, 0x40, 0x10, 0x60, 0x0C, 0x20, 0x02, 0x30,
  0x01, 0x90, 0x00, 0x58, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x05,
  0x80, 0x06, 0x40, 0x06, 0x30, 0x02, 0x08, 0x03, 0x06, 0x01, 0x01, 0x01,
  0x80, 0xC0, 0x80, 0x20, 0xC0, 0x18, 0xC0, 0x06, 0x60, 0x03, 0x60, 0x00,
  0xC0, 0xC0, 0x01, 0xA0, 0x01, 0x98, 0x00, 0x84, 0x00, 0xC3, 0x00, 0x40,
  0x80, 0x60, 0x60, 0x20, 0x10, 0x30, 0x0C, 0x10, 0x02, 0x18, 0x01, 0x8C,
  0x00, 0x44, 0x00, 0x36, 0x00, 0x0A, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x7F, 0xFE, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x18, 0x01,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20,
  0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0xFE, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0xFF, 0x00, 0x80, 0x00, 0x60, 0x00, 0x50, 0x00, 0x2C, 0x00, 0x22, 0x00,
  0x31, 0x80, 0x10, 0x40, 0x18, 0x30, 0x08, 0x08, 0x0C, 0x06, 0x04, 0x01,
  0x06, 0x00, 0xC2, 0x00, 0x23, 0x00, 0x19, 0x00, 0x05, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE0, 0x40, 0x40, 0xC0, 0xC0, 0x40, 0x0F, 0x87, 0x8E,
  0x40, 0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0xFF,
  0x38, 0x16, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x3C, 0x07,
  0x60, 0xD3, 0xF9, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x87, 0xC1, 0x38, 0xE2, 0xC0, 0x65,
  0x00, 0x4C, 0x00, 0xD8, 0x00, 0xB0, 0x01, 0x60, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xB0, 0x01, 0x60, 0x06,
  0xE0, 0x0D, 0x40, 0x32, 0x60, 0xC4, 0x7F, 0x00, 0x03, 0xE0, 0xE3, 0x18,
  0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x10, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x07, 0xC6, 0x38, 0xEC, 0xC0, 0x5B, 0x00,
  0x76, 0x00, 0xE8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xA0, 0x03, 0x60,
  0x0E, 0x40, 0x3C, 0xE0, 0xD8, 0x7F, 0x10, 0x07, 0xC0, 0x79, 0x83, 0x01,
  0x18, 0x06, 0x60, 0x09, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x83, 0xFC, 0x03, 0xE0, 0xC0, 0x30, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x1F, 0x9F, 0xF0, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x07, 0xC6, 0x38,
  0xEC, 0xC0, 0x7B, 0x00, 0x74, 0x00, 0xE8, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xA0, 0x03, 0x60, 0x0E, 0x40, 0x3C, 0xE0, 0xD8, 0x7F, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x19, 0x00, 0x63,
  0xE7, 0x81, 0xFC, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x87, 0xC4, 0xE7, 0xAC, 0x05, 0x40, 0x3C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x10, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C, 0x30, 0xC0,
  0x00, 0x00, 0x02, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x2B, 0xBC,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x34, 0x03, 0x20, 0x11, 0x01, 0x88, 0x18, 0x41, 0x82, 0x18,
  0x10, 0x80, 0x8C, 0x04, 0xE0, 0x2D, 0x81, 0xC4, 0x0C, 0x30, 0x40, 0xC2,
  0x02, 0x10, 0x18, 0x80, 0x44, 0x03, 0x20, 0x0D, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xF0, 0x87, 0x81, 0xF1, 0x31, 0xC7, 0x72, 0x80, 0x90, 0x35, 0x01,
  0xC0, 0x3C, 0x01, 0x80, 0x78, 0x02, 0x00, 0xF0, 0x04, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10,
  0x87, 0xC4, 0xE3, 0xAC, 0x05, 0x40, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x07, 0xC0, 0x38,
  0xE0, 0xC0, 0x63, 0x00, 0x64, 0x00, 0x48, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xA0, 0x02, 0x60, 0x0C, 0x60, 0x10, 0x60, 0xE0, 0x7F, 0x00, 0x87,
  0xC1, 0x38, 0xE2, 0x40, 0x65, 0x00, 0x4C, 0x00, 0xD8, 0x00, 0xB0, 0x01,
  0x60, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xB0, 0x01, 0x60, 0x06, 0xA0, 0x0D, 0x40, 0x32, 0x60, 0xC4, 0x7F,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x00, 0x07, 0xC6, 0x38, 0xEC, 0xC0, 0x5B,
  0x00, 0x74, 0x00, 0xE8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xA0, 0x07,
  0x60, 0x0E, 0xC0, 0x2C, 0xE0, 0xD8, 0xFE, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x87, 0xCE, 0xEC, 0x14, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x00,
  0x0F, 0xC1, 0xC3, 0x98, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0xB8, 0x18, 0xFF, 0x80, 0x30, 0x18, 0x0C,
  0x06, 0x07, 0xFF, 0xFC, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x3F,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x70, 0x03, 0xC0, 0x1A, 0x01, 0x58, 0x12, 0x7F, 0x10, 0xC0, 0x07, 0x80,
  0x09, 0x00, 0x33, 0x00, 0x66, 0x00, 0x84, 0x03, 0x0C, 0x06, 0x18, 0x08,
  0x10, 0x30, 0x30, 0x60, 0x60, 0x80, 0x43, 0x00, 0xC6, 0x01, 0x88, 0x01,
  0x30, 0x02, 0x60, 0x06, 0x80, 0x05, 0x00, 0x0E, 0x00, 0x18, 0x00, 0xC0,
  0x18, 0x02, 0x80, 0x30, 0x05, 0x00, 0x60, 0x1B, 0x01, 0xE0, 0x22, 0x03,
  0x40, 0x44, 0x04, 0x80, 0x8C, 0x09, 0x83, 0x18, 0x33, 0x04, 0x10, 0x42,
  0x08, 0x20, 0x84, 0x10, 0x63, 0x0C, 0x60, 0xC6, 0x08, 0x80, 0x88, 0x11,
  0x01, 0x10, 0x22, 0x03, 0x60, 0x6C, 0x06, 0x80, 0x50, 0x05, 0x00, 0xA0,
  0x0A, 0x01, 0x40, 0x1C, 0x03, 0x80, 0x30, 0x02, 0x00, 0xC0, 0x0D, 0x00,
  0x66, 0x01, 0x0C, 0x0C, 0x10, 0x20, 0x61, 0x80, 0x8C, 0x01, 0x20, 0x07,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0xE0, 0x0C, 0x80, 0x23, 0x01, 0x86, 0x04,
  0x08, 0x30, 0x31, 0x80, 0x44, 0x01, 0xB0, 0x03, 0xC0, 0x06, 0x80, 0x09,
  0x00, 0x13, 0x00, 0x62, 0x00, 0x84, 0x01, 0x0C, 0x06, 0x08, 0x08, 0x10,
  0x10, 0x30, 0x60, 0x20, 0x80, 0x41, 0x00, 0xC6, 0x00, 0x88, 0x01, 0x10,
  0x03, 0x60, 0x02, 0x80, 0x05, 0x00, 0x0E, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x05, 0xC0,
  0x0F, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0F, 0xFF, 0x03, 0xC1, 0x80,
  0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x02, 0x01, 0x83, 0x80, 0x70, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x3C,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0F, 0x03, 0xC0, 0x40,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x40, 0x18, 0x1E, 0x07, 0x00, 0x3C, 0x03, 0xDE, 0x06, 0x07,
  0xFC, 0x01, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 26, 8, 3, -26 },
  { 8, 7, 9, 12, 3, -26 },
  { 16, 19, 26, 21, 1, -26 },
  { 78, 14, 30, 19, 2, -28 },
  { 131, 23, 27, 27, 2, -27 },
  { 209, 19, 27, 22, 2, -27 },
  { 274, 1, 9, 7, 3, -26 },
  { 276, 7, 32, 10, 2, -26 },
  { 304, 7, 32, 10, 1, -26 },
  { 332, 14, 13, 18, 2, -28 },
  { 355, 15, 18, 19, 2, -22 },
  { 389, 4, 9, 7, 1, -4 },
  { 394, 9, 2, 11, 1, -11 },
  { 397, 2, 3, 8, 3, -3 },
  { 398, 11, 26, 12, 1, -26 },
  { 434, 15, 27, 19, 2, -27 },
  { 485, 8, 26, 19, 3, -26 },
  { 511, 14, 27, 19, 2, -27 },
  { 559, 14, 27, 19, 2, -27 },
  { 607, 17, 27, 19, 1, -27 },
  { 665, 15, 26, 19, 2, -26 },
  { 714, 15, 27, 19, 2, -27 },
  { 765, 15, 26, 19, 2, -26 },
  { 814, 15, 27, 19, 2, -27 },
  { 865, 15, 27, 19, 2, -27 },
  { 916, 2, 20, 8, 3, -20 },
  { 921, 4, 25, 8, 1, -20 },
  { 934, 15, 16, 19, 2, -21 },
  { 964, 15, 9, 19, 2, -18 },
  { 981, 15, 16, 19, 2, -21 },
  { 1011, 11, 27, 14, 1, -27 },
  { 1049, 25, 30, 29, 2, -26 },
  { 1143, 19, 26, 19, 0, -26 },
  { 1205, 16, 26, 21, 3, -26 },
  { 1257, 17, 27, 20, 2, -27 },
  { 1315, 18, 26, 23, 3, -26 },
  { 1374, 13, 26, 18, 3, -26 },
  { 1417, 13, 26, 17, 3, -26 },
  { 1460, 19, 27, 24, 2, -27 },
  { 1525, 17, 26, 23, 3, -26 },
  { 1581, 6, 26, 10, 2, -26 },
  { 1601, 8, 33, 8, -3, -26 },
  { 1634, 16, 26, 19, 3, -26 },
  { 1686, 13, 26, 17, 3, -26 },
  { 1729, 23, 26, 29, 3, -26 },
  { 1804, 17, 26, 24, 3, -26 },
  { 1860, 21, 27, 25, 2, -27 },
  { 1931, 14, 26, 19, 3, -26 },
  { 1977, 21, 33, 25, 2, -27 },
  { 2064, 16, 26, 19, 3, -26 },
  { 2116, 14, 27, 18, 2, -27 },
  { 2164, 17, 26, 17, 0, -26 },
  { 2220, 17, 26, 23, 3, -26 },
  { 2276, 19, 26, 19, 0, -26 },
  { 2338, 28, 26, 30, 1, -26 },
  { 2429, 17, 26, 17, 0, -26 },
  { 2485, 17, 26, 17, 0, -26 },
  { 2541, 16, 26, 18, 1, -26 },
  { 2593, 8, 32, 12, 3, -26 },
  { 2625, 11, 26, 12, 1, -26 },
  { 2661, 7, 32, 12, 1, -26 },
  { 2689, 17, 16, 19, 1, -27 },
  { 2723, 15, 2, 15, 0, 3 },
  { 2727, 7, 6, 9, 1, -28 },
  { 2733, 12, 20, 17, 2, -20 },
  { 2763, 15, 28, 20, 3, -28 },
  { 2816, 12, 20, 15, 2, -20 },
  { 2846, 15, 28, 20, 2, -28 },
  { 2899, 14, 20, 18, 2, -20 },
  { 2934, 11, 28, 10, 0, -28 },
  { 2973, 15, 29, 20, 2, -20 },
  { 3028, 13, 28, 19, 3, -28 },
  { 3074, 2, 27, 8, 3, -27 },
  { 3081, 6, 36, 8, -1, -27 },
  { 3108, 13, 28, 16, 3, -28 },
  { 3154, 1, 28, 7, 3, -28 },
  { 3158, 23, 20, 29, 3, -20 },
  { 3216, 13, 20, 19, 3, -20 },
  { 3249, 15, 20, 19, 2, -20 },
  { 3287, 15, 29, 20, 3, -20 },
  { 3342, 15, 29, 20, 2, -20 },
  { 3397, 9, 20, 13, 3, -20 },
  { 3420, 13, 20, 15, 1, -20 },
  { 3453, 9, 24, 11, 1, -24 },
  { 3480, 13, 20, 19, 3, -20 },
  { 3513, 15, 20, 15, 0, -20 },
  { 3551, 23, 20, 24, 0, -20 },
  { 3609, 14, 20, 16, 1, -20 },
  { 3644, 15, 29, 15, 0, -20 },
  { 3699, 12, 20, 14, 1, -20 },
  { 3729, 10, 32, 13, 1, -26 },
  { 3769, 2, 37, 18, 8, -28 },
  { 3779, 11, 32, 13, 1, -26 },
  { 3823, 15, 4, 19, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight37pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT37PT7B_H_
