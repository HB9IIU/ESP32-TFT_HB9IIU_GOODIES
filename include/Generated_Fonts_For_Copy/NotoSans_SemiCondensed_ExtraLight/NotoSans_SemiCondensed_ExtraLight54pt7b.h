#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT54PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight54pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x06, 0xFF, 0xF0, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x20, 0x00, 0x18,
  0x06, 0x00, 0x01, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x40, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x08, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x40, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0xC0, 0x10, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x80, 0x30, 0x00,
  0x18, 0x03, 0x00, 0x01, 0x80, 0x30, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xE0, 0x18, 0x06, 0x00, 0x01, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x40, 0x00, 0x30,
  0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0x31, 0xF0,
  0xE1, 0x81, 0x8E, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x03, 0x00, 0x30, 0x18,
  0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x1C,
  0x0C, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x0F, 0x18, 0x00, 0x1E, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x0D, 0xF0, 0x00,
  0x63, 0xC0, 0x03, 0x07, 0x00, 0x18, 0x1C, 0x00, 0xC0, 0x60, 0x06, 0x03,
  0x00, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x38, 0x03,
  0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0xC8, 0x06, 0x0E, 0x7C, 0x33, 0xC1,
  0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x60, 0x0F, 0xF0, 0x00, 0x60,
  0x0C, 0x18, 0x00, 0x30, 0x0C, 0x06, 0x00, 0x30, 0x06, 0x03, 0x00, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x06, 0x00, 0x30, 0x06, 0x03,
  0x00, 0x18, 0x03, 0x03, 0x00, 0x0C, 0x01, 0x81, 0x80, 0x06, 0x00, 0xC0,
  0x80, 0x03, 0x00, 0x60, 0xC0, 0x01, 0x80, 0x30, 0x60, 0xE0, 0xC0, 0x18,
  0x61, 0xFC, 0x60, 0x0C, 0x31, 0xC7, 0x18, 0x06, 0x31, 0xC1, 0xCC, 0x06,
  0x18, 0xC0, 0x66, 0x03, 0x18, 0x60, 0x31, 0x83, 0x0C, 0x60, 0x0C, 0x7F,
  0x0C, 0x30, 0x06, 0x1F, 0x06, 0x18, 0x03, 0x00, 0x06, 0x0C, 0x01, 0x80,
  0x03, 0x06, 0x00, 0xC0, 0x03, 0x03, 0x00, 0x60, 0x01, 0x81, 0x80, 0x30,
  0x01, 0x80, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x0C, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x0C, 0x00, 0x70,
  0x70, 0x0C, 0x00, 0x1C, 0x70, 0x0E, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xE0, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x00,
  0xC0, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60,
  0x38, 0x00, 0x03, 0x07, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xBC, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x01, 0xC1, 0xC0, 0x06, 0x38, 0x0C, 0x00, 0x67, 0x00, 0x60,
  0x06, 0x60, 0x03, 0x00, 0xCC, 0x00, 0x38, 0x0C, 0xC0, 0x01, 0xC0, 0xCC,
  0x00, 0x0E, 0x18, 0xC0, 0x00, 0x71, 0x8C, 0x00, 0x03, 0x30, 0xC0, 0x00,
  0x1B, 0x0C, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xF0,
  0x60, 0x00, 0x3B, 0x87, 0x00, 0x07, 0x18, 0x38, 0x01, 0xE0, 0xC1, 0xF9,
  0xF8, 0x0E, 0x07, 0xFE, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xC0, 0x70, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x1C,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x06,
  0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06,
  0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x60, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x80, 0x60, 0x1F, 0x06, 0x0F, 0xFC, 0x67, 0xE0,
  0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0x90, 0x00, 0x19, 0x80,
  0x03, 0x0C, 0x00, 0x60, 0xE0, 0x0E, 0x06, 0x01, 0xC0, 0x30, 0x18, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x18, 0xC6, 0x73, 0x18, 0xC6, 0x63, 0x19, 0x8C, 0x00, 0xFF, 0xFF,
  0xFF, 0x6F, 0xFE, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0xF8, 0x03, 0xC0, 0xE0, 0x18, 0x03, 0x81, 0x80, 0x0E, 0x1C, 0x00,
  0x30, 0xC0, 0x01, 0xC6, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0xD8,
  0x00, 0x06, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x36, 0x00,
  0x01, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0xCE, 0x00, 0x06, 0x30, 0x00, 0x31,
  0x80, 0x03, 0x06, 0x00, 0x18, 0x38, 0x01, 0x80, 0xE0, 0x18, 0x03, 0xE7,
  0x80, 0x07, 0xF8, 0x00, 0x00, 0x60, 0x1C, 0x07, 0x83, 0xB0, 0xE6, 0x38,
  0xCE, 0x1F, 0x83, 0xC0, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xFC,
  0x00, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0xE0, 0x03, 0x84, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xC0,
  0x1C, 0x1C, 0x00, 0x38, 0x60, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x20, 0x00, 0x1C, 0xE0, 0x01, 0xE3, 0xF8,
  0x3F, 0x01, 0xFF, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x30,
  0x30, 0x00, 0x18, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0x30, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00,
  0xC0, 0x30, 0x00, 0x30, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x67, 0xFC, 0x03, 0xFF,
  0xFC, 0x0C, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x19, 0x00, 0x01,
  0xCE, 0x00, 0x3C, 0x7F, 0x1F, 0x80, 0x7F, 0xF8, 0x00, 0x10, 0x00, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x1E, 0x01, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x1F, 0x00, 0xE3, 0xFF, 0x83, 0x1E, 0x0F,
  0x0C, 0xC0, 0x0E, 0x36, 0x00, 0x1C, 0xD0, 0x00, 0x33, 0xC0, 0x00, 0x6E,
  0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x76, 0x00, 0x01,
  0x98, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xE1, 0x80, 0x03, 0x07,
  0x00, 0x18, 0x0E, 0x00, 0xE0, 0x1F, 0x1F, 0x00, 0x1F, 0xF0, 0x00, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xE0, 0x1C, 0x06, 0x00, 0x38,
  0x30, 0x00, 0x71, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60,
  0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x70, 0xE0, 0x01, 0x81, 0xC0, 0x0C, 0x03, 0x80, 0xE0, 0x07, 0x87, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0x07, 0x07, 0x00, 0x78,
  0x0F, 0x03, 0x80, 0x0E, 0x0C, 0x00, 0x1C, 0x60, 0x00, 0x33, 0x80, 0x00,
  0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x66, 0x00,
  0x03, 0x0C, 0x00, 0x1C, 0x3C, 0x00, 0xE0, 0x3C, 0x1F, 0x00, 0x7F, 0xF0,
  0x00, 0x08, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0x81, 0xE0, 0x70,
  0x03, 0x83, 0x00, 0x0C, 0x30, 0x00, 0x31, 0x80, 0x01, 0x98, 0x00, 0x06,
  0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xD8, 0x00, 0x1E, 0xE0, 0x00, 0xB3, 0x00, 0x0D, 0x8E, 0x01,
  0xCC, 0x3F, 0xFC, 0x60, 0xFF, 0x83, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x18, 0x7E, 0x00, 0xFF, 0xC0, 0x00, 0xF0, 0x00,
  0x6F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0xFF, 0xE0, 0x18, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x18, 0xE3, 0x8C,
  0x30, 0xC7, 0x18, 0x61, 0x8C, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xFE, 0x1C, 0x07, 0x88, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x07, 0x00, 0x18, 0x60, 0x03, 0xFF, 0x80, 0xC6, 0x00, 0x38, 0x1C,
  0x03, 0x30, 0x03, 0x00, 0x60, 0x19, 0x80, 0x30, 0x03, 0x00, 0xCC, 0x03,
  0x00, 0x10, 0x06, 0xC0, 0x18, 0x01, 0x80, 0x36, 0x01, 0x80, 0x0C, 0x00,
  0xB0, 0x0C, 0x00, 0x60, 0x07, 0x80, 0x60, 0x03, 0x00, 0x3C, 0x03, 0x00,
  0x18, 0x01, 0xE0, 0x18, 0x00, 0xC0, 0x1B, 0x00, 0xC0, 0x06, 0x00, 0xD8,
  0x06, 0x00, 0x30, 0x06, 0xC0, 0x30, 0x01, 0x80, 0x36, 0x01, 0x80, 0x0C,
  0x01, 0xB0, 0x0C, 0x00, 0xE0, 0x09, 0x80, 0x70, 0x05, 0x00, 0xCC, 0x01,
  0x80, 0x6C, 0x0E, 0x30, 0x06, 0x06, 0x70, 0xE1, 0x80, 0x3F, 0xE1, 0xFE,
  0x0C, 0x00, 0x7E, 0x07, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x07, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x18, 0x01, 0x80, 0x01,
  0x80, 0x18, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x60, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x30, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x0C, 0x01, 0xFC, 0x30, 0x00, 0x38,
  0xC0, 0x00, 0x73, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0,
  0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0xEC, 0x00, 0x03, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0xE3,
  0x00, 0x1E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xC0, 0x01, 0xE3, 0x00,
  0x01, 0xCC, 0x00, 0x03, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x6C, 0x00,
  0x03, 0xB0, 0x00, 0x1C, 0xC0, 0x01, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3C, 0x01, 0xE0, 0x78,
  0x00, 0x10, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x10, 0x07, 0xF3, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x02, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x30, 0x07, 0xF0, 0x18, 0x00, 0x3C, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x71, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x06, 0x60, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x19, 0x80, 0x00, 0x1C, 0xC0, 0x00,
  0x1C, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x0C, 0x00,
  0x7C, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0xF8, 0x01, 0xF0, 0x1C, 0x00, 0x02, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x03, 0x38, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x38, 0x00, 0x03, 0x01, 0xE0,
  0x00, 0x70, 0x0F, 0xF1, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC6,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x83, 0xFB, 0xFE, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x03, 0xB1, 0xE7, 0xF8, 0x38,
  0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xEC, 0x00, 0x03, 0x30, 0x00, 0x18,
  0xC0, 0x00, 0xE3, 0x00, 0x07, 0x0C, 0x00, 0x38, 0x30, 0x01, 0xC0, 0xC0,
  0x0E, 0x03, 0x00, 0x30, 0x0C, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0xC0, 0x70,
  0x03, 0x03, 0x80, 0x0C, 0x1C, 0x00, 0x30, 0x60, 0x00, 0xC3, 0x00, 0x03,
  0x1E, 0x00, 0x0C, 0xF8, 0x00, 0x37, 0x70, 0x00, 0xD8, 0xC0, 0x03, 0xC1,
  0x80, 0x0E, 0x07, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x38, 0x03, 0x00, 0x70,
  0x0C, 0x00, 0xC0, 0x30, 0x03, 0x80, 0xC0, 0x07, 0x03, 0x00, 0x0C, 0x0C,
  0x00, 0x38, 0x30, 0x00, 0x70, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x8C, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xD8, 0x00, 0x00, 0x1B, 0xD8, 0x00, 0x00, 0x1B, 0xCC, 0x00, 0x00,
  0x1B, 0xCC, 0x00, 0x00, 0x33, 0xCC, 0x00, 0x00, 0x33, 0xC6, 0x00, 0x00,
  0x73, 0xC6, 0x00, 0x00, 0x63, 0xC7, 0x00, 0x00, 0x63, 0xC3, 0x00, 0x00,
  0xC3, 0xC3, 0x00, 0x00, 0xC3, 0xC1, 0x80, 0x00, 0xC3, 0xC1, 0x80, 0x01,
  0x83, 0xC1, 0x80, 0x01, 0x83, 0xC0, 0xC0, 0x01, 0x83, 0xC0, 0xC0, 0x03,
  0x03, 0xC0, 0xC0, 0x03, 0x03, 0xC0, 0x60, 0x07, 0x03, 0xC0, 0x60, 0x06,
  0x03, 0xC0, 0x70, 0x06, 0x03, 0xC0, 0x30, 0x0C, 0x03, 0xC0, 0x30, 0x0C,
  0x03, 0xC0, 0x18, 0x0C, 0x03, 0xC0, 0x18, 0x18, 0x03, 0xC0, 0x18, 0x18,
  0x03, 0xC0, 0x0C, 0x38, 0x03, 0xC0, 0x0C, 0x30, 0x03, 0xC0, 0x0C, 0x30,
  0x03, 0xC0, 0x06, 0x60, 0x03, 0xC0, 0x06, 0x60, 0x03, 0xC0, 0x07, 0x60,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3E, 0xC0, 0x00, 0x1F,
  0x70, 0x00, 0x0F, 0x98, 0x00, 0x07, 0xC6, 0x00, 0x03, 0xE3, 0x00, 0x01,
  0xF0, 0xC0, 0x00, 0xF8, 0x70, 0x00, 0x7C, 0x18, 0x00, 0x3E, 0x0E, 0x00,
  0x1F, 0x03, 0x00, 0x0F, 0x80, 0xC0, 0x07, 0xC0, 0x70, 0x03, 0xE0, 0x18,
  0x01, 0xF0, 0x0E, 0x00, 0xF8, 0x03, 0x00, 0x7C, 0x00, 0xC0, 0x3E, 0x00,
  0x70, 0x1F, 0x00, 0x18, 0x0F, 0x80, 0x0E, 0x07, 0xC0, 0x03, 0x03, 0xE0,
  0x01, 0xC1, 0xF0, 0x00, 0x60, 0xF8, 0x00, 0x18, 0x7C, 0x00, 0x0E, 0x3E,
  0x00, 0x03, 0x0F, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x63, 0xC0, 0x00, 0x19,
  0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x06, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x1C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0xC0, 0x3F, 0x8C, 0x00, 0x3C, 0xC0,
  0x00, 0xEC, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x00,
  0xCC, 0x00, 0x3C, 0xC0, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF, 0xE0, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x07, 0xF1,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0x58, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x0C, 0x07, 0xF8, 0x30,
  0x00, 0xF0, 0xC0, 0x00, 0xE3, 0x00, 0x01, 0x8C, 0x00, 0x07, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C,
  0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x1C, 0xC0,
  0x00, 0x63, 0x00, 0x03, 0x0C, 0x00, 0x1C, 0x30, 0x01, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xC0, 0x0C, 0x03,
  0x00, 0x38, 0x0C, 0x00, 0x60, 0x30, 0x01, 0xC0, 0xC0, 0x03, 0x03, 0x00,
  0x0E, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xE3, 0x00, 0x01,
  0x8C, 0x00, 0x07, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x6C,
  0x00, 0x01, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x07, 0x80, 0x3C, 0x70,
  0x00, 0x27, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xCC, 0x00, 0x3C, 0x7F, 0x1F, 0xC1, 0xFF, 0xF8, 0x00, 0x18, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0xC0, 0x00,
  0x06, 0x60, 0x00, 0x07, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x87, 0x00,
  0x03, 0x81, 0xE0, 0x07, 0x80, 0x7F, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0x00,
  0x78, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0x80, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x38, 0x03,
  0x80, 0x03, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xD8, 0x00, 0x07, 0x00, 0x00, 0x6C, 0x00, 0x03, 0x80, 0x00, 0x66, 0x00,
  0x03, 0x60, 0x00, 0x33, 0x00, 0x01, 0xB0, 0x00, 0x18, 0xC0, 0x00, 0xD8,
  0x00, 0x0C, 0x60, 0x00, 0x6C, 0x00, 0x0C, 0x30, 0x00, 0x73, 0x00, 0x06,
  0x18, 0x00, 0x31, 0x80, 0x03, 0x06, 0x00, 0x18, 0xC0, 0x03, 0x83, 0x00,
  0x0C, 0x60, 0x01, 0x81, 0x80, 0x06, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x0C,
  0x00, 0x60, 0x30, 0x03, 0x06, 0x00, 0x70, 0x18, 0x01, 0x83, 0x00, 0x30,
  0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x01, 0x80,
  0x60, 0x30, 0x0E, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x00, 0x60, 0x18, 0x06,
  0x03, 0x00, 0x30, 0x18, 0x03, 0x01, 0x80, 0x0C, 0x0C, 0x01, 0x81, 0xC0,
  0x06, 0x06, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x30, 0x60, 0x01, 0x83,
  0x00, 0x18, 0x30, 0x00, 0x61, 0x80, 0x0C, 0x38, 0x00, 0x30, 0xC0, 0x06,
  0x18, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00,
  0x03, 0x30, 0x00, 0x67, 0x00, 0x01, 0x98, 0x00, 0x33, 0x00, 0x00, 0xCC,
  0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x1E, 0x00, 0x03,
  0x60, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x83, 0x00, 0x01, 0x80, 0xC0,
  0x01, 0xC0, 0x60, 0x00, 0xC0, 0x18, 0x00, 0xE0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x70, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x38, 0x00, 0x38, 0x18, 0x00,
  0x0C, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x18, 0x00, 0x30, 0x06, 0x00, 0x38, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x1C,
  0x00, 0x70, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x06,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x63, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x70, 0x00, 0x06,
  0x30, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x18,
  0x0C, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x03, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x01, 0x81, 0xC0, 0x01, 0x81, 0x80,
  0x00, 0xC1, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x66, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x81, 0x80, 0x03,
  0x81, 0x80, 0x03, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0x60, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x18, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0x70, 0x0E,
  0x08, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x01, 0xFF, 0xC1, 0xFC, 0x18, 0xF0, 0x03, 0x38, 0x00, 0x6E, 0x00, 0x0D,
  0x80, 0x01, 0xB0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0x60, 0x01, 0xEC, 0x00, 0x6C, 0xC0, 0x19, 0x9F, 0x0E, 0x30,
  0xFF, 0x86, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0xFE, 0x03, 0x0F, 0xFE, 0x0C, 0x70, 0x1C, 0x33, 0x00,
  0x38, 0xD8, 0x00, 0x73, 0x40, 0x00, 0xCF, 0x00, 0x03, 0xB8, 0x00, 0x06,
  0xE0, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x06, 0xE0, 0x00, 0x1B,
  0x80, 0x00, 0x6E, 0x00, 0x03, 0xBC, 0x00, 0x0C, 0xD0, 0x00, 0x73, 0x60,
  0x03, 0x8C, 0xC0, 0x1C, 0x31, 0xE3, 0xE0, 0xC3, 0xFF, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x70, 0x0C, 0x38, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x04, 0x1F, 0x1F, 0x03, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x1F, 0xC1, 0x83, 0xFF, 0x8C, 0x38, 0x06,
  0x63, 0x80, 0x1B, 0x38, 0x00, 0x79, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xC0,
  0x00, 0x76, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1B,
  0x00, 0x00, 0xD8, 0x00, 0x0E, 0xE0, 0x00, 0x73, 0x00, 0x07, 0x9C, 0x00,
  0x64, 0x70, 0x07, 0x21, 0xF0, 0xF1, 0x03, 0xFE, 0x08, 0x01, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0E, 0x03, 0x81, 0xC0, 0x1C, 0x38, 0x00,
  0xE3, 0x00, 0x06, 0x70, 0x00, 0x66, 0x00, 0x03, 0x60, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x20, 0x7C, 0x7E, 0x03, 0xFF,
  0xC0, 0x01, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1F, 0xF0, 0xFF, 0xF0, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x01, 0xFE, 0x08, 0x3F, 0xF8, 0xC3, 0x80, 0x66, 0x38, 0x01, 0xB3,
  0x80, 0x07, 0x98, 0x00, 0x1D, 0xC0, 0x00, 0xEC, 0x00, 0x03, 0x60, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xB0, 0x00, 0x1D, 0x80,
  0x00, 0xEE, 0x00, 0x07, 0x30, 0x00, 0x79, 0xC0, 0x06, 0xC7, 0x00, 0x66,
  0x1F, 0x1E, 0x30, 0x3F, 0xE1, 0x80, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x39, 0x00, 0x03, 0x8F, 0x00, 0x78, 0x3F, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0xFE,
  0x0C, 0x3F, 0xF8, 0xC6, 0x01, 0xCC, 0xC0, 0x0E, 0xD8, 0x00, 0x6D, 0x00,
  0x06, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0xFF,
  0xB0, 0x00, 0x01, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xD8, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0xBF, 0x9F,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x1D, 0x80, 0x03, 0x30, 0x00,
  0xC6, 0x00, 0x30, 0xC0, 0x0E, 0x18, 0x03, 0x83, 0x00, 0x60, 0x60, 0x18,
  0x0C, 0x06, 0x01, 0x81, 0xC0, 0x30, 0x70, 0x06, 0x0C, 0x00, 0xC3, 0x80,
  0x18, 0xF0, 0x03, 0x37, 0x00, 0x6C, 0x60, 0x0D, 0x86, 0x01, 0xE0, 0xE0,
  0x38, 0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x1C, 0x18, 0x01, 0x83, 0x00, 0x38,
  0x60, 0x03, 0x0C, 0x00, 0x31, 0x80, 0x07, 0x30, 0x00, 0x66, 0x00, 0x0E,
  0xC0, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC1, 0xFC, 0x01, 0xF8, 0x31,
  0xFF, 0x81, 0xFF, 0x8C, 0xE0, 0x70, 0xC0, 0x73, 0x20, 0x0E, 0x60, 0x0E,
  0xD0, 0x01, 0xB0, 0x01, 0xBC, 0x00, 0x38, 0x00, 0x6E, 0x00, 0x0E, 0x00,
  0x0F, 0x80, 0x03, 0x80, 0x03, 0xE0, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x30,
  0x00, 0x3E, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00,
  0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C,
  0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00,
  0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C,
  0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0xC0,
  0xFE, 0x0C, 0x3F, 0xF8, 0xC6, 0x01, 0xCC, 0xC0, 0x0E, 0xD8, 0x00, 0x6D,
  0x00, 0x06, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x30,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x38, 0x38,
  0x00, 0x70, 0xC0, 0x00, 0xC6, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00,
  0x1B, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1D, 0x80, 0x00,
  0x66, 0x00, 0x01, 0x8C, 0x00, 0x0E, 0x30, 0x00, 0x30, 0x60, 0x01, 0x81,
  0xE0, 0x0E, 0x01, 0xF3, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0xFE, 0x03, 0x0F, 0xFE, 0x0C, 0x70, 0x1C, 0x33, 0x00, 0x38, 0xD8, 0x00,
  0x73, 0x40, 0x00, 0xCF, 0x00, 0x03, 0xBC, 0x00, 0x06, 0xE0, 0x00, 0x1B,
  0x80, 0x00, 0x6E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x6F,
  0x00, 0x03, 0xB4, 0x00, 0x0C, 0xD8, 0x00, 0x73, 0x30, 0x01, 0x8E, 0xE0,
  0x1C, 0x39, 0xF3, 0xE0, 0xE1, 0xFF, 0x03, 0x80, 0x40, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x18, 0x3F, 0xF8,
  0xC3, 0x80, 0xE6, 0x38, 0x01, 0xB3, 0x80, 0x07, 0x98, 0x00, 0x1D, 0x80,
  0x00, 0xEC, 0x00, 0x07, 0x60, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0xEE, 0x00, 0x07, 0x30, 0x00,
  0x79, 0xC0, 0x06, 0xC7, 0x00, 0x66, 0x1E, 0x1E, 0x30, 0x7F, 0xE1, 0x80,
  0x70, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0xC1, 0xFF,
  0x0F, 0xFC, 0x70, 0x33, 0x00, 0xD8, 0x03, 0x40, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x03, 0xFE, 0x03, 0xFF, 0xE3, 0xC0, 0x38, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x6C,
  0x00, 0x73, 0xF0, 0xF8, 0x3F, 0xFC, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x07, 0xFF, 0xFF, 0xF8,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0xE2, 0x07, 0xF0, 0x06, 0x00, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x0F, 0x60, 0x00,
  0xB7, 0x00, 0x1B, 0x38, 0x07, 0x31, 0xE3, 0xE3, 0x0F, 0xF8, 0x30, 0x18,
  0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xD8, 0x00, 0x0E, 0xC0, 0x00, 0x67,
  0x00, 0x03, 0x18, 0x00, 0x38, 0xC0, 0x01, 0x87, 0x00, 0x0C, 0x18, 0x00,
  0xE0, 0xC0, 0x06, 0x07, 0x00, 0x30, 0x18, 0x03, 0x80, 0xC0, 0x18, 0x07,
  0x00, 0xC0, 0x18, 0x0E, 0x00, 0xC0, 0x60, 0x07, 0x03, 0x00, 0x18, 0x38,
  0x00, 0xC1, 0x80, 0x07, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC6, 0x00, 0x06,
  0x30, 0x00, 0x19, 0x80, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xCC, 0x00, 0x2C, 0x00, 0x66, 0x00,
  0x36, 0x00, 0x33, 0x00, 0x1B, 0x00, 0x19, 0x80, 0x0D, 0x80, 0x18, 0x60,
  0x06, 0x60, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x18, 0x03, 0x18, 0x03, 0x0C,
  0x01, 0x8C, 0x03, 0x03, 0x01, 0x83, 0x01, 0x81, 0x80, 0xC1, 0x80, 0xC0,
  0xC0, 0x60, 0xC0, 0x60, 0x70, 0x70, 0x30, 0x60, 0x18, 0x30, 0x18, 0x30,
  0x0C, 0x18, 0x0C, 0x18, 0x06, 0x0C, 0x06, 0x0C, 0x03, 0x8C, 0x01, 0x8C,
  0x00, 0xC6, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x63, 0x00, 0x33, 0x80, 0x19,
  0x80, 0x0D, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x03,
  0x60, 0x01, 0xA0, 0x00, 0xB0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x33, 0x80, 0x03, 0x8C,
  0x00, 0x18, 0x30, 0x01, 0xC1, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x38, 0x0E,
  0x00, 0xC0, 0x60, 0x03, 0x06, 0x00, 0x1C, 0x30, 0x00, 0x63, 0x00, 0x01,
  0xB8, 0x00, 0x0D, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xD8, 0x00, 0x0E, 0x60, 0x00, 0x63, 0x00, 0x06, 0x0C, 0x00, 0x70,
  0x70, 0x03, 0x01, 0x80, 0x38, 0x06, 0x01, 0x80, 0x30, 0x18, 0x00, 0xC1,
  0xC0, 0x07, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x1D, 0x80, 0x00, 0x66, 0x00, 0x01, 0x9C, 0x00, 0x0E, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0xC3, 0x80, 0x07, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60,
  0x70, 0x03, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0E, 0x01, 0xC0, 0x18,
  0x06, 0x00, 0x60, 0x18, 0x01, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C,
  0x00, 0x38, 0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x02, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x58, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x02, 0x00,
  0xFC, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x07, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x1F, 0x00, 0x3E, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x07, 0xC0, 0x3F, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x7F, 0xC0, 0x05, 0xC3, 0xE0, 0x1E, 0x00, 0xFC, 0xF8, 0x00,
  0x7F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 39, 12, 4, -39 },
  { 21, 10, 14, 18, 4, -39 },
  { 39, 28, 39, 31, 1, -39 },
  { 176, 21, 44, 27, 3, -41 },
  { 292, 33, 40, 39, 3, -39 },
  { 457, 28, 40, 32, 3, -39 },
  { 597, 2, 14, 10, 4, -39 },
  { 601, 10, 48, 14, 2, -39 },
  { 661, 10, 48, 14, 2, -39 },
  { 721, 20, 19, 26, 3, -41 },
  { 769, 23, 25, 28, 2, -32 },
  { 841, 5, 13, 11, 2, -6 },
  { 850, 12, 2, 16, 2, -16 },
  { 853, 4, 4, 12, 4, -4 },
  { 855, 16, 39, 18, 1, -39 },
  { 933, 21, 39, 27, 3, -39 },
  { 1036, 11, 39, 27, 5, -39 },
  { 1090, 21, 39, 27, 3, -39 },
  { 1193, 22, 40, 27, 2, -39 },
  { 1303, 26, 39, 27, 1, -39 },
  { 1430, 21, 40, 27, 3, -39 },
  { 1535, 22, 40, 27, 3, -39 },
  { 1645, 22, 39, 27, 3, -39 },
  { 1753, 22, 40, 27, 3, -39 },
  { 1863, 21, 40, 27, 3, -39 },
  { 1968, 4, 29, 12, 4, -29 },
  { 1983, 6, 36, 12, 2, -29 },
  { 2010, 23, 24, 28, 2, -31 },
  { 2079, 23, 13, 28, 2, -26 },
  { 2117, 23, 24, 28, 2, -31 },
  { 2186, 17, 39, 20, 1, -39 },
  { 2269, 37, 43, 42, 3, -38 },
  { 2468, 28, 39, 28, 0, -39 },
  { 2605, 22, 39, 30, 5, -39 },
  { 2713, 25, 40, 29, 3, -39 },
  { 2838, 25, 39, 33, 5, -39 },
  { 2960, 18, 39, 26, 5, -39 },
  { 3048, 18, 39, 24, 5, -39 },
  { 3136, 28, 40, 35, 3, -39 },
  { 3276, 24, 39, 34, 5, -39 },
  { 3393, 9, 39, 15, 3, -39 },
  { 3437, 11, 49, 12, -4, -39 },
  { 3505, 22, 39, 27, 5, -39 },
  { 3613, 18, 39, 24, 5, -39 },
  { 3701, 32, 39, 42, 5, -39 },
  { 3857, 25, 39, 35, 5, -39 },
  { 3979, 30, 40, 36, 3, -39 },
  { 4129, 20, 39, 28, 5, -39 },
  { 4227, 30, 48, 36, 3, -39 },
  { 4407, 22, 39, 28, 5, -39 },
  { 4515, 21, 40, 26, 3, -39 },
  { 4620, 24, 39, 24, 0, -39 },
  { 4737, 25, 40, 34, 5, -39 },
  { 4862, 27, 39, 27, 0, -39 },
  { 4994, 41, 39, 43, 1, -39 },
  { 5194, 25, 39, 25, 0, -39 },
  { 5316, 24, 39, 24, 0, -39 },
  { 5433, 23, 39, 26, 2, -39 },
  { 5546, 10, 48, 17, 5, -39 },
  { 5606, 16, 39, 18, 1, -39 },
  { 5684, 10, 48, 17, 2, -39 },
  { 5744, 24, 22, 28, 2, -39 },
  { 5810, 22, 2, 22, 0, 5 },
  { 5816, 9, 8, 13, 2, -41 },
  { 5825, 19, 30, 25, 2, -29 },
  { 5897, 22, 42, 29, 4, -41 },
  { 6013, 18, 30, 23, 3, -29 },
  { 6081, 21, 42, 29, 3, -41 },
  { 6192, 20, 30, 26, 3, -29 },
  { 6267, 16, 41, 14, 1, -41 },
  { 6349, 21, 42, 29, 3, -29 },
  { 6460, 20, 41, 28, 4, -41 },
  { 6563, 3, 39, 11, 4, -39 },
  { 6578, 9, 52, 11, -2, -39 },
  { 6637, 19, 41, 23, 4, -41 },
  { 6735, 3, 41, 11, 4, -41 },
  { 6751, 34, 29, 42, 4, -29 },
  { 6875, 20, 29, 28, 4, -29 },
  { 6948, 22, 30, 28, 3, -29 },
  { 7031, 22, 42, 29, 4, -29 },
  { 7147, 21, 42, 29, 3, -29 },
  { 7258, 14, 29, 18, 4, -29 },
  { 7309, 18, 30, 22, 2, -29 },
  { 7377, 13, 37, 16, 1, -36 },
  { 7438, 20, 30, 28, 4, -29 },
  { 7513, 21, 29, 21, 0, -29 },
  { 7590, 33, 29, 35, 1, -29 },
  { 7710, 21, 29, 23, 1, -29 },
  { 7787, 22, 42, 22, 0, -29 },
  { 7903, 17, 29, 21, 2, -29 },
  { 7965, 15, 48, 19, 2, -39 },
  { 8055, 2, 54, 26, 12, -41 },
  { 8069, 15, 48, 19, 2, -39 },
  { 8159, 23, 5, 28, 2, -22 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight54pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT54PT7B_H_
