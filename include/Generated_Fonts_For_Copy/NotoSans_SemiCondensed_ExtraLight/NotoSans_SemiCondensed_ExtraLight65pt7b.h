#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT65PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight65pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x02, 0xFF, 0xFF,
  0x20, 0xE0, 0x3B, 0x01, 0xD8, 0x0E, 0xC0, 0x76, 0x03, 0xB0, 0x1D, 0x80,
  0xEC, 0x07, 0x60, 0x3B, 0x01, 0xD8, 0x0E, 0xC0, 0x76, 0x03, 0x30, 0x19,
  0x80, 0x4C, 0x02, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x01, 0x80,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x70,
  0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x60, 0x07, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0x80, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x0E, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x3E, 0x30, 0xFC, 0x38,
  0x18, 0x0C, 0x38, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x0C,
  0x01, 0x80, 0x06, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x03, 0x80, 0x30, 0x01,
  0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x1C, 0x03, 0x00,
  0x07, 0x01, 0x80, 0x03, 0xC0, 0xC0, 0x00, 0xF0, 0x60, 0x00, 0x3E, 0x30,
  0x00, 0x07, 0xD8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xBE, 0x00, 0x00, 0xC7, 0xC0, 0x00, 0x60, 0xF0, 0x00,
  0x30, 0x3C, 0x00, 0x18, 0x0E, 0x00, 0x0C, 0x03, 0x80, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C,
  0x00, 0x30, 0x06, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x03, 0x80, 0x06, 0x01,
  0x80, 0x03, 0x01, 0xC8, 0x01, 0x83, 0xC7, 0x80, 0xC7, 0xC3, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x80, 0x07, 0xFC, 0x00, 0x01, 0x80, 0x07, 0x07, 0x00,
  0x01, 0xC0, 0x03, 0x01, 0xC0, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x00, 0xE0,
  0x01, 0x80, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x1C, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x70, 0x0E, 0x00,
  0x0E, 0x00, 0x38, 0x06, 0x00, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80,
  0x0E, 0x03, 0x00, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x81,
  0x80, 0x00, 0x30, 0x01, 0xC1, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0xC0, 0x00,
  0x0C, 0x00, 0x60, 0xE0, 0xFE, 0x06, 0x00, 0x30, 0x60, 0xFF, 0x83, 0x00,
  0x18, 0x70, 0xE0, 0xE1, 0xC0, 0x1C, 0x30, 0xE0, 0x38, 0x60, 0x0C, 0x38,
  0x60, 0x0C, 0x38, 0x0E, 0x18, 0x70, 0x07, 0x0C, 0x07, 0x0C, 0x38, 0x01,
  0x87, 0x87, 0x0C, 0x18, 0x00, 0xC1, 0xFF, 0x06, 0x0C, 0x00, 0x60, 0x3E,
  0x06, 0x06, 0x00, 0x30, 0x00, 0x03, 0x07, 0x00, 0x1C, 0x00, 0x03, 0x83,
  0x80, 0x0E, 0x00, 0x01, 0x81, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x03,
  0x80, 0x00, 0xC0, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x00,
  0x60, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x03, 0x80, 0x0E,
  0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x07, 0x01, 0xC0, 0x03, 0x00, 0x01,
  0xC1, 0xC0, 0x03, 0x00, 0x00, 0x7B, 0xC0, 0x03, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x30,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x06, 0x0E, 0x00, 0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x00, 0x38,
  0xE0, 0x00, 0xE0, 0x06, 0x1C, 0x00, 0x0E, 0x00, 0xC3, 0x00, 0x00, 0xE0,
  0x38, 0xE0, 0x00, 0x1C, 0x06, 0x1C, 0x00, 0x01, 0xC1, 0xC3, 0x80, 0x00,
  0x1C, 0x30, 0x70, 0x00, 0x01, 0xCE, 0x0E, 0x00, 0x00, 0x1D, 0x81, 0xC0,
  0x00, 0x01, 0xF0, 0x18, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x01, 0xF8, 0x0E, 0x00, 0x00, 0x7B, 0x80, 0xE0, 0x00, 0x1E,
  0x38, 0x0E, 0x00, 0x07, 0x83, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x0F, 0xFF,
  0xF0, 0x07, 0x00, 0x7F, 0xF8, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0xED,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x00, 0x70, 0x0C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60,
  0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C,
  0x03, 0x80, 0x30, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x40, 0x08, 0x01, 0x70, 0x08, 0x0F, 0xFE, 0x08, 0x3F, 0x1F,
  0xC9, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x63, 0x00, 0x00, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x03,
  0x80, 0xC0, 0x03, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x06,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x30, 0xE1,
  0xC3, 0x86, 0x0C, 0x38, 0x70, 0xC1, 0x87, 0x0C, 0x38, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x6F, 0xFF, 0xF4, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xF0, 0x7C, 0x01,
  0xE0, 0x0F, 0x00, 0xE0, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0x38,
  0x70, 0x00, 0x1C, 0x30, 0x00, 0x06, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x39, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x0E, 0x00,
  0x06, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x07, 0x00, 0x78, 0x0F, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x38, 0x03, 0xC0,
  0x3E, 0x07, 0xB0, 0x79, 0x87, 0x8C, 0x70, 0x6F, 0x03, 0xF0, 0x1B, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x01, 0xFC, 0x1F, 0x00, 0xF8, 0x00, 0xE0,
  0x78, 0x00, 0x1C, 0x08, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x01, 0xFC, 0x1F, 0x81, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x1E,
  0x10, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x7C, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x06, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70,
  0x03, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x7F, 0x80, 0x0F, 0xFF,
  0xFC, 0x07, 0xFE, 0xFF, 0x01, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x0E, 0x1F, 0x00, 0x1E, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xE0, 0x60,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x70, 0x03, 0x83, 0xFF, 0x80, 0xE3, 0xFF, 0xF8, 0x31, 0xE0,
  0x0F, 0x0C, 0xE0, 0x00, 0xE3, 0x70, 0x00, 0x1C, 0xD8, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x60,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0E,
  0x38, 0x00, 0x03, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x83, 0xF0,
  0x07, 0x80, 0x0F, 0x01, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x06, 0x01,
  0xC0, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x03, 0xE0, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x3C, 0x00, 0xE0, 0x1C, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x1C, 0x70, 0x00,
  0x03, 0x18, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x06, 0xE0,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x07, 0x60, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x6C, 0xE0,
  0x00, 0x1B, 0x1C, 0x00, 0x0D, 0xC7, 0x80, 0x0E, 0x70, 0xF8, 0x0F, 0x1C,
  0x0F, 0xFF, 0x87, 0x00, 0xFF, 0x81, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x6F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F,
  0xFF, 0xF4, 0x0C, 0x3C, 0x78, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE1, 0xC7, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x86, 0x0C,
  0x38, 0x60, 0xC3, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xE0, 0xFC, 0x1F, 0x8E, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0xFE, 0x00, 0x30, 0x60, 0x00, 0xFF,
  0xFC, 0x01, 0x87, 0x00, 0x0F, 0x00, 0xC0, 0x0E, 0x30, 0x00, 0xE0, 0x06,
  0x00, 0x31, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x9C, 0x00, 0xE0, 0x01, 0x80,
  0x0C, 0xE0, 0x06, 0x00, 0x0C, 0x00, 0x66, 0x00, 0x70, 0x00, 0x60, 0x03,
  0x30, 0x03, 0x80, 0x03, 0x00, 0x1D, 0x80, 0x18, 0x00, 0x18, 0x00, 0xEC,
  0x00, 0xC0, 0x00, 0xC0, 0x07, 0xE0, 0x0E, 0x00, 0x06, 0x00, 0x3F, 0x00,
  0x70, 0x00, 0x30, 0x01, 0xF8, 0x03, 0x80, 0x01, 0x80, 0x0D, 0xC0, 0x1C,
  0x00, 0x1C, 0x00, 0x6E, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x70, 0x07, 0x00,
  0x07, 0x00, 0x19, 0x80, 0x18, 0x00, 0x38, 0x01, 0xCC, 0x00, 0xC0, 0x01,
  0xC0, 0x0C, 0x60, 0x06, 0x00, 0x1E, 0x00, 0x63, 0x00, 0x38, 0x00, 0xF0,
  0x07, 0x18, 0x00, 0xC0, 0x0D, 0xC0, 0x30, 0xE0, 0x07, 0x00, 0xC6, 0x03,
  0x87, 0x00, 0x1E, 0x1E, 0x3C, 0x78, 0x18, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x70, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0x80, 0x01, 0xF0, 0x70, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07,
  0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0xFF, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x07, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x0F, 0x1C,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x78,
  0x70, 0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x3E,
  0x00, 0x06, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x02, 0x00, 0xFC, 0x00, 0x38,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x0F, 0xC0, 0x38, 0x00,
  0x07, 0xC0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x3C,
  0x0E, 0x00, 0x07, 0xC0, 0x38, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xF0, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x01, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x1C, 0x07, 0xC0, 0x00,
  0x07, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0C, 0xFF, 0xE7, 0xF0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC8, 0x0F, 0x3F, 0xF8, 0xFF,
  0x80, 0x20, 0x00, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x1C, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x1E, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x38,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0xF0, 0x01, 0xC0,
  0x1C, 0x00, 0x38, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00,
  0x1C, 0x1C, 0x00, 0x03, 0x87, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x0E, 0x3C,
  0x00, 0x01, 0xCF, 0xC0, 0x00, 0x3B, 0x9C, 0x00, 0x07, 0xE3, 0x80, 0x00,
  0xF8, 0x38, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x07,
  0x00, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03,
  0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0xC0, 0x00, 0x00, 0x01, 0xFD, 0xC0, 0x00, 0x00, 0x07, 0xFB, 0x80,
  0x00, 0x00, 0x0D, 0xF3, 0x00, 0x00, 0x00, 0x1B, 0xE7, 0x00, 0x00, 0x00,
  0x77, 0xCE, 0x00, 0x00, 0x00, 0xCF, 0x8C, 0x00, 0x00, 0x03, 0x9F, 0x1C,
  0x00, 0x00, 0x07, 0x3E, 0x18, 0x00, 0x00, 0x0C, 0x7C, 0x38, 0x00, 0x00,
  0x38, 0xF8, 0x70, 0x00, 0x00, 0x61, 0xF0, 0x60, 0x00, 0x00, 0xC3, 0xE0,
  0xE0, 0x00, 0x03, 0x87, 0xC1, 0xC0, 0x00, 0x06, 0x0F, 0x81, 0x80, 0x00,
  0x0C, 0x1F, 0x03, 0x80, 0x00, 0x38, 0x3E, 0x03, 0x00, 0x00, 0x60, 0x7C,
  0x06, 0x00, 0x01, 0xC0, 0xF8, 0x0E, 0x00, 0x03, 0x81, 0xF0, 0x0C, 0x00,
  0x06, 0x03, 0xE0, 0x1C, 0x00, 0x1C, 0x07, 0xC0, 0x38, 0x00, 0x30, 0x0F,
  0x80, 0x30, 0x00, 0x60, 0x1F, 0x00, 0x70, 0x01, 0xC0, 0x3E, 0x00, 0xE0,
  0x03, 0x00, 0x7C, 0x00, 0xC0, 0x06, 0x00, 0xF8, 0x01, 0xC0, 0x1C, 0x01,
  0xF0, 0x01, 0x80, 0x30, 0x03, 0xE0, 0x03, 0x00, 0xE0, 0x07, 0xC0, 0x07,
  0x01, 0xC0, 0x0F, 0x80, 0x06, 0x03, 0x00, 0x1F, 0x00, 0x0E, 0x0E, 0x00,
  0x3E, 0x00, 0x1C, 0x18, 0x00, 0x7C, 0x00, 0x18, 0x30, 0x00, 0xF8, 0x00,
  0x38, 0xE0, 0x01, 0xF0, 0x00, 0x71, 0x80, 0x03, 0xE0, 0x00, 0x67, 0x00,
  0x07, 0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x80, 0x00, 0xD8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xDC, 0x00,
  0x00, 0x1F, 0x70, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x01, 0xF3, 0x80, 0x00,
  0x07, 0xC7, 0x00, 0x00, 0x1F, 0x0C, 0x00, 0x00, 0x7C, 0x38, 0x00, 0x01,
  0xF0, 0x70, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x1F, 0x03, 0x80, 0x00, 0x7C,
  0x06, 0x00, 0x01, 0xF0, 0x1C, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x1F, 0x00,
  0xE0, 0x00, 0x7C, 0x01, 0xC0, 0x01, 0xF0, 0x07, 0x00, 0x07, 0xC0, 0x0E,
  0x00, 0x1F, 0x00, 0x18, 0x00, 0x7C, 0x00, 0x70, 0x01, 0xF0, 0x00, 0xE0,
  0x07, 0xC0, 0x03, 0x80, 0x1F, 0x00, 0x07, 0x00, 0x7C, 0x00, 0x0C, 0x01,
  0xF0, 0x00, 0x38, 0x07, 0xC0, 0x00, 0x70, 0x1F, 0x00, 0x01, 0xC0, 0x7C,
  0x00, 0x03, 0x81, 0xF0, 0x00, 0x0E, 0x07, 0xC0, 0x00, 0x1C, 0x1F, 0x00,
  0x00, 0x38, 0x7C, 0x00, 0x00, 0xE1, 0xF0, 0x00, 0x01, 0xC7, 0xC0, 0x00,
  0x07, 0x1F, 0x00, 0x00, 0x0E, 0x7C, 0x00, 0x00, 0x19, 0xF0, 0x00, 0x00,
  0x77, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xE0, 0x01, 0xF8, 0xE0, 0x00, 0x7C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x78, 0xE0, 0x01, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0x80, 0x07,
  0xE0, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x06, 0x38, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x7C, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x07,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01,
  0xC0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0x0F,
  0xF8, 0x3C, 0x00, 0x0C, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE2, 0x00,
  0x00, 0x78, 0xF8, 0x00, 0x7C, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x80, 0x18, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x70, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x01, 0x80, 0x00, 0x18,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x30, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x37, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0x18,
  0x00, 0x07, 0x30, 0x00, 0x07, 0x06, 0x00, 0x01, 0xCE, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x63, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x60, 0x00, 0x38,
  0x0C, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x87, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0xC1, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x30, 0x30, 0x00,
  0x70, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x01, 0x80, 0x07, 0x03, 0x80,
  0x06, 0x00, 0x70, 0x01, 0x80, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x38, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x0E, 0x01,
  0xC0, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x01, 0x80, 0x70, 0x03, 0x00, 0x70, 0x00, 0x60, 0x1C,
  0x00, 0xE0, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01,
  0x80, 0x06, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x01, 0x80, 0xE0, 0x00, 0x30,
  0x38, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x03,
  0x83, 0x00, 0x03, 0x07, 0x00, 0x00, 0x61, 0xC0, 0x00, 0xC1, 0x80, 0x00,
  0x18, 0x70, 0x00, 0x38, 0x60, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x38, 0x00,
  0x01, 0xC6, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x07, 0x70,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x38,
  0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x38, 0x03, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x03, 0x03, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x18, 0x70,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x33, 0x80, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x18, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x06, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x30, 0x00, 0x38, 0x03, 0x80,
  0x00, 0xE0, 0x18, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x63, 0x80, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x81, 0x80, 0x00, 0x18, 0x0E, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xE0, 0x06, 0x00, 0x06,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x18, 0x01, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x0E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x04, 0x00, 0xFF, 0x00, 0x1F, 0xFF,
  0x81, 0xF8, 0x1F, 0x07, 0x00, 0x1E, 0x10, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xF8, 0x30, 0xF8, 0x00, 0xC7,
  0x00, 0x03, 0x38, 0x00, 0x0D, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xF6, 0x00, 0x06, 0xDC, 0x00, 0x33, 0x38,
  0x03, 0xCC, 0x7F, 0xFC, 0x30, 0xFF, 0xE0, 0xC0, 0x38, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x03, 0xFC, 0x03, 0x87,
  0xFF, 0xC0, 0xE3, 0xE0, 0xF8, 0x39, 0xC0, 0x07, 0x0E, 0xE0, 0x00, 0xE3,
  0xB0, 0x00, 0x1C, 0xF8, 0x00, 0x07, 0x3E, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x06, 0xF0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1B, 0xC0, 0x00, 0x06, 0xF0, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0xEF, 0x80, 0x00, 0x73, 0xE0, 0x00, 0x1C, 0xEC, 0x00, 0x0E,
  0x3B, 0x80, 0x07, 0x0C, 0x78, 0x07, 0x83, 0x0F, 0xFF, 0xC0, 0xC0, 0xFF,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0xFC,
  0x1E, 0x0F, 0x00, 0x10, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x18, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x03, 0xF8, 0x0C, 0x07, 0xFF, 0x83, 0x03, 0xE0, 0xF8, 0xC1,
  0xE0, 0x07, 0x30, 0xE0, 0x00, 0xCC, 0x70, 0x00, 0x1B, 0x1C, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x70, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x07, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3C,
  0x70, 0x00, 0x1B, 0x1C, 0x00, 0x06, 0xC3, 0x80, 0x03, 0x30, 0x78, 0x03,
  0x8C, 0x0F, 0xFF, 0xC3, 0x00, 0xFF, 0xE0, 0xC0, 0x07, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xC1, 0xF0, 0x0F, 0x00, 0x78, 0x1C,
  0x00, 0x38, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x06, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x02, 0x0F,
  0x80, 0x0E, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xFC, 0x30, 0x3E, 0x0F, 0x8C, 0x1E, 0x00, 0x73, 0x0E,
  0x00, 0x0E, 0xC7, 0x00, 0x01, 0xB1, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x0F,
  0x38, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x07, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xB1,
  0xC0, 0x00, 0xEC, 0x38, 0x00, 0x73, 0x07, 0x80, 0x38, 0xC0, 0xFF, 0xFC,
  0x30, 0x0F, 0xFC, 0x0C, 0x00, 0x78, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x3F, 0x80, 0xE1, 0xFF, 0xF0, 0xE3, 0xE0, 0xF8, 0xE7,
  0x00, 0x3C, 0xEE, 0x00, 0x1C, 0xEC, 0x00, 0x0E, 0xF8, 0x00, 0x0E, 0xF0,
  0x00, 0x06, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xEF,
  0xFE, 0x60, 0x00, 0x00, 0x00, 0x0E, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x01,
  0xC0, 0x3C, 0x07, 0x80, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xCF, 0xF1, 0xFC,
  0x1E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x0E, 0xE0, 0x00,
  0x73, 0x80, 0x03, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83,
  0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x80,
  0xE0, 0x0E, 0x07, 0x00, 0x38, 0x38, 0x00, 0xE1, 0xC0, 0x03, 0x8F, 0x00,
  0x0E, 0x3E, 0x00, 0x39, 0x9C, 0x00, 0xEE, 0x70, 0x03, 0xF0, 0xE0, 0x0F,
  0x81, 0x80, 0x3C, 0x07, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x0E, 0x00,
  0x70, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x0C,
  0x38, 0x00, 0x38, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x03, 0xB8,
  0x00, 0x06, 0xE0, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x60, 0xFF, 0xE0, 0x3F, 0xFC, 0x30, 0xF0,
  0xF8, 0x3C, 0x1F, 0x18, 0xC0, 0x1E, 0x38, 0x03, 0xCC, 0xC0, 0x07, 0x38,
  0x00, 0xE7, 0xC0, 0x01, 0xD8, 0x00, 0x3B, 0xE0, 0x00, 0xF8, 0x00, 0x1D,
  0xE0, 0x00, 0x3C, 0x00, 0x06, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x03, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x3F, 0x80, 0xC1, 0xFF, 0xF0, 0xC3, 0xE0, 0xF8, 0xC7, 0x00, 0x3C,
  0xCE, 0x00, 0x1C, 0xEC, 0x00, 0x0E, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x06,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0x81, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0xE0,
  0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0C,
  0x38, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x30, 0x3F, 0xFC, 0x0C, 0x3E, 0x0F, 0x83, 0x1C, 0x00, 0x70,
  0xC6, 0x00, 0x0E, 0x3B, 0x00, 0x01, 0xCF, 0x80, 0x00, 0x73, 0xE0, 0x00,
  0x0E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x6F, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x6F,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF8, 0x00, 0x07, 0x3E, 0x00, 0x01,
  0xCE, 0xC0, 0x00, 0xE3, 0x98, 0x00, 0x70, 0xE7, 0x80, 0x7C, 0x38, 0xFF,
  0xFC, 0x0E, 0x0F, 0xFE, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF8,
  0x30, 0x3E, 0x0F, 0x8C, 0x1E, 0x00, 0x73, 0x0E, 0x00, 0x0C, 0xC7, 0x00,
  0x01, 0xB1, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07,
  0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x0F, 0x38, 0x00, 0x02, 0xC7, 0x00, 0x01, 0xB1, 0xC0, 0x00, 0xEC, 0x38,
  0x00, 0x73, 0x07, 0x80, 0x38, 0xC0, 0xFF, 0xFC, 0x30, 0x1F, 0xFC, 0x0C,
  0x00, 0x78, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x7F, 0xC1, 0xFF, 0xE3, 0xF7, 0xE7, 0x00, 0xEE, 0x00, 0xEC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x7F, 0xFF, 0x07, 0xC0, 0xFC, 0x70, 0x00, 0x67, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xD0, 0x00, 0x1C, 0xF0,
  0x01, 0xE7, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x38, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x70, 0x00, 0x1F, 0x70, 0x00, 0x37, 0x38, 0x00, 0x67, 0x3E,
  0x01, 0xC7, 0x1F, 0xFF, 0x87, 0x07, 0xFF, 0x07, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x60, 0x60, 0x00,
  0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x00, 0xC0, 0x01, 0xC0, 0x38,
  0x00, 0x70, 0x0E, 0x00, 0x18, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x03, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x06,
  0x00, 0x06, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x30, 0x00, 0x0C,
  0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x18, 0xE0, 0x00,
  0x06, 0x38, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0D, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x06,
  0x60, 0x00, 0x3C, 0x00, 0x06, 0x60, 0x00, 0x3E, 0x00, 0x0E, 0x70, 0x00,
  0x3E, 0x00, 0x0E, 0x70, 0x00, 0x66, 0x00, 0x0C, 0x30, 0x00, 0x66, 0x00,
  0x0C, 0x30, 0x00, 0x67, 0x00, 0x1C, 0x38, 0x00, 0xE3, 0x00, 0x1C, 0x38,
  0x00, 0xE3, 0x00, 0x18, 0x18, 0x00, 0xC3, 0x80, 0x18, 0x1C, 0x00, 0xC3,
  0x80, 0x38, 0x1C, 0x01, 0xC1, 0x80, 0x38, 0x1C, 0x01, 0x81, 0x80, 0x30,
  0x0C, 0x01, 0x81, 0xC0, 0x30, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x0E, 0x03,
  0x80, 0xC0, 0x70, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x07, 0x00, 0xE0,
  0x60, 0x07, 0x07, 0x00, 0x60, 0xE0, 0x07, 0x06, 0x00, 0x60, 0xE0, 0x03,
  0x06, 0x00, 0x70, 0xC0, 0x03, 0x0E, 0x00, 0x70, 0xC0, 0x03, 0x8E, 0x00,
  0x31, 0xC0, 0x03, 0x8C, 0x00, 0x31, 0xC0, 0x01, 0x9C, 0x00, 0x39, 0x80,
  0x01, 0x9C, 0x00, 0x19, 0x80, 0x01, 0xD8, 0x00, 0x1B, 0x80, 0x01, 0xD8,
  0x00, 0x1B, 0x80, 0x00, 0xD8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x9C, 0x00, 0x03, 0x87, 0x00,
  0x03, 0x83, 0x80, 0x01, 0x80, 0xE0, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x01, 0x80, 0x60, 0x00, 0xE0, 0x70, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x38, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x07, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x03, 0x00, 0x03, 0x81, 0xC0, 0x03, 0x80, 0x60, 0x01, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x01, 0xC0, 0xE0,
  0x00, 0x70, 0x60, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x78,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x70, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0xC0, 0x38, 0x00, 0x70, 0x06, 0x00, 0x1C, 0x01, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x03, 0x80, 0x30, 0x00, 0x60,
  0x1C, 0x00, 0x18, 0x07, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0, 0xE0, 0x00,
  0x30, 0x38, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x1C, 0x60, 0x00, 0x03, 0x38, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0x00, 0x7F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x01,
  0xF8, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x78, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x27, 0xFF, 0x00, 0x05, 0xE0, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0xF8,
  0x00, 0x3F, 0xFD, 0x00, 0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 47, 14, 5, -46 },
  { 25, 13, 16, 21, 4, -46 },
  { 51, 33, 46, 37, 2, -46 },
  { 241, 25, 53, 33, 3, -49 },
  { 407, 41, 48, 47, 3, -47 },
  { 653, 35, 48, 39, 3, -47 },
  { 863, 3, 16, 12, 4, -46 },
  { 869, 12, 56, 17, 3, -46 },
  { 953, 12, 56, 17, 2, -46 },
  { 1037, 24, 23, 31, 3, -49 },
  { 1106, 27, 30, 33, 3, -38 },
  { 1208, 7, 15, 13, 2, -7 },
  { 1222, 15, 3, 20, 2, -19 },
  { 1228, 4, 6, 14, 5, -5 },
  { 1231, 20, 46, 22, 1, -46 },
  { 1346, 25, 48, 33, 4, -47 },
  { 1496, 13, 46, 33, 6, -46 },
  { 1571, 26, 47, 33, 3, -47 },
  { 1724, 26, 48, 33, 3, -47 },
  { 1880, 31, 47, 33, 1, -47 },
  { 2063, 25, 47, 33, 4, -46 },
  { 2210, 26, 48, 33, 4, -47 },
  { 2366, 27, 46, 33, 3, -46 },
  { 2522, 27, 48, 33, 3, -47 },
  { 2684, 26, 48, 33, 3, -47 },
  { 2840, 4, 36, 14, 5, -35 },
  { 2858, 7, 43, 14, 2, -35 },
  { 2896, 27, 29, 33, 3, -38 },
  { 2994, 27, 16, 33, 3, -31 },
  { 3048, 27, 29, 33, 3, -38 },
  { 3146, 20, 48, 24, 2, -47 },
  { 3266, 45, 52, 51, 3, -46 },
  { 3559, 34, 46, 34, 0, -46 },
  { 3755, 27, 46, 36, 6, -46 },
  { 3911, 30, 48, 35, 4, -47 },
  { 4091, 30, 46, 40, 6, -46 },
  { 4264, 22, 46, 32, 6, -46 },
  { 4391, 22, 46, 29, 6, -46 },
  { 4518, 34, 48, 42, 4, -47 },
  { 4722, 29, 46, 41, 6, -46 },
  { 4889, 11, 46, 18, 3, -46 },
  { 4953, 14, 58, 15, -5, -46 },
  { 5055, 27, 46, 33, 6, -46 },
  { 5211, 22, 46, 29, 6, -46 },
  { 5338, 39, 46, 51, 6, -46 },
  { 5563, 30, 46, 42, 6, -46 },
  { 5736, 36, 48, 44, 4, -47 },
  { 5952, 24, 46, 33, 6, -46 },
  { 6090, 36, 58, 44, 4, -47 },
  { 6351, 27, 46, 34, 6, -46 },
  { 6507, 26, 48, 32, 3, -47 },
  { 6663, 29, 46, 29, 0, -46 },
  { 6830, 30, 47, 41, 6, -46 },
  { 7007, 33, 46, 33, 0, -46 },
  { 7197, 50, 46, 52, 1, -46 },
  { 7485, 30, 46, 30, 0, -46 },
  { 7658, 29, 46, 29, 0, -46 },
  { 7825, 28, 46, 32, 2, -46 },
  { 7986, 12, 56, 20, 6, -46 },
  { 8070, 20, 46, 22, 1, -46 },
  { 8185, 13, 56, 20, 2, -46 },
  { 8276, 29, 27, 33, 2, -47 },
  { 8374, 26, 2, 26, 0, 6 },
  { 8381, 10, 11, 16, 3, -50 },
  { 8395, 22, 36, 30, 3, -35 },
  { 8494, 26, 50, 35, 5, -49 },
  { 8657, 21, 36, 27, 4, -35 },
  { 8752, 26, 50, 35, 3, -49 },
  { 8915, 24, 36, 32, 4, -35 },
  { 9023, 19, 50, 17, 1, -50 },
  { 9142, 26, 51, 35, 3, -35 },
  { 9308, 24, 49, 34, 5, -49 },
  { 9455, 4, 47, 13, 5, -47 },
  { 9479, 11, 63, 13, -2, -47 },
  { 9566, 22, 49, 27, 5, -49 },
  { 9701, 3, 49, 13, 5, -49 },
  { 9720, 41, 35, 51, 5, -35 },
  { 9900, 24, 35, 34, 5, -35 },
  { 10005, 27, 36, 34, 3, -35 },
  { 10127, 26, 50, 35, 5, -35 },
  { 10290, 26, 50, 35, 3, -35 },
  { 10453, 16, 35, 22, 5, -35 },
  { 10523, 21, 36, 27, 3, -35 },
  { 10618, 16, 44, 19, 1, -43 },
  { 10706, 24, 35, 34, 5, -34 },
  { 10811, 26, 34, 26, 0, -34 },
  { 10922, 40, 34, 42, 1, -34 },
  { 11092, 25, 34, 28, 1, -34 },
  { 11199, 26, 50, 26, 0, -34 },
  { 11362, 21, 34, 25, 2, -34 },
  { 11452, 18, 56, 23, 2, -46 },
  { 11578, 3, 66, 31, 14, -50 },
  { 11603, 17, 56, 23, 3, -46 },
  { 11722, 27, 6, 33, 3, -26 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight65pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT65PT7B_H_
