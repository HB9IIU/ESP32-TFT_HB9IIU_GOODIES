#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT71PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight71pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE6, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x00,
  0xEF, 0xFF, 0xF6, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x06, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x06, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x01, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x7C, 0x60, 0xFC, 0x1E, 0x0C, 0x03,
  0x07, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x00,
  0xC0, 0x01, 0xC0, 0x18, 0x00, 0x38, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00,
  0xC0, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x03, 0x80, 0x30, 0x00, 0x70, 0x06,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x1E, 0x03, 0x00, 0x01,
  0xE0, 0x60, 0x00, 0x1F, 0x0C, 0x00, 0x00, 0xF9, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0x7E, 0x00, 0x00, 0x63, 0xF0, 0x00, 0x0C, 0x1F, 0x00, 0x01, 0x80,
  0xF0, 0x00, 0x30, 0x0F, 0x00, 0x06, 0x00, 0xE0, 0x00, 0xC0, 0x0E, 0x00,
  0x18, 0x01, 0xC0, 0x03, 0x00, 0x38, 0x00, 0x60, 0x07, 0x00, 0x0C, 0x00,
  0xE0, 0x01, 0x80, 0x1C, 0x00, 0x30, 0x03, 0x80, 0x06, 0x00, 0x70, 0x00,
  0xC0, 0x0C, 0x00, 0x18, 0x03, 0x80, 0x03, 0x00, 0xF4, 0x00, 0x60, 0x3C,
  0xE0, 0x0C, 0x0F, 0x1F, 0xC1, 0x8F, 0xC3, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x1C, 0x1E, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x18, 0x00, 0x30, 0x07, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x70, 0x00, 0x38, 0x00, 0x60, 0x03, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x18,
  0x03, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0x0C, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0xE0, 0x01, 0x81, 0x80, 0xFC, 0x0E, 0x00, 0x38, 0x38, 0x3F, 0xF0, 0xE0,
  0x03, 0x83, 0x07, 0x87, 0x06, 0x00, 0x38, 0x70, 0xF0, 0x38, 0x60, 0x03,
  0x07, 0x0E, 0x01, 0xC7, 0x00, 0x70, 0xE1, 0xC0, 0x0C, 0x30, 0x07, 0x0E,
  0x1C, 0x00, 0xE3, 0x80, 0xE0, 0xC1, 0x80, 0x0E, 0x1C, 0x1C, 0x1C, 0x18,
  0x00, 0xE0, 0xFF, 0xC1, 0x83, 0x80, 0x06, 0x07, 0xF0, 0x38, 0x38, 0x00,
  0x60, 0x00, 0x03, 0x03, 0x80, 0x07, 0x00, 0x00, 0x70, 0x30, 0x00, 0x70,
  0x00, 0x06, 0x03, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x70, 0x00,
  0x0C, 0x03, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x00, 0x18,
  0x03, 0x00, 0x07, 0x00, 0x03, 0x80, 0x30, 0x00, 0x70, 0x00, 0x30, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x60, 0x00, 0x60, 0x03, 0x80,
  0x06, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x00, 0xE0, 0x01, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x0C, 0x00,
  0x18, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x30,
  0x00, 0x07, 0x03, 0x80, 0x07, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x38, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x3B, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x06, 0x1E, 0x00,
  0x70, 0x00, 0x70, 0xE0, 0x01, 0xC0, 0x03, 0x8E, 0x00, 0x0F, 0x00, 0x1C,
  0x70, 0x00, 0x3C, 0x00, 0xC7, 0x00, 0x00, 0xE0, 0x0E, 0x38, 0x00, 0x03,
  0x80, 0x71, 0xC0, 0x00, 0x0E, 0x03, 0x0C, 0x00, 0x00, 0x38, 0x38, 0x60,
  0x00, 0x00, 0xE1, 0xC3, 0x00, 0x00, 0x07, 0x9C, 0x18, 0x00, 0x00, 0x1D,
  0xC0, 0xC0, 0x00, 0x00, 0x7E, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x00, 0xFC, 0x07, 0x00, 0x00, 0x0F, 0xF0,
  0x3C, 0x00, 0x00, 0xF3, 0x80, 0xE0, 0x00, 0x0F, 0x0E, 0x03, 0xC0, 0x01,
  0xF0, 0x38, 0x0F, 0x80, 0x3E, 0x00, 0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0x80,
  0x7F, 0xFC, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xDB, 0x00, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x80, 0x0C, 0x00, 0x78, 0x03, 0x00, 0xFF,
  0xC0, 0xC0, 0xFD, 0xFE, 0x31, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x33, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x03, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0xE0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x1C,
  0x01, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1E, 0x3C, 0x70, 0xE1,
  0xC3, 0x8E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x73, 0xFF, 0xF7, 0x90, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x18, 0x38,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70,
  0x0F, 0x00, 0x07, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x3C, 0x00, 0xF8, 0x03, 0xB0, 0x0E, 0x60, 0x78, 0xC1, 0xE1, 0x87, 0x83,
  0x1E, 0x06, 0xF0, 0x0F, 0xC0, 0x1B, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x01, 0xE0, 0x70,
  0x00, 0x0E, 0x02, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xC0, 0x7E, 0x03, 0xE0, 0x00, 0xF0, 0xF8, 0x00,
  0x07, 0x86, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x80, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x38, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x07, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x03, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x30, 0x07, 0x00,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xBF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x10,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xE0, 0xFC,
  0x00, 0x7C, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x60,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x03, 0xFF, 0x00, 0x30, 0x7F, 0xFE, 0x03, 0x87, 0xC0, 0xFC,
  0x1C, 0x70, 0x00, 0xF0, 0xE7, 0x00, 0x03, 0xC7, 0x60, 0x00, 0x0E, 0x3F,
  0x00, 0x00, 0x39, 0xF0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0xF0, 0x00, 0xF0, 0x1E,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38,
  0x0E, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xBE, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x1F,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x1F, 0x38, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x0D, 0xC7, 0x00, 0x00,
  0xCE, 0x1E, 0x00, 0x1E, 0x70, 0x7C, 0x03, 0xE3, 0x01, 0xFF, 0xFC, 0x18,
  0x03, 0xFF, 0x80, 0xC0, 0x02, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x10, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x73, 0xFF, 0xF7, 0x90,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x9F, 0xFF, 0xBC, 0x80, 0x1C, 0x3C, 0xF8,
  0xF1, 0xE1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x0F, 0x1C, 0x38, 0x71, 0xE3, 0x87, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x0E,
  0x18, 0x30, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xC0,
  0x7C, 0x18, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x07, 0xFF, 0x00, 0x0C, 0x38, 0x00, 0x1F, 0xFF, 0xC0, 0x0E, 0x38, 0x00,
  0x3C, 0x03, 0xC0, 0x0E, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x06, 0x70, 0x01, 0xC0, 0x01, 0x80, 0x07, 0x60, 0x01,
  0xC0, 0x01, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x01, 0x80, 0x07, 0xE0, 0x03,
  0x80, 0x01, 0x80, 0x07, 0xE0, 0x03, 0x00, 0x01, 0x80, 0x07, 0xE0, 0x07,
  0x00, 0x01, 0x80, 0x07, 0xC0, 0x07, 0x00, 0x01, 0x80, 0x07, 0xC0, 0x07,
  0x00, 0x01, 0x80, 0x07, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x07, 0xC0, 0x06,
  0x00, 0x03, 0x80, 0x07, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x06,
  0x00, 0x03, 0x80, 0x07, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x06, 0xC0, 0x06,
  0x00, 0x03, 0x80, 0x06, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x0E, 0xE0, 0x07,
  0x00, 0x07, 0x80, 0x0E, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x0C, 0xE0, 0x03,
  0x80, 0x0D, 0x80, 0x1C, 0xE0, 0x03, 0x80, 0x0D, 0xC0, 0x18, 0x60, 0x01,
  0xC0, 0x18, 0xC0, 0x38, 0x70, 0x00, 0xF0, 0x78, 0xF0, 0xF0, 0x70, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x70, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x0E,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0x80,
  0x00, 0x7E, 0x0C, 0x00, 0x00, 0x78, 0x60, 0x00, 0x01, 0xE3, 0x00, 0x00,
  0x07, 0x18, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x07,
  0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x07, 0x83, 0x00, 0x00, 0xF8, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x30, 0x00,
  0x07, 0xC1, 0x80, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x01, 0xEC, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x1F, 0x18, 0x00, 0x03, 0xE0, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0xE0, 0x0F, 0x80,
  0x00, 0x10, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x02, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x0F, 0xE0, 0x0C, 0x00, 0x00, 0xF8,
  0x06, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x07, 0x81, 0x80, 0x00, 0x01,
  0xE0, 0xC0, 0x00, 0x00, 0x78, 0x60, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00,
  0x07, 0x18, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00,
  0x1E, 0x18, 0x00, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0x1E, 0x06, 0x00, 0x00,
  0x1E, 0x03, 0x00, 0x00, 0x3E, 0x01, 0x80, 0x00, 0x7E, 0x00, 0xC0, 0x3F,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x03, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x00, 0x1C, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x18,
  0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC8, 0x0F, 0x1F,
  0xFC, 0x3F, 0xF0, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07,
  0x30, 0x00, 0x00, 0x79, 0x80, 0x00, 0x07, 0x8C, 0x00, 0x00, 0x78, 0x60,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x38, 0x18, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x3C, 0x06, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x3C, 0x01, 0x80, 0x01, 0xC0,
  0x0C, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x1E, 0x00, 0x18,
  0x01, 0xE0, 0x00, 0xC0, 0x1E, 0x00, 0x06, 0x01, 0xE0, 0x00, 0x30, 0x0E,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x60, 0xF0, 0x00,
  0x03, 0x0F, 0x80, 0x00, 0x18, 0xFC, 0x00, 0x00, 0xC7, 0x70, 0x00, 0x06,
  0x73, 0xC0, 0x00, 0x37, 0x0E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x00, 0x3C, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1E, 0x00, 0x30, 0x00, 0x70, 0x01,
  0x80, 0x01, 0xC0, 0x0C, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x38, 0x03, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x78,
  0x60, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x3C, 0xC0,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x1E, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF7, 0x00, 0x00,
  0x00, 0x03, 0xFD, 0xC0, 0x00, 0x00, 0x00, 0xDF, 0x30, 0x00, 0x00, 0x00,
  0x77, 0xCE, 0x00, 0x00, 0x00, 0x1D, 0xF3, 0x80, 0x00, 0x00, 0x06, 0x7C,
  0x60, 0x00, 0x00, 0x03, 0x9F, 0x1C, 0x00, 0x00, 0x00, 0xC7, 0xC7, 0x00,
  0x00, 0x00, 0x71, 0xF0, 0xE0, 0x00, 0x00, 0x1C, 0x7C, 0x38, 0x00, 0x00,
  0x06, 0x1F, 0x0E, 0x00, 0x00, 0x03, 0x87, 0xC1, 0xC0, 0x00, 0x00, 0xE1,
  0xF0, 0x70, 0x00, 0x00, 0x30, 0x7C, 0x0C, 0x00, 0x00, 0x1C, 0x1F, 0x03,
  0x80, 0x00, 0x07, 0x07, 0xC0, 0xE0, 0x00, 0x01, 0x81, 0xF0, 0x18, 0x00,
  0x00, 0xE0, 0x7C, 0x07, 0x00, 0x00, 0x30, 0x1F, 0x01, 0xC0, 0x00, 0x1C,
  0x07, 0xC0, 0x38, 0x00, 0x07, 0x01, 0xF0, 0x0E, 0x00, 0x01, 0x80, 0x7C,
  0x03, 0x80, 0x00, 0xE0, 0x1F, 0x00, 0x70, 0x00, 0x38, 0x07, 0xC0, 0x1C,
  0x00, 0x0C, 0x01, 0xF0, 0x03, 0x00, 0x07, 0x00, 0x7C, 0x00, 0xE0, 0x01,
  0xC0, 0x1F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0xC0, 0x06, 0x00, 0x38, 0x01,
  0xF0, 0x01, 0xC0, 0x0C, 0x00, 0x7C, 0x00, 0x70, 0x07, 0x00, 0x1F, 0x00,
  0x0E, 0x01, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x60, 0x01, 0xF0, 0x00, 0xE0,
  0x38, 0x00, 0x7C, 0x00, 0x1C, 0x0E, 0x00, 0x1F, 0x00, 0x07, 0x03, 0x00,
  0x07, 0xC0, 0x00, 0xC1, 0xC0, 0x01, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x7C,
  0x00, 0x0E, 0x38, 0x00, 0x1F, 0x00, 0x01, 0x8E, 0x00, 0x07, 0xC0, 0x00,
  0x73, 0x00, 0x01, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xDC,
  0x00, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x07, 0xC7,
  0x00, 0x00, 0x07, 0xC7, 0x00, 0x00, 0x07, 0xC3, 0x80, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x07, 0xC0,
  0xE0, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0xC0,
  0x38, 0x00, 0x07, 0xC0, 0x1C, 0x00, 0x07, 0xC0, 0x1C, 0x00, 0x07, 0xC0,
  0x0E, 0x00, 0x07, 0xC0, 0x0E, 0x00, 0x07, 0xC0, 0x07, 0x00, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x01, 0xC0, 0x07, 0xC0,
  0x01, 0xC0, 0x07, 0xC0, 0x00, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x07, 0xC0,
  0x00, 0x70, 0x07, 0xC0, 0x00, 0x38, 0x07, 0xC0, 0x00, 0x38, 0x07, 0xC0,
  0x00, 0x1C, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0E, 0x07, 0xC0,
  0x00, 0x07, 0x07, 0xC0, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x03, 0x87, 0xC0,
  0x00, 0x03, 0x87, 0xC0, 0x00, 0x01, 0xC7, 0xC0, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x00, 0xE7, 0xC0, 0x00, 0x00, 0x77, 0xC0, 0x00, 0x00, 0x77, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x83, 0x00,
  0x03, 0xF0, 0xC0, 0x00, 0x3E, 0x30, 0x00, 0x03, 0xCC, 0x00, 0x00, 0x7B,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x7B, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0x30, 0x00,
  0x0F, 0x0C, 0x00, 0x1F, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0x80, 0x01, 0xF8, 0x0C, 0x00, 0x01,
  0xE0, 0x60, 0x00, 0x07, 0x83, 0x00, 0x00, 0x1E, 0x18, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x07, 0x18, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x03, 0xC3, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x3C, 0x06, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x3C, 0x01, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x70, 0x18, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0F, 0x0C, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x01, 0xE3, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00,
  0x3C, 0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x1E,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0x80, 0x7F, 0x07, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE6, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x01, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x38, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0x87, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x18, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x70,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xE0, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0x0E,
  0x00, 0x03, 0x83, 0x80, 0x00, 0xC0, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x0E,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x30, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x03,
  0x00, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x01,
  0x80, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x01,
  0xC0, 0x07, 0x00, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x38, 0x0E, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x70, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x03, 0x83,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x06, 0x0C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x31, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x60, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x01,
  0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x60, 0x0E,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xC0, 0x03, 0xC0,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0xFE,
  0x00, 0x70, 0xF0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x07, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0x70, 0x00, 0x1B, 0xB8, 0x00, 0x0D, 0xCE, 0x00, 0x1C,
  0xE7, 0xC0, 0x1C, 0x71, 0xFF, 0xFC, 0x18, 0x3F, 0xF8, 0x0C, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x7F, 0xE0,
  0x0E, 0x1F, 0xFF, 0x80, 0xC3, 0xE0, 0x7E, 0x0C, 0x78, 0x00, 0xF0, 0xCE,
  0x00, 0x07, 0x0C, 0xC0, 0x00, 0x38, 0xD8, 0x00, 0x01, 0xCD, 0x80, 0x00,
  0x1C, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xCD, 0x80, 0x00,
  0x3C, 0xD8, 0x00, 0x03, 0x8C, 0xC0, 0x00, 0x70, 0xCE, 0x00, 0x0F, 0x0C,
  0x78, 0x03, 0xE0, 0xC3, 0xFF, 0xF8, 0x0C, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xF8, 0x1E, 0x03,
  0xC0, 0x02, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x06, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x7F, 0xE0, 0x70, 0x1F,
  0xFF, 0x87, 0x03, 0xE0, 0x7C, 0x70, 0x78, 0x00, 0xE7, 0x0E, 0x00, 0x07,
  0x71, 0xC0, 0x00, 0x37, 0x3C, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x1F, 0x38,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x1F, 0x3C,
  0x00, 0x03, 0x31, 0xE0, 0x00, 0x33, 0x0F, 0x00, 0x0E, 0x30, 0x7C, 0x01,
  0xC3, 0x03, 0xFF, 0xF8, 0x30, 0x0F, 0xFE, 0x03, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0x83, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x07, 0x30, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x02, 0x03, 0xF0,
  0x03, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0x06, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x30, 0x1F, 0xFF, 0x83, 0x03, 0xE0, 0x7C, 0x30, 0x78, 0x00, 0xE7,
  0x0E, 0x00, 0x07, 0x71, 0xC0, 0x00, 0x3F, 0x3C, 0x00, 0x01, 0xF3, 0x80,
  0x00, 0x1F, 0x38, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xF3, 0x80,
  0x00, 0x1F, 0x3C, 0x00, 0x03, 0x71, 0xE0, 0x00, 0x77, 0x0F, 0x00, 0x0E,
  0x70, 0x7C, 0x03, 0xC7, 0x03, 0xFF, 0xF8, 0x70, 0x0F, 0xFE, 0x07, 0x00,
  0x1F, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x20, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0,
  0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x7F, 0xE0, 0x38, 0x7F, 0xFE, 0x0E, 0x3E, 0x07,
  0xC3, 0x9C, 0x00, 0x78, 0xCE, 0x00, 0x0F, 0x33, 0x00, 0x01, 0xCD, 0x80,
  0x00, 0x3B, 0x40, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x70, 0x77, 0xBF, 0xE7, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1E, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x1C, 0x03, 0xCC, 0xF8, 0xFF, 0x0F, 0xC0, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0,
  0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x00,
  0xE0, 0x70, 0x00, 0xC0, 0xE0, 0x00, 0xC1, 0xE0, 0x00, 0xC1, 0xE0, 0x00,
  0xC3, 0xE0, 0x00, 0xC7, 0x70, 0x00, 0xCE, 0x78, 0x00, 0xCC, 0x38, 0x00,
  0xD8, 0x1C, 0x00, 0xF8, 0x1C, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC0,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0x7F, 0x80, 0x07, 0xFC, 0x0C, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0xC3,
  0xC1, 0xF0, 0x3C, 0x0F, 0x8C, 0x70, 0x07, 0x87, 0x00, 0x3C, 0xCC, 0x00,
  0x38, 0xE0, 0x01, 0xCD, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xD8, 0x00, 0x1D,
  0x80, 0x00, 0xEF, 0x00, 0x00, 0xF8, 0x00, 0x06, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0x30, 0x7F, 0xFE, 0x0C,
  0x3E, 0x07, 0xC3, 0x1C, 0x00, 0x78, 0xCE, 0x00, 0x0F, 0x33, 0x00, 0x01,
  0xCD, 0x80, 0x00, 0x3B, 0x40, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C,
  0x03, 0xC0, 0x01, 0xC0, 0x0F, 0x80, 0x3C, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x3F, 0xE0, 0x0C, 0x0F,
  0xFF, 0x80, 0xC3, 0xF0, 0x7E, 0x0C, 0x78, 0x00, 0xF0, 0xC6, 0x00, 0x07,
  0x8C, 0xC0, 0x00, 0x38, 0xDC, 0x00, 0x01, 0xCD, 0x80, 0x00, 0x1C, 0xF0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x1C, 0xF8, 0x00, 0x01, 0xCD, 0x80, 0x00, 0x3C, 0xDC,
  0x00, 0x03, 0x8E, 0xE0, 0x00, 0x70, 0xE7, 0x00, 0x0F, 0x0E, 0x3C, 0x03,
  0xE0, 0xE1, 0xFF, 0xFC, 0x0E, 0x0F, 0xFF, 0x00, 0xE0, 0x0F, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x30,
  0x1F, 0xFF, 0x83, 0x03, 0xF0, 0x7C, 0x70, 0x78, 0x00, 0xE7, 0x0E, 0x00,
  0x07, 0x71, 0xC0, 0x00, 0x37, 0x3C, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x1F,
  0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF6, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x1F,
  0x3C, 0x00, 0x03, 0x71, 0xC0, 0x00, 0x77, 0x0F, 0x00, 0x0E, 0x70, 0x78,
  0x03, 0xC7, 0x03, 0xFF, 0xF8, 0x70, 0x1F, 0xFE, 0x07, 0x00, 0x3F, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x7F, 0xE0,
  0xFF, 0xF0, 0xFC, 0xF8, 0xE0, 0x0C, 0xE0, 0x06, 0x60, 0x03, 0x60, 0x01,
  0xB0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x7E, 0x03, 0xF1, 0xE0, 0x00, 0x63, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1D, 0x00, 0x00, 0x3B, 0x00, 0x00, 0xE7, 0xC0,
  0x07, 0x8F, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x40, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xF8, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x1B, 0x38, 0x00, 0x0E, 0xCE, 0x00,
  0x03, 0x31, 0xC0, 0x03, 0x8C, 0x7C, 0x03, 0xC3, 0x0F, 0xFF, 0xE0, 0xC0,
  0xFF, 0xF0, 0x30, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x30,
  0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x06, 0x00, 0x70,
  0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x1C,
  0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x1C, 0x03, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0x80, 0x00, 0xE7, 0x00,
  0x01, 0xF8, 0x00, 0x0C, 0x30, 0x00, 0x19, 0x80, 0x01, 0xC3, 0x80, 0x01,
  0x9C, 0x00, 0x1C, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x8C,
  0x00, 0x18, 0x18, 0x00, 0x38, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x0E, 0x00,
  0x38, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x06, 0x00, 0x30,
  0x0C, 0x00, 0x60, 0x60, 0x07, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0,
  0x38, 0x0E, 0x00, 0x70, 0x18, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x80, 0x1C,
  0x1C, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0C, 0x1C,
  0x00, 0x18, 0x30, 0x00, 0xE1, 0x80, 0x01, 0x87, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0xE3, 0x80, 0x01, 0xC6, 0x00, 0x06, 0x38, 0x00, 0x0C,
  0xE0, 0x00, 0x73, 0x00, 0x00, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0,
  0x00, 0x37, 0x00, 0x00, 0xEC, 0x00, 0x03, 0x70, 0x00, 0x06, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x01,
  0xC0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x1C,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x18, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x18,
  0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x30, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x1C, 0x01, 0xC0, 0x01,
  0xC0, 0x1C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xC7, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x0F, 0xC0, 0x0F, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x04,
  0xFF, 0xF8, 0x00, 0x37, 0x81, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x1E, 0xC0,
  0x00, 0xFF, 0xF2, 0x00, 0x00, 0xFF, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 4, 52, 16, 6, -51 },
  { 27, 13, 19, 23, 5, -51 },
  { 58, 37, 51, 40, 2, -51 },
  { 294, 27, 58, 36, 4, -54 },
  { 490, 44, 52, 51, 4, -51 },
  { 776, 37, 52, 42, 4, -51 },
  { 1017, 3, 19, 13, 5, -51 },
  { 1025, 13, 62, 19, 3, -51 },
  { 1126, 13, 62, 19, 3, -51 },
  { 1227, 26, 26, 34, 4, -54 },
  { 1312, 30, 33, 36, 3, -42 },
  { 1436, 7, 17, 14, 3, -8 },
  { 1451, 17, 3, 21, 2, -21 },
  { 1458, 5, 6, 15, 5, -5 },
  { 1462, 22, 51, 24, 1, -51 },
  { 1603, 28, 52, 36, 4, -51 },
  { 1785, 15, 51, 36, 6, -51 },
  { 1881, 28, 51, 36, 4, -51 },
  { 2060, 28, 52, 36, 3, -51 },
  { 2242, 34, 51, 36, 1, -51 },
  { 2459, 28, 52, 36, 4, -51 },
  { 2641, 29, 52, 36, 4, -51 },
  { 2830, 28, 51, 36, 4, -51 },
  { 3009, 28, 52, 36, 4, -51 },
  { 3191, 29, 52, 36, 3, -51 },
  { 3380, 5, 39, 15, 5, -38 },
  { 3405, 7, 47, 15, 3, -38 },
  { 3447, 30, 31, 36, 3, -41 },
  { 3564, 30, 18, 36, 3, -34 },
  { 3632, 30, 31, 36, 3, -41 },
  { 3749, 22, 52, 26, 2, -51 },
  { 3892, 48, 58, 56, 4, -51 },
  { 4240, 37, 51, 37, 0, -51 },
  { 4476, 29, 51, 39, 7, -51 },
  { 4661, 33, 52, 39, 4, -51 },
  { 4876, 33, 51, 44, 7, -51 },
  { 5087, 24, 51, 35, 7, -51 },
  { 5240, 24, 51, 32, 7, -51 },
  { 5393, 37, 52, 46, 4, -51 },
  { 5634, 31, 51, 45, 7, -51 },
  { 5832, 12, 51, 19, 4, -51 },
  { 5909, 15, 64, 16, -5, -51 },
  { 6029, 29, 51, 36, 7, -51 },
  { 6214, 24, 51, 32, 7, -51 },
  { 6367, 42, 51, 56, 7, -51 },
  { 6635, 32, 51, 45, 7, -51 },
  { 6839, 39, 52, 48, 4, -51 },
  { 7093, 26, 51, 37, 7, -51 },
  { 7259, 39, 63, 48, 4, -51 },
  { 7567, 29, 51, 37, 7, -51 },
  { 7752, 27, 52, 35, 4, -51 },
  { 7928, 32, 51, 32, 0, -51 },
  { 8132, 33, 52, 45, 6, -51 },
  { 8347, 36, 51, 36, 0, -51 },
  { 8577, 55, 51, 57, 1, -51 },
  { 8928, 32, 51, 33, 0, -51 },
  { 9132, 32, 51, 32, 0, -51 },
  { 9336, 30, 51, 35, 2, -51 },
  { 9528, 14, 62, 22, 6, -51 },
  { 9637, 22, 51, 24, 1, -51 },
  { 9778, 14, 62, 22, 2, -51 },
  { 9887, 32, 29, 36, 2, -51 },
  { 10003, 29, 3, 29, 0, 6 },
  { 10014, 12, 11, 18, 3, -54 },
  { 10031, 25, 39, 33, 3, -38 },
  { 10153, 28, 55, 38, 6, -54 },
  { 10346, 24, 39, 30, 4, -38 },
  { 10463, 28, 55, 38, 4, -54 },
  { 10656, 27, 39, 35, 4, -38 },
  { 10788, 21, 54, 19, 1, -54 },
  { 10930, 28, 55, 38, 4, -38 },
  { 11123, 26, 54, 37, 6, -54 },
  { 11299, 5, 51, 15, 5, -51 },
  { 11331, 12, 68, 15, -2, -51 },
  { 11433, 24, 54, 30, 6, -54 },
  { 11595, 3, 54, 14, 6, -54 },
  { 11616, 44, 38, 55, 6, -38 },
  { 11825, 26, 38, 37, 6, -38 },
  { 11949, 29, 39, 37, 4, -38 },
  { 12091, 28, 55, 38, 6, -38 },
  { 12284, 28, 55, 38, 4, -38 },
  { 12477, 17, 38, 24, 6, -38 },
  { 12558, 23, 39, 29, 3, -38 },
  { 12671, 18, 48, 20, 1, -47 },
  { 12779, 26, 39, 37, 5, -38 },
  { 12906, 28, 38, 28, 0, -38 },
  { 13039, 44, 38, 46, 1, -38 },
  { 13248, 28, 38, 30, 1, -38 },
  { 13381, 28, 55, 29, 0, -38 },
  { 13574, 22, 38, 28, 3, -38 },
  { 13679, 20, 62, 25, 2, -51 },
  { 13834, 2, 71, 34, 16, -54 },
  { 13852, 19, 62, 25, 3, -51 },
  { 14000, 30, 6, 36, 3, -28 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight71pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT71PT7B_H_
