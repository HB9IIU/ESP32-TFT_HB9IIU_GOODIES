#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT46PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight46pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xC0, 0x00,
  0x37, 0xC0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60,
  0x30, 0x00, 0x40, 0x20, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x20, 0x00, 0xC0,
  0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x80, 0x40, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80,
  0xC0, 0x01, 0x00, 0xC0, 0x01, 0x00, 0x80, 0x03, 0x00, 0x80, 0x03, 0x01,
  0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0x02, 0x01, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03,
  0x00, 0x04, 0x03, 0x00, 0x04, 0x02, 0x00, 0x04, 0x02, 0x00, 0x0C, 0x06,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0x8E, 0x30, 0x47, 0x0C, 0x01, 0x83,
  0x00, 0x40, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0x40, 0xC0,
  0x18, 0x30, 0x07, 0x0C, 0x00, 0xE3, 0x00, 0x0E, 0xC0, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0xCE, 0x00, 0x30, 0xC0, 0x0C, 0x18, 0x03,
  0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0,
  0xC0, 0x30, 0x20, 0x0C, 0x1B, 0x83, 0x1C, 0xFF, 0xFE, 0x03, 0xFC, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x06,
  0x01, 0xC6, 0x00, 0x30, 0x0C, 0x18, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x06,
  0x02, 0x00, 0x80, 0x20, 0x18, 0x0C, 0x01, 0x00, 0xC0, 0x40, 0x08, 0x06,
  0x06, 0x00, 0xC0, 0x30, 0x20, 0x06, 0x01, 0x83, 0x00, 0x30, 0x0C, 0x10,
  0x01, 0x80, 0x61, 0x80, 0x04, 0x03, 0x08, 0x00, 0x20, 0x18, 0xC3, 0xE1,
  0x00, 0xC4, 0x33, 0x8C, 0x04, 0x63, 0x04, 0x60, 0x63, 0x30, 0x31, 0x83,
  0x31, 0x80, 0x8E, 0x71, 0x88, 0x04, 0x3F, 0x18, 0x40, 0x30, 0x00, 0xC6,
  0x01, 0x80, 0x0C, 0x30, 0x0C, 0x00, 0x61, 0x80, 0x60, 0x02, 0x0C, 0x03,
  0x00, 0x30, 0x60, 0x18, 0x01, 0x03, 0x00, 0xC0, 0x18, 0x08, 0x06, 0x00,
  0x80, 0x40, 0x30, 0x0C, 0x03, 0x01, 0x00, 0x40, 0x18, 0x18, 0x06, 0x00,
  0x40, 0xC0, 0x20, 0x03, 0x0C, 0x03, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x03, 0x8F, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x80, 0x30,
  0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x08, 0x03,
  0x00, 0x06, 0x01, 0x80, 0x03, 0x01, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x31,
  0xC0, 0x00, 0x19, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x60, 0x00, 0x06, 0x18, 0x00, 0x06, 0x0E, 0x00, 0xC6, 0x03, 0x00, 0x46,
  0x00, 0xC0, 0x63, 0x00, 0x30, 0x33, 0x00, 0x0C, 0x11, 0x80, 0x03, 0x18,
  0xC0, 0x01, 0xC8, 0x60, 0x00, 0x6C, 0x30, 0x00, 0x1C, 0x08, 0x00, 0x06,
  0x06, 0x00, 0x07, 0x83, 0x80, 0x06, 0x60, 0xE0, 0x0E, 0x38, 0x3C, 0x1E,
  0x0C, 0x07, 0xFC, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0x81, 0x81, 0x81,
  0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x02, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x10, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01,
  0x00, 0xC0, 0x30, 0x18, 0x07, 0xC0, 0x60, 0x60, 0x30, 0x10, 0x18, 0x08,
  0x0C, 0x0C, 0x06, 0x06, 0x06, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06,
  0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x01, 0xC3, 0x0F,
  0x7D, 0xBE, 0x07, 0xF0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x66, 0x00, 0x61,
  0x00, 0x30, 0xC0, 0x30, 0x30, 0x30, 0x0C, 0x08, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x33, 0x33, 0x66, 0x64, 0xCC, 0x80, 0xFF, 0xC0, 0x7D, 0x80, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xF3,
  0xC0, 0x30, 0x1C, 0x0C, 0x01, 0x81, 0x00, 0x18, 0x60, 0x01, 0x0C, 0x00,
  0x33, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x09, 0x80, 0x01, 0x30, 0x00,
  0x34, 0x00, 0x06, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0D, 0x00, 0x01, 0xA0, 0x00, 0x34, 0x00, 0x06, 0xC0, 0x00,
  0xD8, 0x00, 0x13, 0x00, 0x02, 0x60, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x03,
  0x18, 0x00, 0x43, 0x00, 0x18, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x38, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0xC0, 0x70, 0x7C, 0x3B, 0x18, 0xDC, 0x3E, 0x0D,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x07, 0xF8, 0x07,
  0x8F, 0x07, 0x00, 0x60, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xF8, 0x0F, 0x8F, 0x8F, 0x00, 0x71, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x3F, 0xC0,
  0x0F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x68, 0x00, 0x73, 0xE0, 0x78,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x66, 0x00, 0x01, 0x18, 0x00, 0x0C,
  0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x60,
  0x01, 0x81, 0x80, 0x0C, 0x06, 0x00, 0x20, 0x18, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x20, 0x06, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x01,
  0x81, 0x80, 0x06, 0x0C, 0x00, 0x18, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC2, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0xF8, 0x07, 0xFF, 0x81, 0x80, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC8, 0x00, 0xE3, 0xC0, 0xF0, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0xF0, 0xC0, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0xFE, 0x0C, 0xF1, 0xE3, 0x60,
  0x1C, 0xB0, 0x01, 0xA8, 0x00, 0x6C, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x34,
  0x00, 0x0D, 0x80, 0x02, 0x60, 0x01, 0x8C, 0x00, 0xC1, 0x80, 0x70, 0x38,
  0x38, 0x07, 0xF8, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x03, 0xFC, 0x01, 0xE3, 0xC0, 0x60, 0x0C, 0x18, 0x00, 0xC3, 0x00,
  0x0C, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xC4, 0x00,
  0x18, 0xC0, 0x06, 0x0C, 0x00, 0xC1, 0xC0, 0x70, 0x1C, 0x1C, 0x00, 0xEE,
  0x00, 0x07, 0x00, 0x03, 0xB8, 0x01, 0xC1, 0xC0, 0x70, 0x1C, 0x18, 0x00,
  0xC7, 0x00, 0x0C, 0xC0, 0x01, 0x90, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x0C, 0x60, 0x01,
  0x8E, 0x00, 0xE0, 0xF0, 0x78, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xC3,
  0x80, 0x60, 0x18, 0x18, 0x01, 0x86, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00,
  0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x01, 0x60, 0x00,
  0x2C, 0x00, 0x06, 0x80, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x0F, 0x30, 0x01,
  0x67, 0x00, 0x48, 0x78, 0x31, 0x03, 0xFC, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x07, 0x01, 0x03, 0xC0,
  0x3F, 0xE0, 0x00, 0xC0, 0x00, 0x4F, 0xB0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x60, 0x21, 0x8E, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x18, 0xC6, 0x63, 0x18, 0x8C, 0x62, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xE3, 0xE3, 0xC4, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x40, 0x04, 0x30, 0x07, 0xFC, 0x06,
  0x20, 0x0E, 0x04, 0x06, 0x60, 0x18, 0x04, 0x02, 0x60, 0x30, 0x04, 0x02,
  0x60, 0x30, 0x04, 0x03, 0x40, 0x60, 0x04, 0x03, 0x40, 0x60, 0x0C, 0x03,
  0xC0, 0x60, 0x0C, 0x03, 0xC0, 0x60, 0x0C, 0x03, 0xC0, 0x60, 0x0C, 0x03,
  0xC0, 0x60, 0x0C, 0x02, 0xC0, 0x60, 0x0C, 0x02, 0x40, 0x60, 0x0C, 0x06,
  0x40, 0x60, 0x1C, 0x06, 0x40, 0x30, 0x14, 0x0C, 0x60, 0x30, 0x36, 0x0C,
  0x60, 0x1F, 0xE3, 0xF8, 0x20, 0x0F, 0x81, 0xE0, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x02, 0x00,
  0x00, 0xF0, 0x3E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0x42, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x81, 0x00, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01,
  0x00, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0C,
  0x00, 0x30, 0x08, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x10,
  0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC3, 0x00, 0x1C, 0x60, 0x00, 0xCC, 0x00, 0x0D, 0x80,
  0x01, 0xB0, 0x00, 0x36, 0x00, 0x02, 0xC0, 0x00, 0x58, 0x00, 0x1B, 0x00,
  0x03, 0x60, 0x00, 0x6C, 0x00, 0x19, 0x80, 0x07, 0x30, 0x03, 0x87, 0xFF,
  0xC0, 0xFF, 0xFE, 0x18, 0x00, 0x73, 0x00, 0x07, 0x60, 0x00, 0x6C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0D, 0x80, 0x03, 0xB0, 0x00,
  0xE7, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0x8F, 0xC1,
  0xC0, 0x04, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x0C, 0x00, 0xF0, 0x30, 0x00, 0x70, 0xC0, 0x00, 0xC3, 0x00,
  0x01, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x00, 0x00,
  0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30,
  0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x70, 0x3F, 0xFF,
  0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xF8, 0xFE, 0x03, 0x80,
  0x06, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x38, 0x00, 0x03, 0x18, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x07, 0x00,
  0x03, 0x03, 0xF0, 0x3F, 0x00, 0xFF, 0xF8, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x18, 0xFF, 0x3E,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1B, 0xFC, 0xFE, 0x00, 0xC0,
  0x00, 0xF8, 0x00, 0x1B, 0x00, 0x06, 0x60, 0x01, 0x8C, 0x00, 0x61, 0x80,
  0x18, 0x30, 0x07, 0x06, 0x01, 0xC0, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x03,
  0x00, 0x60, 0xC0, 0x0C, 0x38, 0x01, 0x8E, 0x00, 0x31, 0x80, 0x06, 0x78,
  0x00, 0xDB, 0x80, 0x1E, 0x30, 0x03, 0x83, 0x00, 0x60, 0x70, 0x0C, 0x06,
  0x01, 0x80, 0x60, 0x30, 0x0E, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x18, 0x01,
  0x83, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x03, 0x30, 0x00,
  0x36, 0x00, 0x06, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xD8, 0x00, 0x00, 0xBD, 0x80, 0x00, 0x1B, 0xD8, 0x00, 0x01,
  0xBC, 0xC0, 0x00, 0x33, 0xCC, 0x00, 0x03, 0x3C, 0x40, 0x00, 0x23, 0xC6,
  0x00, 0x06, 0x3C, 0x60, 0x00, 0x63, 0xC2, 0x00, 0x04, 0x3C, 0x30, 0x00,
  0xC3, 0xC3, 0x00, 0x0C, 0x3C, 0x18, 0x01, 0x83, 0xC1, 0x80, 0x18, 0x3C,
  0x18, 0x01, 0x83, 0xC0, 0xC0, 0x30, 0x3C, 0x0C, 0x03, 0x03, 0xC0, 0x40,
  0x20, 0x3C, 0x06, 0x06, 0x03, 0xC0, 0x60, 0x60, 0x3C, 0x02, 0x04, 0x03,
  0xC0, 0x30, 0xC0, 0x3C, 0x03, 0x0C, 0x03, 0xC0, 0x19, 0x80, 0x3C, 0x01,
  0x98, 0x03, 0xC0, 0x19, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x30, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3D, 0x80, 0x01, 0xEC, 0x00, 0x0F,
  0x30, 0x00, 0x79, 0x80, 0x03, 0xC6, 0x00, 0x1E, 0x18, 0x00, 0xF0, 0xC0,
  0x07, 0x83, 0x00, 0x3C, 0x18, 0x01, 0xE0, 0x60, 0x0F, 0x03, 0x80, 0x78,
  0x0C, 0x03, 0xC0, 0x30, 0x1E, 0x01, 0x80, 0xF0, 0x06, 0x07, 0x80, 0x30,
  0x3C, 0x00, 0xC1, 0xE0, 0x03, 0x0F, 0x00, 0x18, 0x78, 0x00, 0x63, 0xC0,
  0x03, 0x1E, 0x00, 0x0C, 0xF0, 0x00, 0x37, 0x80, 0x01, 0xBC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x00,
  0xFF, 0x80, 0x01, 0xF1, 0xF0, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x03, 0x01,
  0x80, 0x00, 0xC1, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x06,
  0x60, 0x00, 0x03, 0x20, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x86,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0x38, 0x00, 0xC0,
  0x07, 0x83, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x0C,
  0x00, 0xE3, 0x00, 0x1C, 0xC0, 0x03, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x02, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0B, 0x00, 0x06, 0xC0, 0x01,
  0xB0, 0x00, 0x6C, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x0E, 0x30, 0x3F, 0x0F,
  0xFF, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xF1, 0xF0, 0x01, 0x80, 0x0E, 0x01, 0x80, 0x03, 0x01, 0x80,
  0x00, 0xC1, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x60,
  0x00, 0x03, 0x20, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x86, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0x38, 0x00, 0xE0, 0x07,
  0x83, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83,
  0x00, 0x38, 0x60, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x66,
  0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x02, 0x60, 0x00, 0xCC,
  0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0xC6, 0x00, 0x30, 0xC0, 0x3C, 0x1F,
  0xFE, 0x03, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x30, 0x30,
  0x06, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x00, 0xC3, 0x00, 0x1C, 0x60,
  0x01, 0x8C, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x36, 0x00, 0x06, 0xC0,
  0x00, 0x60, 0x03, 0xFF, 0x03, 0xC3, 0xF1, 0x80, 0x08, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x68, 0x00, 0x73,
  0xE0, 0x78, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0xC0, 0x00, 0x66, 0x00, 0x03,
  0x18, 0x00, 0x30, 0x60, 0x03, 0x81, 0xE0, 0xF0, 0x07, 0xFF, 0x00, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00,
  0x00, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x10, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x40, 0x01, 0x00, 0xC0, 0x06,
  0x01, 0x80, 0x0C, 0x01, 0x00, 0x10, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x04, 0x01, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x10, 0x18, 0x00,
  0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x41, 0x80, 0x00, 0xC6, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D,
  0x80, 0x00, 0x0A, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0D, 0x00, 0x03, 0x80, 0x01, 0x30,
  0x00, 0x70, 0x00, 0x66, 0x00, 0x1A, 0x00, 0x0C, 0xC0, 0x03, 0x60, 0x01,
  0x98, 0x00, 0x6C, 0x00, 0x21, 0x80, 0x09, 0x80, 0x0C, 0x30, 0x03, 0x10,
  0x01, 0x86, 0x00, 0x63, 0x00, 0x30, 0x40, 0x0C, 0x60, 0x0C, 0x0C, 0x01,
  0x0C, 0x01, 0x81, 0x80, 0x60, 0x80, 0x30, 0x30, 0x0C, 0x18, 0x06, 0x06,
  0x01, 0x83, 0x01, 0x80, 0x60, 0x20, 0x60, 0x30, 0x0C, 0x0C, 0x04, 0x06,
  0x01, 0x81, 0x80, 0xC0, 0xC0, 0x30, 0x30, 0x18, 0x30, 0x03, 0x04, 0x03,
  0x06, 0x00, 0x61, 0x80, 0x20, 0xC0, 0x0C, 0x30, 0x06, 0x18, 0x01, 0x86,
  0x00, 0xC6, 0x00, 0x18, 0x80, 0x18, 0xC0, 0x03, 0x30, 0x01, 0x18, 0x00,
  0x66, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x06, 0xC0, 0x00, 0x90, 0x00, 0xD8,
  0x00, 0x1E, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x01, 0x60, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x0C,
  0x06, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x20, 0x03, 0x03, 0x00, 0x18,
  0x30, 0x00, 0x61, 0x80, 0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x36,
  0x00, 0x01, 0x98, 0x00, 0x18, 0xC0, 0x00, 0x83, 0x00, 0x0C, 0x18, 0x00,
  0xC0, 0x60, 0x06, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x20, 0x30, 0x01,
  0x81, 0x80, 0x06, 0x18, 0x00, 0x31, 0x80, 0x00, 0xCC, 0x00, 0x06, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x1B, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x40, 0x00,
  0xC3, 0x00, 0x06, 0x18, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x30, 0x0C,
  0x01, 0x80, 0x60, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0x30, 0x60,
  0x01, 0x82, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x00, 0xD8, 0x00, 0x06,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x0C, 0xFF, 0xFF, 0xC0, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x03, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00,
  0x19, 0x00, 0x01, 0x98, 0x00, 0x30, 0x80, 0x03, 0x0C, 0x00, 0x60, 0x40,
  0x06, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x03, 0x01, 0x80, 0x30, 0x18, 0x01,
  0x83, 0x00, 0x18, 0x30, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0x6C, 0x00,
  0x06, 0xC0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x04, 0x03, 0x01, 0xE0, 0x1F, 0xF8, 0x38, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0xFF, 0x0F, 0xF3, 0x1C, 0x03, 0x70, 0x03, 0x60, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x60, 0x1B, 0x38, 0x31, 0x1F, 0xE1, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x1F, 0x03, 0x3F, 0xF0, 0x9C, 0x0E, 0x2C,
  0x00, 0xCA, 0x00, 0x32, 0x80, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xB0,
  0x00, 0x6E, 0x00, 0x1A, 0x80, 0x0C, 0x90, 0x06, 0x27, 0x07, 0x08, 0x7F,
  0x80, 0x00, 0x7C, 0x03, 0xFF, 0x0F, 0x01, 0x1C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0F,
  0x07, 0x03, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x07, 0xC1, 0x83, 0xFE, 0x30, 0xE0, 0x66, 0x30, 0x06,
  0xCC, 0x00, 0x79, 0x80, 0x07, 0x60, 0x00, 0xEC, 0x00, 0x1D, 0x80, 0x01,
  0xB0, 0x00, 0x34, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x68, 0x00, 0x0D, 0x00, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x0E,
  0xC0, 0x01, 0xCC, 0x00, 0x39, 0x80, 0x0B, 0x18, 0x03, 0x61, 0xC1, 0xCC,
  0x1F, 0xE1, 0x80, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0xE0, 0x60, 0x60, 0x0C,
  0x30, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x09, 0x80, 0x03, 0x60, 0x00, 0xD8,
  0x00, 0x34, 0x00, 0x0D, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x08, 0x3C, 0x0E, 0x03, 0xFF, 0x00,
  0x00, 0xFC, 0x0F, 0x30, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x3F, 0xF8, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x8C, 0x38, 0x19, 0x8C, 0x00, 0xB3,
  0x00, 0x1E, 0x60, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x03, 0x60, 0x00, 0x6C,
  0x00, 0x0D, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x03, 0xB0,
  0x00, 0x73, 0x00, 0x0E, 0x60, 0x02, 0xC6, 0x00, 0xD8, 0x70, 0x73, 0x07,
  0xF8, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x86, 0x00, 0x60, 0xFF,
  0xF8, 0x07, 0xFC, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC1, 0xF0, 0xCF, 0xFC, 0xDC, 0x0E, 0xB0, 0x06, 0xA0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xFD, 0x80, 0x00, 0x0D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x60, 0x07, 0x07, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0xFC, 0xF8, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x6C, 0x01, 0x98,
  0x06, 0x30, 0x1C, 0x60, 0x30, 0xC0, 0xC1, 0x83, 0x03, 0x0C, 0x06, 0x30,
  0x08, 0x60, 0x11, 0xC0, 0x26, 0xC0, 0x59, 0x80, 0xA1, 0x81, 0x81, 0x83,
  0x03, 0x06, 0x03, 0x0C, 0x06, 0x18, 0x06, 0x30, 0x06, 0x60, 0x0C, 0xC0,
  0x0D, 0x80, 0x1B, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xC0, 0x1E, 0x08, 0xFF, 0x07, 0xFC, 0x98, 0x18, 0xC0,
  0xEB, 0x00, 0xD8, 0x06, 0xA0, 0x0D, 0x00, 0x3C, 0x00, 0x70, 0x03, 0xC0,
  0x06, 0x00, 0x3C, 0x00, 0x60, 0x01, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x06, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x06,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0xC0, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x06, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0xC0, 0x06, 0x00, 0x10, 0x01, 0xE0, 0x8F, 0xFC, 0x9C, 0x0E,
  0xB0, 0x06, 0xA0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x00, 0xF0, 0x00, 0xFF,
  0xC0, 0x38, 0x1C, 0x0C, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x01, 0x98, 0x00,
  0x13, 0x00, 0x03, 0x60, 0x00, 0x68, 0x00, 0x0D, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0A, 0x00, 0x03, 0x60, 0x00,
  0x6C, 0x00, 0x0D, 0x80, 0x01, 0x90, 0x00, 0x63, 0x00, 0x0C, 0x30, 0x03,
  0x07, 0x00, 0xE0, 0x78, 0x78, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x21, 0xFF,
  0x09, 0xC0, 0xE2, 0x40, 0x0C, 0xB0, 0x03, 0x28, 0x00, 0x6C, 0x00, 0x1B,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1B, 0x80, 0x06, 0xA0, 0x01, 0xAC, 0x00, 0xCD, 0x80, 0x63,
  0x38, 0x78, 0xC7, 0xF8, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x8C, 0x38, 0x19,
  0x8C, 0x01, 0xB3, 0x00, 0x1E, 0x60, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x07,
  0x60, 0x00, 0x68, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x40, 0x00, 0x6C, 0x00, 0x1D,
  0x80, 0x03, 0xB0, 0x00, 0x73, 0x00, 0x1E, 0x60, 0x02, 0xC6, 0x00, 0xD8,
  0x70, 0x73, 0x07, 0xF8, 0x60, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x03, 0xD1, 0xFE, 0x70, 0x48,
  0x0A, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0xF8, 0xC0, 0x33,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xA0,
  0x03, 0x78, 0x1C, 0x7F, 0xF0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x3F, 0xF8, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC2, 0x0F, 0xC0, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xA0,
  0x00, 0xD8, 0x00, 0x6C, 0x00, 0x56, 0x00, 0x69, 0x80, 0x64, 0x70, 0xE2,
  0x1F, 0xE1, 0xC0, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x19, 0x80, 0x06, 0x30,
  0x01, 0x8C, 0x00, 0xC3, 0x00, 0x30, 0x60, 0x0C, 0x18, 0x06, 0x06, 0x01,
  0x80, 0x80, 0x60, 0x30, 0x30, 0x0C, 0x0C, 0x01, 0x03, 0x00, 0x61, 0x80,
  0x18, 0x60, 0x02, 0x18, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x04, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x3C,
  0x00, 0x60, 0x02, 0xC0, 0x0F, 0x00, 0x64, 0x00, 0xF0, 0x06, 0x60, 0x09,
  0x00, 0x66, 0x01, 0x98, 0x04, 0x60, 0x19, 0x80, 0xC2, 0x01, 0x98, 0x0C,
  0x30, 0x10, 0x80, 0xC3, 0x03, 0x0C, 0x08, 0x30, 0x30, 0xC1, 0x81, 0x82,
  0x0C, 0x18, 0x18, 0x60, 0x61, 0x81, 0x86, 0x06, 0x10, 0x18, 0x60, 0x63,
  0x00, 0xC4, 0x02, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x20, 0x04,
  0x80, 0x36, 0x00, 0x78, 0x01, 0x60, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xE0, 0x01, 0x8C, 0x00,
  0xC3, 0x00, 0x30, 0x60, 0x18, 0x18, 0x0C, 0x03, 0x03, 0x00, 0x61, 0x80,
  0x18, 0xC0, 0x03, 0x30, 0x00, 0x58, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x01,
  0xE0, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x03, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x18, 0x30, 0x03, 0x0C, 0x00, 0xC6, 0x00, 0x1B,
  0x00, 0x07, 0xC0, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x08, 0x80, 0x06, 0x30,
  0x01, 0x8C, 0x00, 0x41, 0x00, 0x30, 0x60, 0x0C, 0x18, 0x02, 0x02, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x10, 0x04, 0x0C, 0x01, 0x83, 0x00, 0x60, 0x80,
  0x08, 0x60, 0x03, 0x18, 0x00, 0xC4, 0x00, 0x13, 0x00, 0x06, 0xC0, 0x01,
  0xA0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x1F, 0x03, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x0F, 0x00, 0xF0, 0x03, 0x80,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x0F, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x80, 0x1F, 0x00, 0xF0, 0x18,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x3C, 0x0F, 0x00, 0x3F, 0x80, 0x3C, 0x3C, 0x0E, 0x00, 0xFF, 0xC0, 0x07,
  0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 33, 10, 4, -33 },
  { 14, 9, 12, 15, 3, -33 },
  { 28, 24, 33, 26, 1, -33 },
  { 127, 18, 38, 23, 2, -35 },
  { 213, 29, 33, 33, 2, -33 },
  { 333, 25, 33, 27, 2, -33 },
  { 437, 2, 12, 8, 3, -33 },
  { 440, 9, 40, 12, 2, -33 },
  { 485, 8, 40, 12, 2, -33 },
  { 525, 17, 17, 22, 2, -35 },
  { 562, 19, 21, 23, 2, -27 },
  { 612, 4, 11, 9, 2, -5 },
  { 618, 10, 1, 14, 2, -13 },
  { 620, 3, 3, 10, 3, -3 },
  { 622, 14, 33, 15, 1, -33 },
  { 680, 19, 33, 23, 2, -33 },
  { 759, 10, 33, 23, 4, -33 },
  { 801, 18, 33, 23, 2, -33 },
  { 876, 18, 33, 23, 2, -33 },
  { 951, 22, 33, 23, 1, -33 },
  { 1042, 18, 33, 23, 3, -33 },
  { 1117, 18, 34, 23, 3, -33 },
  { 1194, 19, 33, 23, 2, -33 },
  { 1273, 19, 33, 23, 2, -33 },
  { 1352, 19, 34, 23, 2, -33 },
  { 1433, 3, 25, 10, 3, -25 },
  { 1443, 5, 31, 10, 2, -25 },
  { 1463, 19, 21, 23, 2, -27 },
  { 1513, 19, 11, 23, 2, -22 },
  { 1540, 19, 21, 23, 2, -27 },
  { 1590, 14, 33, 17, 1, -33 },
  { 1648, 32, 37, 36, 2, -33 },
  { 1796, 24, 33, 24, 0, -33 },
  { 1895, 19, 33, 25, 4, -33 },
  { 1974, 21, 33, 25, 3, -33 },
  { 2061, 22, 33, 29, 4, -33 },
  { 2152, 16, 33, 23, 4, -33 },
  { 2218, 16, 33, 21, 4, -33 },
  { 2284, 24, 33, 30, 3, -33 },
  { 2383, 21, 33, 29, 4, -33 },
  { 2470, 8, 33, 13, 2, -33 },
  { 2503, 10, 41, 10, -4, -33 },
  { 2555, 19, 33, 23, 4, -33 },
  { 2634, 16, 33, 21, 4, -33 },
  { 2700, 28, 33, 36, 4, -33 },
  { 2816, 21, 33, 29, 4, -33 },
  { 2903, 25, 33, 31, 3, -33 },
  { 3007, 18, 33, 24, 4, -33 },
  { 3082, 25, 41, 31, 3, -33 },
  { 3211, 19, 33, 24, 4, -33 },
  { 3290, 18, 33, 23, 2, -33 },
  { 3365, 21, 33, 21, 0, -33 },
  { 3452, 21, 33, 29, 4, -33 },
  { 3539, 23, 33, 23, 0, -33 },
  { 3634, 35, 33, 37, 1, -33 },
  { 3779, 21, 33, 21, 0, -33 },
  { 3866, 21, 33, 21, 0, -33 },
  { 3953, 19, 33, 22, 2, -33 },
  { 4032, 9, 40, 14, 4, -33 },
  { 4077, 14, 33, 15, 1, -33 },
  { 4135, 9, 40, 14, 1, -33 },
  { 4180, 20, 19, 23, 2, -33 },
  { 4228, 19, 2, 18, 0, 4 },
  { 4233, 8, 7, 11, 2, -35 },
  { 4240, 16, 25, 22, 2, -25 },
  { 4290, 18, 35, 24, 4, -35 },
  { 4369, 16, 25, 19, 2, -25 },
  { 4419, 19, 35, 24, 2, -35 },
  { 4503, 18, 25, 22, 2, -25 },
  { 4560, 14, 35, 12, 0, -35 },
  { 4622, 19, 36, 24, 2, -25 },
  { 4708, 16, 35, 24, 4, -35 },
  { 4778, 3, 33, 9, 3, -33 },
  { 4791, 8, 44, 9, -2, -33 },
  { 4835, 15, 35, 19, 4, -35 },
  { 4901, 2, 35, 9, 4, -35 },
  { 4910, 28, 25, 36, 4, -25 },
  { 4998, 16, 25, 24, 4, -25 },
  { 5048, 19, 25, 24, 2, -25 },
  { 5108, 18, 36, 24, 4, -25 },
  { 5189, 19, 36, 24, 2, -25 },
  { 5275, 11, 25, 16, 4, -25 },
  { 5310, 15, 25, 19, 2, -25 },
  { 5357, 11, 30, 13, 1, -30 },
  { 5399, 17, 24, 24, 3, -24 },
  { 5450, 18, 24, 18, 0, -24 },
  { 5504, 28, 24, 29, 1, -24 },
  { 5588, 18, 24, 20, 1, -24 },
  { 5642, 18, 35, 18, 0, -24 },
  { 5721, 14, 24, 18, 2, -24 },
  { 5763, 12, 40, 16, 2, -33 },
  { 5823, 2, 46, 22, 10, -35 },
  { 5835, 12, 40, 16, 2, -33 },
  { 5895, 19, 4, 23, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight46pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT46PT7B_H_
