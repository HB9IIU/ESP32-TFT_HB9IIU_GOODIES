#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT41PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight41pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x80, 0x01, 0x7E,
  0xC3, 0xC3, 0x83, 0x83, 0x83, 0x82, 0x82, 0x82, 0x82, 0x82, 0x00, 0xC0,
  0xC0, 0x04, 0x04, 0x00, 0x20, 0x20, 0x01, 0x01, 0x00, 0x18, 0x08, 0x00,
  0xC0, 0xC0, 0x06, 0x06, 0x00, 0x20, 0x20, 0x01, 0x01, 0x03, 0xFF, 0xFF,
  0xC0, 0xC0, 0x40, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x01, 0x00, 0x08,
  0x08, 0x00, 0x40, 0x40, 0x06, 0x02, 0x00, 0x30, 0x30, 0x3F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xE0, 0x40, 0x40, 0x02, 0x02, 0x00, 0x10, 0x10, 0x01, 0x81,
  0x80, 0x0C, 0x0C, 0x00, 0x40, 0x60, 0x02, 0x02, 0x00, 0x10, 0x10, 0x01,
  0x80, 0x80, 0x00, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x1F, 0xFC, 0x39,
  0x8E, 0x61, 0x80, 0x41, 0x80, 0xC1, 0x80, 0xC1, 0x80, 0xC1, 0x80, 0xC1,
  0x80, 0xC1, 0x80, 0x61, 0x80, 0x31, 0x80, 0x1D, 0x80, 0x07, 0x80, 0x01,
  0xE0, 0x01, 0xF8, 0x01, 0x9C, 0x01, 0x86, 0x01, 0x82, 0x01, 0x83, 0x01,
  0x83, 0x01, 0x83, 0x01, 0x83, 0x01, 0x83, 0x01, 0x86, 0x81, 0x8C, 0xFD,
  0xF8, 0x3F, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0E, 0x00, 0x08,
  0x0F, 0xC0, 0x04, 0x02, 0x18, 0x03, 0x01, 0x83, 0x00, 0x80, 0x40, 0xC0,
  0x60, 0x30, 0x10, 0x10, 0x0C, 0x04, 0x0C, 0x03, 0x01, 0x02, 0x00, 0xC0,
  0x41, 0x80, 0x30, 0x10, 0x40, 0x0C, 0x04, 0x30, 0x03, 0x01, 0x08, 0x00,
  0xC0, 0x46, 0x3C, 0x30, 0x11, 0x1D, 0xC4, 0x0C, 0xC4, 0x11, 0x82, 0x33,
  0x06, 0x21, 0x88, 0x80, 0x8F, 0xC6, 0x20, 0x20, 0xE1, 0x18, 0x08, 0x00,
  0xC6, 0x02, 0x00, 0x21, 0x80, 0xC0, 0x18, 0x60, 0x30, 0x04, 0x18, 0x0C,
  0x03, 0x06, 0x02, 0x00, 0x81, 0x80, 0x80, 0x60, 0x20, 0x20, 0x10, 0x08,
  0x18, 0x0C, 0x03, 0x04, 0x02, 0x00, 0x63, 0x01, 0x80, 0x0F, 0x80, 0x01,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xC1, 0x80, 0x06, 0x03, 0x00, 0x18, 0x0C,
  0x00, 0x40, 0x10, 0x01, 0x00, 0x40, 0x04, 0x01, 0x00, 0x18, 0x0C, 0x00,
  0x60, 0x30, 0x00, 0xC1, 0x80, 0x01, 0x0C, 0x00, 0x06, 0x60, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x30, 0x00, 0x18, 0x40, 0x00, 0xC1, 0x80,
  0x66, 0x03, 0x01, 0x10, 0x06, 0x04, 0xC0, 0x0C, 0x33, 0x00, 0x18, 0x8C,
  0x00, 0x26, 0x30, 0x00, 0xD0, 0xC0, 0x01, 0xC3, 0x00, 0x07, 0x06, 0x00,
  0x36, 0x1C, 0x01, 0x8C, 0x38, 0x1C, 0x10, 0x3F, 0xC0, 0x70, 0xFA, 0xAA,
  0xA0, 0x06, 0x18, 0x20, 0xC1, 0x06, 0x0C, 0x30, 0x60, 0x81, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0x81, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x60, 0x40, 0x81,
  0x83, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x18, 0xE0, 0x20, 0x30, 0x18,
  0x18, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06,
  0x0C, 0x0C, 0x08, 0x18, 0x10, 0x30, 0xE0, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x1C, 0x20, 0xDF, 0x4F, 0x03, 0xE0, 0x03, 0x80,
  0x05, 0x80, 0x19, 0x80, 0x61, 0x01, 0x83, 0x07, 0x03, 0x04, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x7F, 0xFF, 0xC0, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x23, 0x66, 0x64, 0x4C, 0xC8, 0xFF, 0xFF,
  0xF0, 0xDF, 0x80, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x07, 0xFC, 0x07, 0x07, 0x03, 0x01, 0x83, 0x00, 0x61, 0x00, 0x11,
  0x80, 0x0C, 0xC0, 0x06, 0x40, 0x03, 0x20, 0x00, 0xB0, 0x00, 0x58, 0x00,
  0x2C, 0x00, 0x16, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x58, 0x00, 0x24, 0x00, 0x12, 0x00, 0x09, 0x80, 0x0C,
  0xC0, 0x06, 0x60, 0x02, 0x10, 0x03, 0x0C, 0x01, 0x83, 0x01, 0x80, 0xC1,
  0x80, 0x3F, 0x80, 0x03, 0x07, 0x1D, 0x31, 0x61, 0xC1, 0x81, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0xC0, 0x1F, 0xF0,
  0x70, 0x18, 0x40, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x03, 0x80, 0x3F, 0xF0,
  0x70, 0x1C, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x30,
  0x0F, 0xC0, 0x0F, 0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x80, 0x0C, 0xE0, 0x38, 0x7F, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0B, 0x00, 0x03, 0x60, 0x00, 0xCC, 0x00, 0x11,
  0x80, 0x06, 0x30, 0x01, 0x86, 0x00, 0x20, 0xC0, 0x0C, 0x18, 0x03, 0x03,
  0x00, 0x40, 0x60, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x30, 0x30, 0x06,
  0x04, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x03, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x7F, 0xFC, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC2, 0x00, 0xFF, 0xF0, 0x40, 0x38, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x80, 0x18, 0xE0,
  0x70, 0x7F, 0xE0, 0x00, 0x7C, 0x00, 0xFF, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x3F, 0x02, 0x79, 0xE3, 0x60, 0x19, 0xE0,
  0x06, 0xE0, 0x03, 0x70, 0x00, 0xB0, 0x00, 0x78, 0x00, 0x34, 0x00, 0x1A,
  0x00, 0x0D, 0x00, 0x06, 0xC0, 0x03, 0x60, 0x01, 0x10, 0x01, 0x8C, 0x00,
  0xC3, 0x00, 0xC0, 0xC1, 0xC0, 0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x07,
  0xFC, 0x06, 0x03, 0x06, 0x00, 0xC6, 0x00, 0x23, 0x00, 0x19, 0x80, 0x0C,
  0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x0C, 0x01, 0x83, 0x01, 0x80, 0xC1,
  0x80, 0x3B, 0x80, 0x07, 0x00, 0x0E, 0xE0, 0x1C, 0x18, 0x18, 0x07, 0x18,
  0x01, 0x8C, 0x00, 0x6C, 0x00, 0x16, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0x20, 0x01, 0x98, 0x00, 0xC6, 0x00, 0xC1, 0x81, 0xC0, 0x7F,
  0xC0, 0x03, 0xC0, 0x0F, 0xF0, 0x38, 0x18, 0x30, 0x0C, 0x60, 0x06, 0x40,
  0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x07, 0x60, 0x05, 0x30, 0x19, 0x1F,
  0xF1, 0x07, 0xC3, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x40, 0xE0, 0x3F,
  0xC0, 0xDF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xC0, 0x77, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x26, 0x66, 0x44, 0xC8, 0x80,
  0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x80,
  0x00, 0x60, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x03, 0xFE, 0x30, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x01,
  0xC0, 0x06, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x43, 0x00, 0x00, 0x06, 0x20, 0x07, 0xE0, 0x26, 0x01,
  0xC7, 0x02, 0x60, 0x30, 0x30, 0x34, 0x06, 0x03, 0x03, 0x40, 0x40, 0x30,
  0x3C, 0x0C, 0x03, 0x03, 0xC0, 0x80, 0x30, 0x1C, 0x08, 0x02, 0x03, 0xC0,
  0x80, 0x20, 0x3C, 0x08, 0x02, 0x03, 0xC0, 0x80, 0x20, 0x3C, 0x08, 0x06,
  0x02, 0xC0, 0xC0, 0x60, 0x24, 0x0C, 0x0F, 0x06, 0x40, 0x61, 0x90, 0xC6,
  0x03, 0xF1, 0xF8, 0x60, 0x04, 0x06, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x10, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x14, 0x00, 0x00, 0xB0, 0x00, 0x0C, 0x80,
  0x00, 0x44, 0x00, 0x02, 0x30, 0x00, 0x30, 0x80, 0x01, 0x04, 0x00, 0x08,
  0x30, 0x00, 0xC0, 0x80, 0x04, 0x04, 0x00, 0x20, 0x30, 0x03, 0x01, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x7F, 0xFC, 0x02, 0x00,
  0x30, 0x30, 0x01, 0x81, 0x80, 0x04, 0x08, 0x00, 0x30, 0xC0, 0x01, 0x86,
  0x00, 0x04, 0x20, 0x00, 0x33, 0x00, 0x01, 0x90, 0x00, 0x05, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0x80, 0xFF, 0xF0, 0x40, 0x1E, 0x20, 0x01, 0x90, 0x00,
  0xC8, 0x00, 0x34, 0x00, 0x1A, 0x00, 0x0D, 0x00, 0x06, 0x80, 0x03, 0x40,
  0x01, 0xA0, 0x01, 0x90, 0x01, 0x88, 0x03, 0x87, 0xFF, 0x02, 0x01, 0xE1,
  0x00, 0x0C, 0x80, 0x03, 0x40, 0x01, 0xA0, 0x00, 0x50, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x02, 0x80, 0x03, 0x40, 0x03, 0x20,
  0x03, 0x90, 0x1F, 0x8F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xFC, 0x0E,
  0x01, 0x83, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x0E, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x10, 0x0F, 0x82, 0x00,
  0x38, 0x40, 0x01, 0x88, 0x00, 0x19, 0x00, 0x03, 0x20, 0x00, 0x34, 0x00,
  0x06, 0x80, 0x00, 0x50, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x28, 0x00, 0x0D, 0x00, 0x01, 0xA0, 0x00,
  0x24, 0x00, 0x0C, 0x80, 0x03, 0x10, 0x00, 0xC2, 0x00, 0x70, 0x40, 0xFC,
  0x0F, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x03, 0xFF, 0xE8, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0xC0, 0x38, 0x03, 0x81, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x34, 0x00,
  0x00, 0xD0, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xC1,
  0x80, 0x03, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xC0, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x8F, 0xE0, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0xA3, 0x9F, 0x80, 0x80, 0x03, 0x40,
  0x03, 0x20, 0x03, 0x10, 0x03, 0x08, 0x03, 0x04, 0x01, 0x82, 0x01, 0x81,
  0x01, 0x80, 0x81, 0x80, 0x41, 0x80, 0x21, 0x80, 0x10, 0xC0, 0x08, 0xC0,
  0x04, 0xF0, 0x02, 0xD8, 0x01, 0xC6, 0x00, 0xC1, 0x80, 0x40, 0xC0, 0x20,
  0x30, 0x10, 0x0C, 0x08, 0x06, 0x04, 0x01, 0x82, 0x00, 0x61, 0x00, 0x30,
  0x80, 0x0C, 0x40, 0x03, 0x20, 0x01, 0x90, 0x00, 0x68, 0x00, 0x18, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0xFF, 0xFC, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xA0, 0x00, 0x05, 0xB0,
  0x00, 0x05, 0xB0, 0x00, 0x0D, 0x90, 0x00, 0x09, 0x98, 0x00, 0x19, 0x98,
  0x00, 0x19, 0x88, 0x00, 0x11, 0x8C, 0x00, 0x31, 0x8C, 0x00, 0x31, 0x84,
  0x00, 0x21, 0x86, 0x00, 0x61, 0x82, 0x00, 0x41, 0x83, 0x00, 0x41, 0x83,
  0x00, 0xC1, 0x81, 0x00, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x80,
  0x81, 0x01, 0x80, 0xC3, 0x01, 0x80, 0x43, 0x01, 0x80, 0x62, 0x01, 0x80,
  0x66, 0x01, 0x80, 0x24, 0x01, 0x80, 0x3C, 0x01, 0x80, 0x3C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x06,
  0xC0, 0x01, 0xB0, 0x00, 0x66, 0x00, 0x18, 0x80, 0x06, 0x30, 0x01, 0x86,
  0x00, 0x61, 0x80, 0x18, 0x30, 0x06, 0x04, 0x01, 0x81, 0x80, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x01, 0x81, 0x80, 0x60, 0x60, 0x0C, 0x18, 0x01, 0x06,
  0x00, 0x61, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0x66, 0x00, 0x09, 0x80,
  0x03, 0x60, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xFF, 0x00, 0x1C, 0x03, 0x80, 0x60, 0x03, 0x81, 0x80,
  0x03, 0x02, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x10, 0x00, 0x06, 0x60, 0x00,
  0x04, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0D, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x98, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x08, 0x30,
  0x00, 0x30, 0x70, 0x00, 0xC0, 0x70, 0x03, 0x00, 0x78, 0x1C, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xE1, 0x00, 0xF2, 0x00, 0x74, 0x00, 0x68, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xD0, 0x01, 0xA0, 0x0E, 0x7F, 0xF0, 0xFF, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0xFF, 0x00, 0x1C, 0x03, 0x80, 0x60, 0x03, 0x81, 0x80, 0x03, 0x02,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x10, 0x00, 0x06, 0x60, 0x00, 0x04, 0xC0,
  0x00, 0x09, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x34, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0D, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x98, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x08, 0x30, 0x00, 0x30,
  0x70, 0x00, 0xC0, 0x70, 0x03, 0x00, 0x78, 0x1C, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0xFF, 0xE0, 0x40, 0x3C,
  0x20, 0x07, 0x10, 0x01, 0x88, 0x00, 0x64, 0x00, 0x32, 0x00, 0x09, 0x00,
  0x04, 0x80, 0x02, 0x40, 0x03, 0x20, 0x01, 0x90, 0x00, 0x88, 0x00, 0xC4,
  0x00, 0xC2, 0x07, 0xC1, 0xFF, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x18,
  0x10, 0x04, 0x08, 0x03, 0x04, 0x00, 0x82, 0x00, 0x61, 0x00, 0x18, 0x80,
  0x0C, 0x40, 0x03, 0x20, 0x01, 0x90, 0x00, 0x68, 0x00, 0x38, 0x01, 0xE0,
  0x0F, 0xFE, 0x38, 0x06, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0xE0, 0x38, 0x7F, 0xF0, 0xFF, 0xFF,
  0xC0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x16, 0x00,
  0x06, 0xC0, 0x00, 0xCC, 0x00, 0x30, 0xC0, 0x0C, 0x0E, 0x07, 0x00, 0xFF,
  0xC0, 0xC0, 0x00, 0x1A, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x42,
  0x00, 0x06, 0x10, 0x00, 0x30, 0xC0, 0x01, 0x02, 0x00, 0x18, 0x10, 0x00,
  0xC0, 0xC0, 0x04, 0x06, 0x00, 0x60, 0x10, 0x03, 0x00, 0xC0, 0x10, 0x06,
  0x01, 0x80, 0x10, 0x0C, 0x00, 0xC0, 0x40, 0x06, 0x02, 0x00, 0x10, 0x30,
  0x00, 0xC1, 0x80, 0x06, 0x08, 0x00, 0x10, 0xC0, 0x00, 0xC6, 0x00, 0x06,
  0x20, 0x00, 0x13, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x07, 0x80, 0x07,
  0x00, 0x0D, 0x00, 0x0E, 0x00, 0x12, 0x00, 0x14, 0x00, 0x66, 0x00, 0x68,
  0x00, 0xCC, 0x00, 0xD8, 0x01, 0x88, 0x01, 0x30, 0x02, 0x10, 0x02, 0x20,
  0x0C, 0x30, 0x0C, 0x40, 0x18, 0x60, 0x18, 0xC0, 0x30, 0x40, 0x21, 0x80,
  0x40, 0x80, 0x41, 0x01, 0x81, 0x81, 0x82, 0x03, 0x03, 0x03, 0x06, 0x06,
  0x06, 0x04, 0x0C, 0x08, 0x04, 0x08, 0x08, 0x30, 0x0C, 0x30, 0x10, 0x60,
  0x18, 0x60, 0x30, 0xC0, 0x30, 0x80, 0x61, 0x00, 0x21, 0x00, 0x46, 0x00,
  0x66, 0x00, 0x8C, 0x00, 0xCC, 0x01, 0x98, 0x01, 0x90, 0x03, 0x20, 0x01,
  0x20, 0x02, 0xC0, 0x03, 0xC0, 0x05, 0x80, 0x07, 0x80, 0x0B, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC6, 0x00, 0x10, 0x40, 0x06, 0x0C, 0x01, 0x80, 0x80, 0x30, 0x18,
  0x0C, 0x01, 0x01, 0x80, 0x30, 0x60, 0x02, 0x08, 0x00, 0x63, 0x00, 0x06,
  0x40, 0x00, 0xD8, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x05,
  0x00, 0x01, 0xB0, 0x00, 0x23, 0x00, 0x0C, 0x60, 0x03, 0x06, 0x00, 0x60,
  0xC0, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x18, 0x10, 0x01, 0x06, 0x00,
  0x31, 0x80, 0x02, 0x30, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00,
  0x36, 0x00, 0x18, 0x80, 0x06, 0x30, 0x03, 0x04, 0x00, 0xC1, 0x80, 0x20,
  0x20, 0x18, 0x0C, 0x04, 0x01, 0x03, 0x00, 0x60, 0x80, 0x08, 0x60, 0x03,
  0x10, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xE0,
  0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0xFF, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0B, 0x00, 0x06, 0x40, 0x01, 0x18, 0x00, 0xC2, 0x00, 0x20, 0xC0, 0x18,
  0x10, 0x0C, 0x06, 0x03, 0x00, 0x81, 0x80, 0x30, 0x60, 0x04, 0x30, 0x01,
  0x8C, 0x00, 0x66, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0xC1, 0x83,
  0x04, 0x08, 0x10, 0x0F, 0xE0, 0xF1, 0xC2, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x7F, 0xCF, 0x03,
  0x60, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x01,
  0x70, 0x0D, 0x60, 0x64, 0xFF, 0x10, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x61, 0xF8, 0x33, 0x8F, 0x1B, 0x01, 0x8F, 0x00, 0x67, 0x00, 0x1B,
  0x80, 0x0D, 0x80, 0x02, 0xC0, 0x01, 0x60, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x02, 0xC0, 0x01, 0x60,
  0x01, 0xB8, 0x00, 0xDC, 0x00, 0xCD, 0x00, 0xC6, 0xE0, 0xE3, 0x1F, 0xC0,
  0x03, 0xF8, 0x3C, 0x71, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x0C, 0x1F, 0xF0, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x07, 0xE1, 0x0E,
  0x39, 0x18, 0x0D, 0x30, 0x07, 0x60, 0x03, 0x60, 0x03, 0x40, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x03, 0x60, 0x03, 0x20, 0x07, 0x30,
  0x05, 0x1C, 0x19, 0x0F, 0xF1, 0x07, 0xE0, 0x0E, 0x38, 0x18, 0x0C, 0x30,
  0x04, 0x60, 0x06, 0x60, 0x02, 0x40, 0x02, 0x40, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x02, 0x1C, 0x06, 0x07,
  0xFC, 0x03, 0xF8, 0x30, 0x41, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x01, 0xFE, 0x3F, 0xF0, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x00, 0x07, 0xF1, 0x0E, 0x39, 0x18, 0x0D, 0x30, 0x07,
  0x60, 0x03, 0x60, 0x03, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x01,
  0x40, 0x03, 0x60, 0x03, 0x20, 0x07, 0x30, 0x0D, 0x1C, 0x19, 0x0F, 0xF1,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x60, 0x0C, 0x7F, 0xF8, 0x0F, 0xE0, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x87, 0xE3, 0x38, 0xE6, 0xC0, 0x6F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x80, 0x5F, 0x00, 0x00, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x80, 0x0C, 0x1C, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x3E, 0x78, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x3C,
  0x01, 0xB0, 0x0C, 0xC0, 0x63, 0x03, 0x0C, 0x08, 0x30, 0x60, 0xC3, 0x03,
  0x18, 0x0C, 0xE0, 0x33, 0x80, 0xD3, 0x03, 0xC4, 0x0E, 0x18, 0x30, 0x30,
  0xC0, 0xC3, 0x01, 0x8C, 0x03, 0x30, 0x0C, 0xC0, 0x1B, 0x00, 0x2C, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC7, 0xE0, 0x7E,
  0x33, 0x1C, 0x79, 0xCD, 0x01, 0xB0, 0x1B, 0x80, 0x28, 0x02, 0xE0, 0x0E,
  0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0,
  0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03,
  0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30,
  0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00,
  0x30, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x30, 0xC3, 0xF1, 0x9C,
  0x73, 0x60, 0x37, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x40, 0x07, 0xF0, 0x07, 0x1E, 0x06, 0x01, 0x86, 0x00, 0x46,
  0x00, 0x33, 0x00, 0x09, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06, 0x80,
  0x03, 0x60, 0x01, 0x30, 0x01, 0x8C, 0x00, 0x86, 0x00, 0xC1, 0xC1, 0xC0,
  0x3F, 0xC0, 0xC3, 0xF0, 0x67, 0x1E, 0x36, 0x03, 0x1A, 0x00, 0xCE, 0x00,
  0x37, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x02, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x05, 0x80, 0x02,
  0xE0, 0x03, 0x70, 0x01, 0xBC, 0x01, 0x9A, 0x01, 0xCC, 0xC1, 0xC6, 0x3F,
  0x83, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x07, 0xE1,
  0x0E, 0x39, 0x18, 0x0D, 0x30, 0x05, 0x60, 0x03, 0x60, 0x03, 0x40, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x03, 0x60, 0x05,
  0x30, 0x0D, 0x1C, 0x19, 0x0F, 0xF1, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0xC7, 0xF3, 0xBD, 0x83, 0xC0, 0xE0, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x1F, 0xE1, 0xC3, 0xD8, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x07, 0x00, 0x6C, 0x07, 0x3F, 0xE0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30,
  0x1F, 0xFF, 0xFC, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40,
  0x10, 0x06, 0x00, 0xFC, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0D, 0x00, 0x2B, 0x00, 0xD3, 0x07, 0x23, 0xF8, 0x40, 0xC0, 0x03,
  0xC0, 0x03, 0x40, 0x02, 0x60, 0x06, 0x60, 0x06, 0x20, 0x04, 0x30, 0x0C,
  0x30, 0x0C, 0x10, 0x08, 0x18, 0x18, 0x18, 0x18, 0x08, 0x10, 0x0C, 0x30,
  0x0C, 0x30, 0x04, 0x20, 0x06, 0x20, 0x06, 0x60, 0x02, 0x40, 0x03, 0x40,
  0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x80, 0x08, 0x01, 0xC0, 0x0E, 0x00,
  0xB0, 0x07, 0x00, 0x58, 0x02, 0x80, 0x64, 0x03, 0x40, 0x33, 0x01, 0xB0,
  0x11, 0x80, 0x98, 0x08, 0xC0, 0xC4, 0x0C, 0x20, 0x62, 0x06, 0x18, 0x21,
  0x82, 0x0C, 0x10, 0xC1, 0x06, 0x18, 0x21, 0x81, 0x0C, 0x18, 0xC0, 0xC4,
  0x0C, 0x40, 0x66, 0x02, 0x20, 0x13, 0x01, 0x30, 0x09, 0x00, 0xD8, 0x06,
  0x80, 0x68, 0x03, 0xC0, 0x14, 0x00, 0xE0, 0x0A, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x01, 0x00, 0xC0, 0x06, 0x60, 0x06, 0x20, 0x0C, 0x30, 0x08, 0x18,
  0x18, 0x18, 0x30, 0x0C, 0x20, 0x04, 0x60, 0x06, 0xC0, 0x03, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x06, 0x40, 0x0C, 0x60, 0x0C, 0x30, 0x18,
  0x10, 0x10, 0x18, 0x30, 0x08, 0x60, 0x0C, 0x60, 0x06, 0xC0, 0x03, 0xC0,
  0x01, 0x40, 0x03, 0x60, 0x03, 0x60, 0x02, 0x20, 0x06, 0x30, 0x06, 0x30,
  0x04, 0x10, 0x0C, 0x18, 0x0C, 0x18, 0x08, 0x08, 0x18, 0x0C, 0x18, 0x0C,
  0x10, 0x04, 0x30, 0x06, 0x30, 0x06, 0x20, 0x02, 0x60, 0x03, 0x60, 0x03,
  0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xFC,
  0x00, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x04,
  0x00, 0x7F, 0xFC, 0x00, 0xF0, 0x38, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x18, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x07, 0x00, 0x30, 0x06,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x80, 0x30, 0x03, 0x00, 0x1C, 0x0F, 0x03, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x60, 0x0C, 0x03, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0xE0, 0xE0,
  0xE0, 0x1F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 29, 9, 3, -29 },
  { 12, 8, 10, 13, 3, -29 },
  { 22, 21, 29, 23, 1, -29 },
  { 99, 16, 33, 21, 2, -31 },
  { 165, 26, 30, 30, 2, -30 },
  { 263, 22, 30, 24, 2, -30 },
  { 346, 2, 10, 7, 3, -29 },
  { 349, 7, 35, 11, 2, -29 },
  { 380, 8, 35, 11, 1, -29 },
  { 415, 15, 15, 20, 2, -31 },
  { 444, 17, 19, 21, 2, -24 },
  { 485, 4, 10, 8, 2, -5 },
  { 490, 10, 2, 12, 1, -12 },
  { 493, 3, 3, 9, 3, -3 },
  { 495, 12, 29, 14, 1, -29 },
  { 539, 17, 30, 21, 2, -30 },
  { 603, 8, 29, 21, 4, -29 },
  { 632, 16, 30, 21, 2, -30 },
  { 692, 16, 30, 21, 2, -30 },
  { 752, 19, 29, 21, 1, -29 },
  { 821, 16, 29, 21, 3, -29 },
  { 879, 17, 30, 21, 2, -30 },
  { 943, 17, 29, 21, 2, -29 },
  { 1005, 17, 30, 21, 2, -30 },
  { 1069, 16, 30, 21, 2, -30 },
  { 1129, 3, 22, 9, 3, -22 },
  { 1138, 4, 27, 9, 2, -22 },
  { 1152, 17, 18, 21, 2, -24 },
  { 1191, 17, 9, 21, 2, -19 },
  { 1211, 17, 18, 21, 2, -24 },
  { 1250, 13, 30, 15, 1, -30 },
  { 1299, 28, 33, 32, 2, -29 },
  { 1415, 21, 29, 21, 0, -29 },
  { 1492, 17, 29, 23, 4, -29 },
  { 1554, 19, 30, 22, 2, -30 },
  { 1626, 19, 29, 25, 4, -29 },
  { 1695, 14, 29, 20, 4, -29 },
  { 1746, 14, 29, 18, 4, -29 },
  { 1797, 22, 30, 27, 2, -30 },
  { 1880, 18, 29, 26, 4, -29 },
  { 1946, 7, 29, 11, 2, -29 },
  { 1972, 9, 36, 9, -3, -29 },
  { 2013, 17, 29, 21, 4, -29 },
  { 2075, 14, 29, 18, 4, -29 },
  { 2126, 24, 29, 32, 4, -29 },
  { 2213, 18, 29, 26, 4, -29 },
  { 2279, 23, 30, 28, 2, -30 },
  { 2366, 15, 29, 21, 4, -29 },
  { 2421, 23, 37, 28, 2, -30 },
  { 2528, 17, 29, 21, 4, -29 },
  { 2590, 16, 30, 20, 2, -30 },
  { 2650, 18, 29, 19, 0, -29 },
  { 2716, 19, 29, 26, 4, -29 },
  { 2785, 21, 29, 21, 0, -29 },
  { 2862, 31, 29, 33, 1, -29 },
  { 2975, 19, 29, 19, 0, -29 },
  { 3044, 18, 29, 18, 0, -29 },
  { 3110, 18, 29, 20, 1, -29 },
  { 3176, 9, 35, 13, 3, -29 },
  { 3216, 12, 29, 14, 1, -29 },
  { 3260, 8, 35, 13, 1, -29 },
  { 3295, 18, 16, 21, 1, -29 },
  { 3331, 17, 1, 16, 0, 4 },
  { 3334, 6, 6, 10, 2, -31 },
  { 3339, 14, 22, 19, 2, -22 },
  { 3378, 17, 31, 22, 3, -31 },
  { 3444, 14, 22, 17, 2, -22 },
  { 3483, 16, 31, 22, 2, -31 },
  { 3545, 16, 22, 20, 2, -22 },
  { 3589, 13, 31, 11, 0, -31 },
  { 3640, 16, 32, 22, 2, -22 },
  { 3704, 15, 31, 21, 3, -31 },
  { 3763, 3, 30, 8, 3, -30 },
  { 3775, 7, 40, 8, -1, -30 },
  { 3810, 14, 31, 17, 3, -31 },
  { 3865, 2, 31, 8, 3, -31 },
  { 3873, 26, 22, 32, 3, -22 },
  { 3945, 15, 22, 21, 3, -22 },
  { 3987, 17, 22, 21, 2, -22 },
  { 4034, 17, 32, 22, 3, -22 },
  { 4102, 16, 32, 22, 2, -22 },
  { 4166, 10, 22, 14, 3, -22 },
  { 4194, 13, 22, 17, 2, -22 },
  { 4230, 10, 27, 12, 1, -27 },
  { 4264, 15, 22, 21, 3, -22 },
  { 4306, 16, 22, 16, 0, -22 },
  { 4350, 25, 22, 26, 1, -22 },
  { 4419, 16, 22, 18, 1, -22 },
  { 4463, 16, 32, 16, 0, -22 },
  { 4527, 13, 22, 16, 1, -22 },
  { 4563, 12, 35, 14, 1, -29 },
  { 4616, 2, 41, 20, 9, -31 },
  { 4627, 11, 35, 14, 2, -29 },
  { 4676, 17, 3, 21, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight41pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT41PT7B_H_
