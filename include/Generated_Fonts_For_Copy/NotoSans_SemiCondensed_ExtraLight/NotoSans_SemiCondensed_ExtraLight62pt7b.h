#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT62PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight62pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x40,
  0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0x60, 0x36, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x03, 0x60, 0x34, 0x03,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x80, 0x18,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x07, 0x00, 0x30, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0x18, 0x7C, 0x1C,
  0x18, 0x0C, 0x38, 0x18, 0x00, 0x70, 0x18, 0x00, 0x60, 0x18, 0x00, 0xE0,
  0x18, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x18, 0x00, 0xE0,
  0x18, 0x00, 0xE0, 0x18, 0x00, 0x60, 0x18, 0x00, 0x70, 0x18, 0x00, 0x38,
  0x18, 0x00, 0x1C, 0x18, 0x00, 0x0F, 0x18, 0x00, 0x07, 0xD8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1B, 0xE0, 0x00,
  0x18, 0xF0, 0x00, 0x18, 0x3C, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x0E, 0x00,
  0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00,
  0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x07, 0x00,
  0x18, 0x06, 0x00, 0x18, 0x0E, 0x80, 0x18, 0x1C, 0xF0, 0x18, 0x78, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0xE0, 0x00,
  0x30, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x0E,
  0x01, 0xC0, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x03,
  0x80, 0x1C, 0x03, 0x00, 0x07, 0x00, 0x38, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0x18, 0x00, 0x60, 0x30, 0x00, 0x30, 0x00, 0xC0, 0xE0, 0x00,
  0x60, 0x03, 0x81, 0x80, 0x00, 0xE0, 0x07, 0x07, 0x00, 0x01, 0xC0, 0x0E,
  0x0C, 0x00, 0x01, 0x80, 0x1C, 0x38, 0x3F, 0x03, 0x00, 0x30, 0x60, 0xFF,
  0x06, 0x00, 0x61, 0xC3, 0x87, 0x0C, 0x00, 0xC3, 0x0E, 0x07, 0x1C, 0x03,
  0x8E, 0x18, 0x06, 0x18, 0x06, 0x18, 0x60, 0x0E, 0x38, 0x1C, 0x30, 0xC0,
  0x0C, 0x38, 0x70, 0xC1, 0x80, 0x18, 0x3F, 0xC1, 0x87, 0x00, 0x30, 0x1E,
  0x06, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x18, 0x00, 0xE0, 0x00, 0x30, 0x30,
  0x01, 0xC0, 0x00, 0x60, 0x60, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x07, 0x00,
  0x03, 0x01, 0x80, 0x0E, 0x00, 0x0E, 0x03, 0x00, 0x1C, 0x00, 0x18, 0x06,
  0x00, 0x38, 0x00, 0x70, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x1C, 0x00, 0xC0,
  0x03, 0x80, 0x18, 0x01, 0x80, 0x06, 0x00, 0x30, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x0E, 0x00, 0x30, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x00, 0xC0, 0x30,
  0x01, 0x80, 0x01, 0xC0, 0xC0, 0x03, 0x00, 0x01, 0xE7, 0x80, 0x0C, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x06, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x39,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x0E, 0x00, 0x60, 0x01, 0x86,
  0x00, 0x38, 0x00, 0xC7, 0x00, 0x0E, 0x00, 0xE3, 0x00, 0x03, 0x80, 0x63,
  0x80, 0x00, 0xE0, 0x31, 0xC0, 0x00, 0x38, 0x38, 0xE0, 0x00, 0x0C, 0x18,
  0x70, 0x00, 0x07, 0x1C, 0x38, 0x00, 0x01, 0xCC, 0x1C, 0x00, 0x00, 0x7E,
  0x0E, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x0F, 0x01, 0x80, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x0F, 0x38, 0x1E, 0x00, 0x0F,
  0x0E, 0x07, 0x80, 0x1E, 0x03, 0x81, 0xFF, 0xFE, 0x00, 0xE0, 0x3F, 0xFC,
  0x00, 0x38, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x6D, 0xB6, 0xDA,
  0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0xE0, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C,
  0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70,
  0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x20, 0x0C, 0x01, 0xF0,
  0x18, 0x1F, 0xFC, 0x31, 0xFC, 0x3F, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x03,
  0x80, 0x00, 0x0D, 0x80, 0x00, 0x19, 0x80, 0x00, 0x63, 0x80, 0x01, 0xC3,
  0x00, 0x07, 0x03, 0x00, 0x0C, 0x07, 0x00, 0x38, 0x07, 0x00, 0xE0, 0x07,
  0x00, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x71, 0xC7, 0x1C, 0x61, 0x8E, 0x38, 0xC3, 0x1C,
  0x61, 0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xEF, 0xFE, 0x40, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x03, 0x80, 0x60,
  0x00, 0xE0, 0x70, 0x00, 0x30, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x06, 0x18,
  0x00, 0x03, 0x8C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x67, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x03,
  0xB0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x70,
  0x00, 0x03, 0x38, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x61, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x38, 0x38, 0x00, 0x18,
  0x0E, 0x00, 0x1C, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x1C, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x7E,
  0x07, 0x70, 0xF3, 0x8F, 0x1C, 0xF0, 0xEE, 0x07, 0xE0, 0x3A, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x07, 0xE0, 0xF8, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x03, 0x81, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xC3,
  0xF0, 0x7C, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x40, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x3C, 0xF0, 0x00,
  0xF8, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x30, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x38,
  0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x38, 0x03,
  0x80, 0x01, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x00,
  0xC0, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x10, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x30,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x80,
  0x00, 0x70, 0xF0, 0x01, 0xE0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x1C, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0xFF, 0x80, 0xC3,
  0xFF, 0xE0, 0xC7, 0x80, 0x78, 0xCE, 0x00, 0x3C, 0xD8, 0x00, 0x1C, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x07, 0x70, 0x00, 0x06, 0x30, 0x00, 0x06, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x0F, 0x00, 0x78, 0x03,
  0xF7, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xF0, 0x7C, 0x01,
  0xE0, 0x07, 0x81, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x18,
  0x60, 0x00, 0x0E, 0x30, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x71, 0x80, 0x00, 0x30, 0xE0, 0x00,
  0x38, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x07, 0x80, 0x1C, 0x01, 0xE0,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xC7, 0xC0, 0x07, 0x80, 0xF0, 0x07, 0x00, 0x1C, 0x07,
  0x00, 0x07, 0x07, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x19,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x0E, 0x00,
  0x0F, 0x03, 0xC0, 0x0F, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xF0, 0xF8, 0x01,
  0xC0, 0x0E, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x30,
  0xE0, 0x00, 0x1C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x38, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0xF6, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x7C, 0xC0,
  0x00, 0x3E, 0x70, 0x00, 0x37, 0x1C, 0x00, 0x73, 0x87, 0x80, 0xF1, 0x81,
  0xFF, 0xF0, 0xC0, 0x3F, 0xE0, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xEF, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xE4, 0x1C, 0x3C, 0x78, 0xF0, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x38,
  0x70, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0x83, 0xF0, 0xFC, 0x60,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x03,
  0x80, 0x03, 0x8E, 0x00, 0x0F, 0xFF, 0x00, 0x63, 0x80, 0x0F, 0xC3, 0xC0,
  0x18, 0xC0, 0x07, 0x80, 0x30, 0x07, 0x70, 0x03, 0x80, 0x0C, 0x00, 0xDC,
  0x00, 0xC0, 0x07, 0x00, 0x36, 0x00, 0x70, 0x01, 0xC0, 0x0D, 0x80, 0x18,
  0x00, 0x70, 0x03, 0x60, 0x0E, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0x00, 0x07,
  0x00, 0x3E, 0x00, 0xC0, 0x01, 0xC0, 0x0F, 0x80, 0x30, 0x00, 0x60, 0x03,
  0xE0, 0x0C, 0x00, 0x18, 0x00, 0xF8, 0x03, 0x00, 0x06, 0x00, 0x3E, 0x00,
  0xC0, 0x01, 0x80, 0x0F, 0x80, 0x30, 0x00, 0x60, 0x03, 0xE0, 0x0C, 0x00,
  0x18, 0x00, 0xF8, 0x03, 0x00, 0x0E, 0x00, 0x7E, 0x00, 0xC0, 0x03, 0x80,
  0x19, 0x80, 0x38, 0x00, 0xA0, 0x06, 0x60, 0x06, 0x00, 0x6C, 0x03, 0x18,
  0x01, 0xC0, 0x33, 0x01, 0xC6, 0x00, 0x38, 0x1C, 0x60, 0xE1, 0xC0, 0x07,
  0xFE, 0x1F, 0xF0, 0x30, 0x00, 0xFE, 0x03, 0xF8, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x80, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x30,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0xE0, 0x03,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00,
  0xE0, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x70, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x1C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x30, 0x00, 0x3E, 0x18, 0x00,
  0x07, 0x8C, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x73, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x0E, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x1E,
  0x18, 0x00, 0x7C, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0x00, 0x03,
  0xE1, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x3C, 0x60, 0x00, 0xFC,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x60, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0x80,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x7E, 0x01, 0x80,
  0x00, 0x78, 0x0C, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x0E, 0x18, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x07,
  0x30, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x03, 0x83, 0x00, 0x00, 0x3C, 0x18, 0x00, 0x03,
  0xC0, 0xC0, 0x00, 0x78, 0x06, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0xF8, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x02, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x03,
  0x07, 0x80, 0x00, 0x03, 0x03, 0xE0, 0x00, 0x03, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xEF,
  0xF0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC3, 0xFF, 0xFF, 0xF0, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xEC,
  0x1E, 0x7F, 0xE1, 0xFC, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x30,
  0x00, 0x03, 0x98, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x86, 0x00, 0x03, 0x83,
  0x00, 0x03, 0x81, 0x80, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x01, 0xC0,
  0x30, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x06, 0x01, 0xC0,
  0x03, 0x01, 0xE0, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0xE0,
  0x00, 0x30, 0xE0, 0x00, 0x18, 0xF8, 0x00, 0x0C, 0xFC, 0x00, 0x06, 0x67,
  0x00, 0x03, 0x71, 0xC0, 0x01, 0xF0, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x70,
  0x0C, 0x00, 0x30, 0x07, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x38, 0x03, 0x00, 0x0E, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x01, 0xC0,
  0x60, 0x00, 0x70, 0x30, 0x00, 0x38, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x03,
  0x86, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x71, 0x80, 0x00, 0x18, 0xC0, 0x00,
  0x0E, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xBD, 0x80, 0x00, 0x00, 0x1D, 0xEC, 0x00, 0x00, 0x00, 0xDF, 0x70,
  0x00, 0x00, 0x06, 0xF9, 0x80, 0x00, 0x00, 0x77, 0xCE, 0x00, 0x00, 0x03,
  0x3E, 0x70, 0x00, 0x00, 0x19, 0xF1, 0x80, 0x00, 0x01, 0xCF, 0x8E, 0x00,
  0x00, 0x0C, 0x7C, 0x30, 0x00, 0x00, 0x63, 0xE1, 0x80, 0x00, 0x07, 0x1F,
  0x0E, 0x00, 0x00, 0x30, 0xF8, 0x30, 0x00, 0x03, 0x87, 0xC1, 0x80, 0x00,
  0x18, 0x3E, 0x0E, 0x00, 0x00, 0xC1, 0xF0, 0x30, 0x00, 0x0E, 0x0F, 0x81,
  0xC0, 0x00, 0x60, 0x7C, 0x0E, 0x00, 0x03, 0x03, 0xE0, 0x30, 0x00, 0x38,
  0x1F, 0x01, 0xC0, 0x01, 0x80, 0xF8, 0x06, 0x00, 0x0C, 0x07, 0xC0, 0x30,
  0x00, 0xC0, 0x3E, 0x01, 0xC0, 0x06, 0x01, 0xF0, 0x06, 0x00, 0x70, 0x0F,
  0x80, 0x38, 0x03, 0x00, 0x7C, 0x01, 0xC0, 0x18, 0x03, 0xE0, 0x06, 0x01,
  0xC0, 0x1F, 0x00, 0x38, 0x0C, 0x00, 0xF8, 0x01, 0xC0, 0x60, 0x07, 0xC0,
  0x06, 0x07, 0x00, 0x3E, 0x00, 0x38, 0x30, 0x01, 0xF0, 0x00, 0xC3, 0x80,
  0x0F, 0x80, 0x06, 0x18, 0x00, 0x7C, 0x00, 0x38, 0xC0, 0x03, 0xE0, 0x00,
  0xCE, 0x00, 0x1F, 0x00, 0x07, 0x60, 0x00, 0xF8, 0x00, 0x3B, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x1C,
  0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xC6,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x3C, 0x38, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x0C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C,
  0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x03, 0xC0, 0x38,
  0x00, 0x3C, 0x01, 0xC0, 0x03, 0xC0, 0x0C, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x03, 0xC0, 0x03, 0x80, 0x3C, 0x00,
  0x18, 0x03, 0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xE0,
  0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x30, 0x3C, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x18, 0x3C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x03,
  0x98, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x83, 0x00, 0x0F, 0x86, 0x00, 0x07, 0x8C, 0x00, 0x03, 0x98,
  0x00, 0x03, 0xB0, 0x00, 0x07, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1B, 0x00, 0x00, 0x76, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x98, 0x00, 0x1E,
  0x30, 0x00, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x03, 0x98,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x30, 0x00, 0xFC, 0x18,
  0x00, 0x0F, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x07, 0x30, 0x00, 0x01,
  0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x1F, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x01, 0xC0, 0x18, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x03,
  0x00, 0x07, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x1C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x71, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0x60, 0x00,
  0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0xFC, 0x07, 0xF1, 0xFE, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x80,
  0x00, 0x3C, 0xF0, 0x00, 0xF8, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x38, 0x0E, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0x30, 0x03, 0x80, 0x00, 0x60, 0x07, 0x00,
  0x01, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xD8, 0x00, 0x01, 0x8C, 0x00,
  0x01, 0xB8, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x30, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x60, 0x00, 0x18, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x31, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x61, 0x80, 0x01, 0xC1, 0xC0, 0x01,
  0xC3, 0x00, 0x03, 0x01, 0x80, 0x03, 0x06, 0x00, 0x06, 0x03, 0x00, 0x06,
  0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x38,
  0x18, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x30, 0x01, 0xC0, 0x18, 0x00, 0xC0,
  0x70, 0x03, 0x80, 0x38, 0x01, 0x80, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x00, 0xC0, 0x18, 0x03,
  0x80, 0x70, 0x01, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x03, 0x80, 0xE0, 0x06,
  0x01, 0x80, 0x03, 0x01, 0x80, 0x0C, 0x07, 0x00, 0x06, 0x03, 0x00, 0x1C,
  0x0E, 0x00, 0x0E, 0x06, 0x00, 0x18, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x30,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x60, 0xE0, 0x00, 0x30, 0x60, 0x00, 0xE1,
  0xC0, 0x00, 0x70, 0xC0, 0x00, 0xC3, 0x00, 0x00, 0xE3, 0x80, 0x01, 0x86,
  0x00, 0x00, 0xC6, 0x00, 0x03, 0x1C, 0x00, 0x01, 0x8C, 0x00, 0x07, 0x38,
  0x00, 0x03, 0x98, 0x00, 0x06, 0x60, 0x00, 0x07, 0x70, 0x00, 0x0C, 0xC0,
  0x00, 0x06, 0xE0, 0x00, 0x19, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x00, 0xF1, 0x80, 0x00,
  0x0E, 0x1C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x30, 0x07, 0x00, 0x07, 0x00, 0x30, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x18, 0x00, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0xE0, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0x80,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x06, 0x00, 0x70, 0x00, 0x70,
  0x0E, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x18, 0x1C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x60, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x1C, 0x00, 0x38, 0x01, 0x80, 0x01, 0x80, 0x38, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0xC0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0xC0, 0x1C, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x38, 0x01, 0xC0,
  0x03, 0x00, 0x30, 0x00, 0x70, 0x0E, 0x00, 0x06, 0x01, 0x80, 0x00, 0xE0,
  0x70, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x60,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x07, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x03, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0x80, 0x78, 0x20, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x1F, 0xE0,
  0x3F, 0xFF, 0x07, 0xF0, 0x18, 0xF0, 0x00, 0xCE, 0x00, 0x06, 0xE0, 0x00,
  0x36, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0D,
  0xB8, 0x00, 0xED, 0xE0, 0x0E, 0x67, 0xF7, 0xE3, 0x0F, 0xFC, 0x18, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x03, 0xFF,
  0x01, 0x87, 0xFF, 0xC0, 0xC7, 0x00, 0x78, 0x67, 0x00, 0x1C, 0x37, 0x00,
  0x07, 0x1B, 0x00, 0x01, 0xCD, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x33, 0x80,
  0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x0C, 0xF0, 0x00, 0x0E, 0x6C, 0x00,
  0x06, 0x36, 0x00, 0x07, 0x19, 0x80, 0x07, 0x0C, 0x70, 0x0F, 0x06, 0x1F,
  0xFF, 0x03, 0x07, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0xC0, 0xF0, 0x06, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x20, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x03, 0xFE,
  0x06, 0x07, 0xFF, 0xC3, 0x07, 0x80, 0x71, 0x87, 0x00, 0x0C, 0xC7, 0x00,
  0x03, 0x63, 0x00, 0x01, 0xB3, 0x80, 0x00, 0x79, 0x80, 0x00, 0x3D, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0x30, 0x00, 0x07, 0x9C, 0x00,
  0x06, 0xC7, 0x00, 0x03, 0x63, 0xC0, 0x03, 0x30, 0xF0, 0x07, 0x18, 0x3F,
  0xFF, 0x0C, 0x07, 0xFF, 0x06, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x18,
  0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x70,
  0x00, 0x06, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x02, 0x07, 0x80, 0x0E, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0xC3,
  0xFF, 0xF0, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x00, 0xFF, 0xC1, 0x81, 0xFF, 0xF0, 0xC1, 0xE0, 0x1C, 0x61, 0xC0, 0x03,
  0x31, 0xC0, 0x00, 0xD8, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0x60, 0x00,
  0x0F, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0E,
  0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xCC, 0x00, 0x01,
  0x67, 0x00, 0x01, 0xB1, 0xC0, 0x00, 0xD8, 0x70, 0x00, 0xDC, 0x3C, 0x01,
  0xCE, 0x0F, 0xEF, 0xC7, 0x01, 0xFF, 0xC3, 0x80, 0x0C, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x84, 0x00, 0x03, 0xC3, 0x80, 0x03, 0xC1, 0xFC, 0x0F, 0xC0,
  0x3F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x3F,
  0xE0, 0x61, 0xFF, 0xF0, 0xC7, 0x00, 0xF1, 0x9C, 0x00, 0x73, 0x70, 0x00,
  0x66, 0xC0, 0x00, 0xEF, 0x00, 0x00, 0xDE, 0x00, 0x01, 0xB8, 0x00, 0x03,
  0x70, 0x00, 0x06, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0xFF, 0xF4,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x70, 0x3C, 0x07, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18,
  0x0E, 0x03, 0xA3, 0xCF, 0xE3, 0xF0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x01, 0xD8, 0x00, 0x1C,
  0xC0, 0x01, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0xE1, 0x80, 0x0E, 0x0C, 0x00,
  0xE0, 0x60, 0x0E, 0x03, 0x00, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x70, 0x06,
  0x07, 0x00, 0x30, 0x70, 0x01, 0x83, 0x00, 0x0C, 0x3C, 0x00, 0x63, 0xE0,
  0x03, 0x3B, 0x80, 0x1B, 0x8E, 0x00, 0xD8, 0x70, 0x07, 0x81, 0xC0, 0x38,
  0x06, 0x01, 0x80, 0x38, 0x0C, 0x00, 0xE0, 0x60, 0x03, 0x03, 0x00, 0x1C,
  0x18, 0x00, 0x70, 0xC0, 0x03, 0x86, 0x00, 0x0E, 0x30, 0x00, 0x31, 0x80,
  0x01, 0xCC, 0x00, 0x07, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xC1, 0xFF, 0x00, 0x7F, 0xC1, 0x87, 0xFF, 0x03,
  0xFF, 0xC3, 0x1C, 0x07, 0x0F, 0x01, 0xC6, 0x60, 0x07, 0x38, 0x01, 0xCD,
  0x80, 0x06, 0x60, 0x01, 0xDA, 0x00, 0x0F, 0x80, 0x03, 0xBC, 0x00, 0x0F,
  0x00, 0x03, 0x70, 0x00, 0x1C, 0x00, 0x06, 0xE0, 0x00, 0x38, 0x00, 0x0D,
  0xC0, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x01,
  0xF0, 0x00, 0x0C, 0x00, 0x03, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00,
  0x30, 0x00, 0x0F, 0x80, 0x00, 0x60, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0x80, 0x00, 0x7C, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00,
  0x06, 0x00, 0x01, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x80, 0x00, 0x60, 0x00, 0x1F, 0x00,
  0x00, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0x80, 0x00, 0x7C, 0x00, 0x03, 0x00,
  0x00, 0xF8, 0x00, 0x06, 0x00, 0x01, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0xC0, 0xFF, 0x81,
  0x87, 0xFF, 0xC3, 0x1C, 0x03, 0xC6, 0x70, 0x01, 0xCD, 0x80, 0x01, 0x9B,
  0x00, 0x03, 0xBC, 0x00, 0x03, 0x78, 0x00, 0x06, 0xE0, 0x00, 0x0D, 0xC0,
  0x00, 0x1B, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x78, 0x07, 0x80, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x0E,
  0x06, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x70, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0xC0,
  0x00, 0x06, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x70,
  0x60, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0xFF, 0xC0, 0x61, 0xFF, 0xF0, 0x31, 0xE0, 0x1E, 0x19, 0xC0, 0x07, 0x0C,
  0xC0, 0x01, 0xC6, 0xC0, 0x00, 0x73, 0x40, 0x00, 0x39, 0xE0, 0x00, 0x0E,
  0xF0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0D, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x03, 0x3C, 0x00, 0x03, 0x9B,
  0x00, 0x01, 0xCD, 0xC0, 0x01, 0xC6, 0x70, 0x01, 0xC3, 0x1C, 0x01, 0xC1,
  0x87, 0xFF, 0xC0, 0xC1, 0xFF, 0xC0, 0x70, 0x1E, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x81, 0x81, 0xFF, 0xF0, 0xC1,
  0xE0, 0x1C, 0x61, 0xC0, 0x07, 0x31, 0xC0, 0x01, 0xD8, 0xC0, 0x00, 0x6C,
  0xE0, 0x00, 0x1E, 0x60, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x07, 0xB8,
  0x00, 0x03, 0xCC, 0x00, 0x01, 0x67, 0x00, 0x01, 0xB1, 0xC0, 0x01, 0x98,
  0xF0, 0x01, 0xDC, 0x3C, 0x01, 0xCE, 0x0F, 0xFF, 0xC7, 0x01, 0xFF, 0x83,
  0x80, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC1,
  0xFF, 0x87, 0xFF, 0x1C, 0x0E, 0x70, 0x0C, 0xC0, 0x1B, 0x00, 0x34, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0x87, 0x80, 0x1C, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x40, 0x00, 0x3B, 0xC0, 0x07, 0x9F, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xFF, 0x01, 0xFE,
  0x00, 0x60, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x70, 0x00, 0x6D, 0xC0, 0x03,
  0x33, 0xC0, 0x38, 0xC7, 0xFF, 0xC3, 0x0F, 0xFE, 0x0C, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x07, 0x70, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x18, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x38,
  0x0E, 0x00, 0x30, 0x06, 0x00, 0x30, 0x06, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x03, 0x00, 0x60, 0x03, 0x00, 0xE0, 0x03, 0x80, 0xC0, 0x03, 0x80, 0xC0,
  0x01, 0x81, 0xC0, 0x01, 0xC1, 0x80, 0x01, 0xC1, 0x80, 0x00, 0xC3, 0x80,
  0x00, 0xE3, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x67, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0x80, 0x01, 0x98, 0x00, 0x1E, 0x00, 0x06, 0x60, 0x00,
  0x7C, 0x00, 0x19, 0xC0, 0x03, 0xB0, 0x00, 0xE7, 0x00, 0x0C, 0xC0, 0x03,
  0x0C, 0x00, 0x33, 0x00, 0x0C, 0x30, 0x00, 0xCE, 0x00, 0x30, 0xE0, 0x07,
  0x18, 0x01, 0xC1, 0x80, 0x18, 0x60, 0x06, 0x06, 0x00, 0x61, 0xC0, 0x18,
  0x18, 0x03, 0x83, 0x00, 0x60, 0x70, 0x0E, 0x0C, 0x03, 0x80, 0xC0, 0x30,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0xC0,
  0x38, 0x18, 0x06, 0x07, 0x00, 0x60, 0x60, 0x1C, 0x18, 0x01, 0x83, 0x80,
  0x30, 0x60, 0x07, 0x0E, 0x00, 0xC1, 0x80, 0x1C, 0x30, 0x03, 0x0E, 0x00,
  0x30, 0xC0, 0x0E, 0x30, 0x00, 0xC7, 0x00, 0x18, 0xC0, 0x03, 0x98, 0x00,
  0x63, 0x00, 0x0E, 0x60, 0x01, 0x9C, 0x00, 0x19, 0x80, 0x07, 0x60, 0x00,
  0x6E, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00,
  0xD8, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x30, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x30, 0x06, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xC0, 0x01, 0x81, 0xC0, 0x01, 0xC1,
  0x80, 0x00, 0xE3, 0x80, 0x00, 0x67, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x67, 0x00, 0x00, 0xE3, 0x00, 0x01, 0xC3, 0x80, 0x01, 0x81,
  0xC0, 0x03, 0x80, 0xC0, 0x03, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0x70, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x0E, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xB0, 0x00,
  0x01, 0x9C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x38, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x06,
  0x00, 0x0E, 0x03, 0x00, 0x06, 0x01, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x80,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0xE0, 0x03, 0x00, 0x60,
  0x01, 0xC0, 0x30, 0x00, 0x60, 0x38, 0x00, 0x30, 0x18, 0x00, 0x1C, 0x0C,
  0x00, 0x06, 0x0E, 0x00, 0x03, 0x06, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x31, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x03,
  0x60, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x04, 0x3C, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC,
  0x00, 0x7F, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x03,
  0x80, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x03,
  0xE0, 0x0F, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x17, 0x87, 0xC0, 0x0F, 0x00, 0x7E, 0x0E, 0x80, 0x07, 0xFF, 0x20, 0x00,
  0x3F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 45, 14, 5, -44 },
  { 24, 12, 16, 20, 4, -44 },
  { 48, 33, 44, 35, 1, -44 },
  { 230, 24, 51, 32, 3, -47 },
  { 383, 39, 46, 45, 3, -45 },
  { 608, 33, 46, 37, 3, -45 },
  { 798, 3, 16, 11, 4, -44 },
  { 804, 11, 54, 16, 3, -44 },
  { 879, 12, 54, 16, 2, -44 },
  { 960, 23, 22, 30, 3, -47 },
  { 1024, 26, 29, 32, 3, -36 },
  { 1119, 6, 15, 12, 2, -7 },
  { 1131, 14, 2, 19, 2, -18 },
  { 1135, 4, 5, 13, 5, -4 },
  { 1138, 19, 44, 21, 1, -44 },
  { 1243, 25, 46, 32, 3, -45 },
  { 1387, 13, 44, 32, 6, -44 },
  { 1459, 25, 45, 32, 3, -45 },
  { 1600, 24, 46, 32, 3, -45 },
  { 1738, 30, 45, 32, 1, -45 },
  { 1907, 24, 45, 32, 4, -44 },
  { 2042, 24, 46, 32, 4, -45 },
  { 2180, 25, 44, 32, 3, -44 },
  { 2318, 25, 46, 32, 3, -45 },
  { 2462, 25, 46, 32, 3, -45 },
  { 2606, 4, 34, 13, 5, -33 },
  { 2623, 7, 41, 13, 2, -33 },
  { 2659, 26, 27, 32, 3, -36 },
  { 2747, 26, 15, 32, 3, -29 },
  { 2796, 26, 27, 32, 3, -36 },
  { 2884, 19, 46, 23, 2, -45 },
  { 2994, 42, 50, 49, 3, -44 },
  { 3257, 32, 44, 32, 0, -44 },
  { 3433, 25, 44, 34, 6, -44 },
  { 3571, 28, 46, 34, 4, -45 },
  { 3732, 29, 44, 38, 6, -44 },
  { 3892, 21, 44, 30, 6, -44 },
  { 4008, 21, 44, 28, 6, -44 },
  { 4124, 32, 46, 40, 4, -45 },
  { 4308, 28, 44, 39, 6, -44 },
  { 4462, 11, 44, 17, 3, -44 },
  { 4523, 13, 55, 14, -5, -44 },
  { 4613, 25, 44, 31, 6, -44 },
  { 4751, 21, 44, 28, 6, -44 },
  { 4867, 37, 44, 49, 6, -44 },
  { 5071, 28, 44, 40, 6, -44 },
  { 5225, 34, 46, 42, 4, -45 },
  { 5421, 23, 44, 32, 6, -44 },
  { 5548, 34, 56, 42, 4, -45 },
  { 5786, 25, 44, 32, 6, -44 },
  { 5924, 24, 46, 30, 3, -45 },
  { 6062, 28, 44, 28, 0, -44 },
  { 6216, 29, 45, 39, 5, -44 },
  { 6380, 31, 44, 31, 0, -44 },
  { 6551, 47, 44, 50, 1, -44 },
  { 6810, 28, 44, 28, 0, -44 },
  { 6964, 28, 44, 28, 0, -44 },
  { 7118, 26, 44, 30, 2, -44 },
  { 7261, 13, 54, 19, 5, -44 },
  { 7349, 19, 44, 21, 1, -44 },
  { 7454, 12, 54, 19, 2, -44 },
  { 7535, 27, 25, 32, 2, -44 },
  { 7620, 25, 2, 25, 0, 6 },
  { 7627, 11, 9, 15, 2, -47 },
  { 7640, 21, 34, 29, 3, -33 },
  { 7730, 25, 48, 33, 5, -47 },
  { 7880, 21, 34, 26, 3, -33 },
  { 7970, 25, 48, 33, 3, -47 },
  { 8120, 24, 34, 30, 3, -33 },
  { 8222, 18, 47, 16, 1, -47 },
  { 8328, 25, 48, 33, 3, -33 },
  { 8478, 23, 47, 32, 5, -47 },
  { 8614, 3, 45, 13, 5, -45 },
  { 8631, 10, 60, 13, -2, -45 },
  { 8706, 21, 47, 26, 5, -47 },
  { 8830, 3, 47, 13, 5, -47 },
  { 8848, 39, 33, 48, 5, -33 },
  { 9009, 23, 33, 32, 5, -33 },
  { 9104, 26, 34, 32, 3, -33 },
  { 9215, 25, 48, 33, 5, -33 },
  { 9365, 25, 48, 33, 3, -33 },
  { 9515, 15, 33, 21, 5, -33 },
  { 9577, 21, 34, 25, 2, -33 },
  { 9667, 15, 42, 18, 1, -41 },
  { 9746, 22, 34, 32, 5, -33 },
  { 9840, 24, 33, 25, 0, -33 },
  { 9939, 38, 33, 40, 1, -33 },
  { 10096, 24, 33, 27, 1, -33 },
  { 10195, 25, 48, 25, 0, -33 },
  { 10345, 20, 33, 24, 2, -33 },
  { 10428, 17, 54, 22, 2, -44 },
  { 10543, 2, 62, 30, 14, -47 },
  { 10559, 17, 54, 22, 2, -44 },
  { 10674, 26, 6, 32, 3, -25 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight62pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT62PT7B_H_
