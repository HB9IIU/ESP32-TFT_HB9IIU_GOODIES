#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT14PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x40, 0xB6, 0xD0, 0x12, 0x14, 0x24, 0x7F, 0x24, 0x24, 0xFE,
  0x28, 0x48, 0x48, 0x23, 0xE9, 0x4A, 0x30, 0xC5, 0x29, 0x7C, 0x40, 0xE2,
  0xA4, 0xA4, 0xA8, 0xAF, 0xF5, 0x15, 0x25, 0x25, 0x47, 0x71, 0x12, 0x22,
  0x82, 0x1A, 0x64, 0xC6, 0x85, 0xF4, 0xF0, 0x6A, 0xAA, 0xA9, 0xC8, 0x92,
  0x49, 0x25, 0x60, 0x21, 0x3E, 0x45, 0x00, 0x20, 0x82, 0x3F, 0x20, 0x80,
  0xF0, 0xF0, 0x80, 0x11, 0x12, 0x22, 0x44, 0x48, 0x74, 0x63, 0x18, 0xC6,
  0x31, 0x8B, 0x80, 0x2E, 0x92, 0x49, 0x24, 0xF0, 0x42, 0x10, 0x88, 0x88,
  0x87, 0xC0, 0xF0, 0x42, 0x17, 0x04, 0x21, 0x0F, 0x80, 0x08, 0x10, 0x51,
  0x22, 0x48, 0xA1, 0x3F, 0x04, 0x08, 0xFC, 0x21, 0x0F, 0x04, 0x21, 0x0F,
  0x80, 0x7C, 0x21, 0x0F, 0xC6, 0x31, 0x8B, 0xC0, 0xF8, 0x42, 0x21, 0x08,
  0x84, 0x42, 0x00, 0x74, 0x63, 0x17, 0x2A, 0x31, 0x8B, 0x80, 0x74, 0x63,
  0x18, 0xFC, 0x21, 0x0F, 0x80, 0x82, 0x87, 0x80, 0x0C, 0xCC, 0x30, 0x30,
  0x30, 0xFC, 0x00, 0x3F, 0x81, 0x81, 0xC6, 0x62, 0x00, 0xF0, 0x42, 0x11,
  0x11, 0x08, 0x02, 0x00, 0x3E, 0x20, 0xA0, 0x33, 0xDA, 0x2D, 0x16, 0x93,
  0x4D, 0x99, 0x40, 0x1F, 0x80, 0x10, 0x20, 0xA1, 0x42, 0x48, 0x9F, 0x21,
  0x83, 0x04, 0xFA, 0x18, 0x61, 0xFA, 0x18, 0x61, 0x87, 0xE0, 0x3D, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x40, 0xF0, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x85, 0xF0, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0x87, 0xC0, 0xFC, 0x21,
  0x08, 0x7E, 0x10, 0x84, 0x00, 0x3E, 0x82, 0x04, 0x08, 0x11, 0xE0, 0xC1,
  0x42, 0x7C, 0x83, 0x06, 0x0C, 0x1F, 0xF0, 0x60, 0xC1, 0x83, 0x04, 0xEA,
  0xAA, 0xB0, 0x24, 0x92, 0x49, 0x24, 0xF0, 0x86, 0x29, 0x28, 0xE2, 0x89,
  0x22, 0x8A, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xC0, 0x80, 0xE0,
  0xF0, 0x74, 0x5A, 0x2D, 0x16, 0x53, 0x29, 0x98, 0xC4, 0x40, 0x83, 0x86,
  0x8D, 0x19, 0x32, 0x62, 0xC5, 0x87, 0x04, 0x7C, 0x82, 0x82, 0x81, 0x81,
  0x81, 0x81, 0x82, 0x82, 0x7C, 0xFA, 0x18, 0x61, 0x8B, 0xC8, 0x20, 0x82,
  0x00, 0x7C, 0x82, 0x82, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x74, 0x08,
  0x04, 0xFA, 0x18, 0x61, 0x8B, 0xC9, 0x22, 0x8A, 0x10, 0x7C, 0x21, 0x06,
  0x08, 0x21, 0x0F, 0x80, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x40,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0xF8, 0x83, 0x05, 0x12,
  0x24, 0x45, 0x0A, 0x14, 0x30, 0x20, 0x84, 0x30, 0x85, 0x28, 0xA5, 0x24,
  0xA4, 0x94, 0x8C, 0x51, 0x8C, 0x31, 0x82, 0x10, 0x85, 0x14, 0x8A, 0x10,
  0x42, 0x92, 0x46, 0x10, 0x86, 0x14, 0x92, 0x30, 0x41, 0x04, 0x10, 0x40,
  0x7C, 0x10, 0x82, 0x10, 0x42, 0x10, 0x43, 0xF0, 0xF2, 0x49, 0x24, 0x92,
  0x70, 0x84, 0x44, 0x22, 0x21, 0x11, 0xE4, 0x92, 0x49, 0x24, 0xF0, 0x10,
  0x50, 0xA2, 0x24, 0x50, 0x40, 0xFC, 0xA4, 0x69, 0x11, 0xF9, 0x9F, 0x82,
  0x08, 0x2C, 0xCA, 0x18, 0x61, 0x86, 0x1F, 0x80, 0x3C, 0x88, 0x88, 0x87,
  0x08, 0x42, 0xF8, 0xC6, 0x31, 0x8C, 0x5E, 0x74, 0x63, 0x1F, 0x42, 0x0F,
  0x34, 0x4E, 0x44, 0x44, 0x44, 0x40, 0x74, 0x63, 0x18, 0xC6, 0x2F, 0x08,
  0x7E, 0x84, 0x21, 0x6C, 0xC6, 0x31, 0x8C, 0x62, 0x9F, 0xC0, 0x41, 0x55,
  0x55, 0xC0, 0x84, 0x21, 0x19, 0x52, 0x9C, 0x94, 0xA2, 0xFF, 0xE0, 0x33,
  0x66, 0x62, 0x31, 0x18, 0x8C, 0x46, 0x23, 0x11, 0x36, 0x63, 0x18, 0xC6,
  0x31, 0x72, 0x28, 0xA1, 0x86, 0x18, 0x9C, 0x13, 0x28, 0x61, 0x86, 0x18,
  0x7E, 0x82, 0x08, 0x00, 0x74, 0x63, 0x18, 0xC6, 0x2F, 0x08, 0x42, 0x3C,
  0x88, 0x88, 0x88, 0x78, 0x88, 0x61, 0x1F, 0x4F, 0x44, 0x44, 0x44, 0x70,
  0x8C, 0x63, 0x18, 0xC5, 0xE0, 0x8E, 0x24, 0x94, 0x50, 0xC2, 0x00, 0x88,
  0xCA, 0x55, 0x4A, 0xA5, 0x53, 0x10, 0x88, 0xCD, 0x23, 0x0C, 0x31, 0x28,
  0x40, 0x85, 0x24, 0x92, 0x30, 0xC2, 0x08, 0x23, 0x00, 0x78, 0x84, 0x42,
  0x23, 0xE0, 0x12, 0x22, 0x24, 0xC2, 0x22, 0x23, 0xFF, 0xFC, 0x89, 0x24,
  0x8A, 0x49, 0x60, 0x46, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 10, 3, 1, -10 },
  { 3, 3, 4, 5, 1, -10 },
  { 5, 8, 10, 8, 0, -10 },
  { 15, 5, 12, 7, 1, -11 },
  { 23, 8, 10, 10, 1, -10 },
  { 33, 7, 10, 8, 1, -10 },
  { 42, 1, 4, 2, 1, -10 },
  { 43, 2, 12, 4, 1, -10 },
  { 46, 3, 12, 4, 0, -10 },
  { 51, 5, 5, 7, 1, -11 },
  { 55, 6, 6, 7, 1, -8 },
  { 60, 1, 4, 3, 1, -2 },
  { 61, 4, 1, 4, 0, -4 },
  { 62, 1, 1, 3, 1, -1 },
  { 63, 4, 10, 5, 0, -10 },
  { 68, 5, 10, 7, 1, -10 },
  { 75, 3, 10, 7, 1, -10 },
  { 79, 5, 10, 7, 1, -10 },
  { 86, 5, 10, 7, 1, -10 },
  { 93, 7, 10, 7, 0, -10 },
  { 102, 5, 10, 7, 1, -10 },
  { 109, 5, 10, 7, 1, -10 },
  { 116, 5, 10, 7, 1, -10 },
  { 123, 5, 10, 7, 1, -10 },
  { 130, 5, 10, 7, 1, -10 },
  { 137, 1, 7, 3, 1, -7 },
  { 138, 1, 9, 3, 1, -7 },
  { 140, 6, 6, 7, 1, -8 },
  { 145, 6, 4, 7, 1, -7 },
  { 148, 6, 6, 7, 1, -8 },
  { 153, 5, 10, 5, 0, -10 },
  { 160, 9, 11, 11, 1, -10 },
  { 173, 7, 10, 7, 0, -10 },
  { 182, 6, 10, 8, 1, -10 },
  { 190, 6, 10, 8, 1, -10 },
  { 198, 7, 10, 9, 1, -10 },
  { 207, 5, 10, 7, 1, -10 },
  { 214, 5, 10, 6, 1, -10 },
  { 221, 7, 10, 9, 1, -10 },
  { 230, 7, 10, 9, 1, -10 },
  { 239, 2, 10, 4, 1, -10 },
  { 242, 3, 12, 3, -1, -10 },
  { 247, 6, 10, 7, 1, -10 },
  { 255, 5, 10, 6, 1, -10 },
  { 262, 9, 10, 11, 1, -10 },
  { 274, 7, 10, 9, 1, -10 },
  { 283, 8, 10, 9, 1, -10 },
  { 293, 6, 10, 7, 1, -10 },
  { 301, 8, 12, 9, 1, -10 },
  { 313, 6, 10, 7, 1, -10 },
  { 321, 5, 10, 7, 1, -10 },
  { 328, 6, 10, 6, 0, -10 },
  { 336, 7, 10, 9, 1, -10 },
  { 345, 7, 10, 7, 0, -10 },
  { 354, 11, 10, 11, 0, -10 },
  { 368, 6, 10, 6, 0, -10 },
  { 376, 6, 10, 6, 0, -10 },
  { 384, 6, 10, 7, 0, -10 },
  { 392, 3, 12, 4, 1, -10 },
  { 397, 4, 10, 5, 0, -10 },
  { 402, 3, 12, 4, 0, -10 },
  { 407, 7, 6, 7, 0, -10 },
  { 413, 6, 1, 6, 0, 1 },
  { 414, 2, 3, 3, 1, -11 },
  { 415, 4, 8, 7, 1, -8 },
  { 419, 6, 11, 7, 1, -11 },
  { 428, 4, 8, 6, 1, -8 },
  { 432, 5, 11, 7, 1, -11 },
  { 439, 5, 8, 7, 1, -8 },
  { 444, 4, 11, 4, 0, -11 },
  { 450, 5, 11, 7, 1, -8 },
  { 457, 5, 11, 7, 1, -11 },
  { 464, 1, 10, 3, 1, -10 },
  { 466, 2, 13, 3, 0, -10 },
  { 470, 5, 11, 6, 1, -11 },
  { 477, 1, 11, 3, 1, -11 },
  { 479, 9, 8, 11, 1, -8 },
  { 488, 5, 8, 7, 1, -8 },
  { 493, 6, 8, 7, 1, -8 },
  { 499, 6, 11, 7, 1, -8 },
  { 508, 5, 11, 7, 1, -8 },
  { 515, 4, 8, 5, 1, -8 },
  { 519, 4, 8, 6, 1, -8 },
  { 523, 4, 9, 4, 0, -9 },
  { 528, 5, 7, 7, 1, -7 },
  { 533, 6, 7, 6, 0, -7 },
  { 539, 9, 7, 9, 0, -7 },
  { 547, 6, 7, 6, 0, -7 },
  { 553, 6, 10, 6, 0, -7 },
  { 561, 5, 7, 5, 0, -7 },
  { 566, 4, 12, 5, 0, -10 },
  { 572, 1, 14, 7, 3, -11 },
  { 574, 3, 12, 5, 1, -10 },
  { 579, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight14pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT14PT7B_H_
