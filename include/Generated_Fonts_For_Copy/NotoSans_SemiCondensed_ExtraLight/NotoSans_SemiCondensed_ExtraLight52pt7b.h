#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT52PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight52pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB0,
  0x00, 0x0F, 0xFE, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC0, 0xE0, 0x60, 0x30, 0x18, 0x08, 0x00, 0x10, 0x06, 0x00, 0x06, 0x00,
  0x80, 0x00, 0xC0, 0x10, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x60, 0x18, 0x00, 0x08, 0x03, 0x00, 0x03, 0x00, 0x40, 0x00, 0x60, 0x08,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFE, 0x01, 0x80, 0x20, 0x00, 0x30, 0x04, 0x00, 0x06, 0x01, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x02, 0x00, 0xC0, 0x00, 0xC0,
  0x18, 0x00, 0x18, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x0C, 0x00, 0x0C, 0x01,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x80, 0x30, 0x00, 0x10, 0x06, 0x00, 0x06, 0x00, 0x80, 0x00, 0xC0, 0x30,
  0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x40, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x7F, 0xF0, 0x1F, 0xDF, 0xC3,
  0x84, 0x0C, 0x70, 0x40, 0x06, 0x04, 0x00, 0xC0, 0x40, 0x0C, 0x04, 0x00,
  0xC0, 0x40, 0x0C, 0x04, 0x00, 0xC0, 0x40, 0x0C, 0x04, 0x00, 0xC0, 0x40,
  0x06, 0x04, 0x00, 0x70, 0x40, 0x03, 0xC4, 0x00, 0x0F, 0x40, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x47, 0x80, 0x04, 0x1C, 0x00,
  0x40, 0xE0, 0x04, 0x06, 0x00, 0x40, 0x60, 0x04, 0x03, 0x00, 0x40, 0x30,
  0x04, 0x03, 0x00, 0x40, 0x30, 0x04, 0x06, 0x00, 0x40, 0x60, 0x04, 0x0E,
  0x80, 0x41, 0xCF, 0x04, 0x78, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x1F, 0xC0, 0x01, 0x80, 0x30, 0xE0, 0x01, 0x80, 0x60, 0x60, 0x03, 0x00,
  0x60, 0x30, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x10, 0x04, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0x18, 0x08, 0x00,
  0xC0, 0x18, 0x18, 0x00, 0xC0, 0x18, 0x18, 0x00, 0xC0, 0x18, 0x30, 0x00,
  0xC0, 0x18, 0x30, 0x00, 0xC0, 0x18, 0x60, 0x00, 0xC0, 0x18, 0x60, 0xE0,
  0xC0, 0x10, 0xC3, 0xF8, 0xC0, 0x30, 0xC6, 0x1C, 0xC0, 0x31, 0x8C, 0x0C,
  0x60, 0x31, 0x8C, 0x06, 0x60, 0x63, 0x08, 0x06, 0x38, 0xE3, 0x18, 0x02,
  0x1F, 0xC6, 0x18, 0x03, 0x06, 0x06, 0x18, 0x03, 0x00, 0x0C, 0x18, 0x03,
  0x00, 0x0C, 0x18, 0x03, 0x00, 0x08, 0x18, 0x03, 0x00, 0x18, 0x18, 0x03,
  0x00, 0x10, 0x18, 0x03, 0x00, 0x30, 0x18, 0x03, 0x00, 0x30, 0x18, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x0C, 0x06,
  0x00, 0xC0, 0x0C, 0x06, 0x01, 0x80, 0x06, 0x0C, 0x01, 0x80, 0x07, 0x1C,
  0x03, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xC0, 0x18,
  0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0xC0, 0x30, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x18,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xB8, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0x30, 0x01, 0x9C, 0x03,
  0x00, 0x33, 0x00, 0x30, 0x0C, 0xE0, 0x07, 0x01, 0x98, 0x00, 0x70, 0x33,
  0x00, 0x07, 0x0C, 0x60, 0x00, 0x61, 0x8C, 0x00, 0x06, 0x71, 0x80, 0x00,
  0x6C, 0x30, 0x00, 0x0F, 0x06, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x3E, 0x0C,
  0x00, 0x0E, 0xC1, 0xC0, 0x03, 0x8C, 0x1C, 0x00, 0xE0, 0xC1, 0xF1, 0xF8,
  0x1C, 0x1F, 0xFC, 0x01, 0xC0, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFA, 0x80,
  0x01, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0E,
  0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0xE0, 0x30, 0x0C,
  0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30,
  0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x38, 0x10, 0x3F, 0xC2, 0x3F, 0x1F, 0x7E, 0x00, 0x3E, 0x00,
  0x03, 0x80, 0x00, 0xD8, 0x00, 0x31, 0x00, 0x0C, 0x30, 0x01, 0x83, 0x00,
  0x60, 0x30, 0x18, 0x07, 0x03, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x18, 0xCE, 0x63, 0x18, 0xCC, 0x63, 0x11, 0x8C, 0x00, 0xFF, 0xFF,
  0xFF, 0x5F, 0xF0, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xC3,
  0xC0, 0x18, 0x07, 0x01, 0x80, 0x1C, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x8C,
  0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x01, 0x98, 0x00, 0x0D, 0x80, 0x00,
  0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0,
  0x00, 0x36, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00,
  0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x19,
  0x80, 0x01, 0x8E, 0x00, 0x0C, 0x30, 0x00, 0xE1, 0xC0, 0x06, 0x06, 0x00,
  0x70, 0x1C, 0x07, 0x00, 0x78, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0xE0, 0x3C,
  0x1D, 0x87, 0x31, 0xC6, 0x70, 0xF8, 0x1E, 0x03, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x3E, 0x0F, 0x0F, 0x00, 0x38, 0x40, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x78, 0x00, 0x3F, 0xF8, 0x0F, 0xC1, 0xE1, 0xF0, 0x03, 0x86, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x78, 0x01, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x39, 0xC0, 0x03, 0x8F, 0xE0, 0xF8,
  0x0F, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x06,
  0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x03,
  0x80, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x60,
  0x60, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0D, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0x00,
  0x1E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE4, 0x00, 0x0E, 0x30, 0x00, 0xE1, 0xF8, 0x7E,
  0x03, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0x00,
  0x78, 0x18, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x1F, 0x80,
  0xC3, 0xFF, 0x06, 0x78, 0x1E, 0x37, 0x00, 0x39, 0xA0, 0x00, 0xCF, 0x00,
  0x03, 0x70, 0x00, 0x1B, 0x80, 0x00, 0xD8, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00,
  0x0D, 0x80, 0x00, 0xCE, 0x00, 0x06, 0x30, 0x00, 0x31, 0xC0, 0x03, 0x06,
  0x00, 0x38, 0x18, 0x03, 0x80, 0x78, 0x78, 0x01, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xF0, 0x03, 0xC3, 0xE0, 0x30,
  0x03, 0x83, 0x00, 0x0E, 0x38, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C,
  0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x18, 0xC0, 0x00, 0xC7, 0x00,
  0x06, 0x18, 0x00, 0x60, 0x60, 0x07, 0x01, 0xC0, 0x60, 0x07, 0x8E, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0x3C, 0x00, 0xE0, 0x70, 0x0E, 0x01,
  0xC0, 0xC0, 0x03, 0x0E, 0x00, 0x0C, 0x60, 0x00, 0x76, 0x00, 0x01, 0xB0,
  0x00, 0x0D, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x06, 0xC0, 0x00, 0x33, 0x00, 0x03, 0x9C, 0x00, 0x38, 0x70,
  0x03, 0x81, 0xF0, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x7F, 0xC0, 0x1E, 0x0F, 0x03, 0x80, 0x38, 0x30, 0x01, 0x86, 0x00,
  0x0C, 0x60, 0x00, 0xEC, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x0B,
  0x30, 0x01, 0xB1, 0xC0, 0x73, 0x0F, 0xFC, 0x30, 0x1F, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x60, 0x78, 0x07, 0xFF, 0x00, 0x0E, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x19,
  0xCE, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x67, 0x39, 0x8C, 0x63, 0x31, 0x8C, 0x46, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0xF8, 0xF8, 0x3C, 0x40,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0xE0, 0x03, 0x18, 0x01, 0xFF,
  0xC0, 0x66, 0x00, 0x70, 0x38, 0x0C, 0xC0, 0x18, 0x03, 0x00, 0xD8, 0x06,
  0x00, 0x40, 0x1E, 0x00, 0xC0, 0x08, 0x03, 0xC0, 0x30, 0x03, 0x00, 0x78,
  0x06, 0x00, 0x60, 0x0F, 0x00, 0xC0, 0x0C, 0x01, 0xE0, 0x30, 0x01, 0x80,
  0x3C, 0x06, 0x00, 0x30, 0x07, 0x80, 0xC0, 0x06, 0x00, 0xF0, 0x18, 0x00,
  0xC0, 0x1E, 0x03, 0x00, 0x18, 0x03, 0xC0, 0x60, 0x03, 0x00, 0x58, 0x06,
  0x00, 0xE0, 0x1B, 0x00, 0xC0, 0x14, 0x03, 0x60, 0x18, 0x06, 0xC0, 0xCC,
  0x01, 0x81, 0x98, 0x18, 0xC0, 0x1C, 0xF1, 0xDE, 0x18, 0x01, 0xF8, 0x1F,
  0x83, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x10, 0x00,
  0x0F, 0x80, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x23, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x30, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x30,
  0x06, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x60, 0x0C, 0x00,
  0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x30,
  0x00, 0xF1, 0x80, 0x01, 0xCC, 0x00, 0x07, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80,
  0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x33, 0x00, 0x03, 0x98, 0x00, 0x38,
  0xC0, 0x3F, 0x07, 0xFF, 0xE0, 0x30, 0x0F, 0xE1, 0x80, 0x03, 0x8C, 0x00,
  0x06, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x06, 0xC0, 0x00, 0x76, 0x00, 0x07, 0x30,
  0x00, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0xF8, 0x1F, 0x03, 0xC0, 0x02, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x02, 0x01, 0xF8, 0x7E, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xC0,
  0x07, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xC0,
  0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0, 0x01, 0xE0, 0xC0,
  0x07, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF,
  0xEC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0xF0, 0x00, 0x60, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0x81, 0xE0, 0x00, 0x70, 0x0F, 0xE3,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0xFF, 0x9E, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x0F, 0xCF,
  0xF8, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0xEF, 0xF9, 0xFC, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xB0, 0x00,
  0x39, 0x80, 0x03, 0x8C, 0x00, 0x38, 0x60, 0x01, 0x83, 0x00, 0x18, 0x18,
  0x01, 0xC0, 0xC0, 0x1C, 0x06, 0x01, 0xC0, 0x30, 0x1C, 0x01, 0x80, 0xC0,
  0x0C, 0x0C, 0x00, 0x60, 0xE0, 0x03, 0x0E, 0x00, 0x18, 0xE0, 0x00, 0xCF,
  0x00, 0x06, 0x7C, 0x00, 0x36, 0x60, 0x01, 0xE1, 0x80, 0x0E, 0x0E, 0x00,
  0x60, 0x30, 0x03, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0xE0, 0x30, 0x03, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x70, 0x60, 0x01, 0x83,
  0x00, 0x06, 0x18, 0x00, 0x38, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x30, 0x00,
  0x1D, 0x80, 0x00, 0x6C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0x7B, 0x00, 0x00,
  0x06, 0xF6, 0x00, 0x00, 0x19, 0xE6, 0x00, 0x00, 0x33, 0xCC, 0x00, 0x00,
  0x67, 0x98, 0x00, 0x01, 0x8F, 0x18, 0x00, 0x03, 0x1E, 0x30, 0x00, 0x06,
  0x3C, 0x60, 0x00, 0x18, 0x78, 0x60, 0x00, 0x30, 0xF0, 0xC0, 0x00, 0x61,
  0xE1, 0xC0, 0x01, 0x83, 0xC1, 0x80, 0x03, 0x07, 0x83, 0x00, 0x0C, 0x0F,
  0x03, 0x00, 0x18, 0x1E, 0x06, 0x00, 0x30, 0x3C, 0x0C, 0x00, 0xC0, 0x78,
  0x0C, 0x01, 0x80, 0xF0, 0x18, 0x03, 0x01, 0xE0, 0x30, 0x0C, 0x03, 0xC0,
  0x30, 0x18, 0x07, 0x80, 0x60, 0x20, 0x0F, 0x00, 0x60, 0xC0, 0x1E, 0x00,
  0xC1, 0x80, 0x3C, 0x01, 0x86, 0x00, 0x78, 0x01, 0x8C, 0x00, 0xF0, 0x03,
  0x18, 0x01, 0xE0, 0x06, 0x60, 0x03, 0xC0, 0x06, 0xC0, 0x07, 0x80, 0x0D,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x30,
  0x00, 0x60, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7B, 0x00, 0x00, 0xF3, 0x00, 0x01, 0xE6, 0x00,
  0x03, 0xC6, 0x00, 0x07, 0x8E, 0x00, 0x0F, 0x0C, 0x00, 0x1E, 0x1C, 0x00,
  0x3C, 0x18, 0x00, 0x78, 0x18, 0x00, 0xF0, 0x30, 0x01, 0xE0, 0x30, 0x03,
  0xC0, 0x70, 0x07, 0x80, 0x60, 0x0F, 0x00, 0x60, 0x1E, 0x00, 0xC0, 0x3C,
  0x00, 0xC0, 0x78, 0x01, 0xC0, 0xF0, 0x01, 0x81, 0xE0, 0x03, 0x83, 0xC0,
  0x03, 0x07, 0x80, 0x03, 0x0F, 0x00, 0x07, 0x1E, 0x00, 0x06, 0x3C, 0x00,
  0x0E, 0x78, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x19, 0xC0, 0x00,
  0x1B, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7C, 0x0F, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x07, 0x18, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC3, 0x00, 0x1E, 0x60, 0x00, 0xEC, 0x00, 0x0D, 0x80,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x06, 0xC0, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x1C, 0x60, 0x7F, 0x0F, 0xFF,
  0x81, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7C,
  0x0F, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x38, 0x06, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x03, 0x07, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x07,
  0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x30,
  0x01, 0xE1, 0x80, 0x03, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x73, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80,
  0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x03, 0x98, 0x00, 0x18,
  0xC0, 0x01, 0x86, 0x00, 0x18, 0x30, 0x07, 0x81, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x80, 0xC0, 0x0C, 0x06,
  0x00, 0x70, 0x30, 0x01, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x00,
  0xC3, 0x00, 0x07, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xE6, 0x00, 0x03, 0x30,
  0x00, 0x1D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x7F,
  0xFC, 0x1F, 0x03, 0xE3, 0x80, 0x06, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC8,
  0x00, 0x38, 0xFE, 0x3F, 0x07, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x1C, 0x60, 0x00,
  0x0C, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0xFC,
  0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x70, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x18, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x30, 0x00, 0x30, 0x0C,
  0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x60,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x03,
  0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x18, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x60, 0x00, 0x38, 0x00, 0x06,
  0x60, 0x00, 0x3C, 0x00, 0x06, 0x60, 0x00, 0x2C, 0x00, 0x0E, 0x70, 0x00,
  0x6C, 0x00, 0x0C, 0x30, 0x00, 0x6C, 0x00, 0x0C, 0x30, 0x00, 0x66, 0x00,
  0x0C, 0x30, 0x00, 0x66, 0x00, 0x18, 0x38, 0x00, 0xC6, 0x00, 0x18, 0x18,
  0x00, 0xC6, 0x00, 0x18, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x18, 0x00, 0xC3,
  0x00, 0x30, 0x1C, 0x01, 0x83, 0x00, 0x30, 0x0C, 0x01, 0x83, 0x00, 0x30,
  0x0C, 0x01, 0x81, 0x80, 0x30, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x0E, 0x03,
  0x01, 0x80, 0x60, 0x06, 0x03, 0x01, 0x80, 0x60, 0x06, 0x03, 0x00, 0xC0,
  0x60, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x03,
  0x06, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00,
  0x61, 0x80, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x01, 0x8C, 0x00, 0x61, 0x80,
  0x01, 0x8C, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x33, 0x00, 0x01, 0x98,
  0x00, 0x33, 0x00, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x00, 0xD8, 0x00, 0x1B,
  0x00, 0x00, 0xD8, 0x00, 0x1E, 0x00, 0x00, 0xD0, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x70, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x1C,
  0x00, 0x18, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x30, 0x06, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x00,
  0xC1, 0x80, 0x00, 0xC3, 0x00, 0x00, 0x63, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x76, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0xC3, 0x00, 0x01, 0x81, 0x80, 0x01, 0x81, 0xC0, 0x03, 0x00, 0xC0, 0x07,
  0x00, 0xE0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x60,
  0x00, 0x06, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x1D, 0x80,
  0x00, 0x31, 0x80, 0x00, 0xE3, 0x00, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00,
  0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x38, 0x06, 0x00, 0x30, 0x18, 0x00, 0x70, 0x30, 0x00, 0x60, 0xE0,
  0x00, 0xC1, 0x80, 0x00, 0xC7, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x98, 0x00,
  0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0xFF, 0xFE,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x0C,
  0x60, 0x00, 0x18, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x06,
  0x01, 0x80, 0x0C, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x38,
  0x60, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xE0,
  0xFF, 0xFF, 0xF8, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x07,
  0x03, 0xFC, 0x03, 0xFF, 0xC1, 0xC0, 0x38, 0x40, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x1F, 0xC0, 0xFF, 0xF0, 0xF8, 0x0C, 0xF0, 0x03,
  0x30, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x03, 0x5C, 0x01, 0x93, 0xC1,
  0xC4, 0x3F, 0xC1, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x1F, 0xC0, 0x63, 0xFF, 0x83, 0x38, 0x0F, 0x1B, 0x80, 0x18,
  0xD8, 0x00, 0x67, 0x80, 0x03, 0x38, 0x00, 0x0D, 0xC0, 0x00, 0x6E, 0x00,
  0x03, 0x70, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xFC, 0x00, 0x06, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xBC,
  0x00, 0x19, 0xE0, 0x00, 0xCD, 0x80, 0x0C, 0x66, 0x00, 0xE3, 0x1C, 0x3E,
  0x18, 0x7F, 0xC0, 0x00, 0x60, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xC3, 0xC0,
  0x23, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x43, 0xF1, 0xE0, 0x7F, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x01, 0xFC, 0x30, 0x7F, 0xE3, 0x0E, 0x03, 0xB1, 0x80, 0x19,
  0x30, 0x00, 0xD7, 0x00, 0x05, 0x60, 0x00, 0x76, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x77,
  0x00, 0x05, 0x38, 0x00, 0xD1, 0xC0, 0x19, 0x0F, 0x0F, 0x10, 0x7F, 0xC1,
  0x00, 0x20, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x0E, 0x07, 0x01, 0x80,
  0x18, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0x66, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x06, 0x0F, 0x87, 0xE0, 0x3F,
  0xF8, 0x00, 0x10, 0x00, 0x00, 0x7C, 0x03, 0xFC, 0x0E, 0x08, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xFF, 0x1F, 0xFE, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x01, 0xFC, 0x10, 0x7F, 0xF1,
  0x1E, 0x03, 0x91, 0x80, 0x09, 0x30, 0x00, 0xF7, 0x00, 0x07, 0x60, 0x00,
  0x76, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x36,
  0x00, 0x07, 0x60, 0x00, 0x57, 0x00, 0x0F, 0x38, 0x00, 0xB1, 0xC0, 0x1B,
  0x0F, 0x0F, 0x30, 0x7F, 0xC3, 0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE6, 0x00, 0x1C, 0x7E, 0x0F, 0x81, 0xFF, 0xE0, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x1F, 0xC1, 0x8F, 0xFE, 0x33,
  0x80, 0xE6, 0xC0, 0x0E, 0xD0, 0x00, 0xDE, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x5F, 0xF0, 0x00, 0x03, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0x80, 0x01, 0x01, 0xC0, 0xE0, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x8E, 0x7E,
  0x08, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01, 0xB0, 0x00, 0xCC, 0x00, 0x63,
  0x00, 0x38, 0xC0, 0x1C, 0x30, 0x06, 0x0C, 0x03, 0x03, 0x01, 0x80, 0xC0,
  0xE0, 0x30, 0x70, 0x0C, 0x18, 0x03, 0x0C, 0x00, 0xC7, 0x00, 0x33, 0x60,
  0x0D, 0xDC, 0x03, 0x63, 0x00, 0xF0, 0x60, 0x38, 0x18, 0x0C, 0x03, 0x03,
  0x00, 0xE0, 0xC0, 0x18, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0xC0,
  0x07, 0x30, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xF8, 0x03, 0xF0, 0x63, 0xFF,
  0x07, 0xFE, 0x33, 0x01, 0xC6, 0x03, 0x9B, 0x00, 0x66, 0x00, 0xCD, 0x00,
  0x3E, 0x00, 0x37, 0x00, 0x0E, 0x00, 0x1B, 0x80, 0x07, 0x00, 0x0D, 0xC0,
  0x03, 0x80, 0x06, 0xC0, 0x01, 0xC0, 0x01, 0x60, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x60, 0x00, 0x78, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x1E,
  0x00, 0x0C, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x07, 0x80, 0x03, 0x00, 0x03,
  0xC0, 0x01, 0x80, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x60, 0x00,
  0x78, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x0C, 0x00,
  0x0F, 0x00, 0x06, 0x00, 0x07, 0x80, 0x03, 0x00, 0x03, 0xC0, 0x01, 0x80,
  0x01, 0xE0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x30,
  0x00, 0x30, 0xC1, 0xFC, 0x18, 0xFF, 0xE3, 0x38, 0x0E, 0x6C, 0x00, 0xED,
  0x00, 0x0D, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x30, 0x01, 0xFC, 0x00,
  0x3F, 0xF8, 0x03, 0x80, 0xE0, 0x30, 0x01, 0x83, 0x00, 0x06, 0x38, 0x00,
  0x39, 0x80, 0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x36, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xC6, 0x00, 0x0C,
  0x38, 0x00, 0xE0, 0xE0, 0x0E, 0x03, 0xE3, 0xE0, 0x07, 0xFC, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0xFC, 0x06, 0x1F, 0xF8, 0x33, 0x80, 0xF1, 0x98, 0x01,
  0x8D, 0x80, 0x06, 0x68, 0x00, 0x33, 0xC0, 0x00, 0xDC, 0x00, 0x06, 0xE0,
  0x00, 0x37, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0x70, 0x00, 0x1B,
  0xC0, 0x01, 0x9A, 0x00, 0x0C, 0xD8, 0x00, 0xC6, 0x60, 0x0E, 0x31, 0xE3,
  0xE1, 0x87, 0xFC, 0x0C, 0x02, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xFC, 0x10, 0x7F, 0xE1, 0x0E, 0x03, 0x11, 0x80, 0x19, 0x30, 0x00, 0xF7,
  0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x36, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x0F, 0x30,
  0x00, 0xB1, 0xC0, 0x3B, 0x0F, 0x0F, 0x30, 0x7F, 0xC3, 0x00, 0x40, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0xC1, 0xFE, 0x3F, 0xF3, 0x81, 0xB0, 0x0D, 0x80, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x07, 0xFC, 0x0F, 0xFF, 0xCE, 0x00, 0xCE, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x60, 0x03, 0xBE, 0x0F, 0x87, 0xFF,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x7F, 0xFF, 0xFF, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x07, 0x18, 0x3F, 0xC0, 0x10,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3B, 0x00, 0x0B, 0x60, 0x03, 0x66,
  0x00, 0xCC, 0xF8, 0xF1, 0x87, 0xFC, 0x30, 0x18, 0x00, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x06, 0x70, 0x00, 0x63, 0x00, 0x06,
  0x30, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x18, 0x18, 0x01,
  0x80, 0xC0, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x60,
  0x60, 0x06, 0x06, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x01,
  0x8C, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x0D, 0x80, 0x00, 0xD0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x06, 0xC0, 0x03, 0xC0, 0x06, 0xE0, 0x03, 0xC0, 0x06, 0x60,
  0x03, 0xC0, 0x06, 0x60, 0x06, 0xC0, 0x0C, 0x60, 0x06, 0x60, 0x0C, 0x30,
  0x06, 0x60, 0x0C, 0x30, 0x06, 0x60, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x30,
  0x0C, 0x30, 0x18, 0x18, 0x0C, 0x30, 0x18, 0x18, 0x18, 0x30, 0x18, 0x18,
  0x18, 0x18, 0x30, 0x18, 0x18, 0x18, 0x30, 0x0C, 0x18, 0x18, 0x30, 0x0C,
  0x30, 0x18, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x0C, 0x30, 0x0C, 0x60, 0x06,
  0x60, 0x0C, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x06,
  0x60, 0x06, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x60,
  0x00, 0x77, 0x00, 0x06, 0x30, 0x00, 0xC3, 0x80, 0x0C, 0x18, 0x01, 0x80,
  0xC0, 0x38, 0x0E, 0x03, 0x00, 0x60, 0x60, 0x03, 0x0E, 0x00, 0x30, 0xC0,
  0x01, 0x98, 0x00, 0x1D, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0x98, 0x00, 0x19, 0xC0, 0x03, 0x0C, 0x00, 0x70,
  0x60, 0x06, 0x06, 0x00, 0xC0, 0x30, 0x1C, 0x03, 0x81, 0x80, 0x18, 0x38,
  0x00, 0xC3, 0x00, 0x0E, 0x60, 0x00, 0x6E, 0x00, 0x03, 0xC0, 0x00, 0x1B,
  0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x06, 0x18, 0x00,
  0x30, 0xC0, 0x01, 0x83, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x01, 0x80, 0x18, 0x0C,
  0x00, 0xC0, 0x60, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x03,
  0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00,
  0x00, 0xD8, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x02, 0x38, 0x00, 0x1F, 0x80, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xFF, 0x7F,
  0xFF, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x03, 0xF0, 0x1C, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x03, 0xF0, 0x00, 0xE0,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x1E, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xE0, 0x3F, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x80, 0x16, 0x07, 0x80, 0xF0, 0x07,
  0xFE, 0x80, 0x07, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 37, 11, 4, -37 },
  { 15, 9, 13, 17, 4, -37 },
  { 30, 27, 37, 29, 1, -37 },
  { 155, 20, 42, 26, 3, -39 },
  { 260, 32, 39, 38, 3, -38 },
  { 416, 27, 39, 31, 3, -38 },
  { 548, 2, 13, 9, 4, -37 },
  { 552, 10, 45, 14, 2, -37 },
  { 609, 9, 45, 14, 2, -37 },
  { 660, 19, 18, 25, 3, -39 },
  { 703, 22, 24, 27, 2, -30 },
  { 769, 5, 13, 10, 2, -6 },
  { 778, 12, 2, 16, 2, -15 },
  { 781, 3, 4, 11, 4, -4 },
  { 783, 16, 37, 17, 1, -37 },
  { 857, 21, 38, 26, 3, -38 },
  { 957, 11, 37, 26, 5, -37 },
  { 1008, 20, 38, 26, 3, -38 },
  { 1103, 21, 39, 26, 2, -38 },
  { 1206, 25, 37, 26, 1, -37 },
  { 1322, 21, 38, 26, 3, -37 },
  { 1422, 21, 39, 26, 3, -38 },
  { 1525, 21, 37, 26, 3, -37 },
  { 1623, 21, 39, 26, 3, -38 },
  { 1726, 20, 39, 26, 3, -38 },
  { 1824, 3, 28, 11, 4, -28 },
  { 1835, 5, 35, 11, 2, -28 },
  { 1857, 22, 23, 27, 2, -30 },
  { 1921, 22, 13, 27, 2, -25 },
  { 1957, 22, 23, 27, 2, -30 },
  { 2021, 16, 38, 19, 1, -38 },
  { 2097, 35, 42, 41, 3, -37 },
  { 2281, 27, 37, 27, 0, -37 },
  { 2406, 21, 37, 29, 5, -37 },
  { 2504, 24, 39, 28, 3, -38 },
  { 2621, 24, 37, 32, 5, -37 },
  { 2732, 18, 37, 25, 5, -37 },
  { 2816, 18, 37, 23, 5, -37 },
  { 2900, 27, 39, 34, 3, -38 },
  { 3032, 23, 37, 33, 5, -37 },
  { 3139, 9, 37, 14, 3, -37 },
  { 3181, 11, 46, 12, -4, -37 },
  { 3245, 21, 37, 26, 5, -37 },
  { 3343, 17, 37, 23, 5, -37 },
  { 3422, 31, 37, 41, 5, -37 },
  { 3566, 23, 37, 33, 5, -37 },
  { 3673, 29, 39, 35, 3, -38 },
  { 3815, 19, 37, 27, 5, -37 },
  { 3903, 29, 47, 35, 3, -38 },
  { 4074, 21, 37, 27, 5, -37 },
  { 4172, 20, 39, 25, 3, -38 },
  { 4270, 23, 37, 24, 0, -37 },
  { 4377, 25, 38, 33, 4, -37 },
  { 4496, 26, 37, 26, 0, -37 },
  { 4617, 40, 37, 42, 1, -37 },
  { 4802, 24, 37, 24, 0, -37 },
  { 4913, 23, 37, 23, 0, -37 },
  { 5020, 22, 37, 25, 2, -37 },
  { 5122, 11, 45, 16, 4, -37 },
  { 5184, 16, 37, 17, 1, -37 },
  { 5258, 10, 45, 16, 2, -37 },
  { 5315, 23, 21, 27, 2, -37 },
  { 5376, 21, 1, 21, 0, 5 },
  { 5379, 9, 8, 13, 2, -40 },
  { 5388, 18, 29, 24, 2, -28 },
  { 5454, 21, 41, 28, 4, -40 },
  { 5562, 17, 29, 22, 3, -28 },
  { 5624, 20, 41, 28, 3, -40 },
  { 5727, 20, 29, 25, 3, -28 },
  { 5800, 15, 40, 14, 1, -40 },
  { 5875, 20, 41, 28, 3, -28 },
  { 5978, 19, 40, 27, 4, -40 },
  { 6073, 3, 38, 11, 4, -38 },
  { 6088, 9, 51, 11, -2, -38 },
  { 6146, 18, 40, 22, 4, -40 },
  { 6236, 2, 40, 11, 4, -40 },
  { 6246, 33, 28, 41, 4, -28 },
  { 6362, 19, 28, 27, 4, -28 },
  { 6429, 21, 29, 27, 3, -28 },
  { 6506, 21, 40, 28, 4, -28 },
  { 6611, 20, 40, 28, 3, -28 },
  { 6711, 13, 28, 18, 4, -28 },
  { 6757, 17, 29, 21, 2, -28 },
  { 6819, 13, 35, 15, 1, -34 },
  { 6876, 19, 29, 27, 4, -28 },
  { 6945, 20, 28, 21, 0, -28 },
  { 7015, 32, 28, 33, 1, -28 },
  { 7127, 20, 28, 22, 1, -28 },
  { 7197, 21, 41, 21, 0, -28 },
  { 7305, 16, 28, 20, 2, -28 },
  { 7361, 14, 45, 18, 2, -37 },
  { 7440, 1, 53, 25, 12, -40 },
  { 7447, 14, 45, 18, 2, -37 },
  { 7526, 22, 5, 27, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight52pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT52PT7B_H_
