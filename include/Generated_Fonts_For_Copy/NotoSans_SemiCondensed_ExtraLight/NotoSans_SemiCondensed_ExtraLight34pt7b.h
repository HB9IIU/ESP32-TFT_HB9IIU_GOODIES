#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT34PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEA, 0xAA, 0xAA, 0xA0, 0x0F, 0xC7, 0x8F, 0x1E, 0x3C, 0x38,
  0x50, 0xA1, 0x42, 0x01, 0x06, 0x01, 0x82, 0x00, 0x81, 0x00, 0x40, 0x80,
  0x20, 0x40, 0x10, 0x60, 0x08, 0x20, 0xFF, 0xFF, 0x04, 0x08, 0x02, 0x04,
  0x01, 0x02, 0x00, 0x83, 0x00, 0x41, 0x00, 0x60, 0x80, 0x20, 0x41, 0xFF,
  0xFE, 0x08, 0x10, 0x04, 0x18, 0x02, 0x08, 0x03, 0x04, 0x01, 0x02, 0x00,
  0x81, 0x00, 0x40, 0x80, 0x20, 0xC0, 0x02, 0x00, 0x10, 0x03, 0xE0, 0x77,
  0xE6, 0x21, 0x61, 0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x30, 0x80,
  0xC4, 0x03, 0xA0, 0x07, 0x00, 0x0F, 0x00, 0x4C, 0x02, 0x30, 0x10, 0xC0,
  0x82, 0x04, 0x10, 0x20, 0x81, 0x0C, 0x08, 0x58, 0x4C, 0x7F, 0xC0, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x08, 0x00, 0x83, 0xF0, 0x08, 0x10, 0x80, 0x41,
  0x86, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x02, 0x04, 0x10, 0x10, 0x21,
  0x00, 0x81, 0x08, 0x04, 0x08, 0xC0, 0x20, 0x44, 0x71, 0x02, 0x66, 0x4C,
  0x32, 0x61, 0x21, 0x32, 0x09, 0xF9, 0x10, 0x61, 0x19, 0x81, 0x00, 0x8C,
  0x08, 0x0C, 0x60, 0x40, 0x43, 0x02, 0x02, 0x18, 0x10, 0x20, 0xC1, 0x81,
  0x02, 0x08, 0x10, 0x10, 0x40, 0x80, 0xC6, 0x08, 0x03, 0xE0, 0x07, 0x00,
  0x03, 0xF0, 0x01, 0x06, 0x00, 0xC0, 0x80, 0x20, 0x20, 0x08, 0x08, 0x02,
  0x02, 0x00, 0xC0, 0x80, 0x10, 0x60, 0x06, 0x30, 0x00, 0xD8, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x0C, 0xC0, 0x06, 0x18, 0x19, 0x03, 0x06, 0x80, 0x61,
  0x20, 0x08, 0x48, 0x01, 0x22, 0x00, 0x28, 0x80, 0x0C, 0x30, 0x03, 0x84,
  0x01, 0xB1, 0xC1, 0xC4, 0x1F, 0xC0, 0xC0, 0xFF, 0xF5, 0x40, 0x0C, 0x63,
  0x08, 0x61, 0x04, 0x30, 0xC2, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0xC3, 0x04, 0x10, 0x60, 0x83, 0x04, 0x0C, 0xC0, 0xC0, 0xC0, 0x81,
  0x81, 0x02, 0x06, 0x0C, 0x08, 0x10, 0x20, 0x40, 0x81, 0x83, 0x04, 0x08,
  0x10, 0x20, 0xC1, 0x82, 0x04, 0x18, 0x20, 0xC1, 0x0C, 0x00, 0x06, 0x00,
  0x60, 0x02, 0x00, 0x20, 0x82, 0x1F, 0x2F, 0x0F, 0x00, 0x60, 0x09, 0x01,
  0x98, 0x10, 0xC2, 0x04, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x3F, 0xFF, 0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x32, 0x22, 0x64, 0x4C,
  0xFF, 0xF0, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x08,
  0x06, 0x01, 0x00, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0x40, 0x30, 0x08,
  0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x02, 0x00, 0x03, 0x00, 0xFE, 0x0C,
  0x18, 0x40, 0x64, 0x01, 0x20, 0x0F, 0x00, 0x78, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x70, 0x02, 0x80, 0x34, 0x01, 0x30, 0x08, 0x80, 0xC6, 0x0C, 0x0F,
  0xC0, 0x06, 0x1C, 0x4B, 0x1C, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x06, 0x01,
  0xFE, 0x38, 0x18, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x18,
  0x00, 0xFF, 0xF8, 0x03, 0x80, 0xFF, 0x86, 0x03, 0x10, 0x06, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x0F, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0xB0, 0x0C, 0x7F, 0xE0, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x50, 0x00, 0xD0, 0x00, 0x90, 0x01, 0x10, 0x03,
  0x10, 0x02, 0x10, 0x04, 0x10, 0x0C, 0x10, 0x08, 0x10, 0x10, 0x10, 0x30,
  0x10, 0x20, 0x10, 0x60, 0x10, 0x40, 0x10, 0x80, 0x10, 0xFF, 0xFF, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x3F,
  0xF3, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x10, 0x1F, 0xF0, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x1B, 0x01,
  0x8F, 0xF0, 0x00, 0xE0, 0x1F, 0xC0, 0xC0, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x7C, 0x26, 0x18, 0xA0,
  0x13, 0x00, 0x6C, 0x00, 0xB0, 0x02, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xD0,
  0x02, 0x40, 0x09, 0x80, 0x62, 0x01, 0x0C, 0x0C, 0x0F, 0xC0, 0xFF, 0xF8,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x03, 0x00, 0xFF, 0x08, 0x0C, 0x80, 0x24, 0x01, 0xE0, 0x0F, 0x00,
  0x68, 0x03, 0x60, 0x11, 0x01, 0x86, 0x30, 0x1F, 0x00, 0xF8, 0x0C, 0x60,
  0x80, 0xC8, 0x02, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0,
  0x05, 0x00, 0x4E, 0x06, 0x1F, 0xC0, 0x06, 0x01, 0xFE, 0x18, 0x18, 0x80,
  0x6C, 0x01, 0x40, 0x0A, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x34, 0x01, 0xB0, 0x34, 0xF7, 0x21, 0xE1, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x30, 0x7F, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0x33, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x32,
  0x26, 0x64, 0x4C, 0x00, 0x04, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0x00, 0x08,
  0x3F, 0xC8, 0x08, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xFF, 0x00, 0x06, 0x01,
  0x80, 0x30, 0x00, 0x80, 0xC0, 0x00, 0x83, 0x00, 0x00, 0x84, 0x00, 0x01,
  0x98, 0x00, 0x01, 0x20, 0x3F, 0x82, 0x40, 0xC1, 0x07, 0x83, 0x02, 0x0E,
  0x04, 0x04, 0x0C, 0x18, 0x08, 0x18, 0x20, 0x10, 0x30, 0x40, 0x20, 0x60,
  0x80, 0xC1, 0xC1, 0x01, 0x83, 0x82, 0x03, 0x05, 0x02, 0x0E, 0x0A, 0x06,
  0x14, 0x26, 0x07, 0xC7, 0x84, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x16, 0x00, 0x04, 0x80, 0x01, 0x20,
  0x00, 0x8C, 0x00, 0x21, 0x00, 0x08, 0x40, 0x06, 0x10, 0x01, 0x06, 0x00,
  0x40, 0x80, 0x30, 0x20, 0x08, 0x0C, 0x02, 0x01, 0x01, 0xFF, 0xC0, 0x40,
  0x18, 0x10, 0x02, 0x0C, 0x00, 0x82, 0x00, 0x30, 0x80, 0x04, 0x60, 0x01,
  0x10, 0x00, 0x6C, 0x00, 0x0B, 0x00, 0x03, 0xFF, 0xE2, 0x00, 0xC8, 0x01,
  0xA0, 0x02, 0x80, 0x0A, 0x00, 0x38, 0x00, 0xE0, 0x02, 0x80, 0x1A, 0x00,
  0x48, 0x0E, 0x3F, 0xF0, 0x80, 0x32, 0x00, 0x28, 0x00, 0xE0, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0A, 0x00, 0x68, 0x07, 0x3F,
  0xF0, 0x00, 0x60, 0x03, 0xFF, 0x0C, 0x02, 0x18, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E,
  0x02, 0x03, 0xFE, 0xFF, 0xC0, 0x80, 0x70, 0x80, 0x18, 0x80, 0x0C, 0x80,
  0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x18, 0x80,
  0xE0, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFE, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xE8, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xE0, 0xE0, 0x08, 0x60, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x0F, 0xF8, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x34, 0x00, 0x0D, 0x80, 0x03,
  0x20, 0x00, 0xCC, 0x00, 0x31, 0x80, 0x0C, 0x38, 0x07, 0x03, 0xFF, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xFC, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x3F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x8C, 0xF8, 0x80, 0x0E, 0x00,
  0x48, 0x03, 0x20, 0x18, 0x80, 0xC2, 0x06, 0x08, 0x10, 0x20, 0x80, 0x86,
  0x02, 0x30, 0x09, 0xC0, 0x2D, 0x00, 0xA6, 0x03, 0x08, 0x08, 0x30, 0x20,
  0x60, 0x80, 0x82, 0x03, 0x08, 0x06, 0x20, 0x08, 0x80, 0x32, 0x00, 0x68,
  0x00, 0xA0, 0x03, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xA0, 0x00, 0x7B, 0x00,
  0x05, 0x90, 0x00, 0x59, 0x00, 0x0D, 0x98, 0x00, 0x98, 0x80, 0x09, 0x88,
  0x01, 0x98, 0xC0, 0x11, 0x84, 0x01, 0x18, 0x40, 0x21, 0x86, 0x02, 0x18,
  0x20, 0x61, 0x83, 0x04, 0x18, 0x10, 0x41, 0x81, 0x0C, 0x18, 0x18, 0x81,
  0x80, 0x88, 0x18, 0x09, 0x81, 0x80, 0xD0, 0x18, 0x05, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xA0, 0x03, 0xB0, 0x03, 0x90,
  0x03, 0x98, 0x03, 0x8C, 0x03, 0x84, 0x03, 0x86, 0x03, 0x82, 0x03, 0x83,
  0x03, 0x81, 0x03, 0x81, 0x83, 0x80, 0xC3, 0x80, 0x43, 0x80, 0x63, 0x80,
  0x23, 0x80, 0x33, 0x80, 0x1B, 0x80, 0x0B, 0x80, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x03, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x30, 0x18, 0x08, 0x00,
  0x82, 0x00, 0x18, 0xC0, 0x01, 0x10, 0x00, 0x32, 0x00, 0x02, 0xC0, 0x00,
  0x58, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x09, 0x00, 0x01,
  0x30, 0x00, 0x62, 0x00, 0x08, 0x60, 0x03, 0x06, 0x00, 0xC0, 0x60, 0x30,
  0x07, 0xF8, 0x00, 0xFF, 0xC4, 0x03, 0x20, 0x0D, 0x00, 0x28, 0x01, 0xC0,
  0x0E, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xA0, 0x0D, 0x00, 0xC8, 0x3C,
  0x7F, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x30,
  0x18, 0x08, 0x00, 0x82, 0x00, 0x18, 0xC0, 0x01, 0x90, 0x00, 0x32, 0x00,
  0x02, 0xC0, 0x00, 0x58, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x09, 0x00, 0x01, 0x30, 0x00, 0x62, 0x00, 0x08, 0x60, 0x03, 0x06, 0x00,
  0xC0, 0x60, 0x30, 0x07, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0xFF, 0xC2, 0x01, 0x88,
  0x03, 0x20, 0x06, 0x80, 0x1A, 0x00, 0x28, 0x00, 0xA0, 0x06, 0x80, 0x1A,
  0x00, 0x48, 0x03, 0x20, 0x18, 0xFF, 0x82, 0x04, 0x08, 0x18, 0x20, 0x20,
  0x80, 0xC2, 0x01, 0x88, 0x02, 0x20, 0x0C, 0x80, 0x12, 0x00, 0x68, 0x00,
  0xA0, 0x03, 0x03, 0x00, 0xFF, 0x98, 0x04, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0xD0, 0x0C, 0xFF, 0xC0, 0xFF, 0xFE, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0xC0, 0x02, 0x40, 0x06, 0x60, 0x0C,
  0x38, 0x18, 0x0F, 0xF0, 0xC0, 0x01, 0xA0, 0x00, 0x90, 0x00, 0x4C, 0x00,
  0x62, 0x00, 0x31, 0x00, 0x10, 0xC0, 0x18, 0x60, 0x0C, 0x10, 0x04, 0x0C,
  0x02, 0x06, 0x03, 0x01, 0x01, 0x00, 0x80, 0x80, 0x60, 0xC0, 0x10, 0x40,
  0x08, 0x20, 0x06, 0x30, 0x01, 0x10, 0x00, 0x88, 0x00, 0x6C, 0x00, 0x14,
  0x00, 0x0A, 0x00, 0x07, 0x00, 0x01, 0x00, 0x80, 0x08, 0x00, 0xE0, 0x07,
  0x00, 0x2C, 0x01, 0x40, 0x09, 0x00, 0x50, 0x06, 0x40, 0x14, 0x01, 0x10,
  0x0D, 0x80, 0x46, 0x03, 0x20, 0x30, 0x80, 0x88, 0x0C, 0x20, 0x22, 0x02,
  0x08, 0x18, 0xC0, 0x83, 0x06, 0x10, 0x60, 0x41, 0x04, 0x18, 0x10, 0x41,
  0x04, 0x04, 0x30, 0x61, 0x01, 0x8C, 0x08, 0xC0, 0x22, 0x02, 0x30, 0x08,
  0x80, 0x88, 0x02, 0x60, 0x32, 0x00, 0xD8, 0x05, 0x80, 0x14, 0x01, 0x60,
  0x05, 0x00, 0x50, 0x01, 0x40, 0x1C, 0x00, 0x70, 0x03, 0x00, 0x08, 0x00,
  0xC0, 0x60, 0x06, 0x20, 0x04, 0x30, 0x0C, 0x10, 0x08, 0x18, 0x18, 0x08,
  0x10, 0x0C, 0x20, 0x04, 0x60, 0x02, 0x40, 0x03, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x02, 0xC0, 0x06, 0x40, 0x04, 0x20, 0x0C, 0x20, 0x08,
  0x10, 0x18, 0x18, 0x10, 0x08, 0x20, 0x0C, 0x60, 0x04, 0x40, 0x06, 0xC0,
  0x03, 0xC0, 0x06, 0x80, 0x09, 0x80, 0x11, 0x00, 0x63, 0x00, 0x82, 0x03,
  0x06, 0x04, 0x04, 0x18, 0x0C, 0x20, 0x08, 0xC0, 0x11, 0x00, 0x36, 0x00,
  0x28, 0x00, 0x70, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x7F, 0xFC,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0x80, 0x30, 0x04, 0x01, 0x00, 0x60,
  0x08, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x08, 0x03,
  0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x1F, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0B, 0x00, 0x32, 0x00, 0x46, 0x01,
  0x84, 0x02, 0x0C, 0x0C, 0x08, 0x10, 0x18, 0x60, 0x10, 0x80, 0x33, 0x00,
  0x24, 0x00, 0x78, 0x00, 0x40, 0xFF, 0xFC, 0xC1, 0x83, 0x06, 0x0C, 0x1F,
  0xC3, 0x06, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x0F,
  0xF3, 0x81, 0x60, 0x14, 0x01, 0x40, 0x1C, 0x01, 0x40, 0x34, 0x03, 0x60,
  0xD3, 0xF9, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x9F, 0xC5, 0x83, 0x28, 0x0D, 0x80, 0x2C, 0x01, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xE0, 0x0F, 0x00, 0x5C, 0x06, 0xB0, 0x64, 0xFE, 0x00, 0x0F, 0xE3, 0x04,
  0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x23, 0xFC, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x1F,
  0xC9, 0x83, 0x58, 0x0E, 0x80, 0x3C, 0x01, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x0D, 0x00, 0x6C,
  0x07, 0x30, 0x68, 0xFE, 0x40, 0x1F, 0xC1, 0x83, 0x18, 0x0C, 0x80, 0x2C,
  0x01, 0x60, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x10, 0xFF, 0x00, 0x03,
  0xE1, 0x84, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0xFF, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x1F,
  0xC9, 0x83, 0x58, 0x06, 0x80, 0x3C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x0D, 0x00, 0x6C,
  0x05, 0x30, 0x68, 0xFE, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x02, 0x60, 0x61, 0xFE, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x9F, 0xCB, 0x06, 0xE0, 0x2C, 0x03,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x5D, 0x00, 0x02,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x40, 0x08, 0x70, 0x80, 0x00, 0x00,
  0x02, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x86, 0xF0, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x70, 0x1A, 0x06, 0x41,
  0x88, 0x21, 0x08, 0x23, 0x04, 0xC0, 0xB8, 0x14, 0x83, 0x18, 0x41, 0x08,
  0x31, 0x03, 0x20, 0x24, 0x06, 0x80, 0x50, 0x04, 0xFF, 0xFF, 0xFF, 0xC0,
  0x9F, 0x87, 0xE5, 0x86, 0x41, 0xB0, 0x14, 0x05, 0x80, 0xE0, 0x38, 0x02,
  0x01, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40,
  0x9F, 0xCB, 0x06, 0xA0, 0x3C, 0x03, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x0F, 0xC0, 0xC0, 0xC6, 0x01, 0x10, 0x06, 0xC0, 0x0B,
  0x00, 0x28, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xC0, 0x0B, 0x00, 0x24, 0x01, 0x98, 0x04, 0x30, 0x20, 0x7F, 0x00, 0x8F,
  0xC5, 0x83, 0x28, 0x0D, 0x80, 0x2C, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x0F, 0x00, 0x54,
  0x06, 0xB0, 0x64, 0xFE, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x00, 0x1F, 0xC9, 0x83, 0x58, 0x0E, 0x80,
  0x3C, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xE0, 0x0D, 0x00, 0x6C, 0x05, 0x30, 0x68, 0xFE, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x9F, 0xB0, 0xA0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1F, 0xE4, 0x05, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0xC0, 0x4F, 0xF0, 0x20, 0x20, 0x20, 0x20,
  0xFF, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x30, 0x1F, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x80, 0x3C, 0x05, 0x60, 0x93, 0xF1, 0xC0, 0x0A, 0x00,
  0x50, 0x06, 0xC0, 0x22, 0x01, 0x10, 0x18, 0xC0, 0x82, 0x04, 0x10, 0x60,
  0xC2, 0x02, 0x10, 0x11, 0x80, 0xC8, 0x02, 0x40, 0x16, 0x00, 0xA0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x30, 0x0A, 0x01, 0x80, 0x50, 0x0C, 0x06, 0xC0,
  0xF0, 0x22, 0x04, 0x81, 0x10, 0x24, 0x08, 0x81, 0x30, 0xC6, 0x18, 0x84,
  0x10, 0x84, 0x20, 0x84, 0x21, 0x06, 0x61, 0x98, 0x32, 0x04, 0x80, 0x90,
  0x24, 0x04, 0x81, 0xA0, 0x3C, 0x07, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80,
  0x30, 0x0C, 0x00, 0xC0, 0x1A, 0x01, 0x88, 0x18, 0x60, 0x81, 0x0C, 0x0C,
  0x40, 0x34, 0x00, 0xE0, 0x06, 0x00, 0x38, 0x03, 0x40, 0x13, 0x01, 0x88,
  0x18, 0x20, 0x81, 0x8C, 0x04, 0x40, 0x36, 0x00, 0xC0, 0xC0, 0x0D, 0x00,
  0x24, 0x01, 0x98, 0x04, 0x20, 0x10, 0x80, 0xC3, 0x02, 0x04, 0x08, 0x10,
  0x60, 0x61, 0x00, 0x84, 0x02, 0x30, 0x0C, 0x80, 0x12, 0x00, 0x58, 0x01,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x18, 0x03, 0xC0, 0x00, 0x7F, 0xE0, 0x0C, 0x01, 0x00,
  0x60, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x01,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x1F, 0xFC, 0x03, 0x83, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x81, 0x83,
  0x80, 0x60, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x03, 0x00, 0x80, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x06,
  0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x80, 0x1C, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x60, 0xF0, 0x00, 0x10,
  0x03, 0xF8, 0x18, 0x3F, 0x80, 0x08,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 24, 8, 3, -24 },
  { 7, 7, 9, 11, 2, -24 },
  { 15, 17, 24, 19, 1, -24 },
  { 66, 13, 28, 17, 2, -26 },
  { 112, 21, 25, 25, 2, -25 },
  { 178, 18, 25, 20, 2, -25 },
  { 235, 2, 9, 6, 2, -24 },
  { 238, 6, 29, 9, 2, -24 },
  { 260, 7, 29, 9, 1, -24 },
  { 286, 12, 12, 16, 2, -26 },
  { 304, 14, 16, 17, 2, -20 },
  { 332, 4, 8, 7, 1, -4 },
  { 336, 8, 1, 10, 1, -10 },
  { 337, 2, 2, 7, 3, -2 },
  { 338, 10, 24, 11, 1, -24 },
  { 368, 13, 25, 17, 2, -25 },
  { 409, 7, 24, 17, 3, -24 },
  { 430, 13, 25, 17, 2, -25 },
  { 471, 14, 25, 17, 1, -25 },
  { 515, 16, 24, 17, 1, -24 },
  { 563, 13, 24, 17, 2, -24 },
  { 602, 14, 25, 17, 2, -25 },
  { 646, 13, 24, 17, 2, -24 },
  { 685, 13, 25, 17, 2, -25 },
  { 726, 13, 25, 17, 2, -25 },
  { 767, 2, 18, 7, 3, -18 },
  { 772, 4, 22, 7, 1, -18 },
  { 783, 14, 15, 17, 2, -20 },
  { 810, 14, 8, 17, 2, -16 },
  { 824, 14, 15, 17, 2, -20 },
  { 851, 10, 25, 12, 1, -25 },
  { 883, 23, 27, 27, 2, -24 },
  { 961, 18, 24, 18, 0, -24 },
  { 1015, 14, 24, 19, 3, -24 },
  { 1057, 16, 25, 19, 2, -25 },
  { 1107, 16, 24, 21, 3, -24 },
  { 1155, 12, 24, 17, 3, -24 },
  { 1191, 12, 24, 15, 3, -24 },
  { 1227, 18, 25, 22, 2, -25 },
  { 1284, 15, 24, 22, 3, -24 },
  { 1329, 6, 24, 9, 2, -24 },
  { 1347, 8, 30, 8, -3, -24 },
  { 1377, 14, 24, 17, 3, -24 },
  { 1419, 12, 24, 15, 3, -24 },
  { 1455, 20, 24, 27, 3, -24 },
  { 1515, 16, 24, 22, 3, -24 },
  { 1563, 19, 25, 23, 2, -25 },
  { 1623, 13, 24, 18, 3, -24 },
  { 1662, 19, 31, 23, 2, -25 },
  { 1736, 14, 24, 18, 3, -24 },
  { 1778, 13, 25, 17, 2, -25 },
  { 1819, 15, 24, 15, 0, -24 },
  { 1864, 16, 24, 22, 3, -24 },
  { 1912, 17, 24, 17, 0, -24 },
  { 1963, 26, 24, 27, 1, -24 },
  { 2041, 16, 24, 16, 0, -24 },
  { 2089, 15, 24, 15, 0, -24 },
  { 2134, 14, 24, 17, 1, -24 },
  { 2176, 7, 29, 11, 3, -24 },
  { 2202, 10, 24, 11, 1, -24 },
  { 2232, 7, 29, 11, 1, -24 },
  { 2258, 15, 14, 17, 1, -24 },
  { 2285, 14, 1, 14, 0, 3 },
  { 2287, 6, 5, 8, 1, -26 },
  { 2291, 12, 18, 16, 1, -18 },
  { 2318, 13, 26, 18, 3, -26 },
  { 2361, 11, 18, 14, 2, -18 },
  { 2386, 13, 26, 18, 2, -26 },
  { 2429, 13, 18, 17, 2, -18 },
  { 2459, 11, 26, 9, 0, -26 },
  { 2495, 13, 26, 18, 2, -18 },
  { 2538, 12, 26, 18, 3, -26 },
  { 2577, 3, 25, 7, 2, -25 },
  { 2587, 6, 33, 7, -1, -25 },
  { 2612, 11, 26, 14, 3, -26 },
  { 2648, 1, 26, 7, 3, -26 },
  { 2652, 21, 18, 26, 3, -18 },
  { 2700, 12, 18, 18, 3, -18 },
  { 2727, 14, 18, 18, 2, -18 },
  { 2759, 13, 26, 18, 3, -18 },
  { 2802, 13, 26, 18, 2, -18 },
  { 2845, 8, 18, 12, 3, -18 },
  { 2863, 11, 18, 14, 1, -18 },
  { 2888, 8, 22, 10, 1, -22 },
  { 2910, 12, 18, 18, 3, -18 },
  { 2937, 13, 18, 13, 0, -18 },
  { 2967, 21, 18, 22, 0, -18 },
  { 3015, 13, 18, 15, 1, -18 },
  { 3045, 14, 26, 14, 0, -18 },
  { 3091, 11, 18, 13, 1, -18 },
  { 3116, 9, 29, 12, 1, -24 },
  { 3149, 1, 34, 16, 8, -26 },
  { 3154, 10, 29, 12, 1, -24 },
  { 3191, 14, 4, 17, 2, -14 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight34pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT34PT7B_H_
