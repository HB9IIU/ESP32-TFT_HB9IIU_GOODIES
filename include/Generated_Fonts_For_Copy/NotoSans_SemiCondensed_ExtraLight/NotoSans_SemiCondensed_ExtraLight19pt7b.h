#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT19PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight19pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x54, 0x30, 0x99, 0x99, 0x90, 0x08, 0x82, 0x20, 0x88,
  0x24, 0x7F, 0xC4, 0x41, 0x10, 0x44, 0x11, 0x3F, 0xF2, 0x20, 0x88, 0x22,
  0x08, 0x80, 0x10, 0xFE, 0x44, 0x89, 0x12, 0x1C, 0x0C, 0x16, 0x24, 0x48,
  0x99, 0x6F, 0x04, 0x00, 0x60, 0x49, 0x08, 0x88, 0x88, 0x90, 0x89, 0x08,
  0xA4, 0x8A, 0xA9, 0x51, 0x65, 0x10, 0x91, 0x09, 0x11, 0x11, 0x11, 0x12,
  0x0E, 0x38, 0x11, 0x04, 0x21, 0x08, 0x44, 0x0B, 0x01, 0x01, 0xA0, 0x88,
  0x61, 0x28, 0x2A, 0x04, 0x82, 0x9F, 0x10, 0xF8, 0x25, 0x29, 0x24, 0x92,
  0x48, 0x92, 0x20, 0x91, 0x22, 0x49, 0x24, 0x92, 0x52, 0x80, 0x10, 0x23,
  0xF8, 0x82, 0x88, 0x80, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10,
  0x10, 0x6A, 0xF0, 0xC0, 0x04, 0x10, 0x82, 0x08, 0x41, 0x04, 0x20, 0x84,
  0x10, 0x42, 0x00, 0x38, 0x44, 0x42, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x82, 0x82, 0x42, 0x3C, 0x13, 0xD9, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x39, 0x88, 0x08, 0x10, 0x20, 0x41, 0x02, 0x08, 0x20, 0x81, 0x04, 0x1F,
  0xC0, 0x79, 0x08, 0x08, 0x10, 0x20, 0x4F, 0x02, 0x02, 0x04, 0x08, 0x10,
  0x3F, 0x80, 0x02, 0x01, 0x01, 0x81, 0x40, 0xA0, 0x90, 0x88, 0x44, 0x42,
  0x21, 0x3F, 0xE0, 0x40, 0x20, 0x10, 0x7E, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x7C, 0x02, 0x01, 0x01, 0x01, 0x02, 0x02, 0xFC, 0x1E, 0x20, 0x40, 0x40,
  0x80, 0x88, 0xB6, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0xFF, 0x01,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x3C, 0x42, 0x82, 0x82, 0x82, 0x44, 0x38, 0x24, 0x42, 0x81, 0x81, 0x81,
  0x82, 0x7C, 0x38, 0x44, 0x82, 0x82, 0x81, 0x81, 0x82, 0x45, 0x39, 0x02,
  0x02, 0x02, 0x04, 0x78, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x6A, 0x03, 0x0C,
  0x30, 0x40, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x60, 0x18, 0x06, 0x03, 0x0C, 0x30, 0xC0, 0x74, 0x42, 0x10, 0x84, 0x44,
  0x42, 0x10, 0x00, 0x20, 0x07, 0x80, 0xC2, 0x08, 0x08, 0x80, 0x24, 0x78,
  0xC4, 0x46, 0x22, 0x32, 0x11, 0x90, 0x8C, 0x84, 0x62, 0x25, 0x0E, 0xE4,
  0x00, 0x20, 0x00, 0xC1, 0x01, 0xF0, 0x08, 0x03, 0x00, 0xC0, 0x48, 0x12,
  0x04, 0x82, 0x20, 0x84, 0x3F, 0x10, 0x44, 0x09, 0x02, 0x80, 0xA0, 0x10,
  0xF8, 0x86, 0x82, 0x82, 0x82, 0x82, 0xFC, 0x84, 0x82, 0x81, 0x81, 0x81,
  0x82, 0xFC, 0x0F, 0x18, 0x50, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x02, 0x00, 0xFC, 0xF8, 0x43, 0x20, 0x90, 0x28, 0x14,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x50, 0x28, 0x27, 0xE0, 0xFE, 0x08,
  0x20, 0x82, 0x0F, 0xE0, 0x82, 0x08, 0x20, 0x83, 0xF0, 0xFE, 0x08, 0x20,
  0x82, 0x08, 0x3F, 0x82, 0x08, 0x20, 0x82, 0x00, 0x0F, 0x8C, 0x14, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x0F, 0x80, 0x60, 0x14, 0x05, 0x01, 0x20,
  0x47, 0xF0, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0xE9, 0x24, 0x92, 0x49, 0x25, 0xC0, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x12, 0xE0, 0x82, 0x82, 0x84, 0x88, 0x90,
  0xA0, 0xE0, 0xA0, 0x90, 0x88, 0x88, 0x84, 0x82, 0x83, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0xF0, 0x80, 0x30, 0x07, 0x01,
  0xE0, 0x3C, 0x0B, 0x41, 0x68, 0x2C, 0x89, 0x91, 0x32, 0x26, 0x28, 0xC5,
  0x18, 0xC3, 0x08, 0x40, 0x81, 0x81, 0xC1, 0xC1, 0xA1, 0x91, 0x91, 0x89,
  0x89, 0x85, 0x83, 0x83, 0x81, 0x81, 0x1E, 0x04, 0x31, 0x01, 0x20, 0x28,
  0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x20, 0x22, 0x08,
  0x3E, 0x00, 0xF1, 0x1A, 0x0C, 0x18, 0x30, 0x61, 0x7E, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x00, 0x1E, 0x04, 0x31, 0x01, 0x20, 0x28, 0x05, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x20, 0x22, 0x08, 0x3E, 0x00, 0x80,
  0x08, 0x00, 0x80, 0xF0, 0x8C, 0x82, 0x82, 0x82, 0x82, 0x84, 0xF8, 0x88,
  0x88, 0x84, 0x84, 0x82, 0x83, 0x3C, 0x86, 0x04, 0x08, 0x08, 0x08, 0x0E,
  0x02, 0x04, 0x08, 0x10, 0x3F, 0x80, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x7E,
  0x80, 0x60, 0x24, 0x09, 0x02, 0x41, 0x08, 0x42, 0x10, 0x88, 0x22, 0x04,
  0x81, 0x40, 0x50, 0x0C, 0x02, 0x00, 0x81, 0x02, 0x82, 0x05, 0x04, 0x12,
  0x14, 0x24, 0x28, 0x44, 0x50, 0x88, 0x92, 0x12, 0x24, 0x24, 0x48, 0x28,
  0x90, 0x50, 0xC0, 0xC1, 0x81, 0x83, 0x01, 0x06, 0x00, 0x80, 0xA0, 0x90,
  0x84, 0x41, 0x40, 0xA0, 0x20, 0x10, 0x14, 0x12, 0x08, 0x88, 0x44, 0x14,
  0x0C, 0x80, 0xC0, 0x90, 0x48, 0x42, 0x21, 0x20, 0x50, 0x30, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0xFE, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0xFF, 0xF2, 0x49, 0x24, 0x92, 0x49,
  0x24, 0xE0, 0x81, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x20, 0x82, 0x04,
  0x10, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49, 0xE0, 0x10, 0x18, 0x28, 0x24,
  0x44, 0x42, 0x82, 0x81, 0xFF, 0x91, 0x80, 0x7C, 0x10, 0x41, 0x3D, 0x18,
  0x61, 0x85, 0xF0, 0x81, 0x02, 0x04, 0x0F, 0xD0, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x5F, 0x00, 0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x40, 0xF0,
  0x01, 0x01, 0x01, 0x01, 0x3D, 0x43, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x43, 0x3D, 0x3C, 0x86, 0x0C, 0x1F, 0xF0, 0x20, 0x40, 0x40, 0x7C, 0x1C,
  0x82, 0x08, 0x23, 0xE2, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x00, 0x3D,
  0x43, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01, 0x01, 0x02,
  0xC6, 0x38, 0x82, 0x08, 0x20, 0xFE, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x10, 0xE0, 0xAA, 0xAA, 0xA0, 0x32, 0x00, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x22, 0x22, 0xC0, 0x82, 0x08, 0x20, 0x8E, 0x29, 0x28, 0xE2, 0x89, 0x22,
  0x8A, 0x10, 0xFF, 0xFC, 0xFB, 0xF0, 0x86, 0x10, 0xC2, 0x18, 0x43, 0x08,
  0x61, 0x0C, 0x21, 0x84, 0x30, 0x84, 0xFE, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x86, 0x10, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C,
  0xFD, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x85, 0xF2, 0x04, 0x08, 0x10,
  0x00, 0x3D, 0x43, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0x43, 0x7D, 0x01,
  0x01, 0x01, 0x01, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x7E, 0x08, 0x20, 0x60,
  0x60, 0x41, 0x07, 0xE0, 0x22, 0x11, 0xF4, 0x21, 0x08, 0x42, 0x10, 0x43,
  0x80, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x42, 0xFC, 0x83, 0x05,
  0x0A, 0x24, 0x44, 0x8A, 0x14, 0x18, 0x20, 0x82, 0x14, 0x61, 0x46, 0x24,
  0x52, 0x49, 0x22, 0x92, 0x28, 0xC2, 0x8C, 0x30, 0xC1, 0x04, 0x43, 0x42,
  0x24, 0x18, 0x18, 0x18, 0x24, 0x24, 0x42, 0xC3, 0x81, 0x42, 0x42, 0x42,
  0x24, 0x24, 0x24, 0x18, 0x18, 0x10, 0x10, 0x10, 0x20, 0x20, 0xC0, 0xFC,
  0x20, 0x84, 0x20, 0x84, 0x10, 0x83, 0xF0, 0x19, 0x08, 0x42, 0x10, 0x88,
  0xC2, 0x08, 0x42, 0x10, 0x84, 0x18, 0xFF, 0xFF, 0xE0, 0x82, 0x08, 0x42,
  0x10, 0x84, 0x19, 0x08, 0x42, 0x10, 0x84, 0xC0, 0x60, 0x9F,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 14, 4, 1, -14 },
  { 5, 4, 5, 6, 1, -14 },
  { 8, 10, 14, 11, 0, -14 },
  { 26, 7, 15, 10, 1, -14 },
  { 40, 12, 14, 14, 1, -14 },
  { 61, 10, 14, 11, 1, -14 },
  { 79, 1, 5, 3, 1, -14 },
  { 80, 3, 17, 5, 1, -14 },
  { 87, 3, 17, 5, 1, -14 },
  { 94, 7, 6, 9, 1, -14 },
  { 100, 8, 9, 10, 1, -11 },
  { 109, 2, 4, 4, 1, -2 },
  { 110, 4, 1, 6, 1, -6 },
  { 111, 2, 1, 4, 1, -1 },
  { 112, 6, 14, 6, 0, -14 },
  { 123, 8, 14, 10, 1, -14 },
  { 137, 4, 14, 10, 2, -14 },
  { 144, 7, 14, 10, 1, -14 },
  { 157, 7, 14, 10, 1, -14 },
  { 170, 9, 14, 10, 0, -14 },
  { 186, 8, 14, 10, 1, -14 },
  { 200, 8, 14, 10, 1, -14 },
  { 214, 8, 14, 10, 1, -14 },
  { 228, 8, 14, 10, 1, -14 },
  { 242, 8, 14, 10, 1, -14 },
  { 256, 2, 10, 4, 1, -10 },
  { 259, 2, 12, 4, 1, -10 },
  { 262, 8, 8, 10, 1, -11 },
  { 270, 8, 5, 10, 1, -9 },
  { 275, 8, 8, 10, 1, -11 },
  { 283, 5, 14, 7, 1, -14 },
  { 292, 13, 16, 15, 1, -14 },
  { 318, 10, 14, 10, 0, -14 },
  { 336, 8, 14, 11, 2, -14 },
  { 350, 9, 14, 10, 1, -14 },
  { 366, 9, 14, 12, 2, -14 },
  { 382, 6, 14, 9, 2, -14 },
  { 393, 6, 14, 8, 2, -14 },
  { 404, 10, 14, 12, 1, -14 },
  { 422, 8, 14, 12, 2, -14 },
  { 436, 3, 14, 5, 1, -14 },
  { 442, 4, 17, 4, -1, -14 },
  { 451, 8, 14, 10, 2, -14 },
  { 465, 6, 14, 9, 2, -14 },
  { 476, 11, 14, 15, 2, -14 },
  { 496, 8, 14, 12, 2, -14 },
  { 510, 11, 14, 13, 1, -14 },
  { 530, 7, 14, 10, 2, -14 },
  { 543, 11, 17, 13, 1, -14 },
  { 567, 8, 14, 10, 2, -14 },
  { 581, 7, 14, 9, 1, -14 },
  { 594, 9, 14, 9, 0, -14 },
  { 610, 8, 14, 12, 2, -14 },
  { 624, 10, 14, 10, 0, -14 },
  { 642, 15, 14, 15, 0, -14 },
  { 669, 9, 14, 9, 0, -14 },
  { 685, 9, 14, 9, 0, -14 },
  { 701, 8, 14, 9, 1, -14 },
  { 715, 3, 17, 6, 2, -14 },
  { 722, 6, 14, 6, 0, -14 },
  { 733, 3, 17, 6, 1, -14 },
  { 740, 8, 8, 10, 1, -14 },
  { 748, 8, 1, 8, 0, 2 },
  { 749, 3, 3, 5, 1, -15 },
  { 751, 6, 10, 9, 1, -10 },
  { 759, 7, 14, 10, 2, -14 },
  { 772, 6, 10, 8, 1, -10 },
  { 780, 8, 14, 10, 1, -14 },
  { 794, 7, 10, 9, 1, -10 },
  { 803, 6, 15, 5, 0, -15 },
  { 815, 8, 15, 10, 1, -10 },
  { 830, 6, 14, 10, 2, -14 },
  { 841, 2, 14, 4, 1, -14 },
  { 845, 4, 19, 4, -1, -14 },
  { 855, 6, 14, 8, 2, -14 },
  { 866, 1, 14, 4, 1, -14 },
  { 868, 11, 10, 15, 2, -10 },
  { 882, 6, 10, 10, 2, -10 },
  { 890, 8, 10, 10, 1, -10 },
  { 900, 7, 14, 10, 2, -10 },
  { 913, 8, 14, 10, 1, -10 },
  { 927, 4, 10, 7, 2, -10 },
  { 932, 6, 10, 8, 1, -10 },
  { 940, 5, 13, 5, 0, -13 },
  { 949, 7, 10, 10, 1, -10 },
  { 958, 7, 10, 8, 0, -10 },
  { 967, 12, 10, 12, 0, -10 },
  { 982, 8, 10, 8, 0, -10 },
  { 992, 8, 15, 8, 0, -10 },
  { 1007, 6, 10, 7, 1, -10 },
  { 1015, 5, 17, 7, 1, -14 },
  { 1026, 1, 19, 9, 4, -14 },
  { 1029, 5, 17, 7, 1, -14 },
  { 1040, 8, 2, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight19pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT19PT7B_H_
