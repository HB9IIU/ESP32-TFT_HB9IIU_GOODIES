#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT45PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x05, 0x82, 0xC1, 0x60, 0xB0, 0x40, 0x00, 0x60,
  0x30, 0x00, 0x80, 0x40, 0x01, 0x00, 0x80, 0x02, 0x03, 0x00, 0x0C, 0x06,
  0x00, 0x18, 0x0C, 0x00, 0x30, 0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0x40,
  0x01, 0x01, 0x80, 0xFF, 0xFF, 0xF8, 0x0C, 0x06, 0x00, 0x18, 0x08, 0x00,
  0x20, 0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06,
  0x03, 0x00, 0x0C, 0x06, 0x00, 0x10, 0x08, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x81, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x08, 0x04,
  0x00, 0x10, 0x08, 0x00, 0x20, 0x10, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0,
  0x03, 0x01, 0x80, 0x04, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x3F, 0xF8, 0x1C, 0xCF, 0x0C, 0x30, 0x46, 0x0C, 0x01, 0x83, 0x00,
  0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0x60, 0xC0, 0x18,
  0x30, 0x03, 0x0C, 0x00, 0x73, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x03, 0x78, 0x00, 0xC7, 0x00, 0x30, 0xE0, 0x0C, 0x18, 0x03, 0x03,
  0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x02, 0x00, 0xC1, 0x80,
  0x30, 0xEC, 0x0C, 0x73, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x60, 0x30, 0xC0, 0x0C, 0x02, 0x04, 0x00, 0x80, 0x60, 0x60, 0x18, 0x04,
  0x02, 0x01, 0x80, 0x40, 0x20, 0x30, 0x04, 0x02, 0x03, 0x00, 0xC0, 0x30,
  0x60, 0x0C, 0x03, 0x06, 0x00, 0xC0, 0x30, 0x40, 0x0C, 0x03, 0x0C, 0x00,
  0xC0, 0x30, 0x80, 0x04, 0x02, 0x18, 0x70, 0x40, 0x21, 0x1F, 0xC4, 0x06,
  0x31, 0x86, 0x60, 0x62, 0x30, 0x62, 0x04, 0x62, 0x02, 0x30, 0xC4, 0x60,
  0x31, 0xF8, 0xC6, 0x03, 0x06, 0x08, 0x60, 0x30, 0x01, 0x86, 0x01, 0x00,
  0x10, 0x60, 0x10, 0x03, 0x06, 0x01, 0x00, 0x30, 0x60, 0x10, 0x06, 0x06,
  0x01, 0x00, 0x60, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30,
  0x08, 0x02, 0x02, 0x01, 0x80, 0x30, 0x60, 0x10, 0x01, 0x8C, 0x03, 0x00,
  0x0F, 0x80, 0x00, 0x60, 0x00, 0x03, 0xF8, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x06, 0x00, 0x08, 0x02, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18,
  0x03, 0x00, 0x18, 0x03, 0x00, 0x08, 0x02, 0x00, 0x0C, 0x06, 0x00, 0x0C,
  0x0E, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x18, 0x30, 0x06, 0x30,
  0x18, 0x06, 0x60, 0x1C, 0x06, 0x60, 0x0C, 0x04, 0xC0, 0x06, 0x0C, 0xC0,
  0x03, 0x0C, 0xC0, 0x01, 0x98, 0xC0, 0x00, 0xD8, 0xC0, 0x00, 0x70, 0x40,
  0x00, 0x60, 0x60, 0x00, 0xF0, 0x60, 0x01, 0xD8, 0x30, 0x03, 0x8C, 0x1E,
  0x0E, 0x06, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0x06, 0x04, 0x0C,
  0x18, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60,
  0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x06, 0x03, 0xC0,
  0x60, 0x60, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x06,
  0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x02, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x30, 0x60,
  0x60, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x02, 0x04, 0x07, 0xE2, 0x1E, 0x3F, 0x78, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xD8, 0x00, 0x46, 0x00, 0x61, 0x80, 0x60, 0xC0, 0x60, 0x30, 0x10, 0x0C,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x33, 0x32, 0x66, 0x64, 0xCC, 0x80, 0xFF, 0xFF, 0xF0, 0x7D,
  0x80, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0x00, 0xE0, 0xE0,
  0x70, 0x1C, 0x18, 0x03, 0x0C, 0x00, 0x63, 0x00, 0x18, 0x80, 0x02, 0x60,
  0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00, 0xD0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0x40, 0x00, 0xD0, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60,
  0x00, 0xD8, 0x00, 0x32, 0x00, 0x08, 0xC0, 0x06, 0x30, 0x01, 0x86, 0x00,
  0xC0, 0xC0, 0x60, 0x3C, 0x70, 0x03, 0xF8, 0x00, 0x01, 0x81, 0xC1, 0xA3,
  0x93, 0x8B, 0x07, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x03, 0xFE,
  0x03, 0xC1, 0xC1, 0x80, 0x18, 0x40, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xC0, 0x07, 0xFE, 0x03, 0x80, 0xE3, 0x80, 0x1C, 0x40, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x03, 0xE0, 0x0F,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xE8, 0x00, 0x73, 0xC0, 0x78, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x40, 0x00, 0x1A,
  0x00, 0x01, 0x90, 0x00, 0x0C, 0x80, 0x00, 0xC4, 0x00, 0x0C, 0x20, 0x00,
  0x61, 0x00, 0x06, 0x08, 0x00, 0x20, 0x40, 0x03, 0x02, 0x00, 0x30, 0x10,
  0x01, 0x00, 0x80, 0x18, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0xC0,
  0x08, 0x0C, 0x00, 0x40, 0x60, 0x02, 0x06, 0x00, 0x10, 0x20, 0x00, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x3F, 0xFE, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x03, 0xFF, 0x81, 0xE0, 0xF0, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x64, 0x00, 0x73, 0xC0, 0xF0, 0xFF, 0xE0, 0x00, 0x18,
  0x00, 0x7F, 0xC0, 0x78, 0x10, 0x38, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x7C, 0x0C, 0xFF, 0xC2, 0x70, 0x38, 0xB0, 0x03,
  0x28, 0x00, 0x4C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x24, 0x00, 0x19, 0x80,
  0x06, 0x60, 0x01, 0x8C, 0x00, 0xC1, 0x80, 0x60, 0x70, 0x78, 0x07, 0xF8,
  0x00, 0x20, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x01, 0xFF, 0x01, 0xE0, 0xE0, 0x60, 0x0C,
  0x30, 0x01, 0x88, 0x00, 0x66, 0x00, 0x09, 0x80, 0x03, 0x60, 0x00, 0xD8,
  0x00, 0x23, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x03, 0x03, 0x03, 0x80, 0x71,
  0xC0, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xC7, 0x01, 0xC0, 0x60, 0xE0, 0x0C,
  0x30, 0x01, 0x98, 0x00, 0x34, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x05, 0x00, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x63, 0x80,
  0x38, 0x78, 0x38, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x01, 0xFE, 0x01, 0xC0,
  0xC0, 0xE0, 0x18, 0x30, 0x03, 0x18, 0x00, 0x46, 0x00, 0x19, 0x00, 0x06,
  0xC0, 0x00, 0xB0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x34, 0x00, 0x0D, 0x80, 0x07, 0x60, 0x01, 0xCC, 0x00, 0xB1, 0x80,
  0xEC, 0x3F, 0xE3, 0x01, 0xE0, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x81, 0xC0, 0x3F, 0xE0, 0x01, 0x80, 0x00, 0x7D,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFB, 0x37, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x33, 0x66, 0x66, 0x4C, 0xC8, 0x00,
  0x00, 0x20, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x10, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x01, 0xFF, 0x8E, 0x07, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x70, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x0C, 0x60,
  0x07, 0xF0, 0x18, 0x80, 0x3C, 0xF0, 0x13, 0x00, 0xC0, 0x60, 0x26, 0x03,
  0x00, 0xC0, 0x6C, 0x06, 0x01, 0x80, 0xD0, 0x18, 0x03, 0x01, 0xA0, 0x30,
  0x06, 0x03, 0xC0, 0x40, 0x0C, 0x07, 0x80, 0x80, 0x18, 0x0F, 0x01, 0x00,
  0x20, 0x1E, 0x02, 0x00, 0x40, 0x3C, 0x04, 0x00, 0x80, 0x78, 0x08, 0x03,
  0x00, 0x90, 0x18, 0x07, 0x03, 0x20, 0x30, 0x1E, 0x06, 0x60, 0x30, 0x24,
  0x18, 0xC0, 0x3B, 0xCE, 0xE1, 0x80, 0x3E, 0x0F, 0x81, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x04, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xB0, 0x00, 0x01, 0x60, 0x00, 0x06, 0x40, 0x00, 0x0C,
  0xC0, 0x00, 0x11, 0x80, 0x00, 0x61, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x10, 0x18, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x30, 0x01, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xC0, 0x02, 0x01, 0x00, 0x06, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x08, 0x10, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x21, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xB0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x18, 0x1F, 0xC3, 0x00, 0x1C, 0x60,
  0x00, 0xCC, 0x00, 0x19, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0,
  0x00, 0xD8, 0x00, 0x1B, 0x00, 0x02, 0x60, 0x00, 0xCC, 0x00, 0x31, 0x80,
  0x0E, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xC0, 0x07, 0x18, 0x00, 0x33, 0x00,
  0x03, 0x60, 0x00, 0x6C, 0x00, 0x05, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00,
  0x19, 0x80, 0x0E, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x0F,
  0xFE, 0x03, 0xC0, 0x70, 0x70, 0x01, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x06, 0x07, 0xF0,
  0x30, 0x01, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x00,
  0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00,
  0x36, 0x00, 0x03, 0x30, 0x00, 0x39, 0x80, 0x01, 0x8C, 0x00, 0x38, 0x60,
  0x07, 0x83, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0x00, 0xF8,
  0x38, 0x00, 0x20, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x31,
  0x80, 0x00, 0x61, 0x80, 0x00, 0xC1, 0xC0, 0x01, 0x81, 0xF0, 0x1F, 0x00,
  0xFF, 0xF8, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30,
  0x1B, 0xF9, 0xF8, 0xC0, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x0C, 0x60, 0x03,
  0x0C, 0x00, 0xE1, 0x80, 0x38, 0x30, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x60,
  0x18, 0x18, 0x03, 0x07, 0x00, 0x61, 0xC0, 0x0C, 0x30, 0x01, 0x8C, 0x00,
  0x33, 0xC0, 0x06, 0xD8, 0x00, 0xF1, 0x80, 0x1C, 0x30, 0x03, 0x03, 0x00,
  0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x30, 0x06, 0x06, 0x00, 0xC0,
  0xC0, 0x0C, 0x18, 0x01, 0xC3, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x39,
  0x80, 0x03, 0x30, 0x00, 0x36, 0x00, 0x07, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFD, 0x00, 0x00, 0x17,
  0xB0, 0x00, 0x06, 0xF6, 0x00, 0x00, 0xDE, 0x60, 0x00, 0x13, 0xCC, 0x00,
  0x06, 0x78, 0x80, 0x00, 0xCF, 0x18, 0x00, 0x11, 0xE3, 0x00, 0x06, 0x3C,
  0x20, 0x00, 0xC7, 0x86, 0x00, 0x30, 0xF0, 0xC0, 0x06, 0x1E, 0x0C, 0x00,
  0x83, 0xC1, 0x80, 0x30, 0x78, 0x30, 0x06, 0x0F, 0x03, 0x00, 0x81, 0xE0,
  0x60, 0x30, 0x3C, 0x04, 0x06, 0x07, 0x80, 0xC0, 0x80, 0xF0, 0x18, 0x30,
  0x1E, 0x01, 0x06, 0x03, 0xC0, 0x31, 0x80, 0x78, 0x06, 0x30, 0x0F, 0x00,
  0x64, 0x01, 0xE0, 0x0D, 0x80, 0x3C, 0x01, 0xB0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0x30, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3D, 0x80, 0x01, 0xEC, 0x00, 0x0F, 0x30,
  0x00, 0x79, 0x80, 0x03, 0xC6, 0x00, 0x1E, 0x18, 0x00, 0xF0, 0xC0, 0x07,
  0x83, 0x00, 0x3C, 0x18, 0x01, 0xE0, 0x60, 0x0F, 0x01, 0x80, 0x78, 0x0C,
  0x03, 0xC0, 0x30, 0x1E, 0x01, 0x80, 0xF0, 0x06, 0x07, 0x80, 0x30, 0x3C,
  0x00, 0xC1, 0xE0, 0x03, 0x0F, 0x00, 0x18, 0x78, 0x00, 0x63, 0xC0, 0x03,
  0x1E, 0x00, 0x0C, 0xF0, 0x00, 0x37, 0x80, 0x01, 0xBC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x3C, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0xE0, 0x38, 0x01, 0xC0, 0x06, 0x01, 0x80, 0x01, 0x81, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x20,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x05, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x60, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x86, 0x00, 0x01, 0x81, 0x80,
  0x00, 0xC0, 0xE0, 0x00, 0xC0, 0x38, 0x01, 0xC0, 0x0F, 0x83, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x60, 0xFE, 0x30, 0x03, 0x98, 0x00, 0xEC,
  0x00, 0x36, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1B, 0x00, 0x0D, 0x80,
  0x1C, 0xC0, 0x3C, 0x7F, 0xF8, 0x3F, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xE0, 0x38, 0x01, 0xC0, 0x06, 0x01,
  0x80, 0x01, 0x81, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x60, 0x00, 0x06, 0x20, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x05, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x16, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x86,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0x38, 0x01, 0xC0,
  0x0F, 0x83, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xF0, 0x18, 0x7F,
  0x83, 0x00, 0x38, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x03, 0x30, 0x00,
  0x66, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00,
  0xCC, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01, 0x86, 0x00, 0xE0, 0xFF, 0xF8,
  0x1F, 0xFC, 0x03, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x30,
  0x30, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x00, 0xC3, 0x00, 0x0C,
  0x60, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x36, 0x00, 0x07,
  0x00, 0xF0, 0x01, 0xFF, 0xC1, 0xE0, 0x38, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xE8, 0x00, 0x73, 0xE0, 0x78,
  0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x16, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00,
  0xC3, 0x00, 0x06, 0x1C, 0x00, 0xE0, 0x3C, 0x1E, 0x00, 0xFF, 0xC0, 0xC0,
  0x00, 0x06, 0x80, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x46, 0x00,
  0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x30, 0x00, 0x40, 0x60, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x04,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x01, 0x80,
  0x04, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x18, 0x00, 0x10, 0x30, 0x00,
  0x30, 0x60, 0x00, 0x61, 0x80, 0x00, 0x43, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x88, 0x00, 0x01, 0x30, 0x00, 0x03, 0x60, 0x00, 0x06, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x30, 0x00, 0x34, 0x00, 0x1C, 0x00, 0x0D, 0x80, 0x07, 0x80, 0x06,
  0x60, 0x01, 0xE0, 0x01, 0x98, 0x00, 0x48, 0x00, 0x62, 0x00, 0x32, 0x00,
  0x18, 0xC0, 0x0C, 0xC0, 0x0C, 0x30, 0x03, 0x30, 0x03, 0x0C, 0x00, 0x84,
  0x00, 0xC1, 0x00, 0x61, 0x00, 0x30, 0x60, 0x18, 0x60, 0x18, 0x18, 0x06,
  0x18, 0x06, 0x06, 0x01, 0x02, 0x01, 0x80, 0x80, 0xC0, 0x80, 0x40, 0x30,
  0x30, 0x30, 0x30, 0x0C, 0x0C, 0x0C, 0x0C, 0x03, 0x02, 0x01, 0x03, 0x00,
  0x41, 0x80, 0x60, 0x80, 0x18, 0x60, 0x18, 0x60, 0x06, 0x18, 0x06, 0x18,
  0x01, 0x84, 0x00, 0x86, 0x00, 0x23, 0x00, 0x31, 0x00, 0x0C, 0xC0, 0x0C,
  0xC0, 0x03, 0x30, 0x03, 0x30, 0x00, 0xC8, 0x00, 0x4C, 0x00, 0x16, 0x00,
  0x12, 0x00, 0x05, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x31, 0x80, 0x03, 0x04, 0x00, 0x18, 0x30, 0x01, 0x80, 0xC0, 0x0C,
  0x06, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x03, 0x06, 0x00, 0x18,
  0x30, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x06, 0xC0, 0x00, 0x36,
  0x00, 0x03, 0x18, 0x00, 0x10, 0xC0, 0x01, 0x83, 0x00, 0x18, 0x08, 0x00,
  0xC0, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x06, 0x00, 0x30, 0x30, 0x01,
  0x83, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x00, 0xD8, 0x00, 0x07, 0xC0,
  0x00, 0x36, 0x00, 0x02, 0x60, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0xC1,
  0x80, 0x0C, 0x18, 0x01, 0x80, 0x80, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x06, 0x06, 0x00, 0x60, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x88,
  0x00, 0x19, 0x80, 0x00, 0xD0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFE, 0xC0, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0xFF,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x07, 0xFE, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x02, 0xC0, 0x00, 0xD8, 0x00, 0x11, 0x80, 0x06, 0x30, 0x00, 0x83, 0x00,
  0x30, 0x60, 0x04, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x0C, 0x0C, 0x01, 0x83,
  0x00, 0x18, 0x60, 0x03, 0x18, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x00, 0x78,
  0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x80, 0x0F, 0xF0, 0x3E, 0x3C, 0x20, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x3F,
  0x07, 0xFF, 0x1C, 0x03, 0x30, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0B, 0x60, 0x1B, 0x70, 0x73,
  0x1F, 0xE3, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x7F, 0x82, 0x38, 0x70, 0x98, 0x06, 0x2C, 0x00, 0xCA, 0x00, 0x33,
  0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x0B, 0x00, 0x02, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xB0, 0x00,
  0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB8, 0x00, 0xCA, 0x00, 0x32,
  0xC0, 0x18, 0x9C, 0x1C, 0x23, 0xFE, 0x00, 0x01, 0xFF, 0x07, 0x8E, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0F, 0x06, 0x03, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x3F, 0x84, 0x3C, 0x71, 0x1C, 0x02,
  0x4E, 0x00, 0x53, 0x00, 0x15, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x34,
  0x00, 0x0D, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xD0, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00,
  0xCC, 0x00, 0x73, 0x00, 0x14, 0x60, 0x09, 0x0E, 0x0E, 0x41, 0xFE, 0x10,
  0x03, 0xF8, 0x07, 0x8E, 0x07, 0x01, 0x83, 0x00, 0x63, 0x00, 0x11, 0x00,
  0x0D, 0x80, 0x06, 0xC0, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x04, 0x3C,
  0x1E, 0x07, 0xFC, 0x01, 0xFC, 0x0C, 0x10, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x07, 0xFE, 0x3F, 0xF8,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x03, 0xF8, 0x43, 0xC7, 0x91, 0xC0, 0x24, 0xE0, 0x05,
  0x30, 0x01, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0D, 0x00, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0C, 0xC0, 0x05,
  0x30, 0x01, 0x46, 0x00, 0xB0, 0xE0, 0xCC, 0x1F, 0xE3, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0E, 0x30, 0x07, 0x0F, 0xFF, 0x80, 0x3F, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x87, 0xF0, 0x8E, 0x3C, 0x98, 0x0E,
  0xA0, 0x06, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x5F, 0xA0, 0x00, 0x09, 0x24, 0x92,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x40, 0x02, 0x07, 0x07, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06,
  0x06, 0xFC, 0x78, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x34,
  0x00, 0xC8, 0x03, 0x10, 0x06, 0x20, 0x18, 0x40, 0x60, 0x81, 0x81, 0x06,
  0x02, 0x0C, 0x04, 0x30, 0x08, 0xE0, 0x13, 0xC0, 0x2C, 0xC0, 0x50, 0x80,
  0xC1, 0x81, 0x81, 0x82, 0x03, 0x04, 0x03, 0x08, 0x03, 0x10, 0x06, 0x20,
  0x06, 0x40, 0x0C, 0x80, 0x0D, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x87, 0xE0, 0x3F, 0x09, 0xC7, 0x8E, 0x3C, 0xB0, 0x19, 0x80, 0xCA, 0x00,
  0xD0, 0x06, 0xE0, 0x0E, 0x00, 0x6C, 0x00, 0x60, 0x02, 0xC0, 0x06, 0x00,
  0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80,
  0x06, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x38, 0x00, 0x60,
  0x03, 0x80, 0x06, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x38,
  0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x06,
  0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x38, 0x00, 0x60, 0x03,
  0x87, 0xF0, 0x8E, 0x3C, 0x98, 0x0E, 0xA0, 0x06, 0xA0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x03, 0xFC, 0x01, 0xE3, 0xC0, 0x70, 0x0C, 0x1C, 0x00, 0xC3, 0x00, 0x08,
  0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x02, 0x40, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1A,
  0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x19, 0x80, 0x03, 0x18, 0x00, 0x63,
  0x00, 0x18, 0x30, 0x06, 0x03, 0x83, 0x80, 0x1F, 0xE0, 0x87, 0xF8, 0x23,
  0x87, 0x09, 0x80, 0x62, 0xC0, 0x0C, 0xA0, 0x03, 0x30, 0x00, 0x6C, 0x00,
  0x1B, 0x00, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x28, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x01, 0xB0,
  0x00, 0x6C, 0x00, 0x1B, 0x80, 0x0C, 0xA0, 0x03, 0x24, 0x01, 0x89, 0xC1,
  0xC2, 0x1F, 0xE0, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x43, 0xC7, 0x11, 0xC0, 0x64, 0xC0,
  0x0D, 0x30, 0x01, 0x58, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0D, 0x00, 0x03, 0x40, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0C, 0x80,
  0x05, 0x30, 0x03, 0x46, 0x01, 0xB1, 0xE0, 0xCC, 0x1F, 0xE3, 0x00, 0x80,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x87,
  0xF1, 0xDE, 0x60, 0x58, 0x0A, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x0F, 0xF8, 0x78, 0x79,
  0x80, 0x13, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xD0,
  0x03, 0xBC, 0x0E, 0x3F, 0xF0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x3F, 0xFF, 0xFF, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC2, 0x0F, 0xC0, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xD0, 0x00, 0xEC, 0x00, 0x76, 0x00, 0x79, 0x80, 0x6C, 0xF0, 0xE6,
  0x1F, 0xE3, 0xC0, 0x00, 0xD0, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x20,
  0x01, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x40, 0x08, 0x18, 0x06, 0x06, 0x01,
  0x81, 0x80, 0x40, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x02, 0x00, 0x61, 0x80,
  0x18, 0x60, 0x06, 0x10, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0x80, 0x01,
  0x60, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x80, 0x06, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x05, 0x00, 0x26, 0x00, 0xB0,
  0x04, 0xC0, 0x36, 0x01, 0x98, 0x06, 0x40, 0x33, 0x00, 0x8C, 0x04, 0x30,
  0x31, 0x80, 0x86, 0x06, 0x30, 0x30, 0xC0, 0xC2, 0x06, 0x08, 0x10, 0x60,
  0x81, 0x86, 0x0C, 0x10, 0x30, 0xC0, 0x86, 0x06, 0x10, 0x18, 0xC0, 0x46,
  0x03, 0x10, 0x0C, 0xC0, 0x62, 0x01, 0x98, 0x04, 0xC0, 0x32, 0x00, 0xD8,
  0x02, 0xC0, 0x1A, 0x00, 0x78, 0x01, 0x40, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xC0, 0xE0, 0x01, 0xB0, 0x01, 0x8C, 0x01, 0x86,
  0x00, 0xC1, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x60, 0x0C, 0x60, 0x02, 0x30,
  0x01, 0xB0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1B, 0x00, 0x0D,
  0x80, 0x0C, 0x60, 0x06, 0x18, 0x06, 0x0C, 0x06, 0x03, 0x03, 0x00, 0x83,
  0x00, 0x63, 0x00, 0x19, 0x80, 0x0D, 0x80, 0x03, 0xC0, 0x00, 0xD8, 0x00,
  0x36, 0x00, 0x19, 0x80, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x30,
  0x60, 0x0C, 0x18, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x40, 0x30, 0x30, 0x0C,
  0x0C, 0x01, 0x82, 0x00, 0x61, 0x80, 0x18, 0x60, 0x02, 0x10, 0x00, 0xCC,
  0x00, 0x13, 0x00, 0x04, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x3C,
  0x07, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x78, 0x0E, 0x00, 0x78, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x07, 0x00, 0x3E, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x07, 0x80, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01,
  0xE0, 0x07, 0x01, 0xE0, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0C, 0x07, 0x80, 0xF0, 0x00, 0x3F, 0x00, 0x2F, 0xF8, 0x07,
  0x01, 0xE7, 0x40, 0x0F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 32, 10, 4, -32 },
  { 9, 9, 11, 15, 3, -32 },
  { 22, 23, 32, 26, 1, -32 },
  { 114, 18, 37, 23, 2, -34 },
  { 198, 28, 33, 33, 2, -33 },
  { 314, 24, 33, 27, 2, -33 },
  { 413, 2, 11, 8, 3, -32 },
  { 416, 8, 39, 12, 2, -32 },
  { 455, 8, 39, 12, 2, -32 },
  { 494, 17, 16, 22, 2, -34 },
  { 528, 19, 21, 23, 2, -26 },
  { 578, 4, 11, 9, 2, -5 },
  { 584, 10, 2, 14, 2, -13 },
  { 587, 3, 3, 10, 3, -3 },
  { 589, 13, 32, 15, 1, -32 },
  { 641, 18, 33, 23, 2, -33 },
  { 716, 9, 32, 23, 4, -32 },
  { 752, 18, 33, 23, 2, -33 },
  { 827, 18, 33, 23, 2, -33 },
  { 902, 21, 32, 23, 1, -32 },
  { 986, 17, 32, 23, 3, -32 },
  { 1054, 18, 34, 23, 3, -33 },
  { 1131, 18, 32, 23, 2, -32 },
  { 1203, 18, 33, 23, 2, -33 },
  { 1278, 18, 34, 23, 2, -33 },
  { 1355, 3, 24, 10, 3, -24 },
  { 1364, 4, 30, 10, 2, -24 },
  { 1379, 19, 20, 23, 2, -26 },
  { 1427, 19, 11, 23, 2, -21 },
  { 1454, 19, 20, 23, 2, -26 },
  { 1502, 14, 33, 16, 1, -33 },
  { 1560, 31, 36, 35, 2, -32 },
  { 1700, 23, 32, 23, 0, -32 },
  { 1792, 19, 32, 25, 4, -32 },
  { 1868, 20, 33, 25, 3, -33 },
  { 1951, 21, 32, 28, 4, -32 },
  { 2035, 16, 32, 22, 4, -32 },
  { 2099, 16, 32, 20, 4, -32 },
  { 2163, 23, 33, 29, 3, -33 },
  { 2258, 20, 32, 28, 4, -32 },
  { 2338, 8, 32, 12, 2, -32 },
  { 2370, 9, 40, 10, -3, -32 },
  { 2415, 19, 32, 23, 4, -32 },
  { 2491, 15, 32, 20, 4, -32 },
  { 2551, 27, 32, 35, 4, -32 },
  { 2659, 21, 32, 29, 4, -32 },
  { 2743, 25, 33, 30, 3, -33 },
  { 2847, 17, 32, 23, 4, -32 },
  { 2915, 25, 41, 30, 3, -33 },
  { 3044, 19, 32, 24, 4, -32 },
  { 3120, 18, 33, 22, 2, -33 },
  { 3195, 20, 32, 20, 0, -32 },
  { 3275, 21, 32, 29, 4, -32 },
  { 3359, 23, 32, 23, 0, -32 },
  { 3451, 34, 32, 36, 1, -32 },
  { 3587, 21, 32, 21, 0, -32 },
  { 3671, 20, 32, 20, 0, -32 },
  { 3751, 19, 32, 22, 1, -32 },
  { 3827, 9, 39, 14, 4, -32 },
  { 3871, 13, 32, 15, 1, -32 },
  { 3923, 9, 39, 14, 1, -32 },
  { 3967, 19, 18, 23, 2, -32 },
  { 4010, 18, 2, 18, 0, 4 },
  { 4015, 7, 7, 11, 2, -34 },
  { 4022, 16, 24, 21, 2, -24 },
  { 4070, 18, 34, 24, 4, -34 },
  { 4147, 16, 24, 19, 2, -24 },
  { 4195, 18, 34, 24, 2, -34 },
  { 4272, 17, 24, 22, 2, -24 },
  { 4323, 14, 34, 12, 0, -34 },
  { 4383, 18, 35, 24, 2, -24 },
  { 4462, 16, 34, 23, 4, -34 },
  { 4530, 3, 33, 9, 3, -33 },
  { 4543, 8, 44, 9, -2, -33 },
  { 4587, 15, 34, 19, 4, -34 },
  { 4651, 1, 34, 9, 4, -34 },
  { 4656, 28, 24, 35, 4, -24 },
  { 4740, 16, 24, 23, 4, -24 },
  { 4788, 19, 24, 23, 2, -24 },
  { 4845, 18, 35, 24, 4, -24 },
  { 4924, 18, 35, 24, 2, -24 },
  { 5003, 11, 24, 15, 4, -24 },
  { 5036, 15, 24, 18, 2, -24 },
  { 5081, 11, 30, 13, 1, -30 },
  { 5123, 17, 24, 23, 3, -24 },
  { 5174, 18, 24, 18, 0, -24 },
  { 5228, 27, 24, 29, 1, -24 },
  { 5309, 17, 24, 19, 1, -24 },
  { 5360, 18, 35, 18, 0, -24 },
  { 5439, 14, 24, 18, 2, -24 },
  { 5481, 12, 39, 16, 2, -32 },
  { 5540, 2, 45, 22, 10, -34 },
  { 5552, 12, 39, 16, 2, -32 },
  { 5611, 19, 4, 23, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight45pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT45PT7B_H_
