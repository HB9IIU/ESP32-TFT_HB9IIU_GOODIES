#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT35PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xA8, 0x03, 0xC0, 0xC3, 0x87, 0x0A, 0x14,
  0x28, 0x50, 0xA1, 0x42, 0x01, 0x02, 0x00, 0x40, 0x80, 0x30, 0x60, 0x0C,
  0x10, 0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0x40, 0x08, 0x10, 0x7F, 0xFF,
  0xC1, 0x82, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x08, 0x01, 0x02, 0x00,
  0xC1, 0x80, 0x30, 0x40, 0xFF, 0xFF, 0x82, 0x04, 0x00, 0x81, 0x00, 0x20,
  0x40, 0x08, 0x30, 0x06, 0x08, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x20,
  0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x3F, 0xE6, 0x21, 0x21, 0x02, 0x08,
  0x10, 0x40, 0x82, 0x04, 0x10, 0x30, 0x80, 0x84, 0x03, 0x20, 0x0F, 0x00,
  0x1E, 0x00, 0x5C, 0x02, 0x30, 0x10, 0xC0, 0x82, 0x04, 0x10, 0x20, 0x81,
  0x04, 0x08, 0x20, 0x42, 0xC2, 0x73, 0xFE, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x00, 0x3E, 0x00, 0x81, 0x88, 0x06, 0x04, 0x10, 0x10, 0x20, 0x40, 0xC0,
  0x81, 0x02, 0x02, 0x06, 0x18, 0x08, 0x18, 0x40, 0x20, 0x63, 0x00, 0x81,
  0x88, 0x02, 0x06, 0x60, 0x08, 0x11, 0x1E, 0x20, 0x4C, 0x84, 0x41, 0x26,
  0x19, 0x88, 0x90, 0x23, 0xE4, 0x40, 0x80, 0x11, 0x02, 0x00, 0x84, 0x08,
  0x02, 0x10, 0x30, 0x10, 0x40, 0x80, 0x41, 0x02, 0x03, 0x04, 0x08, 0x08,
  0x10, 0x20, 0x60, 0x61, 0x81, 0x00, 0x84, 0x0C, 0x01, 0xE0, 0x0F, 0xC0,
  0x06, 0x18, 0x03, 0x02, 0x00, 0xC0, 0xC0, 0x20, 0x30, 0x08, 0x0C, 0x03,
  0x03, 0x00, 0x40, 0x80, 0x18, 0x60, 0x02, 0x30, 0x00, 0x78, 0x00, 0x18,
  0x00, 0x1B, 0x00, 0x0C, 0x60, 0x06, 0x08, 0x0B, 0x01, 0x02, 0xC0, 0x21,
  0xA0, 0x0C, 0x48, 0x01, 0xB2, 0x00, 0x38, 0x80, 0x06, 0x30, 0x03, 0x84,
  0x01, 0x91, 0xC0, 0xC6, 0x1F, 0xC0, 0xC0, 0xFD, 0x55, 0x40, 0x0C, 0x61,
  0x0C, 0x21, 0x84, 0x10, 0xC3, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x83, 0x0C, 0x10, 0x60, 0x82, 0x04, 0x18, 0x20, 0x40, 0xC0, 0xC0,
  0x80, 0x81, 0x03, 0x02, 0x06, 0x0C, 0x08, 0x10, 0x20, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x04, 0x08, 0x30, 0x41, 0x82, 0x08,
  0x30, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x71, 0x1C,
  0xFF, 0x00, 0xC0, 0x05, 0x00, 0x4C, 0x06, 0x20, 0x60, 0x82, 0x06, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x3F, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x33, 0x22, 0x64, 0x44, 0x80, 0xFF, 0xF0, 0x00,
  0x40, 0x30, 0x08, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x02, 0x01, 0x80,
  0x40, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80,
  0x60, 0x10, 0x04, 0x03, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0x61, 0x82, 0x03,
  0x18, 0x04, 0x40, 0x19, 0x00, 0x2C, 0x00, 0xB0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x90, 0x02, 0x40, 0x19, 0x80, 0x43, 0x03, 0x06,
  0x18, 0x0F, 0xC0, 0x02, 0x1C, 0x69, 0x9E, 0x28, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x1F, 0xC3, 0x81, 0x84, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0xFF, 0xFC, 0x3F, 0xC3, 0x81,
  0x88, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x06, 0x07, 0xE0, 0x1F, 0xC0, 0x01, 0xC0, 0x01, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x30, 0x18, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x50, 0x00, 0x90, 0x01, 0x90, 0x01, 0x10, 0x03, 0x10, 0x06, 0x10, 0x04,
  0x10, 0x0C, 0x10, 0x08, 0x10, 0x10, 0x10, 0x30, 0x10, 0x20, 0x10, 0x40,
  0x10, 0xC0, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x3F, 0xF0, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x05, 0xFC, 0x1C, 0x38, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x30,
  0x18, 0x7F, 0xC0, 0x03, 0xF8, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0xFE, 0x24, 0x0C,
  0xA0, 0x1B, 0x00, 0x2C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x50, 0x03, 0x40, 0x0D, 0x80, 0x22, 0x01, 0x86, 0x0C, 0x0F, 0xE0, 0xFF,
  0xFC, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x1F, 0xC0, 0xC0, 0xC6, 0x01,
  0x90, 0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x06, 0x60, 0x10, 0xC0,
  0xC1, 0xCC, 0x01, 0xE0, 0x0D, 0xC0, 0xE1, 0x86, 0x03, 0x10, 0x06, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x0F, 0x00, 0x24, 0x01, 0x8C,
  0x0C, 0x1F, 0xE0, 0x1F, 0xC0, 0xC1, 0x86, 0x03, 0x30, 0x04, 0xC0, 0x1A,
  0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x07,
  0x40, 0x1D, 0x81, 0xB1, 0xFC, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x70, 0x7F, 0x00, 0xBC,
  0x00, 0x00, 0x00, 0x3C, 0x23, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x32, 0x26, 0x44, 0x48, 0x00, 0x04, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x08,
  0x00, 0x00, 0x7F, 0x18, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00, 0x40,
  0x18, 0x02, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xC1, 0xC0, 0x06, 0x00, 0x30, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x08, 0x30, 0x00, 0x04, 0x20, 0x00, 0x04, 0x60, 0x3F,
  0x02, 0x40, 0x61, 0x82, 0x40, 0x81, 0x82, 0xC1, 0x81, 0x02, 0x81, 0x01,
  0x03, 0x83, 0x01, 0x03, 0x83, 0x01, 0x03, 0x83, 0x01, 0x03, 0x83, 0x01,
  0x02, 0x83, 0x01, 0x02, 0x81, 0x03, 0x02, 0x81, 0x03, 0x86, 0xC1, 0x84,
  0x8C, 0x40, 0xF8, 0x78, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x01, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x06, 0x80, 0x01, 0x20,
  0x00, 0x4C, 0x00, 0x31, 0x00, 0x08, 0x40, 0x02, 0x18, 0x01, 0x82, 0x00,
  0x40, 0x80, 0x10, 0x30, 0x0C, 0x04, 0x02, 0x01, 0x00, 0xFF, 0xE0, 0x7F,
  0xF8, 0x10, 0x02, 0x04, 0x00, 0xC3, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01,
  0x98, 0x00, 0x24, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0x40, 0xFF, 0xC1,
  0x80, 0xE3, 0x00, 0x66, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0xB0, 0x01, 0x60,
  0x06, 0xC0, 0x0D, 0x80, 0x13, 0x00, 0xC7, 0xFF, 0x0F, 0xFF, 0x18, 0x03,
  0x30, 0x03, 0x60, 0x02, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x58, 0x01, 0xB0, 0x06, 0x60, 0x38, 0xFF, 0xC0, 0x03, 0xFE, 0x06,
  0x03, 0x0C, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x01, 0x03, 0xFE, 0xFF,
  0xC0, 0x60, 0x78, 0x30, 0x06, 0x18, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x13,
  0x00, 0x0D, 0x80, 0x02, 0xC0, 0x01, 0x60, 0x00, 0xB0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x05, 0x80, 0x02, 0xC0, 0x01, 0x60,
  0x00, 0xB0, 0x00, 0xD8, 0x00, 0x4C, 0x00, 0x66, 0x00, 0x63, 0x00, 0x61,
  0x81, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0x81,
  0xC0, 0x70, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x0F, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x50,
  0x00, 0x14, 0x00, 0x05, 0x80, 0x01, 0x20, 0x00, 0x4C, 0x00, 0x11, 0xC0,
  0x04, 0x1C, 0x03, 0x03, 0xFF, 0x80, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xFC, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0xFC, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0xFC, 0xC0, 0x0D,
  0x80, 0x33, 0x00, 0x46, 0x01, 0x8C, 0x06, 0x18, 0x18, 0x30, 0x60, 0x61,
  0x80, 0xC2, 0x01, 0x8C, 0x03, 0x30, 0x06, 0xE0, 0x0F, 0x60, 0x1C, 0x40,
  0x30, 0xC0, 0x60, 0xC0, 0xC0, 0x81, 0x81, 0x83, 0x01, 0x86, 0x01, 0x0C,
  0x03, 0x18, 0x02, 0x30, 0x06, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xF0, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xE8, 0x00, 0x0F, 0xE0, 0x00, 0x5D, 0x00, 0x02,
  0xE8, 0x00, 0x27, 0x60, 0x01, 0x39, 0x00, 0x19, 0xC8, 0x00, 0x8E, 0x60,
  0x04, 0x71, 0x00, 0x63, 0x88, 0x02, 0x1C, 0x60, 0x10, 0xE1, 0x01, 0x87,
  0x0C, 0x08, 0x38, 0x20, 0xC1, 0xC1, 0x04, 0x0E, 0x0C, 0x20, 0x70, 0x23,
  0x03, 0x81, 0x10, 0x1C, 0x0C, 0x80, 0xE0, 0x2C, 0x07, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0xC0, 0x30, 0x08, 0xC0, 0x01, 0xE0, 0x01, 0xA0, 0x01, 0xF0,
  0x01, 0xD0, 0x01, 0xD8, 0x01, 0xC8, 0x01, 0xCC, 0x01, 0xC6, 0x01, 0xC2,
  0x01, 0xC3, 0x01, 0xC1, 0x01, 0xC1, 0x81, 0xC0, 0xC1, 0xC0, 0x41, 0xC0,
  0x61, 0xC0, 0x21, 0xC0, 0x31, 0xC0, 0x11, 0xC0, 0x09, 0xC0, 0x0D, 0xC0,
  0x05, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0x03, 0xFC, 0x01, 0xC0, 0xE0,
  0x60, 0x06, 0x18, 0x00, 0x42, 0x00, 0x0C, 0xC0, 0x00, 0x90, 0x00, 0x1A,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x28,
  0x00, 0x0D, 0x00, 0x01, 0xB0, 0x00, 0x22, 0x00, 0x0C, 0x60, 0x01, 0x06,
  0x00, 0x40, 0x70, 0x30, 0x03, 0xFC, 0x00, 0xFF, 0x86, 0x07, 0x30, 0x0D,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x80, 0x2C, 0x06, 0x7F, 0xE3, 0xF0, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x03, 0xFC, 0x01, 0xC0, 0xE0, 0x60, 0x06, 0x18, 0x00, 0x42, 0x00, 0x0C,
  0xC0, 0x00, 0x90, 0x00, 0x1A, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x28, 0x00, 0x0D, 0x00, 0x01, 0xB0, 0x00, 0x22,
  0x00, 0x0C, 0x60, 0x01, 0x06, 0x00, 0x40, 0x70, 0x30, 0x03, 0xFC, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0xFF, 0x81, 0x81, 0xC3, 0x00, 0xC6, 0x00, 0xCC, 0x00, 0x98,
  0x01, 0x30, 0x02, 0x60, 0x04, 0xC0, 0x09, 0x80, 0x13, 0x00, 0x66, 0x01,
  0x8C, 0x1E, 0x1F, 0xF0, 0x30, 0x60, 0x60, 0x40, 0xC0, 0xC1, 0x80, 0x83,
  0x01, 0x86, 0x01, 0x8C, 0x01, 0x18, 0x03, 0x30, 0x02, 0x60, 0x06, 0xC0,
  0x06, 0x1F, 0xF1, 0x80, 0xD8, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0xD8, 0x0C, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0x40, 0x03, 0x60, 0x02, 0x20, 0x06, 0x38, 0x1C, 0x0F, 0xF0, 0xC0, 0x00,
  0xF0, 0x00, 0x24, 0x00, 0x19, 0x80, 0x04, 0x60, 0x01, 0x08, 0x00, 0xC2,
  0x00, 0x20, 0xC0, 0x08, 0x10, 0x06, 0x04, 0x01, 0x01, 0x80, 0x40, 0x20,
  0x30, 0x08, 0x0C, 0x03, 0x02, 0x00, 0x41, 0x80, 0x10, 0x60, 0x06, 0x10,
  0x00, 0x84, 0x00, 0x23, 0x00, 0x0C, 0x80, 0x01, 0x20, 0x00, 0x58, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x1C, 0x00, 0xC0, 0x0D, 0x00, 0x78, 0x03, 0x40, 0x16, 0x00, 0x90,
  0x04, 0x80, 0x26, 0x01, 0x20, 0x18, 0x80, 0xCC, 0x04, 0x20, 0x23, 0x01,
  0x08, 0x08, 0x40, 0x43, 0x02, 0x10, 0x30, 0x41, 0x86, 0x08, 0x10, 0x61,
  0x82, 0x04, 0x10, 0x20, 0x81, 0x84, 0x08, 0x60, 0x23, 0x03, 0x10, 0x08,
  0xC0, 0xC4, 0x02, 0x20, 0x11, 0x00, 0xC8, 0x04, 0xC0, 0x16, 0x01, 0xA0,
  0x05, 0x80, 0x68, 0x01, 0x40, 0x0A, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00,
  0xC0, 0x03, 0x00, 0x30, 0x00, 0x60, 0x03, 0x20, 0x06, 0x30, 0x04, 0x10,
  0x0C, 0x18, 0x08, 0x08, 0x18, 0x0C, 0x10, 0x04, 0x20, 0x06, 0x60, 0x02,
  0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x02, 0x40, 0x06,
  0x60, 0x04, 0x20, 0x0C, 0x30, 0x08, 0x10, 0x18, 0x08, 0x10, 0x0C, 0x30,
  0x04, 0x60, 0x06, 0x40, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x02, 0x60,
  0x06, 0x20, 0x04, 0x30, 0x0C, 0x10, 0x08, 0x10, 0x18, 0x18, 0x10, 0x08,
  0x30, 0x0C, 0x20, 0x04, 0x60, 0x06, 0x40, 0x02, 0xC0, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x7F, 0xFE, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0xFF, 0xFE, 0xFF, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x1F, 0xFF, 0x80,
  0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0x40, 0xFE, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x3F, 0xFF, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x40, 0x02, 0x40, 0x06, 0x20, 0x04, 0x20,
  0x0C, 0x10, 0x08, 0x10, 0x18, 0x18, 0x10, 0x08, 0x30, 0x0C, 0x20, 0x04,
  0x40, 0x06, 0xC0, 0x03, 0xFF, 0xFC, 0xC1, 0x83, 0x04, 0x08, 0x10, 0x0F,
  0x87, 0x9C, 0x40, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x01,
  0xF1, 0xFB, 0x60, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80,
  0x7C, 0x09, 0x7F, 0x10, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x87, 0x82, 0x73, 0x8A, 0x03, 0x38,
  0x06, 0xC0, 0x0B, 0x00, 0x28, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x2C, 0x00, 0xB0, 0x06, 0xA0, 0x32,
  0xC1, 0x88, 0xFC, 0x00, 0x07, 0xE1, 0xE7, 0x30, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x81, 0x0F, 0xF0, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x07,
  0x8C, 0x73, 0xB3, 0x03, 0xD8, 0x07, 0x40, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0xD0, 0x05, 0x60, 0x14, 0xC0, 0x91, 0xFC, 0x40, 0x07, 0x80, 0xE7,
  0x0C, 0x0C, 0xC0, 0x24, 0x01, 0xE0, 0x0F, 0x00, 0x30, 0x01, 0x80, 0x0F,
  0xFF, 0xE0, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0xC0, 0x83, 0xFC, 0x03, 0xC0, 0xEC, 0x30, 0x04, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x1F, 0x9F, 0xF0, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x00, 0x07, 0x84, 0x73, 0x93, 0x03, 0xD8,
  0x07, 0x40, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xD0, 0x07, 0x60, 0x1C,
  0xC0, 0xB1, 0xFC, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x19, 0x00, 0xC7, 0xFE, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x87, 0x84, 0xC7, 0x28, 0x0D,
  0x80, 0x2C, 0x01, 0x60, 0x0A, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0xF0, 0x0A, 0xAA, 0xAA, 0xAA, 0xAA, 0x80, 0x0C, 0x30, 0x00,
  0x00, 0x00, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x86, 0xF0, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x28,
  0x04, 0x80, 0xC8, 0x18, 0x83, 0x08, 0x20, 0x84, 0x08, 0x80, 0x98, 0x0B,
  0xC0, 0xA6, 0x0C, 0x20, 0x83, 0x08, 0x10, 0x81, 0x88, 0x0C, 0x80, 0x48,
  0x06, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xE0, 0x8F, 0x03, 0xE2, 0x67, 0x1D,
  0xCA, 0x06, 0x81, 0xB0, 0x0C, 0x02, 0xC0, 0x30, 0x0A, 0x00, 0xC0, 0x38,
  0x02, 0x00, 0xE0, 0x08, 0x03, 0x80, 0x20, 0x0E, 0x00, 0x80, 0x38, 0x02,
  0x00, 0xE0, 0x08, 0x03, 0x80, 0x20, 0x0E, 0x00, 0x80, 0x38, 0x02, 0x00,
  0xE0, 0x08, 0x03, 0x80, 0x20, 0x0E, 0x00, 0x80, 0x38, 0x02, 0x00, 0xC0,
  0x87, 0x84, 0xE7, 0x28, 0x0D, 0x80, 0x2C, 0x01, 0x60, 0x0A, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x07, 0xC0, 0x73, 0x83, 0x01,
  0x18, 0x06, 0x40, 0x0B, 0x00, 0x3C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x34, 0x00, 0xD0, 0x02, 0x20,
  0x18, 0xC0, 0xC0, 0xFE, 0x00, 0x87, 0x82, 0x73, 0x8B, 0x03, 0x28, 0x06,
  0xC0, 0x0B, 0x00, 0x28, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x2C, 0x00, 0xB0, 0x06, 0xA0, 0x32, 0xC1,
  0x88, 0xFC, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x00, 0x07, 0x84, 0x73, 0x93, 0x03, 0xD8, 0x07,
  0x40, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xD0, 0x07, 0x60, 0x1C, 0xC1,
  0xB1, 0xFC, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x8F, 0x9F, 0xA0, 0xE0, 0xC0, 0xC0, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x0F, 0xC3, 0x8F, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x2C, 0x06, 0x7F, 0xC0, 0x20, 0x20, 0x20, 0x20, 0x7F, 0xFF, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x30, 0x30, 0x1F, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x38, 0x03, 0xC0, 0x76, 0x0D, 0x3F, 0x90, 0x80, 0x0F, 0x00,
  0x24, 0x00, 0x90, 0x06, 0x60, 0x10, 0x80, 0x42, 0x03, 0x0C, 0x08, 0x10,
  0x20, 0x41, 0x81, 0x84, 0x02, 0x10, 0x08, 0xC0, 0x32, 0x00, 0x48, 0x01,
  0x60, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x10, 0x05, 0x00, 0xC0,
  0x34, 0x03, 0x80, 0x98, 0x0A, 0x02, 0x20, 0x28, 0x08, 0x81, 0xB0, 0x62,
  0x04, 0xC1, 0x0C, 0x11, 0x04, 0x10, 0xC4, 0x10, 0x42, 0x18, 0xC1, 0x08,
  0x22, 0x06, 0x20, 0x88, 0x09, 0x82, 0x20, 0x24, 0x0D, 0x80, 0x90, 0x14,
  0x03, 0xC0, 0x50, 0x06, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x00,
  0xC0, 0x1A, 0x00, 0x98, 0x0C, 0x40, 0x41, 0x04, 0x0C, 0x60, 0x22, 0x01,
  0xB0, 0x07, 0x00, 0x10, 0x01, 0xC0, 0x1B, 0x00, 0x88, 0x0C, 0x60, 0x41,
  0x04, 0x04, 0x60, 0x32, 0x00, 0xB0, 0x06, 0xC0, 0x05, 0x00, 0x34, 0x00,
  0x98, 0x02, 0x20, 0x18, 0x80, 0x43, 0x01, 0x04, 0x0C, 0x10, 0x20, 0x60,
  0x80, 0x86, 0x02, 0x10, 0x0C, 0x40, 0x13, 0x00, 0x48, 0x01, 0xA0, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x0F, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x01, 0x80,
  0x20, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0xFF, 0x80, 0x01, 0xC1,
  0xC0, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x06, 0x07, 0x03, 0x80, 0x18, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x30, 0x04, 0x00, 0xF0,
  0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xC0, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80,
  0x38, 0x07, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x3E, 0x08, 0x00, 0x7C, 0x07, 0x1C,
  0x18, 0x1F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 25, 8, 3, -25 },
  { 8, 7, 9, 11, 2, -25 },
  { 16, 18, 25, 20, 1, -25 },
  { 73, 13, 29, 18, 2, -27 },
  { 121, 22, 25, 25, 2, -25 },
  { 190, 18, 25, 21, 2, -25 },
  { 247, 2, 9, 6, 2, -25 },
  { 250, 6, 31, 9, 2, -25 },
  { 274, 7, 31, 9, 1, -25 },
  { 302, 13, 13, 17, 2, -27 },
  { 324, 14, 16, 18, 2, -20 },
  { 352, 4, 9, 7, 1, -4 },
  { 357, 8, 1, 11, 1, -10 },
  { 358, 2, 2, 8, 3, -2 },
  { 359, 10, 25, 12, 1, -25 },
  { 391, 14, 25, 18, 2, -25 },
  { 435, 7, 25, 18, 3, -25 },
  { 457, 14, 25, 18, 2, -25 },
  { 501, 14, 25, 18, 2, -25 },
  { 545, 16, 25, 18, 1, -25 },
  { 595, 14, 25, 18, 2, -25 },
  { 639, 14, 25, 18, 2, -25 },
  { 683, 14, 25, 18, 2, -25 },
  { 727, 14, 25, 18, 2, -25 },
  { 771, 14, 25, 18, 2, -25 },
  { 815, 2, 19, 8, 3, -19 },
  { 820, 4, 24, 7, 1, -19 },
  { 832, 14, 15, 18, 2, -20 },
  { 859, 14, 9, 18, 2, -17 },
  { 875, 14, 15, 18, 2, -20 },
  { 902, 11, 25, 13, 1, -25 },
  { 937, 24, 28, 27, 2, -25 },
  { 1021, 18, 25, 18, 0, -25 },
  { 1078, 15, 25, 19, 3, -25 },
  { 1125, 16, 25, 19, 2, -25 },
  { 1175, 17, 25, 22, 3, -25 },
  { 1229, 12, 25, 17, 3, -25 },
  { 1267, 12, 25, 16, 3, -25 },
  { 1305, 18, 25, 23, 2, -25 },
  { 1362, 16, 25, 22, 3, -25 },
  { 1412, 6, 25, 10, 2, -25 },
  { 1431, 8, 31, 8, -3, -25 },
  { 1462, 15, 25, 18, 3, -25 },
  { 1509, 12, 25, 16, 3, -25 },
  { 1547, 21, 25, 27, 3, -25 },
  { 1613, 16, 25, 22, 3, -25 },
  { 1663, 19, 25, 23, 2, -25 },
  { 1723, 13, 25, 18, 3, -25 },
  { 1764, 19, 31, 23, 2, -25 },
  { 1838, 15, 25, 18, 3, -25 },
  { 1885, 13, 25, 17, 2, -25 },
  { 1926, 16, 25, 16, 0, -25 },
  { 1976, 16, 25, 22, 3, -25 },
  { 2026, 18, 25, 18, 0, -25 },
  { 2083, 26, 25, 28, 1, -25 },
  { 2165, 16, 25, 16, 0, -25 },
  { 2215, 16, 25, 16, 0, -25 },
  { 2265, 15, 25, 17, 1, -25 },
  { 2312, 7, 31, 11, 3, -25 },
  { 2340, 10, 25, 12, 1, -25 },
  { 2372, 7, 31, 11, 1, -25 },
  { 2400, 16, 14, 18, 1, -25 },
  { 2428, 14, 1, 14, 0, 3 },
  { 2430, 6, 6, 9, 1, -27 },
  { 2435, 12, 19, 16, 2, -19 },
  { 2464, 14, 27, 19, 3, -27 },
  { 2512, 12, 19, 15, 2, -19 },
  { 2541, 14, 27, 19, 2, -27 },
  { 2589, 13, 19, 17, 2, -19 },
  { 2620, 11, 27, 9, 0, -27 },
  { 2658, 14, 27, 19, 2, -19 },
  { 2706, 13, 27, 18, 3, -27 },
  { 2750, 2, 25, 7, 3, -25 },
  { 2757, 6, 33, 7, -1, -25 },
  { 2782, 12, 27, 15, 3, -27 },
  { 2823, 1, 27, 7, 3, -27 },
  { 2827, 22, 19, 27, 3, -19 },
  { 2880, 13, 19, 18, 3, -19 },
  { 2911, 14, 19, 18, 2, -19 },
  { 2945, 14, 27, 19, 3, -19 },
  { 2993, 14, 27, 19, 2, -19 },
  { 3041, 8, 19, 12, 3, -19 },
  { 3060, 12, 19, 14, 1, -19 },
  { 3089, 8, 23, 10, 1, -23 },
  { 3112, 12, 19, 18, 3, -19 },
  { 3141, 14, 19, 14, 0, -19 },
  { 3175, 22, 19, 22, 0, -19 },
  { 3228, 13, 19, 15, 1, -19 },
  { 3259, 14, 27, 14, 0, -19 },
  { 3307, 11, 19, 14, 1, -19 },
  { 3334, 10, 31, 12, 1, -25 },
  { 3373, 1, 36, 17, 8, -27 },
  { 3378, 10, 31, 12, 1, -25 },
  { 3417, 14, 3, 18, 2, -14 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight35pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT35PT7B_H_
