#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT16PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0xD0, 0x12, 0x09, 0x04, 0x8F, 0xF1, 0x21, 0x10,
  0x91, 0xFE, 0x24, 0x12, 0x09, 0x00, 0x21, 0xFA, 0x28, 0xA1, 0x81, 0x89,
  0x24, 0x92, 0xFC, 0x20, 0x60, 0x24, 0x49, 0x22, 0x48, 0x94, 0x25, 0x69,
  0xA5, 0xA9, 0x12, 0x44, 0x92, 0x24, 0x8E, 0x30, 0x48, 0x44, 0x48, 0x48,
  0x30, 0x50, 0x89, 0x89, 0x86, 0x86, 0x79, 0xF0, 0x6A, 0x49, 0x24, 0x92,
  0x24, 0x40, 0x89, 0x22, 0x49, 0x29, 0x29, 0x00, 0x20, 0x8D, 0xC8, 0x51,
  0x20, 0x10, 0x41, 0x3F, 0x10, 0x41, 0x00, 0xF0, 0xE0, 0x80, 0x08, 0x44,
  0x22, 0x10, 0x88, 0x42, 0x20, 0x31, 0x28, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x5E, 0x3D, 0x11, 0x11, 0x11, 0x11, 0x10, 0x72, 0x20, 0x41, 0x04,
  0x20, 0x84, 0x21, 0x04, 0x3F, 0x72, 0x20, 0x41, 0x04, 0x27, 0x81, 0x04,
  0x10, 0x7E, 0x04, 0x0C, 0x14, 0x14, 0x24, 0x44, 0x44, 0xFF, 0x04, 0x04,
  0x04, 0xFE, 0x08, 0x20, 0xF8, 0x10, 0x41, 0x04, 0x1F, 0x80, 0x1D, 0x84,
  0x20, 0x83, 0xE8, 0x61, 0x86, 0x18, 0x5E, 0xFC, 0x10, 0x82, 0x08, 0x41,
  0x04, 0x20, 0x84, 0x00, 0x31, 0x38, 0x61, 0x85, 0xE4, 0xA1, 0x86, 0x18,
  0x5E, 0x33, 0x28, 0x61, 0x86, 0x18, 0xDD, 0x04, 0x10, 0xBC, 0xC0, 0x80,
  0xC1, 0xE0, 0x0C, 0xC4, 0x20, 0x60, 0x60, 0x40, 0xFC, 0x00, 0x3F, 0xC0,
  0xC0, 0x81, 0x19, 0x88, 0x00, 0x74, 0x42, 0x10, 0x88, 0x84, 0x20, 0x00,
  0x40, 0x3F, 0x88, 0x09, 0x01, 0x47, 0x99, 0x13, 0x22, 0x64, 0x4C, 0x91,
  0x9F, 0xD0, 0x01, 0x00, 0x10, 0x81, 0xE0, 0x08, 0x18, 0x14, 0x24, 0x24,
  0x22, 0x3E, 0x42, 0x41, 0x81, 0x81, 0xFD, 0x06, 0x0C, 0x18, 0x5F, 0xA0,
  0xC1, 0x83, 0x07, 0xF0, 0x1C, 0x45, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x01, 0x01, 0xF0, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82,
  0x82, 0xFC, 0xFE, 0x08, 0x20, 0xFE, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0xFE,
  0x08, 0x20, 0x83, 0xF8, 0x20, 0x82, 0x08, 0x00, 0x1E, 0x21, 0x40, 0x80,
  0x80, 0x80, 0x87, 0x81, 0x81, 0x81, 0x41, 0x3F, 0x81, 0x81, 0x81, 0x81,
  0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0xE9, 0x24, 0x92, 0x4B, 0x80,
  0x24, 0x92, 0x49, 0x24, 0x93, 0x80, 0x87, 0x12, 0x24, 0x8A, 0x1A, 0x24,
  0x44, 0x85, 0x0A, 0x08, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F,
  0xC0, 0xC0, 0x70, 0x3A, 0x0E, 0x85, 0xA1, 0x64, 0x59, 0x26, 0x49, 0x8A,
  0x63, 0x18, 0x44, 0xC1, 0xC1, 0xA1, 0x91, 0x91, 0x89, 0x89, 0x85, 0x85,
  0x83, 0x81, 0x1C, 0x31, 0x10, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x90, 0x47, 0xC0, 0xFE, 0x18, 0x61, 0x87, 0xE8, 0x20, 0x82, 0x08,
  0x00, 0x1C, 0x31, 0x10, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x90, 0x47, 0xC0, 0x40, 0x10, 0x0C, 0xFD, 0x06, 0x0C, 0x18, 0x5F, 0x22,
  0x44, 0x85, 0x0A, 0x08, 0x3B, 0x18, 0x20, 0x81, 0x03, 0x81, 0x04, 0x10,
  0x7E, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x81, 0x81,
  0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x18, 0x18, 0x08, 0x82, 0x1A, 0x30,
  0x91, 0x44, 0x8A, 0x24, 0x52, 0x14, 0x90, 0xA2, 0x85, 0x14, 0x28, 0xC0,
  0x82, 0x04, 0x10, 0xC2, 0x88, 0x91, 0x41, 0x02, 0x0A, 0x12, 0x44, 0x86,
  0x08, 0x82, 0x89, 0x11, 0x22, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFC,
  0x20, 0x84, 0x10, 0x82, 0x10, 0x42, 0x0F, 0xC0, 0xF8, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x8F, 0x82, 0x10, 0x42, 0x10, 0x42, 0x10, 0x42, 0xF1, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x1F, 0x30, 0x51, 0x22, 0x28, 0x50, 0xC0, 0xFC,
  0x90, 0x74, 0x42, 0x17, 0xC6, 0x31, 0xF8, 0x81, 0x02, 0x05, 0xCC, 0x50,
  0x60, 0xC1, 0x83, 0x06, 0x17, 0xC0, 0x3A, 0x21, 0x08, 0x42, 0x10, 0x78,
  0x04, 0x10, 0x4D, 0x4E, 0x18, 0x61, 0x86, 0x18, 0x5F, 0x31, 0x28, 0x61,
  0xFE, 0x08, 0x20, 0x7C, 0x3A, 0x11, 0xE4, 0x21, 0x08, 0x42, 0x10, 0x80,
  0x39, 0x18, 0x61, 0x86, 0x18, 0x61, 0x7C, 0x10, 0x41, 0xF8, 0x82, 0x08,
  0x2E, 0xC6, 0x18, 0x61, 0x86, 0x18, 0x61, 0xCF, 0xF0, 0x24, 0x02, 0x49,
  0x24, 0x92, 0x4E, 0x82, 0x08, 0x20, 0x8A, 0x4A, 0x38, 0x92, 0x48, 0xA1,
  0xFF, 0xF0, 0x31, 0xB2, 0x98, 0x46, 0x11, 0x84, 0x61, 0x18, 0x46, 0x11,
  0x84, 0x40, 0x3B, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x39, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x78, 0x39, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xE2, 0xB9,
  0x02, 0x04, 0x08, 0x00, 0x31, 0x38, 0x61, 0x86, 0x18, 0x61, 0x7C, 0x10,
  0x41, 0x04, 0x3C, 0x88, 0x88, 0x88, 0x80, 0x74, 0x61, 0x06, 0x08, 0x21,
  0xF0, 0x44, 0xF4, 0x44, 0x44, 0x44, 0x30, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x5F, 0x86, 0x14, 0x92, 0x48, 0xA3, 0x04, 0x84, 0x53, 0x14, 0xA5, 0x2A,
  0x52, 0x8C, 0xA3, 0x10, 0x84, 0xC4, 0x50, 0xA0, 0x83, 0x05, 0x11, 0x43,
  0x85, 0x14, 0x52, 0x28, 0xA3, 0x04, 0x10, 0x82, 0x30, 0xF8, 0x88, 0x44,
  0x22, 0x1F, 0x34, 0x44, 0x44, 0x84, 0x44, 0x44, 0x61, 0xFF, 0xFF, 0xC4,
  0x44, 0x42, 0x12, 0x44, 0x44, 0x48, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 11, 4, 1, -11 },
  { 3, 3, 4, 5, 1, -11 },
  { 5, 9, 11, 9, 0, -11 },
  { 18, 6, 13, 8, 1, -12 },
  { 28, 10, 12, 12, 1, -12 },
  { 43, 8, 12, 10, 1, -12 },
  { 55, 1, 4, 3, 1, -11 },
  { 56, 3, 14, 4, 1, -11 },
  { 62, 3, 14, 4, 1, -11 },
  { 68, 6, 6, 8, 1, -12 },
  { 73, 6, 7, 8, 1, -9 },
  { 79, 1, 4, 3, 1, -2 },
  { 80, 3, 1, 5, 1, -5 },
  { 81, 1, 1, 3, 1, -1 },
  { 82, 5, 11, 5, 0, -11 },
  { 89, 6, 12, 8, 1, -12 },
  { 98, 4, 11, 8, 1, -11 },
  { 104, 6, 12, 8, 1, -12 },
  { 113, 6, 12, 8, 1, -12 },
  { 122, 8, 11, 8, 0, -11 },
  { 133, 6, 11, 8, 1, -11 },
  { 142, 6, 12, 8, 1, -12 },
  { 151, 6, 11, 8, 1, -11 },
  { 160, 6, 12, 8, 1, -12 },
  { 169, 6, 12, 8, 1, -12 },
  { 178, 1, 9, 3, 1, -9 },
  { 180, 1, 11, 3, 1, -9 },
  { 182, 6, 7, 8, 1, -9 },
  { 188, 6, 4, 8, 1, -8 },
  { 191, 6, 7, 8, 1, -9 },
  { 197, 5, 12, 6, 0, -12 },
  { 205, 11, 13, 13, 1, -11 },
  { 223, 8, 11, 8, 0, -11 },
  { 234, 7, 11, 9, 1, -11 },
  { 244, 7, 12, 9, 1, -12 },
  { 255, 8, 11, 10, 1, -11 },
  { 266, 6, 11, 8, 1, -11 },
  { 275, 6, 11, 7, 1, -11 },
  { 284, 8, 12, 10, 1, -12 },
  { 296, 8, 11, 10, 1, -11 },
  { 307, 3, 11, 4, 1, -11 },
  { 312, 3, 14, 4, -1, -11 },
  { 318, 7, 11, 8, 1, -11 },
  { 328, 6, 11, 7, 1, -11 },
  { 337, 10, 11, 13, 1, -11 },
  { 351, 8, 11, 10, 1, -11 },
  { 362, 9, 12, 11, 1, -12 },
  { 376, 6, 11, 8, 1, -11 },
  { 385, 9, 15, 11, 1, -12 },
  { 402, 7, 11, 8, 1, -11 },
  { 412, 6, 12, 8, 1, -12 },
  { 421, 7, 11, 7, 0, -11 },
  { 431, 8, 11, 10, 1, -11 },
  { 442, 8, 11, 8, 0, -11 },
  { 453, 13, 11, 13, 0, -11 },
  { 471, 7, 11, 7, 0, -11 },
  { 481, 7, 11, 7, 0, -11 },
  { 491, 6, 11, 8, 1, -11 },
  { 500, 4, 14, 5, 1, -11 },
  { 507, 5, 11, 5, 0, -11 },
  { 514, 4, 14, 5, 0, -11 },
  { 521, 7, 6, 8, 1, -11 },
  { 527, 6, 1, 6, 0, 1 },
  { 528, 2, 2, 4, 1, -12 },
  { 529, 5, 9, 7, 1, -9 },
  { 535, 7, 12, 9, 1, -12 },
  { 546, 5, 9, 7, 1, -9 },
  { 552, 6, 12, 9, 1, -12 },
  { 561, 6, 9, 8, 1, -9 },
  { 568, 5, 12, 4, 0, -12 },
  { 576, 6, 13, 9, 1, -9 },
  { 586, 6, 12, 8, 1, -12 },
  { 595, 1, 12, 3, 1, -12 },
  { 597, 3, 16, 3, -1, -12 },
  { 603, 6, 12, 7, 1, -12 },
  { 612, 1, 12, 3, 1, -12 },
  { 614, 10, 9, 12, 1, -9 },
  { 626, 6, 9, 8, 1, -9 },
  { 633, 6, 9, 8, 1, -9 },
  { 640, 7, 13, 9, 1, -9 },
  { 652, 6, 13, 9, 1, -9 },
  { 662, 4, 9, 5, 1, -9 },
  { 667, 5, 9, 7, 1, -9 },
  { 673, 4, 11, 5, 0, -11 },
  { 679, 6, 8, 8, 1, -8 },
  { 685, 6, 8, 6, 0, -8 },
  { 691, 10, 8, 10, 0, -8 },
  { 701, 7, 8, 7, 0, -8 },
  { 708, 6, 12, 6, 0, -8 },
  { 717, 5, 8, 6, 1, -8 },
  { 722, 4, 14, 6, 1, -11 },
  { 729, 1, 16, 8, 3, -12 },
  { 731, 4, 14, 6, 1, -11 },
  { 738, 6, 1, 8, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight16pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT16PT7B_H_
