#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT55PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight55pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x06, 0xFF, 0xF0, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x30, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x01, 0x00, 0x60, 0x00, 0x18, 0x03,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x08, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x03, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x60, 0x08, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x07, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x00, 0x18, 0x02, 0x00,
  0x00, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x04, 0x01,
  0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xF8, 0xF1, 0x81, 0x8E, 0x0C, 0x00, 0x60, 0x60,
  0x07, 0x03, 0x00, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60,
  0x30, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x83, 0x00,
  0x0E, 0x18, 0x00, 0x3C, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x67, 0xC0, 0x03, 0x0F, 0x00, 0x18, 0x1C,
  0x00, 0xC0, 0x60, 0x06, 0x03, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x0E, 0x00, 0xC0, 0x60,
  0x06, 0x07, 0x60, 0x30, 0x73, 0xF1, 0x9F, 0x0F, 0xFF, 0xE0, 0x03, 0xF8,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x18, 0x03, 0x86, 0x00, 0x0C,
  0x00, 0xC0, 0xC0, 0x03, 0x00, 0x60, 0x30, 0x01, 0x80, 0x18, 0x06, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x30, 0x03, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x60, 0x03, 0x00,
  0x30, 0x30, 0x00, 0xC0, 0x0C, 0x0C, 0x00, 0x30, 0x03, 0x06, 0x00, 0x0C,
  0x00, 0xC1, 0x80, 0x03, 0x00, 0x30, 0xC0, 0x00, 0xC0, 0x18, 0x30, 0xFC,
  0x30, 0x06, 0x18, 0x7F, 0x8C, 0x01, 0x86, 0x38, 0x71, 0x80, 0x63, 0x0C,
  0x0C, 0x60, 0x30, 0xC6, 0x01, 0x8C, 0x0C, 0x61, 0x80, 0x63, 0x86, 0x18,
  0x60, 0x18, 0x7F, 0x0C, 0x30, 0x03, 0x07, 0x83, 0x0C, 0x00, 0xC0, 0x01,
  0x83, 0x00, 0x30, 0x00, 0x60, 0xC0, 0x0C, 0x00, 0x18, 0x30, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0xC0, 0x03, 0x03, 0x00, 0x30, 0x01, 0x80, 0xC0, 0x0C,
  0x00, 0x60, 0x30, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x18, 0x06, 0x00, 0xC0, 0x07,
  0x01, 0x80, 0x30, 0x00, 0xC0, 0xC0, 0x18, 0x00, 0x1C, 0x60, 0x06, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x0C,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xE0, 0x03, 0x00, 0x03, 0x00, 0x38, 0x00, 0x18,
  0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0x9E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x60, 0x30, 0x01, 0xC6, 0x01, 0xC0, 0x0C, 0x70, 0x07,
  0x00, 0x63, 0x00, 0x1C, 0x03, 0x30, 0x00, 0x70, 0x31, 0x80, 0x01, 0x81,
  0x8C, 0x00, 0x06, 0x0C, 0x60, 0x00, 0x38, 0xC3, 0x00, 0x00, 0xE6, 0x18,
  0x00, 0x03, 0xE0, 0xC0, 0x00, 0x0F, 0x06, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x07, 0xC0, 0xC0, 0x00, 0x73, 0x07, 0x00, 0x07, 0x1C, 0x1E, 0x00, 0xF0,
  0x70, 0x7E, 0x7F, 0x01, 0xC0, 0xFF, 0xE0, 0x07, 0x00, 0x20, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0xE0, 0x1C,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x30,
  0x0C, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18,
  0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x0E, 0x06, 0x03, 0xFC, 0x61, 0xF1, 0xF6, 0xF8, 0x03,
  0xFC, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x19, 0x80, 0x03, 0x0C, 0x00,
  0x30, 0xE0, 0x06, 0x06, 0x00, 0xC0, 0x30, 0x1C, 0x03, 0x80, 0x80, 0x10,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x18, 0xC6, 0x73, 0x98, 0xC6, 0x63, 0x18, 0x8C, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x6F, 0xFF, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x78,
  0x78, 0x03, 0x80, 0x70, 0x1C, 0x00, 0xE0, 0x60, 0x01, 0x83, 0x00, 0x03,
  0x0C, 0x00, 0x0C, 0x70, 0x00, 0x39, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98,
  0x00, 0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x06, 0x60, 0x00,
  0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x30, 0x00, 0x30,
  0xC0, 0x00, 0xC3, 0x80, 0x07, 0x06, 0x00, 0x18, 0x1C, 0x00, 0xE0, 0x38,
  0x07, 0x00, 0x7C, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x3C, 0x0F, 0x83, 0xB0, 0xE6, 0x70, 0xDC, 0x1F, 0x03, 0x40, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0x81, 0xE0,
  0xE0, 0x03, 0x86, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xF0, 0x3C, 0x1E, 0x00, 0x38,
  0x60, 0x00, 0x71, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x80, 0x00, 0x73, 0x80, 0x03, 0x8F, 0xF0, 0xFC,
  0x07, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x30, 0x00,
  0x07, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x18, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x80,
  0x30, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x30, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0,
  0x30, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x7F, 0xFF, 0x01,
  0xFE, 0x7F, 0x02, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x20, 0x00, 0x38, 0xE0, 0x03, 0xC3, 0xF8, 0xFE, 0x01, 0xFF, 0xE0,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0x01, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0xFF, 0x03, 0x8F, 0xFF, 0x0C, 0x70, 0x0E, 0x33, 0x00, 0x1C, 0xD8, 0x00,
  0x3B, 0xC0, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80,
  0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x70, 0x00, 0x1C, 0xC0, 0x00,
  0x63, 0x80, 0x01, 0x86, 0x00, 0x0C, 0x1C, 0x00, 0x70, 0x38, 0x03, 0x80,
  0x7C, 0x3C, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0xF0, 0x3C, 0x07, 0x00, 0x38, 0x38, 0x00, 0x70, 0xC0, 0x00,
  0xC7, 0x00, 0x03, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66,
  0x00, 0x01, 0x98, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xC0, 0x01, 0xC1, 0x80,
  0x06, 0x07, 0x00, 0x70, 0x0F, 0x03, 0x80, 0x0F, 0x3C, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x03, 0xDF, 0x00, 0x3C, 0x0E, 0x01, 0xC0, 0x1C, 0x0E,
  0x00, 0x18, 0x30, 0x00, 0x31, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xB0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x76, 0x00, 0x01, 0x9C, 0x00, 0x0E, 0x30,
  0x00, 0x70, 0x70, 0x03, 0x80, 0xF8, 0x7C, 0x01, 0xFF, 0xC0, 0x00, 0x20,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xE0, 0x78, 0x06, 0x00, 0x70,
  0x30, 0x00, 0xE1, 0xC0, 0x01, 0x86, 0x00, 0x07, 0x38, 0x00, 0x0C, 0xC0,
  0x00, 0x33, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x76, 0x00, 0x03, 0xD8, 0x00, 0x0F, 0x70, 0x00, 0x7C, 0xE0,
  0x07, 0x61, 0xE0, 0x39, 0x83, 0xFF, 0xC6, 0x03, 0xF8, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x03, 0x07, 0xC0,
  0x0F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xF6, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xF0, 0x3C, 0xF3, 0xC6,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x18, 0x63, 0x8E, 0x30, 0xC7, 0x18, 0x61, 0x8C, 0x30,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x1F, 0xFE, 0x3E, 0x07, 0x88, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0xFF, 0x00, 0x63, 0x00,
  0x1F, 0xFC, 0x03, 0x30, 0x03, 0xC0, 0x60, 0x0D, 0x80, 0x18, 0x03, 0x00,
  0x6C, 0x01, 0x80, 0x18, 0x03, 0xE0, 0x18, 0x00, 0xC0, 0x1E, 0x00, 0xC0,
  0x06, 0x00, 0xF0, 0x06, 0x00, 0x30, 0x07, 0x80, 0x60, 0x01, 0x80, 0x3C,
  0x03, 0x00, 0x0C, 0x01, 0xE0, 0x18, 0x00, 0x60, 0x0F, 0x00, 0xC0, 0x03,
  0x00, 0x78, 0x06, 0x00, 0x18, 0x03, 0xC0, 0x30, 0x01, 0xC0, 0x1E, 0x01,
  0x80, 0x0E, 0x00, 0xF0, 0x0C, 0x00, 0x70, 0x0D, 0x80, 0x70, 0x03, 0x80,
  0x6C, 0x01, 0x80, 0x3C, 0x03, 0x60, 0x0E, 0x03, 0x20, 0x31, 0x80, 0x38,
  0x39, 0x83, 0x0C, 0x00, 0xFF, 0x87, 0xF8, 0x60, 0x01, 0xF0, 0x1F, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x20,
  0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0xC0, 0x18, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x06, 0x00, 0x07, 0x00, 0x60, 0x00, 0x30, 0x0C, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18,
  0x18, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x83, 0x00, 0x07, 0x86, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x98, 0x00,
  0x03, 0x30, 0x00, 0x07, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x0D, 0x80, 0x00,
  0x1B, 0x00, 0x00, 0x76, 0x00, 0x00, 0xEC, 0x00, 0x01, 0x98, 0x00, 0x03,
  0x30, 0x00, 0x0C, 0x60, 0x00, 0x38, 0xC0, 0x01, 0xE1, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x06, 0x00, 0x7E, 0x0C, 0x00, 0x0F, 0x18, 0x00, 0x07, 0x30,
  0x00, 0x07, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x3B, 0x00, 0x00,
  0xE6, 0x00, 0x03, 0x8C, 0x00, 0x1E, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0x03, 0xE0, 0x3C,
  0x00, 0x10, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x0C,
  0x03, 0xF9, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x0C, 0x00, 0x3E, 0x03, 0x00, 0x01, 0xE0, 0xC0,
  0x00, 0x38, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x07,
  0x0C, 0x00, 0x03, 0x83, 0x00, 0x03, 0xC0, 0xC0, 0x07, 0xC0, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xFB,
  0xFF, 0xFF, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0xFC, 0x03, 0xC0,
  0x00, 0xE0, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x01, 0x80, 0xF8, 0x00, 0x3C, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0xFF, 0x8E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC7,
  0xFF, 0xFE, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0E, 0x03, 0xA0, 0xE7, 0xF8, 0x7C, 0x00, 0xC0, 0x00,
  0x1D, 0x80, 0x00, 0x73, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x18, 0x00, 0x38, 0x30, 0x00, 0xE0, 0x60, 0x03, 0x80, 0xC0, 0x0E, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x60, 0x06, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x18,
  0x1C, 0x00, 0x30, 0x70, 0x00, 0x61, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x8F,
  0x00, 0x03, 0x3F, 0x00, 0x06, 0xE6, 0x00, 0x0F, 0x8E, 0x00, 0x1E, 0x0E,
  0x00, 0x38, 0x0C, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x38, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x70,
  0x30, 0x00, 0x60, 0x60, 0x00, 0xE0, 0xC0, 0x00, 0xE1, 0x80, 0x00, 0xC3,
  0x00, 0x01, 0xC6, 0x00, 0x01, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x03, 0xB0,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFB, 0x00, 0x00, 0x01, 0xBD, 0x80, 0x00, 0x00, 0xDE, 0xC0, 0x00, 0x00,
  0x6F, 0x30, 0x00, 0x00, 0x67, 0x98, 0x00, 0x00, 0x33, 0xCE, 0x00, 0x00,
  0x19, 0xE3, 0x00, 0x00, 0x18, 0xF1, 0x80, 0x00, 0x0C, 0x78, 0xE0, 0x00,
  0x0E, 0x3C, 0x30, 0x00, 0x06, 0x1E, 0x18, 0x00, 0x03, 0x0F, 0x06, 0x00,
  0x03, 0x07, 0x83, 0x00, 0x01, 0x83, 0xC1, 0x80, 0x00, 0xC1, 0xE0, 0x60,
  0x00, 0xC0, 0xF0, 0x30, 0x00, 0x60, 0x78, 0x1C, 0x00, 0x30, 0x3C, 0x06,
  0x00, 0x30, 0x1E, 0x03, 0x00, 0x18, 0x0F, 0x01, 0xC0, 0x1C, 0x07, 0x80,
  0x60, 0x0C, 0x03, 0xC0, 0x30, 0x06, 0x01, 0xE0, 0x0C, 0x06, 0x00, 0xF0,
  0x06, 0x03, 0x00, 0x78, 0x03, 0x01, 0x80, 0x3C, 0x00, 0xC1, 0x80, 0x1E,
  0x00, 0x60, 0xC0, 0x0F, 0x00, 0x38, 0x60, 0x07, 0x80, 0x0C, 0x60, 0x03,
  0xC0, 0x06, 0x30, 0x01, 0xE0, 0x03, 0xB8, 0x00, 0xF0, 0x00, 0xD8, 0x00,
  0x78, 0x00, 0x6C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3D, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x0F,
  0x30, 0x00, 0x07, 0x9C, 0x00, 0x03, 0xC6, 0x00, 0x01, 0xE1, 0x80, 0x00,
  0xF0, 0xE0, 0x00, 0x78, 0x30, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x06, 0x00,
  0x0F, 0x01, 0x80, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0x30, 0x01, 0xE0, 0x1C,
  0x00, 0xF0, 0x06, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x1E, 0x00,
  0x30, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x06, 0x03, 0xC0, 0x03, 0x81, 0xE0,
  0x00, 0xC0, 0xF0, 0x00, 0x30, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x06, 0x1E,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0xC7, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x1D,
  0xE0, 0x00, 0x06, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x0D, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x06, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x30, 0x00, 0xF1, 0x80, 0x01, 0xCC, 0x00, 0x06, 0x60,
  0x00, 0x3B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x76, 0x00, 0x03, 0x30, 0x00, 0x31,
  0x80, 0x07, 0x8C, 0x07, 0xF0, 0x7F, 0xFE, 0x03, 0xFC, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x0D, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0x80, 0x70, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3F, 0x9F, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0x00, 0x0F, 0x06,
  0x00, 0x07, 0x0C, 0x00, 0x07, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x1C, 0xC0, 0x00, 0x39, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x98, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00,
  0x38, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC3, 0x00, 0x0F, 0x06, 0x00, 0xF8,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0E, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x18, 0x0C,
  0x00, 0x38, 0x18, 0x00, 0x30, 0x30, 0x00, 0x70, 0x60, 0x00, 0x60, 0xC0,
  0x00, 0x61, 0x80, 0x00, 0xE3, 0x00, 0x00, 0xC6, 0x00, 0x01, 0xCC, 0x00,
  0x01, 0x98, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x3F,
  0xFF, 0x03, 0xC0, 0x7C, 0x38, 0x00, 0x23, 0x80, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0xE3,
  0xFC, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x06, 0x60, 0x00, 0x03, 0x38, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x83,
  0x80, 0x03, 0x81, 0xE0, 0x03, 0x80, 0x3F, 0xBF, 0x80, 0x0F, 0xFF, 0x00,
  0x00, 0x10, 0x00, 0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x01, 0x83, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x30, 0x1C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x07,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x38, 0x01,
  0x80, 0x01, 0x80, 0x18, 0x00, 0x18, 0x03, 0x80, 0x01, 0xC0, 0x30, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xD8, 0x00, 0x07, 0x00, 0x00, 0x76, 0x00, 0x01, 0xE0, 0x00, 0x19,
  0x80, 0x00, 0x78, 0x00, 0x06, 0x60, 0x00, 0x1E, 0x00, 0x01, 0x8C, 0x00,
  0x0D, 0x80, 0x00, 0xE3, 0x00, 0x03, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xCC,
  0x00, 0x0C, 0x30, 0x00, 0x33, 0x00, 0x03, 0x06, 0x00, 0x1C, 0xC0, 0x01,
  0xC1, 0x80, 0x06, 0x18, 0x00, 0x60, 0x60, 0x01, 0x86, 0x00, 0x18, 0x18,
  0x00, 0x61, 0x80, 0x06, 0x03, 0x00, 0x38, 0x60, 0x03, 0x80, 0xC0, 0x0C,
  0x0C, 0x00, 0xC0, 0x30, 0x03, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0xC0,
  0x0C, 0x01, 0x80, 0x70, 0x30, 0x07, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x60, 0x18, 0x00, 0xC0,
  0xE0, 0x18, 0x0E, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00,
  0xC0, 0xC0, 0x03, 0x03, 0x00, 0x30, 0x30, 0x00, 0x61, 0xC0, 0x0C, 0x1C,
  0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x61, 0x80, 0x01,
  0x86, 0x00, 0x18, 0x60, 0x00, 0x33, 0x80, 0x06, 0x30, 0x00, 0x0C, 0xC0,
  0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x0C,
  0xC0, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0x03,
  0x1C, 0x00, 0x03, 0x86, 0x00, 0x01, 0x83, 0x80, 0x01, 0x80, 0xC0, 0x00,
  0xC0, 0x70, 0x00, 0xC0, 0x18, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x70, 0x00, 0xC0, 0x30, 0x00, 0x70, 0x38, 0x00, 0x18, 0x18, 0x00, 0x0E,
  0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x60, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x0C,
  0x00, 0x30, 0x06, 0x00, 0x38, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x1C, 0x00,
  0x30, 0x0C, 0x00, 0x1C, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x03, 0x86, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x73, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0E, 0xE0,
  0x00, 0x03, 0xB0, 0x00, 0x01, 0x9C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x70, 0x18, 0x00, 0x30,
  0x0C, 0x00, 0x38, 0x03, 0x00, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0C,
  0x00, 0x30, 0x0E, 0x00, 0x1C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x83,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x71, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0xFF,
  0xFF, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x76, 0x00, 0x00, 0x66, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0xC3, 0x00, 0x01, 0xC1, 0x80, 0x01, 0x81, 0x80, 0x03, 0x00, 0xC0, 0x03,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x0C,
  0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x80, 0x00, 0x78, 0x00, 0x7F, 0xF0, 0x1F, 0x87, 0x81,
  0x80, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x7F, 0x01, 0xFF, 0xF0, 0x7C, 0x07, 0x1E, 0x00, 0x73, 0x80,
  0x07, 0x70, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0x60, 0x00, 0xF6, 0x00, 0x1B, 0x70, 0x01, 0x33,
  0x80, 0x73, 0x1E, 0x1E, 0x30, 0xFF, 0x83, 0x00, 0x80, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x3C, 0x03, 0x87, 0xFE,
  0x0E, 0x78, 0x3C, 0x3B, 0x80, 0x38, 0xEC, 0x00, 0x73, 0x60, 0x00, 0xCD,
  0x00, 0x01, 0xBC, 0x00, 0x06, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xBC, 0x00,
  0x06, 0xF0, 0x00, 0x3B, 0x60, 0x00, 0xCC, 0xC0, 0x07, 0x33, 0x80, 0x78,
  0xC7, 0xCF, 0xC3, 0x07, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x7F, 0xF0, 0x7E, 0x1C, 0x3C, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x01,
  0x07, 0xE7, 0xC0, 0x7F, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x38, 0x0C, 0x0F, 0xFC, 0x30, 0x78, 0x78,
  0xC7, 0x80, 0x33, 0x18, 0x00, 0x6C, 0xE0, 0x00, 0xB3, 0x00, 0x03, 0xD8,
  0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x76, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x70, 0x00,
  0x3C, 0xC0, 0x00, 0xB3, 0x80, 0x06, 0xC7, 0x00, 0x33, 0x0F, 0x87, 0x8C,
  0x0F, 0xF8, 0x30, 0x02, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x01,
  0xE1, 0xE0, 0x1C, 0x03, 0x81, 0x80, 0x0E, 0x1C, 0x00, 0x30, 0xC0, 0x01,
  0xCC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0xB8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x7E, 0x7F, 0x01, 0xFF,
  0xE0, 0x00, 0x50, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0x81, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xFC, 0x30, 0xF8, 0x78,
  0xC7, 0x80, 0x33, 0x18, 0x00, 0x6C, 0xE0, 0x00, 0xB3, 0x00, 0x03, 0xD8,
  0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x76, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x70, 0x00,
  0x2C, 0xC0, 0x01, 0xB3, 0x80, 0x06, 0xC7, 0x00, 0x73, 0x0F, 0x87, 0x8C,
  0x0F, 0xF8, 0x30, 0x02, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x10, 0x00, 0x18, 0x78, 0x01, 0xE0, 0xFF, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x07, 0x81, 0x87, 0xFE,
  0x33, 0xC1, 0xE6, 0xE0, 0x0E, 0xD0, 0x00, 0xDE, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0C, 0x7F, 0xF0, 0x00, 0x00, 0x36,
  0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x01, 0x81,
  0xC0, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x81, 0xDF, 0xCF, 0xC0, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0xEC, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x0C,
  0x30, 0x07, 0x0C, 0x03, 0x83, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x0C,
  0x1C, 0x03, 0x0E, 0x00, 0xC3, 0x00, 0x31, 0xC0, 0x0C, 0xF8, 0x03, 0x66,
  0x00, 0xF1, 0xC0, 0x2C, 0x30, 0x0E, 0x06, 0x03, 0x01, 0xC0, 0xC0, 0x30,
  0x30, 0x06, 0x0C, 0x01, 0xC3, 0x00, 0x30, 0xC0, 0x0E, 0x30, 0x01, 0x8C,
  0x00, 0x33, 0x00, 0x0E, 0xC0, 0x01, 0xB0, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x60,
  0x21, 0xFF, 0x01, 0xFF, 0x08, 0xE1, 0xE0, 0xE1, 0xE2, 0x60, 0x1C, 0x60,
  0x1C, 0xB0, 0x03, 0x30, 0x03, 0xA8, 0x00, 0x78, 0x00, 0x6E, 0x00, 0x1E,
  0x00, 0x1B, 0x00, 0x07, 0x00, 0x06, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x00,
  0x70, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F,
  0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00,
  0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03,
  0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00,
  0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x78, 0x10, 0x7F, 0xE2, 0x3C, 0x1E, 0x4E,
  0x00, 0xE9, 0x00, 0x0D, 0x60, 0x01, 0xE8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x07, 0xFF, 0x00, 0x1E, 0x1F,
  0x00, 0x70, 0x07, 0x01, 0x80, 0x07, 0x07, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x30, 0x00, 0x0C, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x36,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x07, 0x38, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x70, 0x00, 0x60, 0x70, 0x01, 0xC0, 0x70, 0x07,
  0x00, 0x7C, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70,
  0x04, 0x1F, 0xF8, 0x21, 0xE1, 0xE1, 0x18, 0x03, 0x89, 0x80, 0x0E, 0x58,
  0x00, 0x3A, 0x80, 0x00, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xDC, 0x00,
  0x06, 0xA0, 0x00, 0x77, 0x80, 0x03, 0x36, 0x00, 0x39, 0xB8, 0x03, 0x8C,
  0xF9, 0xF8, 0x61, 0xFF, 0x03, 0x00, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xFC, 0x30, 0xF8, 0x78, 0xC7,
  0x80, 0x33, 0x18, 0x00, 0x6C, 0xE0, 0x00, 0xB7, 0x00, 0x03, 0xD8, 0x00,
  0x07, 0x60, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x76, 0x00, 0x01, 0xD8, 0x00, 0x0F, 0x70, 0x00, 0x2C,
  0xC0, 0x01, 0xB3, 0x80, 0x0C, 0xC7, 0x00, 0x73, 0x0F, 0x8F, 0x8C, 0x0F,
  0xF8, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x64, 0x3F, 0xE3, 0xEF, 0x38, 0x09, 0x80, 0x58, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0xE1, 0xE0, 0xFC, 0xE0, 0x02,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x78, 0x00, 0x1B, 0x00, 0x0E, 0xFE, 0x3F, 0x0F, 0xFF, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x78, 0xC0, 0xFF, 0x00, 0x40, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0xF7, 0x00, 0x1B, 0x38,
  0x03, 0x31, 0xF3, 0xE3, 0x0F, 0xFC, 0x30, 0x08, 0x00, 0xE0, 0x00, 0x1D,
  0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0xC3, 0x00, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x03,
  0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x18, 0x06, 0x00,
  0x60, 0x18, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30,
  0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0,
  0x00, 0x33, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x70,
  0x00, 0x6E, 0x00, 0x1E, 0x00, 0x19, 0x80, 0x07, 0x80, 0x06, 0x60, 0x01,
  0x60, 0x03, 0x18, 0x00, 0xCC, 0x00, 0xC7, 0x00, 0x33, 0x00, 0x30, 0xC0,
  0x0C, 0xC0, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x0C, 0x01, 0x86, 0x01, 0x81,
  0x80, 0x61, 0x80, 0x60, 0x60, 0x18, 0x60, 0x18, 0x18, 0x0C, 0x1C, 0x0C,
  0x06, 0x03, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0x30, 0x60, 0x30,
  0x30, 0x0C, 0x18, 0x06, 0x18, 0x03, 0x06, 0x01, 0x86, 0x00, 0x61, 0x80,
  0x61, 0x80, 0x18, 0xC0, 0x1C, 0x60, 0x06, 0x30, 0x03, 0x30, 0x01, 0x8C,
  0x00, 0xCC, 0x00, 0x36, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03,
  0x60, 0x01, 0xE0, 0x00, 0xD8, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x39,
  0x80, 0x03, 0x8E, 0x00, 0x18, 0x30, 0x01, 0xC0, 0xC0, 0x0C, 0x07, 0x00,
  0xC0, 0x18, 0x0E, 0x00, 0xE0, 0x60, 0x03, 0x06, 0x00, 0x0C, 0x30, 0x00,
  0x73, 0x00, 0x01, 0xB8, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0xDC, 0x00, 0x0E, 0x60, 0x00, 0x61, 0x80, 0x06,
  0x0C, 0x00, 0x70, 0x30, 0x03, 0x01, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x18,
  0x18, 0x00, 0xE1, 0xC0, 0x03, 0x0C, 0x00, 0x1C, 0xE0, 0x00, 0x6E, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x66, 0x00, 0x01, 0x8C, 0x00,
  0x06, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x18,
  0x18, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x03,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00,
  0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xBF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3E, 0x01, 0xFC, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x7E, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x3F, 0x00,
  0x70, 0x00, 0x1F, 0x80, 0x02, 0xFF, 0xC0, 0x0F, 0x81, 0xE0, 0x3C, 0x00,
  0xFF, 0xE8, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 39, 12, 4, -39 },
  { 21, 10, 14, 18, 4, -39 },
  { 39, 29, 39, 31, 1, -39 },
  { 181, 21, 45, 28, 3, -42 },
  { 300, 34, 41, 40, 3, -40 },
  { 475, 29, 41, 33, 3, -40 },
  { 624, 2, 14, 10, 4, -39 },
  { 628, 11, 48, 15, 2, -39 },
  { 694, 10, 48, 15, 2, -39 },
  { 754, 20, 20, 26, 3, -42 },
  { 804, 24, 25, 28, 2, -32 },
  { 879, 5, 13, 11, 2, -6 },
  { 888, 13, 2, 17, 2, -16 },
  { 892, 4, 4, 12, 4, -4 },
  { 894, 17, 39, 18, 1, -39 },
  { 977, 22, 41, 28, 3, -40 },
  { 1090, 11, 39, 28, 5, -39 },
  { 1144, 21, 40, 28, 3, -40 },
  { 1249, 22, 41, 28, 2, -40 },
  { 1362, 26, 39, 28, 1, -39 },
  { 1489, 22, 40, 28, 3, -39 },
  { 1599, 22, 41, 28, 3, -40 },
  { 1712, 22, 39, 28, 3, -39 },
  { 1820, 22, 41, 28, 3, -40 },
  { 1933, 22, 41, 28, 3, -40 },
  { 2046, 4, 29, 12, 4, -29 },
  { 2061, 6, 36, 12, 2, -29 },
  { 2088, 24, 24, 28, 2, -32 },
  { 2160, 23, 13, 28, 3, -26 },
  { 2198, 24, 24, 28, 2, -32 },
  { 2270, 17, 40, 20, 1, -40 },
  { 2355, 37, 44, 43, 3, -39 },
  { 2559, 28, 39, 28, 0, -39 },
  { 2696, 23, 39, 30, 5, -39 },
  { 2809, 25, 41, 30, 3, -40 },
  { 2938, 26, 39, 34, 5, -39 },
  { 3065, 19, 39, 27, 5, -39 },
  { 3158, 19, 39, 25, 5, -39 },
  { 3251, 29, 41, 36, 3, -40 },
  { 3400, 25, 39, 35, 5, -39 },
  { 3522, 9, 39, 15, 3, -39 },
  { 3566, 11, 49, 12, -4, -39 },
  { 3634, 23, 39, 28, 5, -39 },
  { 3747, 19, 39, 25, 5, -39 },
  { 3840, 33, 39, 43, 5, -39 },
  { 4001, 25, 39, 35, 5, -39 },
  { 4123, 31, 41, 37, 3, -40 },
  { 4282, 21, 39, 28, 5, -39 },
  { 4385, 31, 49, 37, 3, -40 },
  { 4575, 23, 39, 29, 5, -39 },
  { 4688, 21, 41, 27, 3, -40 },
  { 4796, 25, 39, 25, 0, -39 },
  { 4918, 25, 40, 35, 5, -39 },
  { 5043, 28, 39, 28, 0, -39 },
  { 5180, 42, 39, 44, 1, -39 },
  { 5385, 25, 39, 25, 0, -39 },
  { 5507, 25, 39, 25, 0, -39 },
  { 5629, 23, 39, 27, 2, -39 },
  { 5742, 11, 48, 17, 5, -39 },
  { 5808, 17, 39, 18, 1, -39 },
  { 5891, 11, 48, 17, 2, -39 },
  { 5957, 24, 22, 28, 2, -39 },
  { 6023, 22, 2, 22, 0, 5 },
  { 6029, 9, 9, 14, 2, -42 },
  { 6040, 20, 31, 26, 2, -30 },
  { 6118, 22, 43, 29, 4, -42 },
  { 6237, 18, 31, 23, 3, -30 },
  { 6307, 22, 43, 29, 3, -42 },
  { 6426, 21, 31, 27, 3, -30 },
  { 6508, 16, 42, 14, 1, -42 },
  { 6592, 22, 43, 29, 3, -30 },
  { 6711, 19, 42, 29, 5, -42 },
  { 6811, 3, 40, 11, 4, -40 },
  { 6826, 9, 53, 11, -2, -40 },
  { 6886, 18, 42, 23, 5, -42 },
  { 6981, 2, 42, 11, 5, -42 },
  { 6992, 34, 30, 43, 5, -30 },
  { 7120, 19, 30, 29, 5, -30 },
  { 7192, 23, 31, 29, 3, -30 },
  { 7282, 21, 43, 29, 5, -30 },
  { 7395, 22, 43, 29, 3, -30 },
  { 7514, 13, 30, 19, 5, -30 },
  { 7563, 18, 31, 23, 2, -30 },
  { 7633, 14, 37, 16, 1, -36 },
  { 7698, 20, 30, 29, 4, -29 },
  { 7773, 22, 29, 22, 0, -29 },
  { 7853, 34, 29, 35, 1, -29 },
  { 7977, 21, 29, 24, 1, -29 },
  { 8054, 22, 42, 22, 0, -29 },
  { 8170, 17, 29, 21, 2, -29 },
  { 8232, 15, 48, 19, 2, -39 },
  { 8322, 2, 56, 27, 12, -42 },
  { 8336, 15, 48, 19, 2, -39 },
  { 8426, 23, 5, 28, 3, -22 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight55pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT55PT7B_H_
