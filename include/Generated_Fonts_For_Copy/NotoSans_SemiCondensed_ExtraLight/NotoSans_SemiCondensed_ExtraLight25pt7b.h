#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT25PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight25pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xA0, 0xB0, 0x99, 0x99, 0x99, 0x90, 0x08, 0x40,
  0x42, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x23, 0xDE, 0xE2, 0x10, 0x10,
  0x80, 0x84, 0x04, 0x21, 0xFD, 0xE1, 0x10, 0x10, 0x80, 0x84, 0x04, 0x20,
  0x21, 0x01, 0x08, 0x00, 0x04, 0x01, 0x03, 0xF9, 0x10, 0x84, 0x21, 0x08,
  0x41, 0x10, 0x64, 0x06, 0x00, 0x60, 0x16, 0x04, 0x41, 0x10, 0x44, 0x11,
  0x04, 0xBD, 0xC0, 0xC0, 0x10, 0x38, 0x08, 0x44, 0x10, 0x44, 0x10, 0x84,
  0x20, 0x82, 0x20, 0x82, 0x40, 0x82, 0x40, 0x84, 0x9C, 0x44, 0xA2, 0x45,
  0x22, 0x39, 0x21, 0x02, 0x41, 0x02, 0x41, 0x04, 0x41, 0x04, 0x21, 0x04,
  0x21, 0x08, 0x22, 0x18, 0x1E, 0x1F, 0x01, 0x88, 0x08, 0x20, 0x41, 0x02,
  0x08, 0x10, 0xC0, 0x44, 0x01, 0xC0, 0x0C, 0x01, 0xA0, 0x10, 0x82, 0x82,
  0x18, 0x09, 0x40, 0x2A, 0x01, 0x88, 0x0C, 0x40, 0x91, 0xF8, 0x40, 0xFE,
  0x18, 0x88, 0x44, 0x21, 0x10, 0x84, 0x21, 0x08, 0x42, 0x08, 0x42, 0x08,
  0x41, 0x0C, 0x82, 0x10, 0x42, 0x08, 0x42, 0x10, 0x82, 0x11, 0x08, 0x42,
  0x11, 0x08, 0x44, 0x40, 0x08, 0x02, 0x00, 0x83, 0x23, 0x3F, 0x03, 0x01,
  0x20, 0xC8, 0x21, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x55, 0xA0, 0xFC,
  0xB0, 0x01, 0x01, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0xC0, 0x1F, 0x08, 0x66, 0x09, 0x01,
  0x40, 0x50, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x40, 0x50,
  0x14, 0x05, 0x02, 0x20, 0x87, 0xC0, 0x08, 0xCB, 0x90, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x40, 0x3E, 0x10, 0x60, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x06, 0x01,
  0x00, 0x80, 0x40, 0x3F, 0xF0, 0x3F, 0x30, 0x60, 0x08, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x3E, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x03, 0x80, 0x9F, 0xC0, 0x01, 0x80, 0x30, 0x0A, 0x02, 0x40, 0x48, 0x11,
  0x04, 0x20, 0x84, 0x20, 0x84, 0x11, 0x02, 0x40, 0x48, 0x08, 0xFF, 0xC0,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x7F, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x78, 0xC3, 0x00, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x03, 0x81,
  0x7F, 0x00, 0x0F, 0x86, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x7C,
  0xA0, 0xB0, 0x1C, 0x07, 0x01, 0x40, 0x50, 0x14, 0x05, 0x01, 0x20, 0x87,
  0xC0, 0xFF, 0xC0, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x00,
  0x1F, 0x08, 0x24, 0x05, 0x01, 0x40, 0x50, 0x12, 0x08, 0x4C, 0x0C, 0x04,
  0xC6, 0x09, 0x01, 0x80, 0x60, 0x18, 0x05, 0x01, 0x60, 0x8F, 0xC0, 0x1E,
  0x18, 0x64, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x40, 0xD0, 0x73,
  0xE4, 0x01, 0x00, 0x40, 0x20, 0x08, 0x06, 0x03, 0x1F, 0x80, 0xE0, 0x00,
  0x02, 0xC0, 0x68, 0x00, 0x00, 0x01, 0x24, 0xA4, 0x00, 0x20, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x10, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x80, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0x40, 0x00, 0xFD, 0x0C, 0x08, 0x10, 0x20, 0x40, 0x82, 0x08, 0x20,
  0x81, 0x02, 0x04, 0x00, 0x00, 0x20, 0x40, 0x01, 0xF0, 0x03, 0x06, 0x06,
  0x00, 0x86, 0x00, 0x22, 0x00, 0x12, 0x07, 0x85, 0x0C, 0x42, 0x84, 0x21,
  0x84, 0x10, 0xC2, 0x08, 0x61, 0x04, 0x30, 0x82, 0x18, 0x41, 0x0C, 0x21,
  0x89, 0x0F, 0x3C, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01,
  0xFF, 0x00, 0x02, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x48, 0x04, 0x40,
  0x22, 0x01, 0x10, 0x10, 0x40, 0x82, 0x07, 0xF0, 0x40, 0x42, 0x02, 0x10,
  0x11, 0x00, 0x48, 0x02, 0xC0, 0x14, 0x00, 0x40, 0xFE, 0x10, 0x32, 0x01,
  0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x04, 0xFF, 0x10, 0x32, 0x01, 0x40,
  0x28, 0x03, 0x00, 0x60, 0x14, 0x02, 0x80, 0x9F, 0xE0, 0x07, 0xE1, 0x81,
  0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x18, 0x00, 0xFF,
  0xFE, 0x08, 0x18, 0x80, 0x48, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x04,
  0x81, 0x8F, 0xE0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0xFF, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F, 0xC0,
  0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F, 0xA0,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x00, 0x07, 0xF0, 0x40,
  0x44, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x07, 0xD0, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x04, 0x80, 0x26, 0x01, 0x18,
  0x08, 0x3F, 0xC0, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0xFF, 0xF8, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x27, 0xC0, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0x80, 0x50, 0x12, 0x06,
  0x41, 0x88, 0x21, 0x08, 0x22, 0x04, 0x80, 0xB8, 0x1D, 0x03, 0x10, 0x42,
  0x08, 0x21, 0x02, 0x20, 0x44, 0x04, 0x80, 0x50, 0x0C, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x7F, 0xC0, 0xC0, 0x03, 0x80, 0x0E, 0x80, 0x1D,
  0x00, 0x3A, 0x00, 0xB2, 0x01, 0x64, 0x04, 0xC8, 0x09, 0x88, 0x13, 0x10,
  0x46, 0x10, 0x8C, 0x21, 0x18, 0x44, 0x30, 0x48, 0x60, 0x90, 0xC1, 0x41,
  0x81, 0x83, 0x02, 0x04, 0xC0, 0x1C, 0x01, 0xA0, 0x1A, 0x01, 0x90, 0x19,
  0x01, 0x88, 0x18, 0x41, 0x84, 0x18, 0x21, 0x82, 0x18, 0x11, 0x81, 0x98,
  0x09, 0x80, 0x58, 0x05, 0x80, 0x38, 0x03, 0x0F, 0xC0, 0x60, 0xC2, 0x01,
  0x88, 0x02, 0x40, 0x05, 0x00, 0x14, 0x00, 0x50, 0x01, 0x80, 0x07, 0x00,
  0x14, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00, 0x12, 0x00, 0x88, 0x02, 0x10,
  0x30, 0x3F, 0x80, 0xFE, 0x20, 0x48, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06,
  0x02, 0x80, 0xA3, 0xCF, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x00, 0x0F, 0xC0, 0x60, 0xC2, 0x01, 0x88, 0x02, 0x40, 0x05, 0x00,
  0x14, 0x00, 0x50, 0x01, 0x80, 0x07, 0x00, 0x14, 0x00, 0x50, 0x01, 0x40,
  0x05, 0x00, 0x12, 0x00, 0x88, 0x02, 0x10, 0x30, 0x3F, 0x80, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0xFC, 0x10, 0x32, 0x02, 0x40, 0x28, 0x05,
  0x00, 0xA0, 0x14, 0x04, 0x81, 0x1F, 0xC2, 0x10, 0x41, 0x08, 0x31, 0x02,
  0x20, 0x24, 0x04, 0x80, 0x50, 0x0C, 0x1F, 0x98, 0x14, 0x03, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x18, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x10,
  0x04, 0x03, 0x00, 0xBF, 0xC0, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x24, 0x02, 0x60, 0x41, 0xF8, 0x80, 0x1C, 0x00,
  0x90, 0x04, 0x80, 0x44, 0x02, 0x10, 0x10, 0x81, 0x84, 0x08, 0x10, 0x40,
  0x82, 0x04, 0x20, 0x11, 0x00, 0x88, 0x04, 0x80, 0x14, 0x00, 0xA0, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x60, 0x34, 0x06, 0x02, 0x40, 0x60, 0x24, 0x06,
  0x02, 0x20, 0x90, 0x42, 0x09, 0x04, 0x20, 0x90, 0x42, 0x09, 0x04, 0x11,
  0x08, 0x81, 0x10, 0x88, 0x11, 0x08, 0x81, 0x10, 0x88, 0x0A, 0x05, 0x00,
  0xA0, 0x50, 0x0A, 0x05, 0x00, 0xA0, 0x50, 0x04, 0x02, 0x00, 0x40, 0x20,
  0x40, 0x28, 0x08, 0x81, 0x18, 0x41, 0x08, 0x12, 0x02, 0x40, 0x30, 0x06,
  0x00, 0xC0, 0x28, 0x04, 0x81, 0x10, 0x21, 0x08, 0x33, 0x02, 0x40, 0x30,
  0x04, 0x80, 0x28, 0x05, 0x01, 0x10, 0x22, 0x08, 0x61, 0x04, 0x40, 0x88,
  0x0A, 0x01, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0xFF, 0xC0, 0x10, 0x08, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0x80, 0x3F,
  0xF0, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x7C, 0xC0, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10,
  0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0xF8, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xFC, 0x04,
  0x01, 0x40, 0x28, 0x08, 0x81, 0x10, 0x41, 0x08, 0x22, 0x02, 0x40, 0x50,
  0x0C, 0xFF, 0xC0, 0xC4, 0x21, 0x7F, 0x00, 0x80, 0x20, 0x10, 0x08, 0x3C,
  0xE2, 0x81, 0x80, 0xC0, 0x60, 0x78, 0x57, 0xC8, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x23, 0x0B, 0x33, 0x02, 0xC0, 0xA0, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0xC0, 0xB0, 0x6B, 0xF0, 0x1F, 0x90, 0x10, 0x08,
  0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0xF8, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x41, 0x13, 0xB4, 0x83, 0x40, 0x50, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x01, 0x40, 0x48, 0x31, 0xF4, 0x1F,
  0x08, 0x24, 0x09, 0x01, 0x80, 0x7F, 0xF8, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x81, 0x1F, 0x80, 0x0F, 0x10, 0x10, 0x20, 0x20, 0x20, 0xFC, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x3F,
  0x48, 0x34, 0x05, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x14,
  0x04, 0x83, 0x1F, 0x40, 0x10, 0x04, 0x01, 0x00, 0x50, 0x23, 0xF0, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x62, 0xCD, 0x83, 0xC0, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0xC7, 0xFF, 0xC0,
  0x11, 0x00, 0x01, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1E,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x0D, 0x04, 0x84, 0x44, 0x24,
  0x16, 0x0B, 0x86, 0x42, 0x11, 0x08, 0x82, 0x40, 0xA0, 0x60, 0xFF, 0xFF,
  0xE0, 0xBE, 0x7C, 0xC1, 0x82, 0x81, 0x82, 0x81, 0x01, 0x81, 0x01, 0x81,
  0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81,
  0x01, 0x81, 0x01, 0xBF, 0x60, 0xF0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x3F, 0x84, 0x11, 0x01, 0x20, 0x28,
  0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x48, 0x09, 0x01, 0x10, 0x41, 0xF0,
  0xBF, 0x30, 0x2C, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x1C, 0x0A, 0x86, 0xBF, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00,
  0x3F, 0x48, 0x34, 0x05, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50,
  0x14, 0x0D, 0x83, 0x3F, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0xBF, 0x0C, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x80, 0x7F, 0xC0,
  0x80, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x01, 0x01, 0x81, 0xFE, 0x20,
  0x40, 0x87, 0xF2, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x0F, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x68, 0x37, 0xE8, 0x80, 0x50, 0x24, 0x09, 0x02, 0x21, 0x08, 0x42,
  0x10, 0x48, 0x12, 0x04, 0x80, 0xC0, 0x30, 0x0C, 0x00, 0xC1, 0x81, 0x41,
  0x82, 0x41, 0x82, 0x41, 0x42, 0x22, 0x42, 0x22, 0x44, 0x22, 0x24, 0x24,
  0x24, 0x14, 0x24, 0x14, 0x28, 0x14, 0x18, 0x18, 0x18, 0x08, 0x18, 0x81,
  0xA0, 0x98, 0x84, 0x41, 0x40, 0xC0, 0x20, 0x28, 0x24, 0x11, 0x10, 0x58,
  0x28, 0x08, 0x80, 0x50, 0x24, 0x09, 0x02, 0x21, 0x08, 0x42, 0x10, 0x48,
  0x12, 0x04, 0x80, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x0E, 0x00, 0xFF, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20,
  0x40, 0x80, 0xFF, 0x0E, 0x30, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x41,
  0x87, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0x80, 0xC0, 0x40, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x30, 0x71, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x83, 0x18, 0x00, 0x78,
  0x30, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 18, 6, 2, -18 },
  { 6, 4, 7, 8, 2, -18 },
  { 10, 13, 18, 14, 1, -18 },
  { 40, 10, 20, 13, 1, -19 },
  { 65, 16, 18, 18, 1, -18 },
  { 101, 13, 18, 15, 1, -18 },
  { 131, 1, 7, 4, 2, -18 },
  { 132, 5, 22, 7, 1, -18 },
  { 146, 5, 22, 7, 1, -18 },
  { 160, 10, 9, 12, 1, -19 },
  { 172, 11, 12, 13, 1, -15 },
  { 189, 2, 6, 5, 1, -3 },
  { 191, 6, 1, 8, 1, -7 },
  { 192, 2, 2, 5, 2, -2 },
  { 193, 8, 18, 8, 0, -18 },
  { 211, 10, 18, 13, 1, -18 },
  { 234, 5, 18, 13, 2, -18 },
  { 246, 10, 18, 13, 1, -18 },
  { 269, 10, 18, 13, 1, -18 },
  { 292, 11, 18, 13, 1, -18 },
  { 317, 9, 18, 13, 2, -18 },
  { 338, 10, 18, 13, 1, -18 },
  { 361, 10, 18, 13, 1, -18 },
  { 384, 10, 18, 13, 1, -18 },
  { 407, 10, 18, 13, 1, -18 },
  { 430, 2, 13, 5, 2, -13 },
  { 434, 3, 16, 5, 1, -13 },
  { 440, 11, 12, 13, 1, -15 },
  { 457, 11, 6, 13, 1, -12 },
  { 466, 11, 12, 13, 1, -15 },
  { 483, 7, 18, 9, 1, -18 },
  { 499, 17, 20, 20, 1, -18 },
  { 542, 13, 18, 13, 0, -18 },
  { 572, 11, 18, 14, 2, -18 },
  { 597, 12, 18, 14, 1, -18 },
  { 624, 12, 18, 16, 2, -18 },
  { 651, 9, 18, 12, 2, -18 },
  { 672, 9, 18, 11, 2, -18 },
  { 693, 13, 18, 16, 1, -18 },
  { 723, 12, 18, 16, 2, -18 },
  { 750, 5, 18, 7, 1, -18 },
  { 762, 5, 22, 6, -2, -18 },
  { 776, 11, 18, 13, 2, -18 },
  { 801, 9, 18, 11, 2, -18 },
  { 822, 15, 18, 20, 2, -18 },
  { 856, 12, 18, 16, 2, -18 },
  { 883, 14, 18, 17, 1, -18 },
  { 915, 10, 18, 13, 2, -18 },
  { 938, 14, 22, 17, 1, -18 },
  { 977, 11, 18, 13, 2, -18 },
  { 1002, 10, 18, 12, 1, -18 },
  { 1025, 11, 18, 11, 0, -18 },
  { 1050, 12, 18, 16, 2, -18 },
  { 1077, 13, 18, 13, 0, -18 },
  { 1107, 20, 18, 20, 0, -18 },
  { 1152, 11, 18, 11, 0, -18 },
  { 1177, 11, 18, 11, 0, -18 },
  { 1202, 10, 18, 12, 1, -18 },
  { 1225, 5, 22, 8, 2, -18 },
  { 1239, 8, 18, 8, 0, -18 },
  { 1257, 5, 22, 8, 1, -18 },
  { 1271, 11, 10, 13, 1, -18 },
  { 1285, 10, 1, 10, 0, 2 },
  { 1287, 4, 4, 6, 1, -19 },
  { 1289, 9, 13, 12, 1, -13 },
  { 1304, 10, 19, 13, 2, -19 },
  { 1328, 9, 13, 10, 1, -13 },
  { 1343, 10, 19, 13, 1, -19 },
  { 1367, 10, 13, 12, 1, -13 },
  { 1384, 8, 19, 7, 0, -19 },
  { 1403, 10, 19, 13, 1, -13 },
  { 1427, 9, 19, 13, 2, -19 },
  { 1449, 1, 18, 5, 2, -18 },
  { 1452, 4, 24, 5, -1, -18 },
  { 1464, 9, 19, 11, 2, -19 },
  { 1486, 1, 19, 5, 2, -19 },
  { 1489, 16, 13, 19, 2, -13 },
  { 1515, 9, 13, 13, 2, -13 },
  { 1530, 11, 13, 13, 1, -13 },
  { 1548, 10, 19, 13, 2, -13 },
  { 1572, 10, 19, 13, 1, -13 },
  { 1596, 6, 13, 9, 2, -13 },
  { 1606, 8, 13, 10, 1, -13 },
  { 1619, 7, 16, 7, 0, -16 },
  { 1633, 9, 13, 13, 2, -13 },
  { 1648, 10, 13, 10, 0, -13 },
  { 1665, 16, 13, 16, 0, -13 },
  { 1691, 9, 13, 11, 1, -13 },
  { 1706, 10, 19, 10, 0, -13 },
  { 1730, 8, 13, 10, 1, -13 },
  { 1743, 7, 22, 9, 1, -18 },
  { 1763, 1, 25, 12, 5, -19 },
  { 1767, 7, 22, 9, 1, -18 },
  { 1787, 11, 2, 13, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight25pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT25PT7B_H_
