#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT22PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0x99, 0x99, 0x99, 0x08, 0x81, 0x10, 0x42, 0x08, 0x41,
  0x11, 0xFF, 0xC4, 0x40, 0x88, 0x21, 0x04, 0x23, 0xFF, 0x11, 0x02, 0x20,
  0x44, 0x10, 0x82, 0x10, 0x08, 0x04, 0x1F, 0xC9, 0x08, 0x84, 0x42, 0x20,
  0x90, 0x38, 0x06, 0x02, 0xC1, 0x20, 0x88, 0x44, 0x25, 0x94, 0x3C, 0x04,
  0x00, 0x30, 0x21, 0x20, 0x88, 0x44, 0x21, 0x10, 0x84, 0x82, 0x12, 0x08,
  0x53, 0x22, 0x52, 0x4A, 0x84, 0xCA, 0x10, 0x48, 0x41, 0x21, 0x08, 0x84,
  0x22, 0x11, 0x04, 0x84, 0x1E, 0x1C, 0x02, 0x20, 0x21, 0x04, 0x10, 0x21,
  0x02, 0x20, 0x14, 0x01, 0x80, 0x28, 0x04, 0x42, 0x82, 0x28, 0x12, 0x80,
  0xC8, 0x0C, 0x41, 0x43, 0xE3, 0xFC, 0x12, 0x24, 0x48, 0x88, 0x88, 0x88,
  0x88, 0x44, 0x42, 0x30, 0x84, 0x42, 0x22, 0x11, 0x11, 0x11, 0x11, 0x22,
  0x24, 0x80, 0x08, 0x08, 0x08, 0xEB, 0x1C, 0x18, 0x24, 0x62, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x87, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x00, 0x5A, 0x80,
  0xF8, 0xC0, 0x02, 0x04, 0x10, 0x20, 0x41, 0x02, 0x08, 0x10, 0x20, 0x81,
  0x02, 0x08, 0x10, 0x40, 0x1E, 0x11, 0x90, 0x48, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x14, 0x0A, 0x08, 0x84, 0x7C, 0x09, 0xD3,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x3C, 0x61, 0x00, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01,
  0x01, 0xFF, 0x3C, 0x61, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x78, 0x02,
  0x00, 0x80, 0x20, 0x10, 0x08, 0x08, 0x05, 0xFC, 0x01, 0x00, 0x20, 0x0A,
  0x02, 0x40, 0x48, 0x11, 0x04, 0x20, 0x84, 0x20, 0x84, 0x11, 0x02, 0x7F,
  0xF0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x7F, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x20, 0xEC, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x06, 0x04, 0xFC,
  0x0F, 0x08, 0x08, 0x08, 0x04, 0x02, 0x02, 0x79, 0x42, 0xC0, 0xC0, 0x60,
  0x30, 0x14, 0x0A, 0x04, 0x84, 0x7C, 0xFF, 0x80, 0x40, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40,
  0x3E, 0x20, 0x90, 0x48, 0x14, 0x0A, 0x08, 0x88, 0x38, 0x36, 0x20, 0xA0,
  0x30, 0x18, 0x0C, 0x05, 0x04, 0x7C, 0x3C, 0x21, 0x10, 0x50, 0x28, 0x0C,
  0x06, 0x03, 0x03, 0x42, 0x9E, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0xF8,
  0xC0, 0x30, 0x50, 0x00, 0x05, 0xA8, 0x00, 0x81, 0x83, 0x06, 0x04, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x0C, 0x18, 0x30, 0x60, 0x40, 0x00,
  0xFA, 0x10, 0x41, 0x04, 0x10, 0x82, 0x10, 0x82, 0x08, 0x00, 0x02, 0x18,
  0x03, 0xC0, 0x18, 0x60, 0x40, 0x21, 0x00, 0x24, 0x00, 0x28, 0x7C, 0x61,
  0x08, 0xC4, 0x11, 0x88, 0x23, 0x10, 0x46, 0x21, 0x0C, 0x43, 0x18, 0x4A,
  0x48, 0x63, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x1F, 0xC0, 0x04, 0x00,
  0xC0, 0x28, 0x05, 0x00, 0x90, 0x22, 0x04, 0x40, 0x84, 0x20, 0x87, 0xF0,
  0x81, 0x20, 0x24, 0x04, 0x80, 0x60, 0x0C, 0x01, 0xFC, 0x41, 0xA0, 0x50,
  0x18, 0x0C, 0x06, 0x05, 0xFC, 0x83, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x05, 0xFC, 0x0F, 0xC4, 0x12, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x03, 0x00, 0x3F, 0xFC, 0x20,
  0xC8, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x28, 0x13, 0xF8, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x07, 0xC1, 0x83, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x81, 0xF8, 0x01, 0x80, 0x14, 0x01, 0x40, 0x12, 0x01, 0x30,
  0x10, 0xFE, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0xFF,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xF4, 0x44,
  0x44, 0x44, 0x44, 0x44, 0x44, 0x4F, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x45, 0xE0, 0x80, 0xC0, 0xA0, 0x90, 0x88,
  0x84, 0x42, 0x41, 0x60, 0xD0, 0x44, 0x21, 0x10, 0x88, 0x24, 0x0A, 0x05,
  0x01, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x7F, 0x80, 0x0E, 0x00, 0xF0, 0x07, 0x40, 0x3A, 0x02, 0xD0,
  0x16, 0x40, 0xB2, 0x09, 0x90, 0x4C, 0x44, 0x62, 0x23, 0x11, 0x18, 0x50,
  0xC2, 0x86, 0x0C, 0x30, 0x41, 0x80, 0x70, 0x1C, 0x06, 0x81, 0xA0, 0x64,
  0x18, 0x86, 0x21, 0x84, 0x61, 0x18, 0x26, 0x05, 0x81, 0x60, 0x38, 0x0E,
  0x01, 0x0F, 0x81, 0x04, 0x20, 0x24, 0x01, 0x40, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40, 0x12, 0x02, 0x20, 0x61,
  0xF8, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x8E, 0xF0, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x0F, 0x81, 0x04, 0x20, 0x24, 0x01, 0x40,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40,
  0x12, 0x02, 0x20, 0x61, 0xF8, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0xFC,
  0x41, 0x20, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x04, 0xFC, 0x44, 0x21, 0x10,
  0x48, 0x24, 0x0A, 0x05, 0x01, 0x3F, 0x20, 0xA0, 0x10, 0x08, 0x04, 0x01,
  0x00, 0x60, 0x0E, 0x00, 0x80, 0x40, 0x10, 0x08, 0x08, 0x05, 0xFC, 0xFF,
  0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x14, 0x08, 0xFC, 0x80, 0x30, 0x05, 0x01, 0x20, 0x24, 0x04, 0x41, 0x08,
  0x21, 0x04, 0x11, 0x02, 0x20, 0x44, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80,
  0x20, 0x80, 0x80, 0xA0, 0x60, 0x50, 0x30, 0x28, 0x28, 0x24, 0x14, 0x11,
  0x09, 0x08, 0x84, 0x84, 0x44, 0x44, 0x22, 0x22, 0x09, 0x09, 0x04, 0x84,
  0x82, 0x82, 0x81, 0x41, 0x40, 0x60, 0x60, 0x30, 0x30, 0x10, 0x10, 0x40,
  0x50, 0x22, 0x08, 0x84, 0x11, 0x04, 0x80, 0xC0, 0x30, 0x0C, 0x02, 0x81,
  0x20, 0x44, 0x21, 0x10, 0x24, 0x0A, 0x01, 0x80, 0x50, 0x24, 0x09, 0x04,
  0x21, 0x08, 0x81, 0x20, 0x48, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0xFF, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10,
  0x08, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0xFF, 0xF8, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x80, 0x81, 0x02, 0x02, 0x04,
  0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0x81, 0xF1, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x08, 0x06, 0x05, 0x02, 0x42,
  0x21, 0x09, 0x04, 0x81, 0x80, 0x80, 0xFF, 0x80, 0x84, 0x21, 0x3C, 0x42,
  0x02, 0x01, 0x01, 0x1F, 0x61, 0x81, 0x81, 0x83, 0x83, 0x7D, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x05, 0xE3, 0x09, 0x02, 0x81, 0x40, 0xA0, 0x30, 0x18,
  0x0C, 0x0A, 0x05, 0x84, 0xBE, 0x00, 0x1F, 0x20, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x3F, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0xE4, 0x8E, 0x83, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x05, 0x02, 0x83,
  0x3E, 0x80, 0x1C, 0x11, 0x10, 0x50, 0x28, 0x0F, 0xFE, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x07, 0xE0, 0x0E, 0x20, 0x81, 0x02, 0x1F, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x1E, 0xB0, 0xD0, 0x70, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0x50, 0x67, 0xD0, 0x08, 0x04, 0x02,
  0x02, 0x7E, 0x00, 0x80, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC2, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xCF, 0xFF, 0x11, 0x00,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xE0, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x61, 0x44, 0x91, 0x22, 0x86, 0x88, 0x91, 0x21, 0x42, 0x82,
  0xFF, 0xFF, 0x80, 0xB8, 0xF6, 0x28, 0x60, 0xC3, 0x04, 0x18, 0x20, 0xC1,
  0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x10, 0xBC,
  0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x1E,
  0x10, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0x50, 0x47,
  0xC0, 0xBC, 0x61, 0x20, 0x50, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x40,
  0xB0, 0x97, 0xC8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x1C, 0xB1, 0xD0,
  0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0xD0, 0x67, 0xD0, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0xBE, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x00, 0x3C, 0x86, 0x04, 0x0C, 0x0E, 0x03, 0x01, 0x02, 0x04, 0x0F, 0xE0,
  0x20, 0x8F, 0xC8, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xF0, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0x83, 0x7D, 0x80,
  0xC0, 0x90, 0x48, 0x24, 0x21, 0x10, 0x88, 0x48, 0x14, 0x0A, 0x06, 0x01,
  0x00, 0x81, 0x05, 0x0C, 0x14, 0x30, 0x90, 0xA2, 0x44, 0x88, 0x92, 0x22,
  0x49, 0x09, 0x14, 0x28, 0x50, 0x61, 0x41, 0x86, 0x04, 0x08, 0x40, 0xA0,
  0x88, 0x82, 0x41, 0x40, 0x60, 0x30, 0x28, 0x12, 0x11, 0x10, 0x58, 0x10,
  0x80, 0xC0, 0x90, 0x48, 0x24, 0x21, 0x10, 0x88, 0x48, 0x14, 0x0A, 0x06,
  0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0xE0, 0x00, 0xFE, 0x08, 0x10, 0x40,
  0x82, 0x04, 0x10, 0x40, 0x82, 0x07, 0xF0, 0x0C, 0x42, 0x08, 0x20, 0x82,
  0x08, 0x23, 0x04, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81, 0xC0, 0xFF, 0xFF,
  0xFC, 0xC0, 0x82, 0x04, 0x10, 0x41, 0x04, 0x10, 0x71, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x8E, 0x00, 0x70, 0xC7, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 16, 5, 2, -16 },
  { 3, 4, 6, 7, 2, -16 },
  { 6, 11, 16, 12, 1, -16 },
  { 28, 9, 18, 11, 1, -17 },
  { 49, 14, 16, 16, 1, -16 },
  { 77, 12, 16, 13, 1, -16 },
  { 101, 1, 6, 4, 1, -16 },
  { 102, 4, 19, 6, 1, -16 },
  { 112, 4, 19, 6, 1, -16 },
  { 122, 8, 8, 11, 1, -17 },
  { 130, 9, 10, 11, 1, -13 },
  { 142, 2, 5, 4, 1, -2 },
  { 144, 5, 1, 7, 1, -6 },
  { 145, 1, 2, 5, 2, -2 },
  { 146, 7, 16, 7, 0, -16 },
  { 160, 9, 16, 11, 1, -16 },
  { 178, 5, 16, 11, 2, -16 },
  { 188, 9, 16, 11, 1, -16 },
  { 206, 9, 16, 11, 1, -16 },
  { 224, 11, 16, 11, 0, -16 },
  { 246, 9, 16, 11, 1, -16 },
  { 264, 9, 16, 11, 1, -16 },
  { 282, 9, 16, 11, 1, -16 },
  { 300, 9, 16, 11, 1, -16 },
  { 318, 9, 16, 11, 1, -16 },
  { 336, 1, 12, 5, 2, -12 },
  { 338, 2, 15, 5, 1, -12 },
  { 342, 9, 10, 11, 1, -13 },
  { 354, 9, 5, 11, 1, -10 },
  { 360, 9, 10, 11, 1, -13 },
  { 372, 6, 16, 8, 1, -16 },
  { 384, 15, 18, 17, 1, -16 },
  { 418, 11, 16, 11, 0, -16 },
  { 440, 9, 16, 12, 2, -16 },
  { 458, 10, 16, 12, 1, -16 },
  { 478, 10, 16, 14, 2, -16 },
  { 498, 8, 16, 11, 2, -16 },
  { 514, 8, 16, 10, 2, -16 },
  { 530, 12, 16, 14, 1, -16 },
  { 554, 10, 16, 14, 2, -16 },
  { 574, 4, 16, 6, 1, -16 },
  { 582, 5, 20, 5, -2, -16 },
  { 595, 9, 16, 11, 2, -16 },
  { 613, 7, 16, 10, 2, -16 },
  { 627, 13, 16, 17, 2, -16 },
  { 653, 10, 16, 14, 2, -16 },
  { 673, 12, 16, 15, 1, -16 },
  { 697, 8, 16, 11, 2, -16 },
  { 713, 12, 20, 15, 1, -16 },
  { 743, 9, 16, 12, 2, -16 },
  { 761, 9, 16, 11, 1, -16 },
  { 779, 10, 16, 10, 0, -16 },
  { 799, 10, 16, 14, 2, -16 },
  { 819, 11, 16, 11, 0, -16 },
  { 841, 17, 16, 18, 0, -16 },
  { 875, 10, 16, 10, 0, -16 },
  { 895, 10, 16, 10, 0, -16 },
  { 915, 9, 16, 11, 1, -16 },
  { 933, 4, 19, 7, 2, -16 },
  { 943, 7, 16, 7, 0, -16 },
  { 957, 4, 19, 7, 1, -16 },
  { 967, 9, 9, 11, 1, -16 },
  { 978, 9, 1, 9, 0, 2 },
  { 980, 4, 4, 5, 1, -17 },
  { 982, 8, 12, 10, 1, -12 },
  { 994, 9, 17, 12, 2, -17 },
  { 1014, 8, 12, 9, 1, -12 },
  { 1026, 9, 17, 12, 1, -17 },
  { 1046, 9, 12, 11, 1, -12 },
  { 1060, 7, 17, 6, 0, -17 },
  { 1075, 9, 17, 12, 1, -12 },
  { 1095, 8, 17, 11, 2, -17 },
  { 1112, 1, 16, 5, 2, -16 },
  { 1114, 4, 21, 5, -1, -16 },
  { 1125, 7, 17, 9, 2, -17 },
  { 1140, 1, 17, 4, 2, -17 },
  { 1143, 13, 12, 17, 2, -12 },
  { 1163, 8, 12, 11, 2, -12 },
  { 1175, 9, 12, 11, 1, -12 },
  { 1189, 9, 17, 12, 2, -12 },
  { 1209, 9, 17, 12, 1, -12 },
  { 1229, 5, 12, 8, 2, -12 },
  { 1237, 7, 12, 9, 1, -12 },
  { 1248, 6, 14, 6, 0, -14 },
  { 1259, 8, 12, 11, 2, -12 },
  { 1271, 9, 12, 9, 0, -12 },
  { 1285, 14, 12, 14, 0, -12 },
  { 1306, 9, 12, 9, 0, -12 },
  { 1320, 9, 17, 9, 0, -12 },
  { 1340, 7, 12, 9, 1, -12 },
  { 1351, 6, 19, 8, 1, -16 },
  { 1366, 1, 22, 11, 5, -17 },
  { 1369, 6, 19, 8, 1, -16 },
  { 1384, 9, 2, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight22pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT22PT7B_H_
