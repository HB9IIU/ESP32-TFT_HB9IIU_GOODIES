#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT10PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xF0, 0x29, 0x54, 0xAF, 0xA9, 0x40, 0x5F, 0x64, 0xDF, 0x40,
  0xD3, 0x4D, 0xBD, 0x35, 0x55, 0xC0, 0x71, 0x45, 0x18, 0x96, 0x27, 0x40,
  0xC0, 0x5A, 0xA9, 0x40, 0xD5, 0x55, 0x80, 0x4F, 0x50, 0x21, 0x3E, 0x42,
  0x00, 0xC0, 0xE0, 0x80, 0x24, 0xA5, 0x20, 0xE9, 0x99, 0x99, 0xE0, 0x75,
  0x54, 0xF1, 0x11, 0x24, 0xF0, 0xF1, 0x17, 0x11, 0xF0, 0x11, 0x94, 0xA9,
  0x3C, 0x40, 0xE8, 0xC2, 0x11, 0xE0, 0xE8, 0xE9, 0x99, 0xE0, 0xF8, 0x84,
  0x22, 0x11, 0x00, 0xE9, 0xAE, 0x99, 0xE0, 0x79, 0x95, 0x31, 0x70, 0x08,
  0x0C, 0x19, 0x30, 0x60, 0x80, 0xF8, 0x3E, 0xC1, 0x06, 0xC8, 0x00, 0xE4,
  0xA4, 0x10, 0x7A, 0x1B, 0xF3, 0xD6, 0xF8, 0x1E, 0x21, 0x14, 0xA6, 0xC6,
  0x20, 0xF9, 0x9E, 0x99, 0xF0, 0xF8, 0x88, 0x88, 0x70, 0xF4, 0x63, 0x18,
  0xCB, 0x80, 0xF2, 0x79, 0x38, 0xF2, 0x79, 0x20, 0x7C, 0x21, 0x78, 0xC5,
  0xE0, 0x99, 0x9F, 0x99, 0x90, 0xD5, 0x5C, 0x55, 0x55, 0xC0, 0x9A, 0xCC,
  0xAA, 0x90, 0x92, 0x49, 0x38, 0x86, 0x38, 0xF3, 0xD6, 0xDA, 0x40, 0x99,
  0xDB, 0xB9, 0x90, 0xF4, 0x63, 0x18, 0xC7, 0xC0, 0xE9, 0x9E, 0x88, 0x80,
  0xF4, 0x63, 0x18, 0xC7, 0xC2, 0x10, 0xF9, 0x9E, 0xAA, 0x90, 0x78, 0x42,
  0x11, 0xF0, 0xF2, 0x22, 0x22, 0x20, 0x99, 0x99, 0x99, 0xF0, 0x8C, 0x54,
  0xA5, 0x10, 0x80, 0x91, 0x99, 0x5A, 0x5A, 0x66, 0x24, 0x24, 0x92, 0x98,
  0x46, 0x2A, 0x20, 0x99, 0x52, 0x22, 0x20, 0x78, 0x88, 0x44, 0x23, 0xE0,
  0xEA, 0xAA, 0xC0, 0x91, 0x22, 0x48, 0xD5, 0x55, 0xC0, 0x22, 0x95, 0x10,
  0xF0, 0x90, 0x71, 0x79, 0xF0, 0x88, 0xE9, 0x99, 0x9E, 0xF2, 0x4E, 0x11,
  0x5B, 0x99, 0x9F, 0xF7, 0x4E, 0x2B, 0x24, 0x92, 0xF6, 0xDE, 0x78, 0x93,
  0x5B, 0x6D, 0x3E, 0x3F, 0x80, 0x92, 0x5D, 0xAD, 0xFF, 0xFE, 0x9A, 0x69,
  0xA4, 0xF6, 0xDA, 0xF9, 0x99, 0xE0, 0xF9, 0x99, 0xE8, 0x80, 0xF6, 0xDE,
  0x48, 0xEA, 0x80, 0xF8, 0x61, 0xF0, 0x5D, 0x24, 0x98, 0xB6, 0xDE, 0x99,
  0x66, 0x40, 0x96, 0xD6, 0xD2, 0x48, 0xD6, 0x26, 0x90, 0x99, 0x66, 0x24,
  0xC0, 0x72, 0x44, 0xF0, 0x69, 0x2C, 0x92, 0x20, 0xFF, 0xC0, 0xC9, 0x22,
  0x92, 0x80, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 2, 1, -7 },
  { 2, 2, 2, 3, 1, -7 },
  { 3, 5, 7, 6, 0, -7 },
  { 8, 3, 9, 5, 1, -8 },
  { 12, 6, 7, 7, 1, -7 },
  { 18, 6, 7, 6, 0, -7 },
  { 24, 1, 2, 2, 0, -7 },
  { 25, 2, 9, 3, 0, -7 },
  { 28, 2, 9, 3, 0, -7 },
  { 31, 3, 4, 5, 1, -8 },
  { 33, 5, 5, 5, 0, -6 },
  { 37, 1, 2, 2, 0, -1 },
  { 38, 3, 1, 3, 0, -3 },
  { 39, 1, 1, 2, 1, -1 },
  { 40, 3, 7, 3, 0, -7 },
  { 43, 4, 7, 5, 1, -7 },
  { 47, 2, 7, 5, 1, -7 },
  { 49, 4, 7, 5, 0, -7 },
  { 53, 4, 7, 5, 0, -7 },
  { 57, 5, 7, 5, 0, -7 },
  { 62, 4, 7, 5, 1, -7 },
  { 66, 4, 7, 5, 1, -7 },
  { 70, 5, 7, 5, 0, -7 },
  { 75, 4, 7, 5, 1, -7 },
  { 79, 4, 7, 5, 0, -7 },
  { 83, 1, 5, 2, 1, -5 },
  { 84, 1, 6, 2, 0, -5 },
  { 85, 5, 5, 5, 0, -6 },
  { 89, 5, 3, 5, 0, -5 },
  { 91, 5, 5, 5, 0, -6 },
  { 95, 3, 7, 4, 0, -7 },
  { 98, 6, 8, 8, 1, -7 },
  { 104, 5, 7, 5, 0, -7 },
  { 109, 4, 7, 6, 1, -7 },
  { 113, 4, 7, 5, 1, -7 },
  { 117, 5, 7, 6, 1, -7 },
  { 122, 3, 7, 5, 1, -7 },
  { 125, 3, 7, 4, 1, -7 },
  { 128, 5, 7, 7, 1, -7 },
  { 133, 4, 7, 6, 1, -7 },
  { 137, 2, 7, 3, 0, -7 },
  { 139, 2, 9, 2, -1, -7 },
  { 142, 4, 7, 5, 1, -7 },
  { 146, 3, 7, 5, 1, -7 },
  { 149, 6, 7, 8, 1, -7 },
  { 155, 4, 7, 6, 1, -7 },
  { 159, 5, 7, 7, 1, -7 },
  { 164, 4, 7, 5, 1, -7 },
  { 168, 5, 9, 7, 1, -7 },
  { 174, 4, 7, 5, 1, -7 },
  { 178, 4, 7, 5, 0, -7 },
  { 182, 4, 7, 5, 0, -7 },
  { 186, 4, 7, 6, 1, -7 },
  { 190, 5, 7, 5, 0, -7 },
  { 195, 8, 7, 8, 0, -7 },
  { 202, 5, 7, 5, 0, -7 },
  { 207, 4, 7, 4, 0, -7 },
  { 211, 5, 7, 5, 0, -7 },
  { 216, 2, 9, 3, 1, -7 },
  { 219, 3, 7, 3, 0, -7 },
  { 222, 2, 9, 3, 0, -7 },
  { 225, 5, 4, 5, 0, -7 },
  { 228, 4, 1, 4, 0, 1 },
  { 229, 2, 2, 2, 0, -8 },
  { 230, 4, 5, 5, 0, -5 },
  { 233, 4, 8, 5, 1, -8 },
  { 237, 3, 5, 4, 1, -5 },
  { 239, 4, 8, 5, 1, -8 },
  { 243, 3, 5, 5, 1, -5 },
  { 245, 3, 8, 3, 0, -8 },
  { 248, 3, 7, 5, 1, -5 },
  { 251, 3, 8, 5, 1, -8 },
  { 254, 1, 7, 2, 1, -7 },
  { 255, 1, 9, 2, 0, -7 },
  { 257, 3, 8, 4, 1, -8 },
  { 260, 1, 8, 2, 1, -8 },
  { 261, 6, 5, 8, 1, -5 },
  { 265, 3, 5, 5, 1, -5 },
  { 267, 4, 5, 5, 1, -5 },
  { 270, 4, 7, 5, 1, -5 },
  { 274, 3, 7, 5, 1, -5 },
  { 277, 2, 5, 3, 1, -5 },
  { 279, 4, 5, 4, 0, -5 },
  { 282, 3, 7, 3, 0, -7 },
  { 285, 3, 5, 5, 1, -5 },
  { 287, 4, 5, 4, 0, -5 },
  { 290, 6, 5, 6, 0, -5 },
  { 294, 4, 5, 4, 0, -5 },
  { 297, 4, 7, 4, 0, -5 },
  { 301, 4, 5, 4, 0, -5 },
  { 304, 3, 9, 3, 0, -7 },
  { 308, 1, 10, 5, 2, -8 },
  { 310, 3, 9, 3, 0, -7 },
  { 314, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight10pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT10PT7B_H_
