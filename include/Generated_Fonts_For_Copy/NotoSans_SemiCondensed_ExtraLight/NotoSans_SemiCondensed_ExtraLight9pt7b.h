#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT9PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xC0, 0x33, 0xD5, 0xF5, 0x30, 0x6B, 0xA4, 0x33, 0xE2, 0x42,
  0xAB, 0x2F, 0x74, 0xD4, 0xC0, 0x22, 0x94, 0xCA, 0xCD, 0xE0, 0xC0, 0x6A,
  0xA4, 0xD5, 0x5C, 0x2B, 0x60, 0x2F, 0x22, 0xC0, 0xC0, 0x80, 0x29, 0x29,
  0x00, 0x25, 0x99, 0x99, 0x70, 0xD5, 0x50, 0x61, 0x11, 0x24, 0xF0, 0x69,
  0x16, 0x11, 0xF0, 0x22, 0x59, 0x71, 0xF3, 0x13, 0xC0, 0x72, 0x7B, 0x78,
  0xF1, 0x22, 0x24, 0x69, 0x96, 0x99, 0x70, 0x69, 0x99, 0x71, 0x60, 0x88,
  0x8C, 0x3C, 0x61, 0xFF, 0xE1, 0x2C, 0xC4, 0x94, 0x10, 0x7C, 0xB6, 0xAD,
  0x5B, 0xE8, 0x0E, 0x00, 0x23, 0x14, 0xE9, 0x44, 0xF9, 0xE9, 0x9E, 0x78,
  0x88, 0x88, 0xF0, 0xF9, 0x99, 0x9E, 0xF3, 0xC9, 0xC0, 0xF3, 0xC9, 0x00,
  0x78, 0x8A, 0x99, 0xF0, 0x99, 0xF9, 0x99, 0xD5, 0x70, 0x55, 0x57, 0xAC,
  0x8C, 0xA9, 0x92, 0x49, 0xC0, 0x8C, 0x67, 0xBD, 0xD4, 0x99, 0xDB, 0xB9,
  0x64, 0xA3, 0x18, 0xC7, 0xC0, 0xF6, 0xE9, 0x00, 0x64, 0xA3, 0x18, 0xC7,
  0x44, 0x10, 0xE9, 0xAC, 0xA9, 0x78, 0x86, 0x11, 0xF0, 0xF2, 0x22, 0x22,
  0x99, 0x99, 0x9F, 0x8C, 0x94, 0xA6, 0x10, 0x93, 0x25, 0xAB, 0x66, 0x48,
  0x80, 0x96, 0x26, 0x59, 0x96, 0x62, 0x22, 0xF2, 0x24, 0x4F, 0xEA, 0xAC,
  0x89, 0x22, 0x40, 0xD5, 0x5C, 0x65, 0x90, 0xF0, 0x90, 0x61, 0x79, 0xF0,
  0x93, 0xDB, 0x78, 0x78, 0x88, 0x60, 0x11, 0x79, 0x99, 0x70, 0x69, 0xF8,
  0x70, 0x6B, 0x24, 0x90, 0x79, 0x99, 0x71, 0xF0, 0x93, 0xDB, 0x68, 0xBE,
  0xBF, 0x80, 0x92, 0xE9, 0xA8, 0xFE, 0xDD, 0x6B, 0x5A, 0x80, 0xF6, 0xDA,
  0x79, 0x99, 0x70, 0xF6, 0xDF, 0x20, 0x79, 0x99, 0x71, 0x10, 0xEA, 0x80,
  0x71, 0x1E, 0xBA, 0x90, 0xB6, 0xDE, 0x9A, 0xA4, 0x40, 0xA6, 0x9B, 0x96,
  0x48, 0x96, 0x46, 0x90, 0x9A, 0xA4, 0x44, 0xC0, 0x65, 0x2E, 0x69, 0x44,
  0x98, 0xFF, 0x80, 0xC9, 0x14, 0xB0, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 1, 2, 3, 1, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 8, 5, 0, -7 },
  { 11, 6, 7, 7, 0, -7 },
  { 17, 5, 7, 5, 0, -7 },
  { 22, 1, 2, 2, 0, -6 },
  { 23, 2, 7, 2, 0, -6 },
  { 25, 2, 7, 2, 0, -6 },
  { 27, 4, 3, 4, 0, -7 },
  { 29, 4, 4, 5, 0, -5 },
  { 31, 1, 2, 2, 0, -1 },
  { 32, 2, 1, 3, 0, -3 },
  { 33, 1, 1, 2, 0, -1 },
  { 34, 3, 6, 3, 0, -6 },
  { 37, 4, 7, 5, 0, -7 },
  { 41, 2, 6, 5, 1, -6 },
  { 43, 4, 7, 5, 0, -7 },
  { 47, 4, 7, 5, 0, -7 },
  { 51, 4, 6, 5, 0, -6 },
  { 54, 3, 6, 5, 1, -6 },
  { 57, 3, 7, 5, 1, -7 },
  { 60, 4, 6, 5, 0, -6 },
  { 63, 4, 7, 5, 0, -7 },
  { 67, 4, 7, 5, 0, -7 },
  { 71, 1, 5, 2, 0, -5 },
  { 72, 1, 6, 2, 0, -5 },
  { 73, 4, 4, 5, 0, -5 },
  { 75, 4, 2, 5, 0, -4 },
  { 76, 4, 4, 5, 0, -5 },
  { 78, 3, 7, 3, 0, -7 },
  { 81, 7, 7, 7, 0, -6 },
  { 88, 5, 6, 5, 0, -6 },
  { 92, 4, 6, 5, 1, -6 },
  { 95, 4, 7, 5, 1, -7 },
  { 99, 4, 6, 6, 1, -6 },
  { 102, 3, 6, 4, 1, -6 },
  { 105, 3, 6, 4, 1, -6 },
  { 108, 4, 7, 6, 1, -7 },
  { 112, 4, 6, 6, 1, -6 },
  { 115, 2, 6, 2, 0, -6 },
  { 117, 2, 8, 2, -1, -6 },
  { 119, 4, 6, 5, 1, -6 },
  { 122, 3, 6, 4, 1, -6 },
  { 125, 5, 6, 7, 1, -6 },
  { 129, 4, 6, 6, 1, -6 },
  { 132, 5, 7, 6, 1, -7 },
  { 137, 3, 6, 5, 1, -6 },
  { 140, 5, 9, 6, 1, -7 },
  { 146, 4, 6, 5, 1, -6 },
  { 149, 4, 7, 4, 0, -7 },
  { 153, 4, 6, 4, 0, -6 },
  { 156, 4, 6, 6, 1, -6 },
  { 159, 5, 6, 5, 0, -6 },
  { 163, 7, 6, 7, 0, -6 },
  { 169, 4, 6, 4, 0, -6 },
  { 172, 4, 6, 4, 0, -6 },
  { 175, 4, 6, 4, 0, -6 },
  { 178, 2, 7, 3, 1, -6 },
  { 180, 3, 6, 3, 0, -6 },
  { 183, 2, 7, 3, 0, -6 },
  { 185, 4, 3, 5, 0, -6 },
  { 187, 4, 1, 4, 0, 0 },
  { 188, 2, 2, 2, 0, -7 },
  { 189, 4, 5, 4, 0, -5 },
  { 192, 3, 7, 5, 1, -7 },
  { 195, 4, 5, 4, 0, -5 },
  { 198, 4, 7, 5, 0, -7 },
  { 202, 4, 5, 4, 0, -5 },
  { 205, 3, 7, 2, 0, -7 },
  { 208, 4, 7, 5, 0, -5 },
  { 212, 3, 7, 5, 1, -7 },
  { 215, 1, 7, 2, 0, -7 },
  { 216, 1, 9, 2, 0, -7 },
  { 218, 3, 7, 4, 1, -7 },
  { 221, 1, 7, 2, 0, -7 },
  { 222, 5, 5, 7, 1, -5 },
  { 226, 3, 5, 5, 1, -5 },
  { 228, 4, 5, 5, 0, -5 },
  { 231, 3, 7, 5, 1, -5 },
  { 234, 4, 7, 5, 0, -5 },
  { 238, 2, 5, 3, 1, -5 },
  { 240, 3, 5, 4, 0, -5 },
  { 242, 2, 6, 3, 0, -6 },
  { 244, 3, 5, 5, 1, -5 },
  { 246, 4, 5, 4, 0, -5 },
  { 249, 6, 5, 6, 0, -5 },
  { 253, 4, 5, 4, 0, -5 },
  { 256, 4, 7, 4, 0, -5 },
  { 260, 3, 5, 4, 0, -5 },
  { 262, 3, 7, 3, 0, -6 },
  { 265, 1, 9, 4, 2, -7 },
  { 267, 3, 7, 3, 0, -6 },
  { 270, 4, 1, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight9pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT9PT7B_H_
