#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT63PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight63pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF4,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x60, 0x36, 0x03,
  0x60, 0x36, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x38, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x30, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x03, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0x63, 0xF8, 0x3C, 0x30,
  0x18, 0x38, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x0C, 0x03,
  0x00, 0x0E, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x01, 0xC0,
  0x30, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x0E,
  0x03, 0x00, 0x03, 0x81, 0x80, 0x00, 0xF0, 0xC0, 0x00, 0x3E, 0x60, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0x3E, 0x00, 0x01, 0x87, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x60,
  0x38, 0x00, 0x30, 0x0E, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x06,
  0x00, 0xE0, 0x03, 0x00, 0x70, 0x01, 0x80, 0x38, 0x00, 0xC0, 0x18, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x18, 0x07, 0x00, 0x0C, 0x07, 0x20,
  0x06, 0x07, 0x1F, 0x03, 0x0F, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x0E, 0x00, 0x79, 0xE0, 0x00, 0x18, 0x00, 0xC0, 0xE0,
  0x00, 0x60, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x01, 0xC0, 0x03, 0x00,
  0x1C, 0x01, 0x80, 0x06, 0x00, 0x30, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x01, 0x80, 0x0C, 0x01, 0x80,
  0x07, 0x00, 0x18, 0x07, 0x00, 0x0E, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x00,
  0x60, 0x38, 0x00, 0x38, 0x00, 0xC0, 0x60, 0x00, 0x70, 0x01, 0x81, 0xC0,
  0x00, 0xE0, 0x03, 0x03, 0x00, 0x01, 0xC0, 0x06, 0x0E, 0x00, 0x01, 0x80,
  0x0C, 0x18, 0x04, 0x03, 0x00, 0x38, 0x30, 0x7F, 0x06, 0x00, 0x70, 0xC1,
  0xEF, 0x0C, 0x00, 0xC1, 0x87, 0x07, 0x1C, 0x01, 0x86, 0x1C, 0x07, 0x18,
  0x07, 0x0C, 0x30, 0x06, 0x38, 0x0C, 0x30, 0xE0, 0x0C, 0x30, 0x38, 0x61,
  0x80, 0x1C, 0x7D, 0xE1, 0xC3, 0x00, 0x18, 0x7F, 0x83, 0x06, 0x00, 0x30,
  0x1C, 0x0E, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x00, 0x70,
  0x30, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x06,
  0x00, 0x06, 0x01, 0x80, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x18, 0x00, 0x30,
  0x06, 0x00, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x01, 0xC0,
  0x70, 0x03, 0x00, 0x01, 0xC1, 0xC0, 0x06, 0x00, 0x01, 0xEF, 0x00, 0x1C,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x60,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x38, 0xF0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00,
  0x07, 0x87, 0x00, 0x00, 0x07, 0x03, 0x80, 0x01, 0x87, 0x00, 0xE0, 0x01,
  0xC7, 0x00, 0x38, 0x00, 0xE3, 0x00, 0x0E, 0x00, 0x63, 0x80, 0x03, 0x80,
  0x31, 0x80, 0x00, 0xE0, 0x39, 0xC0, 0x00, 0x70, 0x18, 0xE0, 0x00, 0x1C,
  0x0C, 0x70, 0x00, 0x07, 0x0E, 0x38, 0x00, 0x01, 0xC6, 0x1C, 0x00, 0x00,
  0x77, 0x0E, 0x00, 0x00, 0x1F, 0x07, 0x00, 0x00, 0x0F, 0x01, 0x80, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x03, 0xB8, 0x1C, 0x00,
  0x03, 0x8E, 0x07, 0x00, 0x07, 0x83, 0x83, 0xE0, 0x0F, 0x81, 0xC0, 0x7F,
  0xFF, 0x00, 0x70, 0x1F, 0xFE, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xFF,
  0xFF, 0xDB, 0x6D, 0xB6, 0xDB, 0x00, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x30,
  0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x60,
  0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80,
  0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x70, 0x18, 0x0E, 0xFC,
  0x18, 0x3F, 0x1F, 0x99, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x66, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xC3, 0x00, 0x01,
  0x81, 0x80, 0x03, 0x81, 0xC0, 0x07, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0x70, 0x04, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x06, 0x1C, 0x38,
  0x60, 0xC3, 0x86, 0x0C, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0E, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x18, 0x18, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x70, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03,
  0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x70, 0x00, 0x18, 0x0C, 0x00,
  0x0E, 0x03, 0x80, 0x07, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x03,
  0xC0, 0x3E, 0x07, 0xF0, 0x7B, 0x87, 0x1C, 0x70, 0xEF, 0x07, 0xF0, 0x3E,
  0x01, 0xD0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x07, 0xC0, 0x1E, 0x07,
  0x80, 0x03, 0x81, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1C, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xC0, 0x0F, 0x0F,
  0x00, 0x03, 0xC3, 0x00, 0x00, 0xE1, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x20, 0x00,
  0x0F, 0x1E, 0x00, 0x1F, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x38, 0x01, 0x80, 0x01, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00,
  0x38, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x38,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x07, 0x00, 0x00, 0x60, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x73, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0x03, 0xF0, 0x20, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x80, 0x00, 0x78, 0xF0, 0x01, 0xF0,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x07, 0x80, 0x18, 0x3F, 0xFC, 0x0C,
  0x3F, 0x3F, 0x06, 0x38, 0x01, 0xC3, 0x30, 0x00, 0x71, 0xB0, 0x00, 0x1C,
  0xF0, 0x00, 0x06, 0x78, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x33, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0x70,
  0x00, 0x0C, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x03, 0x80, 0x07, 0x00,
  0xE0, 0x0F, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x70, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x70, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x03, 0x80,
  0x07, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x00, 0xF3, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xDF, 0x00, 0x03, 0xC1, 0xF0,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x38, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x39, 0x80, 0x00, 0x06, 0xE0,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x0E, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x3C,
  0x00, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0xE0, 0x00,
  0x1C, 0x70, 0x00, 0x06, 0x30, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x16,
  0x70, 0x00, 0x1B, 0x1C, 0x00, 0x19, 0x8F, 0x00, 0x38, 0xC3, 0xF1, 0xF8,
  0x60, 0x7F, 0xF0, 0x70, 0x07, 0xE0, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x6F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x40, 0x0C, 0x3C, 0x78,
  0xF1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x71, 0xC3, 0x87,
  0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x06, 0x1C, 0x30, 0x61, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xFC, 0x70, 0x03, 0xC8, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x3F, 0xF0, 0x03, 0x8E, 0x00, 0x1F, 0xFF,
  0x00, 0x31, 0x80, 0x07, 0x80, 0x60, 0x06, 0x30, 0x01, 0xC0, 0x0C, 0x00,
  0xCE, 0x00, 0x70, 0x01, 0x80, 0x1D, 0xC0, 0x0C, 0x00, 0x30, 0x01, 0xB0,
  0x03, 0x80, 0x06, 0x00, 0x36, 0x00, 0x60, 0x00, 0xC0, 0x06, 0xC0, 0x0C,
  0x00, 0x18, 0x00, 0xD8, 0x03, 0x80, 0x03, 0x00, 0x1F, 0x00, 0x60, 0x00,
  0x60, 0x03, 0xE0, 0x0C, 0x00, 0x0C, 0x00, 0x7C, 0x01, 0x80, 0x01, 0x80,
  0x0F, 0x80, 0x30, 0x00, 0x30, 0x01, 0xF0, 0x06, 0x00, 0x0E, 0x00, 0x3E,
  0x00, 0xC0, 0x01, 0xC0, 0x0F, 0xC0, 0x18, 0x00, 0x38, 0x01, 0xB8, 0x03,
  0x00, 0x07, 0x00, 0x33, 0x00, 0x70, 0x01, 0xE0, 0x06, 0x60, 0x06, 0x00,
  0x3C, 0x01, 0x8C, 0x00, 0xE0, 0x0D, 0x80, 0x31, 0x80, 0x0C, 0x03, 0x98,
  0x0C, 0x38, 0x01, 0xE0, 0xE3, 0x87, 0x83, 0x00, 0x1F, 0xF8, 0x3F, 0xE0,
  0x60, 0x00, 0xFC, 0x03, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x38, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x1C, 0x30, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x38, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x0C, 0x00, 0x3F, 0x83, 0x00, 0x00, 0xF0, 0xC0,
  0x00, 0x0E, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xC3,
  0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x03, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0x30,
  0x00, 0x0F, 0x0C, 0x00, 0x1F, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x01, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x01, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x30,
  0x01, 0xFE, 0x01, 0x80, 0x00, 0xF8, 0x0C, 0x00, 0x01, 0xE0, 0x60, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x0E, 0x18, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x1E, 0x06, 0x00, 0x03, 0xE0,
  0x30, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF6, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7C,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x03, 0x01, 0xE0,
  0x00, 0x03, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFC, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x7F, 0xFF, 0xFE, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x60, 0xF3, 0xFF, 0x1F, 0xF0, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x0E,
  0x0C, 0x00, 0x07, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x30, 0x00,
  0xE0, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x30,
  0x07, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x00, 0xC0, 0xF0, 0x00,
  0x30, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC7, 0xC0,
  0x00, 0x33, 0xB8, 0x00, 0x0C, 0xCE, 0x00, 0x03, 0x61, 0xC0, 0x00, 0xF8,
  0x38, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x00, 0x38, 0x00,
  0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x0E,
  0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0E, 0x03, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFD, 0x80, 0x00, 0x00, 0x0F, 0xEE, 0x00, 0x00, 0x00, 0x6F, 0x70,
  0x00, 0x00, 0x07, 0x79, 0x80, 0x00, 0x00, 0x33, 0xCE, 0x00, 0x00, 0x01,
  0x9E, 0x70, 0x00, 0x00, 0x1C, 0xF1, 0x80, 0x00, 0x00, 0xC7, 0x8E, 0x00,
  0x00, 0x06, 0x3C, 0x30, 0x00, 0x00, 0x71, 0xE1, 0x80, 0x00, 0x03, 0x0F,
  0x0E, 0x00, 0x00, 0x18, 0x78, 0x30, 0x00, 0x01, 0xC3, 0xC1, 0xC0, 0x00,
  0x0C, 0x1E, 0x0E, 0x00, 0x00, 0xE0, 0xF0, 0x30, 0x00, 0x06, 0x07, 0x81,
  0xC0, 0x00, 0x30, 0x3C, 0x0E, 0x00, 0x03, 0x81, 0xE0, 0x30, 0x00, 0x18,
  0x0F, 0x01, 0xC0, 0x00, 0xC0, 0x78, 0x06, 0x00, 0x0E, 0x03, 0xC0, 0x30,
  0x00, 0x60, 0x1E, 0x01, 0xC0, 0x03, 0x00, 0xF0, 0x06, 0x00, 0x38, 0x07,
  0x80, 0x38, 0x01, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x06, 0x00,
  0xC0, 0x0F, 0x00, 0x38, 0x06, 0x00, 0x78, 0x00, 0xC0, 0x70, 0x03, 0xC0,
  0x06, 0x03, 0x00, 0x1E, 0x00, 0x38, 0x18, 0x00, 0xF0, 0x00, 0xC1, 0xC0,
  0x07, 0x80, 0x06, 0x0C, 0x00, 0x3C, 0x00, 0x38, 0xE0, 0x01, 0xE0, 0x00,
  0xC7, 0x00, 0x0F, 0x00, 0x07, 0x30, 0x00, 0x78, 0x00, 0x3B, 0x80, 0x03,
  0xC0, 0x00, 0xD8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x3C, 0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x1C, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x06, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C,
  0x03, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0xC0, 0x0C,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x03,
  0xC0, 0x03, 0x80, 0x3C, 0x00, 0x18, 0x03, 0xC0, 0x01, 0xC0, 0x3C, 0x00,
  0x0C, 0x03, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70,
  0x3C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x18, 0x3C, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00,
  0x33, 0xC0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x0E, 0x18,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x34, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0x00, 0x3F,
  0x86, 0x00, 0x07, 0x8C, 0x00, 0x03, 0x98, 0x00, 0x03, 0xB0, 0x00, 0x03,
  0x60, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xEC, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x30, 0x00, 0x3C, 0x60, 0x03,
  0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x0E, 0x18,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xBF, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x0C, 0x00, 0xFF, 0x03, 0x00, 0x03,
  0xE0, 0xC0, 0x00, 0x3C, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x8C, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x3C, 0x0C,
  0x00, 0x3E, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x30, 0x03, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x00,
  0xE0, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x30,
  0x00, 0x18, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x38,
  0x30, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x0E, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC1, 0xF0, 0x01, 0xC1, 0xE0, 0x00, 0x21, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x20, 0x00, 0x0F, 0x1E, 0x00, 0x1F, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0xE0, 0x06, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x01,
  0xC0, 0x03, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x07,
  0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x1C, 0x30,
  0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x60,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x06, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0xE0, 0x00,
  0x0E, 0x30, 0x00, 0x07, 0x60, 0x00, 0x0E, 0x38, 0x00, 0x06, 0x60, 0x00,
  0x0C, 0x38, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x70, 0x00,
  0x1C, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x1C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x38, 0x00,
  0x38, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x0E, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x30, 0x06, 0x00, 0x18, 0x1C, 0x00,
  0x70, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x07, 0x00, 0x30, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x0E, 0x00,
  0xE0, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x03, 0x80, 0x60, 0x06, 0x00,
  0xC0, 0x03, 0x80, 0x60, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x07, 0x01,
  0xC0, 0x01, 0x80, 0xE0, 0x03, 0x01, 0xC0, 0x01, 0xC0, 0xC0, 0x03, 0x01,
  0x80, 0x01, 0xC0, 0xC0, 0x03, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x03, 0x83,
  0x80, 0x00, 0xC1, 0xC0, 0x01, 0x83, 0x80, 0x00, 0xE1, 0x80, 0x01, 0x83,
  0x00, 0x00, 0xE1, 0x80, 0x01, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x01, 0xC7,
  0x00, 0x00, 0x63, 0x80, 0x00, 0xC7, 0x00, 0x00, 0x73, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x73, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x33, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x37, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x1C, 0x03, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xE0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x70, 0x03, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0D,
  0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x18, 0x03, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x06, 0x03, 0x80, 0x00, 0x38, 0x18, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C,
  0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x70, 0x07, 0x00, 0x06, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x38, 0x01, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xC0, 0x38, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60, 0x70, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x1C, 0x01, 0x80, 0x01,
  0x80, 0x18, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x60, 0x06, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x38, 0x18, 0x00, 0x01, 0x83, 0x80, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x00, 0xFF, 0x00, 0x1F,
  0xFF, 0x01, 0xF8, 0x3E, 0x07, 0x00, 0x3C, 0x10, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x3F, 0x00, 0x71, 0xE0, 0x01,
  0xCE, 0x00, 0x07, 0x70, 0x00, 0x1D, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0x77, 0x00, 0x0C, 0xCE, 0x00, 0xE3,
  0x1F, 0xBF, 0x0C, 0x3F, 0xF0, 0x30, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x81, 0xFE, 0x01, 0xC3, 0xFF, 0xC0, 0xE3,
  0xE1, 0xF0, 0x73, 0x80, 0x1C, 0x3B, 0x00, 0x07, 0x1B, 0x00, 0x01, 0xCD,
  0x80, 0x00, 0x67, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x06,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0D, 0xC0,
  0x00, 0x0E, 0xF0, 0x00, 0x07, 0x78, 0x00, 0x03, 0x36, 0x00, 0x03, 0x9B,
  0x00, 0x03, 0x8C, 0xC0, 0x03, 0xC6, 0x38, 0x03, 0xC3, 0x0F, 0xFF, 0xC1,
  0x83, 0xFF, 0x80, 0x00, 0x2E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0xF0, 0x1F, 0x87, 0x81, 0xE0, 0x02, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x02, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0xFC, 0x06, 0x03, 0xFF, 0xC3, 0x03, 0xE0,
  0xF1, 0x83, 0x80, 0x1C, 0xC3, 0x80, 0x07, 0x63, 0x80, 0x01, 0xB3, 0x80,
  0x00, 0x79, 0xC0, 0x00, 0x3C, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x0E, 0xE0, 0x00,
  0x07, 0x30, 0x00, 0x03, 0x9C, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xE3, 0x80,
  0x01, 0xB0, 0xE0, 0x01, 0x98, 0x78, 0x01, 0xCC, 0x0F, 0xFF, 0x86, 0x03,
  0xFF, 0x83, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xE0,
  0x03, 0xE1, 0xF0, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x0C,
  0x18, 0x00, 0x0E, 0x38, 0x00, 0x06, 0x30, 0x00, 0x06, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x02, 0x07, 0x80, 0x0E, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0x81, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xF0, 0xC0, 0xF8, 0x3C, 0x60, 0xE0, 0x07, 0x30, 0xE0, 0x00,
  0xD8, 0xE0, 0x00, 0x6C, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x30, 0x00,
  0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x07,
  0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x58, 0xE0, 0x00, 0x6C, 0x38, 0x00, 0x66, 0x0E, 0x00,
  0xE3, 0x03, 0xFF, 0xE1, 0x80, 0xFF, 0xE0, 0xC0, 0x0F, 0x80, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE1, 0x80, 0x00, 0xE0, 0xFC, 0x03, 0xE0,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x1F, 0xC0, 0x70, 0xFF, 0xF0, 0xE3, 0xC1, 0xF1, 0xCE, 0x00, 0xF3, 0xB0,
  0x00, 0x67, 0xC0, 0x00, 0xED, 0x80, 0x00, 0xDE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0x5F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x80, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE8, 0x73, 0xFC, 0xFC, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0xB8, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x80,
  0x07, 0x0E, 0x00, 0x18, 0x38, 0x00, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x38,
  0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xE0, 0x38, 0x03, 0x81, 0xC0, 0x0E,
  0x0E, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x8F, 0x00, 0x0C, 0x6E,
  0x00, 0x33, 0x98, 0x00, 0xDC, 0x70, 0x03, 0x60, 0xE0, 0x0F, 0x03, 0x80,
  0x38, 0x07, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0x38, 0x0E, 0x00, 0x70, 0x38,
  0x00, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0xE0, 0x00, 0x63, 0x80, 0x01, 0xCE, 0x00, 0x03, 0xB8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x1F, 0x81, 0x87,
  0xFF, 0x01, 0xFF, 0xC3, 0x1E, 0x0F, 0x07, 0x83, 0xE6, 0x70, 0x07, 0x1C,
  0x01, 0xCC, 0xC0, 0x06, 0x70, 0x01, 0xDB, 0x00, 0x0E, 0xC0, 0x01, 0xBC,
  0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0x00, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00,
  0x0F, 0x80, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0x80, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x0E, 0x00,
  0x01, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xC0,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x7F, 0x81, 0x83, 0xFF, 0xC3, 0x0F, 0x07,
  0xC6, 0x38, 0x03, 0xCC, 0xC0, 0x01, 0xDB, 0x00, 0x03, 0xB4, 0x00, 0x03,
  0x78, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0C, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x3E, 0x0F, 0x80, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07,
  0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x0C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x60, 0xFF, 0xF0, 0x30, 0xF8, 0x7C, 0x18, 0xE0, 0x07,
  0x0C, 0xE0, 0x01, 0xC6, 0x60, 0x00, 0x73, 0x60, 0x00, 0x19, 0xA0, 0x00,
  0x0E, 0xF0, 0x00, 0x07, 0x78, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x78, 0x00, 0x01, 0xBC, 0x00, 0x01,
  0xDA, 0x00, 0x00, 0xCD, 0x80, 0x00, 0xE7, 0x60, 0x00, 0xE3, 0xB8, 0x00,
  0xF1, 0xCE, 0x00, 0xF0, 0xE3, 0xFF, 0xF0, 0x70, 0x7F, 0xE0, 0x38, 0x07,
  0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0xF0, 0xC0, 0xF8, 0x7C, 0x60, 0xE0, 0x07, 0x30, 0xE0,
  0x01, 0xD8, 0xE0, 0x00, 0x6C, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x0F, 0x30,
  0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00,
  0x07, 0x60, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0xD8, 0xE0, 0x00, 0x6C, 0x38, 0x00, 0x66, 0x1E,
  0x00, 0xE3, 0x07, 0xFF, 0xE1, 0x80, 0xFF, 0xE0, 0xC0, 0x0F, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7E, 0xC1, 0xFF,
  0xC3, 0xEE, 0xC7, 0x00, 0xCC, 0x00, 0xD8, 0x00, 0xD8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xC3, 0xE0, 0x7C,
  0x38, 0x00, 0x63, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1B, 0x00,
  0x01, 0xDE, 0x00, 0x3C, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x70,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7B, 0x00, 0x01, 0xF7, 0x00, 0x06, 0x6F,
  0x00, 0x1C, 0xCF, 0x00, 0x71, 0x8F, 0xFF, 0xC3, 0x07, 0xFE, 0x06, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x01, 0x9C, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0x30, 0x00, 0x18, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x03, 0x00, 0x06,
  0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x30, 0x01, 0x80, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x70, 0x00, 0xE0,
  0x38, 0x00, 0x30, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x03,
  0x06, 0x00, 0x01, 0x87, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x31, 0x80, 0x00,
  0x18, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x19, 0x80, 0x00, 0xF0, 0x00,
  0x33, 0x00, 0x03, 0x60, 0x00, 0xE7, 0x00, 0x06, 0xC0, 0x01, 0x8E, 0x00,
  0x0D, 0x80, 0x03, 0x0C, 0x00, 0x3B, 0x80, 0x06, 0x18, 0x00, 0x63, 0x00,
  0x1C, 0x38, 0x00, 0xC6, 0x00, 0x30, 0x70, 0x03, 0x8E, 0x00, 0x60, 0x60,
  0x07, 0x1C, 0x00, 0xC0, 0xC0, 0x0C, 0x18, 0x03, 0x81, 0xC0, 0x18, 0x30,
  0x06, 0x03, 0x80, 0x70, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xC0, 0x70, 0x0E, 0x07, 0x01, 0xC0, 0xC0, 0x1C, 0x0E, 0x03,
  0x81, 0x80, 0x18, 0x18, 0x03, 0x03, 0x00, 0x30, 0x30, 0x06, 0x0E, 0x00,
  0x70, 0xE0, 0x0E, 0x18, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x00, 0xC3, 0x00,
  0x18, 0x60, 0x01, 0x8E, 0x00, 0x31, 0xC0, 0x03, 0x9C, 0x00, 0x73, 0x00,
  0x03, 0x30, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x0D, 0xC0,
  0x01, 0xB8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x06, 0x00, 0x07,
  0x03, 0x80, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x30, 0x01, 0x80, 0x1C, 0x01,
  0xC0, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x30,
  0x60, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x70, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x0C, 0x00,
  0x07, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x0E, 0x01, 0x80, 0x07, 0x01, 0xC0, 0x01, 0xC1, 0xC0, 0x00,
  0x60, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x71, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x38, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x0C, 0x06, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03,
  0x00, 0x60, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0xE0, 0x03, 0x80, 0x60, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x38, 0x00, 0x38,
  0x18, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x06, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x63, 0x80, 0x00, 0x31, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x06, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x04, 0x3C, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x3F,
  0x80, 0x1E, 0x00, 0x0F, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0xE0, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xF0, 0x07, 0xE0, 0x03,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x5F, 0xFE, 0x00, 0x1F, 0x03, 0xE0, 0x1F,
  0x00, 0x3F, 0xBE, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 46, 14, 5, -45 },
  { 24, 12, 16, 21, 4, -45 },
  { 48, 32, 45, 36, 2, -45 },
  { 228, 25, 52, 32, 3, -48 },
  { 391, 39, 47, 46, 3, -46 },
  { 621, 33, 47, 38, 3, -46 },
  { 815, 3, 16, 11, 4, -45 },
  { 821, 11, 55, 17, 3, -45 },
  { 897, 12, 55, 17, 2, -45 },
  { 980, 24, 23, 30, 3, -48 },
  { 1049, 26, 29, 32, 3, -37 },
  { 1144, 7, 15, 12, 2, -7 },
  { 1158, 15, 2, 19, 2, -18 },
  { 1162, 4, 5, 14, 5, -4 },
  { 1165, 19, 45, 21, 1, -45 },
  { 1272, 26, 47, 32, 3, -46 },
  { 1425, 13, 45, 32, 6, -45 },
  { 1499, 25, 46, 32, 3, -46 },
  { 1643, 25, 47, 32, 3, -46 },
  { 1790, 30, 45, 32, 1, -45 },
  { 1959, 24, 46, 32, 4, -45 },
  { 2097, 25, 47, 32, 4, -46 },
  { 2244, 26, 45, 32, 3, -45 },
  { 2391, 26, 47, 32, 3, -46 },
  { 2544, 25, 47, 32, 3, -46 },
  { 2691, 4, 35, 14, 5, -34 },
  { 2709, 7, 42, 13, 2, -34 },
  { 2746, 26, 28, 32, 3, -37 },
  { 2837, 26, 15, 32, 3, -30 },
  { 2886, 26, 28, 32, 3, -37 },
  { 2977, 19, 47, 23, 2, -46 },
  { 3089, 43, 51, 49, 3, -45 },
  { 3364, 33, 45, 33, 0, -45 },
  { 3550, 26, 45, 35, 6, -45 },
  { 3697, 29, 47, 34, 4, -46 },
  { 3868, 29, 45, 39, 6, -45 },
  { 4032, 21, 45, 31, 6, -45 },
  { 4151, 21, 45, 28, 6, -45 },
  { 4270, 32, 47, 41, 4, -46 },
  { 4458, 28, 45, 40, 6, -45 },
  { 4616, 11, 45, 17, 3, -45 },
  { 4678, 13, 56, 14, -5, -45 },
  { 4769, 26, 45, 32, 6, -45 },
  { 4916, 21, 45, 28, 6, -45 },
  { 5035, 37, 45, 49, 6, -45 },
  { 5244, 28, 45, 40, 6, -45 },
  { 5402, 35, 47, 42, 4, -46 },
  { 5608, 23, 45, 32, 6, -45 },
  { 5738, 35, 57, 42, 4, -46 },
  { 5988, 26, 45, 33, 6, -45 },
  { 6135, 25, 47, 31, 3, -46 },
  { 6282, 28, 45, 29, 0, -45 },
  { 6440, 30, 46, 40, 5, -45 },
  { 6613, 32, 45, 32, 0, -45 },
  { 6793, 48, 45, 50, 1, -45 },
  { 7063, 29, 45, 29, 0, -45 },
  { 7227, 28, 45, 28, 0, -45 },
  { 7385, 27, 45, 31, 2, -45 },
  { 7537, 13, 55, 20, 5, -45 },
  { 7627, 19, 45, 21, 1, -45 },
  { 7734, 12, 55, 20, 2, -45 },
  { 7817, 28, 26, 32, 2, -45 },
  { 7908, 25, 2, 25, 0, 6 },
  { 7915, 10, 10, 16, 3, -48 },
  { 7928, 22, 35, 29, 3, -34 },
  { 8025, 25, 49, 34, 5, -48 },
  { 8179, 22, 35, 26, 3, -34 },
  { 8276, 25, 49, 34, 3, -48 },
  { 8430, 24, 35, 31, 3, -34 },
  { 8535, 19, 48, 17, 1, -48 },
  { 8649, 25, 49, 33, 3, -34 },
  { 8803, 23, 48, 33, 5, -48 },
  { 8941, 3, 46, 13, 5, -46 },
  { 8959, 10, 61, 13, -2, -46 },
  { 9036, 22, 48, 27, 5, -48 },
  { 9168, 3, 48, 13, 5, -48 },
  { 9186, 39, 34, 49, 5, -34 },
  { 9352, 23, 34, 33, 5, -34 },
  { 9450, 26, 35, 33, 3, -34 },
  { 9564, 25, 49, 33, 5, -34 },
  { 9718, 25, 49, 33, 3, -34 },
  { 9872, 16, 34, 22, 5, -34 },
  { 9940, 21, 35, 26, 2, -34 },
  { 10032, 16, 42, 18, 1, -41 },
  { 10116, 23, 34, 33, 5, -33 },
  { 10214, 25, 33, 25, 0, -33 },
  { 10318, 39, 33, 40, 1, -33 },
  { 10479, 25, 33, 27, 1, -33 },
  { 10583, 25, 48, 25, 0, -33 },
  { 10733, 20, 33, 25, 2, -33 },
  { 10816, 17, 55, 22, 2, -45 },
  { 10933, 2, 64, 30, 14, -48 },
  { 10949, 17, 55, 22, 3, -45 },
  { 11066, 26, 6, 32, 3, -25 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight63pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT63PT7B_H_
