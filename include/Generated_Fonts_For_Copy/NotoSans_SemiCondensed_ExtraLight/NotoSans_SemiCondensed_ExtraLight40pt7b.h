#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT40PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight40pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x80, 0x01, 0x7E,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x00, 0x80,
  0x80, 0x04, 0x04, 0x00, 0x20, 0x20, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00,
  0xC0, 0x80, 0x04, 0x04, 0x00, 0x20, 0x20, 0x01, 0x01, 0x03, 0xFF, 0xFF,
  0xC0, 0xC0, 0xC0, 0x06, 0x04, 0x00, 0x20, 0x20, 0x01, 0x01, 0x00, 0x08,
  0x08, 0x00, 0x40, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x20, 0x01, 0x01, 0x01,
  0xFF, 0xFF, 0xC0, 0x40, 0x40, 0x02, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81,
  0x80, 0x08, 0x08, 0x00, 0x40, 0x40, 0x02, 0x02, 0x00, 0x10, 0x30, 0x01,
  0x81, 0x80, 0x00, 0x01, 0x00, 0x01, 0x00, 0x07, 0xF0, 0x1F, 0x7C, 0x31,
  0x04, 0x61, 0x00, 0xC1, 0x00, 0xC1, 0x00, 0xC1, 0x00, 0xC1, 0x00, 0xC1,
  0x00, 0x41, 0x00, 0x61, 0x00, 0x39, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x01, 0x38, 0x01, 0x0C, 0x01, 0x06, 0x01, 0x02, 0x01, 0x02, 0x01,
  0x03, 0x01, 0x02, 0x01, 0x02, 0x01, 0x06, 0x81, 0x0C, 0xF9, 0x78, 0x3F,
  0xE0, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x1E, 0x00, 0x30, 0x19, 0x80,
  0x10, 0x18, 0x60, 0x08, 0x08, 0x10, 0x0C, 0x04, 0x0C, 0x04, 0x06, 0x06,
  0x06, 0x03, 0x01, 0x02, 0x01, 0x80, 0x83, 0x00, 0xC0, 0x41, 0x00, 0x60,
  0x21, 0x80, 0x30, 0x10, 0x80, 0x18, 0x08, 0xC2, 0x0C, 0x0C, 0x47, 0xE2,
  0x06, 0x66, 0x11, 0x02, 0x22, 0x0C, 0xC3, 0x33, 0x02, 0x33, 0x11, 0x81,
  0x8F, 0x18, 0x80, 0xC0, 0x08, 0x40, 0x60, 0x0C, 0x20, 0x30, 0x04, 0x10,
  0x18, 0x02, 0x08, 0x0C, 0x03, 0x04, 0x06, 0x01, 0x02, 0x03, 0x01, 0x81,
  0x81, 0x80, 0x80, 0xC0, 0x80, 0xC0, 0x20, 0xC0, 0x40, 0x18, 0x40, 0x60,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0x7B, 0x80, 0x02, 0x06, 0x00, 0x30, 0x10,
  0x01, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x40, 0x30, 0x02, 0x01, 0x80, 0x18,
  0x08, 0x00, 0x40, 0xC0, 0x03, 0x0C, 0x00, 0x0C, 0xC0, 0x00, 0x2C, 0x00,
  0x01, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0x18, 0x00, 0x30, 0x60, 0x13, 0x01,
  0x81, 0x90, 0x0C, 0x0D, 0x80, 0x30, 0x4C, 0x00, 0xC6, 0x60, 0x03, 0x23,
  0x00, 0x0F, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x83, 0x00, 0x1E, 0x18, 0x01,
  0x98, 0x70, 0x38, 0x60, 0xFF, 0x01, 0x80, 0xFF, 0xE0, 0x02, 0x08, 0x30,
  0xC1, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x18, 0x30, 0x60, 0xC0, 0x81, 0x83, 0x02, 0x06, 0x0C,
  0x0C, 0x08, 0x18, 0x18, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x0C,
  0x04, 0x06, 0x06, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18,
  0x30, 0x20, 0xE0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x08, 0x10,
  0x3E, 0x23, 0xC7, 0xFC, 0x01, 0xC0, 0x02, 0x80, 0x0D, 0x80, 0x31, 0x80,
  0x41, 0x01, 0x83, 0x06, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x6D, 0xB4, 0xB4,
  0x80, 0xFF, 0xFF, 0xF0, 0x5F, 0x80, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x00, 0x03, 0xE0, 0x0F, 0x78, 0x18, 0x18, 0x30, 0x0C, 0x20, 0x06,
  0x60, 0x06, 0x60, 0x02, 0x40, 0x02, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x03, 0x60, 0x02,
  0x60, 0x06, 0x20, 0x06, 0x30, 0x04, 0x18, 0x0C, 0x0C, 0x38, 0x07, 0xF0,
  0x01, 0x07, 0x0F, 0x1B, 0x73, 0xE3, 0x83, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x0F, 0xC0, 0x3E, 0xF0, 0x60, 0x18, 0x40,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xFF, 0xFF, 0x0F, 0xE0, 0x3E, 0xF8, 0xE0, 0x1C, 0x80, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x38, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x80, 0x0C, 0xE0, 0x38, 0x7F,
  0xE0, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0A, 0x00, 0x03,
  0x40, 0x00, 0xC8, 0x00, 0x11, 0x00, 0x06, 0x20, 0x01, 0x84, 0x00, 0x20,
  0x80, 0x0C, 0x10, 0x01, 0x02, 0x00, 0x60, 0x40, 0x18, 0x08, 0x02, 0x01,
  0x00, 0xC0, 0x20, 0x30, 0x04, 0x04, 0x00, 0x81, 0x80, 0x10, 0x60, 0x02,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x7F, 0xF8,
  0xFF, 0xF1, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0F, 0xFC, 0x1E, 0x1E,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x1A, 0x00,
  0x66, 0x03, 0x87, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xEE, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0xC0, 0x47, 0xF8, 0xDC, 0x0C, 0xD0, 0x06, 0xE0,
  0x02, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40,
  0x01, 0x60, 0x01, 0x60, 0x03, 0x20, 0x03, 0x30, 0x06, 0x18, 0x06, 0x0C,
  0x1C, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x07, 0xE0, 0x1F, 0x78, 0x30, 0x0C, 0x20, 0x06, 0x60, 0x06, 0x60,
  0x02, 0x40, 0x02, 0x40, 0x02, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x18,
  0x18, 0x0E, 0x70, 0x03, 0xC0, 0x07, 0xE0, 0x0C, 0x38, 0x30, 0x0C, 0x60,
  0x06, 0x60, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x60, 0x02, 0x60, 0x06, 0x38, 0x1C, 0x0F, 0xF0, 0x07,
  0xC0, 0x1E, 0xF0, 0x30, 0x18, 0x60, 0x0C, 0x40, 0x04, 0xC0, 0x06, 0xC0,
  0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x40, 0x07, 0x60, 0x07, 0x30, 0x1B, 0x1C, 0x73, 0x0F, 0xE3, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x40, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x7E, 0x39, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x8C, 0x63, 0x11, 0x8C, 0x46, 0x00, 0x00, 0x01,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0x8F,
  0xBC, 0x80, 0x60, 0x03, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x38, 0x03,
  0x80, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x30,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x02, 0x60, 0x1F, 0xE0,
  0x6C, 0x06, 0x04, 0x0D, 0x01, 0x80, 0x80, 0xA0, 0x60, 0x10, 0x1C, 0x0C,
  0x02, 0x03, 0x81, 0x00, 0x40, 0x70, 0x20, 0x08, 0x0E, 0x0C, 0x03, 0x01,
  0xC1, 0x80, 0x60, 0x38, 0x30, 0x0C, 0x07, 0x02, 0x01, 0x81, 0xE0, 0x40,
  0x30, 0x2C, 0x0C, 0x0A, 0x04, 0x80, 0x83, 0x61, 0x90, 0x1F, 0xC7, 0xE3,
  0x00, 0x60, 0x30, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x03, 0x80, 0x00,
  0x14, 0x00, 0x00, 0xA0, 0x00, 0x0D, 0x80, 0x00, 0x4C, 0x00, 0x02, 0x20,
  0x00, 0x31, 0x80, 0x01, 0x0C, 0x00, 0x08, 0x20, 0x00, 0xC1, 0x80, 0x04,
  0x0C, 0x00, 0x20, 0x20, 0x03, 0x01, 0x80, 0x10, 0x0C, 0x00, 0x80, 0x20,
  0x0C, 0x01, 0x80, 0x7F, 0xFC, 0x02, 0x00, 0x20, 0x30, 0x01, 0x81, 0x00,
  0x0C, 0x08, 0x00, 0x20, 0xC0, 0x01, 0x84, 0x00, 0x0C, 0x20, 0x00, 0x23,
  0x00, 0x01, 0x90, 0x00, 0x0D, 0x80, 0x00, 0x2C, 0x00, 0x01, 0x80, 0xFE,
  0x00, 0xFF, 0xF0, 0x80, 0x1C, 0x80, 0x06, 0x80, 0x06, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x0C, 0x80,
  0x18, 0xFF, 0xF0, 0xFF, 0xF0, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x06, 0x80, 0x0C, 0x80, 0xF8, 0xFF, 0xE0, 0x00, 0x7F, 0x00,
  0x3F, 0xFC, 0x1C, 0x01, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x60, 0x1F, 0xFC, 0xFF, 0x00, 0x3F, 0xFC, 0x08, 0x03,
  0xC2, 0x00, 0x38, 0x80, 0x03, 0x20, 0x00, 0xC8, 0x00, 0x1A, 0x00, 0x02,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x1A, 0x00, 0x04,
  0x80, 0x03, 0x20, 0x01, 0x88, 0x01, 0xC2, 0x07, 0xC0, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x1F, 0xFF, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x0F, 0xDF, 0x81, 0xC0, 0x06, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x01, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x50,
  0x00, 0x02, 0x80, 0x00, 0x16, 0x00, 0x00, 0xB0, 0x00, 0x04, 0x80, 0x00,
  0x26, 0x00, 0x01, 0x18, 0x00, 0x08, 0x60, 0x00, 0x41, 0x80, 0x02, 0x07,
  0x80, 0xF0, 0x0F, 0xFE, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0xFF,
  0xFC, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8F,
  0xE0, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x8E,
  0xFC, 0x80, 0x03, 0x80, 0x06, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x18, 0x80,
  0x30, 0x80, 0x60, 0x80, 0xC0, 0x81, 0x80, 0x83, 0x00, 0x83, 0x00, 0x86,
  0x00, 0x8C, 0x00, 0x9C, 0x00, 0xB6, 0x00, 0xE3, 0x00, 0xC3, 0x00, 0x81,
  0x80, 0x80, 0x80, 0x80, 0xC0, 0x80, 0x60, 0x80, 0x20, 0x80, 0x30, 0x80,
  0x18, 0x80, 0x18, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x06, 0x80, 0x03, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFF, 0x80, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xA0, 0x00, 0x0F, 0xB0,
  0x00, 0x0B, 0xB0, 0x00, 0x1B, 0x90, 0x00, 0x1B, 0x98, 0x00, 0x13, 0x98,
  0x00, 0x33, 0x88, 0x00, 0x33, 0x8C, 0x00, 0x23, 0x8C, 0x00, 0x63, 0x84,
  0x00, 0x43, 0x86, 0x00, 0x43, 0x82, 0x00, 0xC3, 0x83, 0x00, 0x83, 0x83,
  0x01, 0x83, 0x81, 0x01, 0x83, 0x81, 0x81, 0x03, 0x81, 0x83, 0x03, 0x80,
  0x82, 0x03, 0x80, 0xC2, 0x03, 0x80, 0xC6, 0x03, 0x80, 0x44, 0x03, 0x80,
  0x6C, 0x03, 0x80, 0x2C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x18, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xB0,
  0x00, 0xE4, 0x00, 0x39, 0x80, 0x0E, 0x20, 0x03, 0x8C, 0x00, 0xE1, 0x80,
  0x38, 0x60, 0x0E, 0x0C, 0x03, 0x81, 0x00, 0xE0, 0x60, 0x38, 0x0C, 0x0E,
  0x03, 0x03, 0x80, 0x60, 0xE0, 0x08, 0x38, 0x03, 0x0E, 0x00, 0x43, 0x80,
  0x18, 0xE0, 0x03, 0x38, 0x00, 0xCE, 0x00, 0x1B, 0x80, 0x02, 0xE0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xBE, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x18, 0x18, 0x00, 0x30, 0xC0, 0x00,
  0x62, 0x00, 0x01, 0x98, 0x00, 0x02, 0x60, 0x00, 0x0D, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x50, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x50, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x32, 0x00, 0x00, 0x8C,
  0x00, 0x06, 0x10, 0x00, 0x10, 0x60, 0x00, 0xC0, 0xC0, 0x06, 0x01, 0xC0,
  0x70, 0x01, 0xFF, 0x00, 0xFC, 0x01, 0xFF, 0xC2, 0x00, 0xE4, 0x00, 0xE8,
  0x00, 0xD0, 0x00, 0xA0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x28, 0x00, 0xD0, 0x01, 0x20, 0x0E, 0x40, 0xF8, 0xFF, 0x81,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xBE, 0x00, 0x60, 0x0E, 0x03, 0x00, 0x18, 0x18, 0x00,
  0x30, 0xC0, 0x00, 0x62, 0x00, 0x01, 0x98, 0x00, 0x02, 0x60, 0x00, 0x0D,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x50, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x50, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x32,
  0x00, 0x00, 0x8C, 0x00, 0x06, 0x10, 0x00, 0x10, 0x60, 0x00, 0xC0, 0xC0,
  0x06, 0x01, 0xC0, 0x70, 0x01, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0xFC, 0x00, 0xFF, 0xE0, 0x80, 0x38, 0x80, 0x1C, 0x80, 0x0C,
  0x80, 0x04, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06,
  0x80, 0x04, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x70, 0xFF, 0xC0, 0x81, 0x80,
  0x80, 0xC0, 0x80, 0x40, 0x80, 0x60, 0x80, 0x20, 0x80, 0x30, 0x80, 0x18,
  0x80, 0x18, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x06, 0x80, 0x03,
  0x07, 0xF0, 0x1F, 0x7E, 0x30, 0x02, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0xE0, 0x38, 0x7F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x06, 0x80, 0x00, 0xD0, 0x00, 0x1B, 0x00,
  0x02, 0x60, 0x00, 0xC6, 0x00, 0x18, 0xE0, 0x06, 0x0F, 0x03, 0x80, 0x7F,
  0xC0, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x26, 0x00, 0x06, 0x60,
  0x00, 0x62, 0x00, 0x04, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x10, 0x00, 0x81,
  0x80, 0x08, 0x18, 0x01, 0x80, 0x80, 0x18, 0x08, 0x01, 0x00, 0xC0, 0x30,
  0x04, 0x03, 0x00, 0x40, 0x20, 0x06, 0x06, 0x00, 0x20, 0x60, 0x02, 0x04,
  0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x98, 0x00, 0x19,
  0x80, 0x00, 0x90, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30,
  0x00, 0xD0, 0x01, 0xC0, 0x03, 0x40, 0x07, 0x80, 0x09, 0x80, 0x16, 0x00,
  0x66, 0x00, 0x48, 0x01, 0x88, 0x03, 0x20, 0x06, 0x20, 0x0C, 0xC0, 0x10,
  0xC0, 0x23, 0x00, 0xC3, 0x00, 0x84, 0x03, 0x04, 0x06, 0x18, 0x08, 0x10,
  0x18, 0x60, 0x20, 0x60, 0x41, 0x81, 0x81, 0x81, 0x02, 0x06, 0x02, 0x0C,
  0x0C, 0x10, 0x08, 0x30, 0x30, 0x40, 0x30, 0x80, 0xC3, 0x00, 0xC2, 0x01,
  0x0C, 0x01, 0x18, 0x06, 0x20, 0x04, 0x60, 0x18, 0x80, 0x19, 0x00, 0x66,
  0x00, 0x64, 0x00, 0x98, 0x00, 0xB0, 0x02, 0x40, 0x02, 0xC0, 0x0D, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x01, 0x80, 0x01,
  0x80, 0x06, 0x00, 0x60, 0x00, 0xC8, 0x00, 0x63, 0x00, 0x18, 0x40, 0x0C,
  0x18, 0x03, 0x02, 0x01, 0x80, 0xC0, 0x40, 0x18, 0x30, 0x06, 0x08, 0x00,
  0xC6, 0x00, 0x31, 0x00, 0x06, 0xC0, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x01, 0xB0, 0x00, 0x4C, 0x00, 0x31, 0x80, 0x18, 0x60,
  0x06, 0x0C, 0x03, 0x01, 0x00, 0x80, 0x60, 0x60, 0x08, 0x10, 0x03, 0x0C,
  0x00, 0x46, 0x00, 0x19, 0x80, 0x02, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xF0,
  0x00, 0x26, 0x00, 0x19, 0x80, 0x06, 0x30, 0x03, 0x0C, 0x00, 0xC1, 0x80,
  0x60, 0x60, 0x18, 0x08, 0x04, 0x03, 0x03, 0x00, 0x40, 0x80, 0x18, 0x60,
  0x02, 0x10, 0x00, 0xCC, 0x00, 0x12, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFF, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30,
  0xFF, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0x00,
  0x40, 0x00, 0x38, 0x00, 0x0A, 0x00, 0x06, 0xC0, 0x01, 0x30, 0x00, 0xC6,
  0x00, 0x21, 0x80, 0x18, 0x20, 0x04, 0x0C, 0x03, 0x01, 0x00, 0x80, 0x60,
  0x60, 0x08, 0x10, 0x03, 0x0C, 0x00, 0x46, 0x00, 0x19, 0x80, 0x02, 0xC0,
  0x00, 0xC0, 0xFF, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x40, 0x03, 0x80,
  0x7F, 0x83, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x7F, 0xC7, 0x83, 0x70, 0x0D, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x7C, 0x01, 0xF0, 0x0B, 0x60, 0x6C, 0xFE,
  0x30, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x80, 0xCF, 0xF0, 0xD8, 0x1C, 0xD0,
  0x0C, 0xE0, 0x06, 0xE0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x06, 0xE0, 0x06, 0xF0, 0x0C, 0xD8, 0x38, 0xCF,
  0xF0, 0x00, 0x60, 0x1F, 0xF1, 0xC0, 0x8E, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x1C, 0x08, 0x1F, 0xE0, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x81, 0x0F, 0xF1,
  0x18, 0x19, 0x30, 0x0D, 0x20, 0x05, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x03, 0x60, 0x05, 0x30, 0x0D,
  0x18, 0x19, 0x0F, 0xF1, 0x00, 0x80, 0x1F, 0xE0, 0x60, 0x61, 0x80, 0x62,
  0x00, 0x4C, 0x00, 0xD0, 0x01, 0xA0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0xC0, 0xE0, 0xFF, 0x80, 0x00, 0x40,
  0x3F, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0xFF, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x80, 0x0F,
  0xF1, 0x18, 0x19, 0x30, 0x05, 0x20, 0x07, 0x60, 0x03, 0x40, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x03, 0x60, 0x07, 0x30,
  0x0F, 0x18, 0x1B, 0x0F, 0xF3, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x60, 0x1C, 0x3F, 0xF8, 0x03,
  0x80, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC1, 0x81, 0x9F, 0xE3, 0x60, 0x67, 0x80, 0x6E,
  0x00, 0x5C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xC0, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x30, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x1B, 0xE6, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x6C, 0x03, 0x30, 0x18, 0xC0, 0xC3, 0x02,
  0x0C, 0x18, 0x30, 0xC0, 0xC6, 0x03, 0x30, 0x0C, 0xE0, 0x34, 0x80, 0xF3,
  0x03, 0x86, 0x0C, 0x18, 0x30, 0x30, 0xC0, 0x43, 0x01, 0x8C, 0x03, 0x30,
  0x04, 0xC0, 0x1B, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0x80, 0x30, 0x67, 0xF0, 0xFF, 0x36, 0x0C, 0xC0, 0xDE, 0x03,
  0x40, 0x2E, 0x01, 0xC0, 0x1E, 0x00, 0x60, 0x0F, 0x00, 0x30, 0x07, 0x80,
  0x18, 0x01, 0xC0, 0x08, 0x00, 0xE0, 0x04, 0x00, 0x70, 0x02, 0x00, 0x38,
  0x01, 0x00, 0x1C, 0x00, 0x80, 0x0E, 0x00, 0x40, 0x07, 0x00, 0x20, 0x03,
  0x80, 0x10, 0x01, 0xC0, 0x08, 0x00, 0xE0, 0x04, 0x00, 0x70, 0x02, 0x00,
  0x38, 0x01, 0x00, 0x1C, 0x00, 0x80, 0x0E, 0x00, 0x40, 0x04, 0x01, 0x81,
  0x9F, 0xE3, 0x60, 0x66, 0x80, 0x6E, 0x00, 0x5C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xC0, 0x01, 0xC0, 0x07, 0xFC, 0x06, 0x03, 0x06, 0x00,
  0xC2, 0x00, 0x23, 0x00, 0x19, 0x00, 0x0D, 0x80, 0x02, 0xC0, 0x01, 0x60,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0B, 0x00, 0x04,
  0x80, 0x02, 0x40, 0x03, 0x30, 0x01, 0x88, 0x01, 0x86, 0x00, 0x81, 0xC1,
  0xC0, 0x3F, 0x80, 0x01, 0x80, 0xC7, 0xF0, 0xD8, 0x1C, 0xD0, 0x0C, 0xE0,
  0x06, 0xE0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x06, 0xE0, 0x06, 0xD0, 0x0C, 0xDC, 0x18, 0xC7, 0xF0, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x0F, 0xF1, 0x18, 0x19, 0x30,
  0x0D, 0x60, 0x07, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x40, 0x03, 0x60, 0x07, 0x60, 0x07, 0x30, 0x0F, 0x18, 0x1B, 0x0F,
  0xE3, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x01, 0x33, 0xFD, 0x83, 0x40,
  0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x02,
  0x01, 0xFF, 0x98, 0x05, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x40,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x05, 0x00, 0x6C, 0x06, 0x7F, 0xE0, 0x10,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x3F, 0xF3, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x03, 0xF0, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0E, 0x80, 0x1D, 0x80, 0x59, 0x83, 0x31, 0xFC, 0x60,
  0xC0, 0x03, 0x40, 0x02, 0x60, 0x06, 0x60, 0x06, 0x20, 0x04, 0x30, 0x0C,
  0x30, 0x0C, 0x10, 0x08, 0x18, 0x18, 0x18, 0x18, 0x08, 0x10, 0x08, 0x30,
  0x0C, 0x30, 0x04, 0x20, 0x04, 0x60, 0x06, 0x60, 0x02, 0x40, 0x02, 0xC0,
  0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x80, 0x18, 0x03, 0xC0, 0x18, 0x03,
  0xC0, 0x3C, 0x02, 0xC0, 0x3C, 0x02, 0x40, 0x24, 0x06, 0x60, 0x24, 0x06,
  0x60, 0x66, 0x04, 0x20, 0x66, 0x04, 0x20, 0x42, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x08, 0x10, 0x81, 0x08, 0x10, 0x81, 0x18, 0x19, 0x81, 0x98,
  0x19, 0x81, 0x90, 0x09, 0x00, 0x90, 0x0B, 0x00, 0xB0, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xC0, 0x06, 0xC0,
  0x18, 0xC0, 0x61, 0x80, 0xC1, 0x83, 0x01, 0x04, 0x03, 0x18, 0x03, 0x60,
  0x02, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x14, 0x00, 0x6C, 0x01, 0x8C, 0x03,
  0x08, 0x0C, 0x18, 0x10, 0x10, 0x60, 0x31, 0x80, 0x33, 0x00, 0x2C, 0x00,
  0x60, 0xC0, 0x03, 0x40, 0x02, 0x60, 0x02, 0x20, 0x06, 0x20, 0x04, 0x30,
  0x04, 0x10, 0x0C, 0x10, 0x08, 0x18, 0x08, 0x08, 0x18, 0x08, 0x10, 0x0C,
  0x10, 0x04, 0x30, 0x04, 0x20, 0x06, 0x20, 0x02, 0x60, 0x02, 0x40, 0x03,
  0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xF8,
  0x00, 0x70, 0x00, 0x7F, 0xF8, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0F,
  0xFF, 0x80, 0x00, 0x20, 0x3C, 0x0C, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60,
  0x18, 0x1E, 0x03, 0xE0, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x01, 0x80,
  0x30, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x18, 0x06, 0x00, 0x70, 0x3C, 0x18, 0x06, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x0E, 0x0F, 0x00, 0x3E, 0x00, 0xF3, 0xC0, 0xE0, 0x3F, 0xD0, 0x03,
  0x80,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 29, 9, 3, -29 },
  { 12, 7, 11, 13, 3, -29 },
  { 22, 21, 29, 23, 1, -29 },
  { 99, 16, 32, 20, 2, -30 },
  { 163, 25, 29, 29, 2, -29 },
  { 254, 21, 29, 24, 2, -29 },
  { 331, 1, 11, 7, 3, -29 },
  { 333, 7, 35, 11, 2, -29 },
  { 364, 8, 35, 11, 1, -29 },
  { 399, 15, 14, 19, 2, -30 },
  { 426, 17, 18, 20, 2, -23 },
  { 465, 3, 9, 8, 2, -4 },
  { 469, 10, 2, 12, 1, -12 },
  { 472, 3, 3, 9, 3, -3 },
  { 474, 12, 29, 13, 1, -29 },
  { 518, 16, 29, 20, 2, -29 },
  { 576, 8, 29, 20, 4, -29 },
  { 605, 16, 29, 20, 2, -29 },
  { 663, 16, 29, 20, 2, -29 },
  { 721, 19, 29, 20, 1, -29 },
  { 790, 15, 29, 20, 3, -29 },
  { 845, 16, 29, 20, 2, -29 },
  { 903, 16, 29, 20, 2, -29 },
  { 961, 16, 29, 20, 2, -29 },
  { 1019, 16, 29, 20, 2, -29 },
  { 1077, 3, 21, 9, 3, -21 },
  { 1085, 5, 26, 9, 1, -21 },
  { 1102, 17, 17, 20, 2, -23 },
  { 1139, 17, 10, 20, 2, -19 },
  { 1161, 17, 17, 20, 2, -23 },
  { 1198, 12, 29, 15, 1, -29 },
  { 1242, 27, 32, 31, 2, -28 },
  { 1350, 21, 29, 21, 0, -29 },
  { 1427, 16, 29, 22, 4, -29 },
  { 1485, 19, 29, 22, 2, -29 },
  { 1554, 18, 29, 25, 4, -29 },
  { 1620, 13, 29, 20, 4, -29 },
  { 1668, 13, 29, 18, 4, -29 },
  { 1716, 21, 29, 26, 2, -29 },
  { 1793, 18, 29, 25, 4, -29 },
  { 1859, 7, 29, 11, 2, -29 },
  { 1885, 8, 36, 9, -3, -29 },
  { 1921, 16, 29, 20, 4, -29 },
  { 1979, 13, 29, 18, 4, -29 },
  { 2027, 24, 29, 31, 4, -29 },
  { 2114, 18, 29, 26, 4, -29 },
  { 2180, 22, 29, 27, 2, -29 },
  { 2260, 15, 29, 21, 4, -29 },
  { 2315, 22, 36, 27, 2, -29 },
  { 2414, 16, 29, 21, 4, -29 },
  { 2472, 16, 29, 20, 2, -29 },
  { 2530, 18, 29, 18, 0, -29 },
  { 2596, 19, 29, 25, 3, -29 },
  { 2665, 20, 29, 20, 0, -29 },
  { 2738, 30, 29, 32, 1, -29 },
  { 2847, 18, 29, 18, 0, -29 },
  { 2913, 18, 29, 18, 0, -29 },
  { 2979, 17, 29, 19, 1, -29 },
  { 3041, 8, 35, 13, 3, -29 },
  { 3076, 12, 29, 13, 1, -29 },
  { 3120, 8, 35, 13, 1, -29 },
  { 3155, 18, 17, 20, 1, -29 },
  { 3194, 16, 1, 16, 0, 4 },
  { 3196, 6, 7, 10, 2, -31 },
  { 3202, 14, 22, 19, 2, -22 },
  { 3241, 16, 30, 21, 3, -30 },
  { 3301, 14, 22, 17, 2, -22 },
  { 3340, 16, 30, 21, 2, -30 },
  { 3400, 15, 22, 19, 2, -22 },
  { 3442, 12, 31, 11, 0, -31 },
  { 3489, 16, 32, 21, 2, -22 },
  { 3553, 15, 30, 21, 3, -30 },
  { 3610, 2, 29, 8, 3, -29 },
  { 3618, 6, 39, 8, -1, -29 },
  { 3648, 14, 30, 17, 3, -30 },
  { 3701, 2, 30, 8, 3, -30 },
  { 3709, 25, 22, 31, 3, -22 },
  { 3778, 15, 22, 21, 3, -22 },
  { 3820, 17, 22, 21, 2, -22 },
  { 3867, 16, 31, 21, 3, -22 },
  { 3929, 16, 31, 21, 2, -22 },
  { 3991, 10, 22, 14, 3, -22 },
  { 4019, 13, 22, 16, 2, -22 },
  { 4055, 10, 26, 12, 1, -26 },
  { 4088, 15, 21, 21, 3, -21 },
  { 4128, 16, 21, 16, 0, -21 },
  { 4170, 24, 21, 26, 1, -21 },
  { 4233, 15, 21, 17, 1, -21 },
  { 4273, 16, 31, 16, 0, -21 },
  { 4335, 13, 21, 16, 1, -21 },
  { 4370, 11, 35, 14, 1, -29 },
  { 4419, 1, 40, 19, 9, -30 },
  { 4424, 10, 35, 14, 2, -29 },
  { 4468, 17, 4, 20, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight40pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT40PT7B_H_
