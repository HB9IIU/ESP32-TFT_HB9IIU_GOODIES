#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT49PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF6, 0xDB, 0x6C, 0x92, 0x49, 0x24, 0x92, 0x48, 0x00,
  0x00, 0xFF, 0x80, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x40, 0xD0, 0x34, 0x0D,
  0x02, 0x40, 0x90, 0x24, 0x09, 0x02, 0x40, 0x80, 0x00, 0x30, 0x08, 0x00,
  0x08, 0x06, 0x00, 0x02, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18,
  0x00, 0x18, 0x04, 0x00, 0x06, 0x01, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x40,
  0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xC0, 0x20, 0x00, 0x30, 0x08, 0x00, 0x08, 0x06, 0x00, 0x06, 0x01, 0x80,
  0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x04, 0x00, 0x06, 0x01,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0x03, 0x00, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x20, 0x18, 0x00,
  0x08, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x10,
  0x00, 0x18, 0x04, 0x00, 0x04, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x1F,
  0xFF, 0x8C, 0x30, 0x66, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30,
  0x08, 0x0C, 0x02, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0E, 0x0C, 0x01,
  0x83, 0x00, 0x38, 0xC0, 0x07, 0xB0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x33, 0x80, 0x0C, 0x38, 0x03, 0x06, 0x00, 0xC0, 0xC0, 0x30,
  0x30, 0x0C, 0x04, 0x03, 0x01, 0x00, 0xC0, 0x40, 0x30, 0x30, 0x0C, 0x0C,
  0x03, 0x07, 0x80, 0xC3, 0xB8, 0x31, 0xCF, 0xFF, 0xE0, 0x7F, 0xC0, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x1F, 0x80, 0x03, 0x00,
  0xC7, 0x00, 0x18, 0x06, 0x0C, 0x00, 0x60, 0x10, 0x18, 0x03, 0x00, 0xC0,
  0x60, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x01, 0x80, 0x20, 0x0C,
  0x04, 0x00, 0x80, 0x30, 0x30, 0x02, 0x00, 0xC0, 0x80, 0x08, 0x03, 0x06,
  0x00, 0x20, 0x0C, 0x10, 0x00, 0x80, 0x30, 0xC0, 0x02, 0x00, 0xC3, 0x00,
  0x0C, 0x03, 0x18, 0x7E, 0x30, 0x08, 0x63, 0x1C, 0xC0, 0x63, 0x18, 0x11,
  0x01, 0x8C, 0x40, 0x66, 0x0C, 0x63, 0x01, 0x8C, 0x71, 0x8C, 0x02, 0x1F,
  0x8C, 0x30, 0x0C, 0x00, 0x30, 0x80, 0x30, 0x01, 0x82, 0x00, 0xC0, 0x06,
  0x08, 0x03, 0x00, 0x10, 0x20, 0x0C, 0x00, 0xC0, 0x80, 0x30, 0x02, 0x02,
  0x00, 0xC0, 0x18, 0x08, 0x03, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x20, 0x08, 0x03, 0x01, 0x80, 0x60, 0x04, 0x06, 0x01, 0x80, 0x18, 0x30,
  0x0C, 0x00, 0x31, 0xC0, 0x30, 0x00, 0x7E, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x38, 0x70, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x01, 0x80,
  0x03, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x02, 0x00, 0x0C, 0x01,
  0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x10, 0x06, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x77, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x18, 0x18, 0x01, 0x8C, 0x03, 0x00, 0x63, 0x00, 0x60, 0x19, 0x80,
  0x0C, 0x04, 0x60, 0x03, 0x83, 0x10, 0x00, 0x70, 0xCC, 0x00, 0x0C, 0x63,
  0x00, 0x01, 0x98, 0xC0, 0x00, 0x3C, 0x18, 0x00, 0x07, 0x06, 0x00, 0x03,
  0xC1, 0x80, 0x00, 0xF8, 0x30, 0x00, 0xE6, 0x0E, 0x00, 0x70, 0xC1, 0xF0,
  0xF8, 0x18, 0x1F, 0xF8, 0x03, 0xFF, 0x55, 0x55, 0x40, 0x01, 0x81, 0x81,
  0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0E,
  0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0xC0, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03,
  0x01, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x0E, 0x08, 0x1B, 0xF2, 0x3F, 0x0F, 0xF8, 0x00, 0x30, 0x00, 0x14, 0x00,
  0x0C, 0x80, 0x06, 0x30, 0x01, 0x06, 0x00, 0xC1, 0xC0, 0x60, 0x30, 0x38,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x39, 0x8C, 0x63, 0x31, 0x8C, 0x46, 0x30, 0xFF, 0xFF,
  0xFC, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0xFF, 0x80, 0x3C, 0x78, 0x0E, 0x03, 0x83, 0x80, 0x38, 0x60, 0x03, 0x18,
  0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xC8, 0x00, 0x1B, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xA0, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x21, 0x80,
  0x0C, 0x18, 0x03, 0x03, 0x80, 0xE0, 0x3C, 0x78, 0x01, 0xFC, 0x00, 0x00,
  0xE0, 0x3C, 0x0D, 0x83, 0x31, 0xC6, 0x70, 0xFC, 0x1A, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x07, 0xFC, 0x01, 0xE1, 0xF0, 0x78, 0x03, 0x82, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xE0, 0xF0, 0xF0, 0x03, 0x84,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x07, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0xC0, 0x03, 0x8F, 0xC1, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0x98, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61,
  0x80, 0x01, 0x83, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x30, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x30, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1B, 0xFE,
  0x03, 0xFF, 0xF0, 0x20, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0xC0, 0x07, 0x1F, 0x03, 0xC0, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x7C, 0x10, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x30, 0xFF,
  0x86, 0x70, 0x38, 0xD8, 0x01, 0x9E, 0x00, 0x1B, 0x80, 0x03, 0x70, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0D, 0x00, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00,
  0xCC, 0x00, 0x31, 0xC0, 0x0E, 0x1C, 0x03, 0x81, 0xE1, 0xE0, 0x0F, 0xF0,
  0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xE3, 0xE0,
  0xE0, 0x0E, 0x18, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x01, 0x90, 0x00, 0x32,
  0x00, 0x06, 0x40, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x38, 0x00, 0xC3,
  0x80, 0x38, 0x38, 0x0E, 0x03, 0x87, 0x00, 0x1D, 0xC0, 0x01, 0xE0, 0x00,
  0xF7, 0x00, 0x38, 0x38, 0x1C, 0x03, 0x83, 0x00, 0x18, 0xC0, 0x01, 0xB0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x33, 0x00, 0x0E, 0x30,
  0x03, 0x83, 0xC1, 0xE0, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0xF0, 0xF0,
  0x1C, 0x03, 0x83, 0x80, 0x18, 0x30, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00,
  0x66, 0x00, 0x06, 0x40, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x76, 0x00, 0x07, 0x60,
  0x00, 0xF3, 0x00, 0x0B, 0x18, 0x03, 0xB1, 0xE0, 0x73, 0x07, 0xFC, 0x30,
  0x0E, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x03, 0x07, 0xC0, 0x3F, 0xF0, 0x00, 0x60,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x39,
  0xCE, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0xC6, 0x31, 0x98, 0xC6, 0x23, 0x18, 0x00, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xF1, 0xF0, 0xF1, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x38, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x01, 0x18, 0x00, 0xFF, 0x00, 0xCC, 0x00,
  0xFF, 0xC0, 0x66, 0x01, 0xC0, 0x60, 0x16, 0x00, 0xC0, 0x30, 0x0F, 0x00,
  0xC0, 0x18, 0x07, 0x80, 0x40, 0x0C, 0x03, 0xC0, 0x60, 0x06, 0x01, 0xE0,
  0x30, 0x03, 0x00, 0xE0, 0x18, 0x01, 0x80, 0x70, 0x08, 0x00, 0xC0, 0x38,
  0x04, 0x00, 0x60, 0x1C, 0x02, 0x00, 0x30, 0x0E, 0x01, 0x00, 0x30, 0x05,
  0x00, 0xC0, 0x18, 0x06, 0xC0, 0x60, 0x0E, 0x03, 0x60, 0x30, 0x0F, 0x01,
  0xB0, 0x0C, 0x04, 0x81, 0x98, 0x07, 0x0E, 0x61, 0x84, 0x01, 0xFE, 0x1F,
  0x83, 0x00, 0x38, 0x03, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x10, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x03,
  0x20, 0x00, 0x01, 0x98, 0x00, 0x00, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x18, 0x00,
  0x08, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x02, 0x00, 0xC0,
  0x03, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x01, 0x83, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x80, 0x00, 0x0C, 0xC0,
  0x00, 0x06, 0x60, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x60,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x80, 0x07, 0x88, 0x00, 0x1C, 0x80, 0x00,
  0xC8, 0x00, 0x0C, 0x80, 0x00, 0x68, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00,
  0x06, 0x80, 0x00, 0x68, 0x00, 0x0C, 0x80, 0x00, 0xC8, 0x00, 0x18, 0x80,
  0x03, 0x88, 0x01, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x80, 0x03, 0x88,
  0x00, 0x0C, 0x80, 0x00, 0x68, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x68, 0x00, 0x06, 0x80, 0x00, 0xC8, 0x00, 0x1C, 0x80, 0x07, 0x8F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x07, 0xE1, 0xF0, 0x38, 0x00,
  0x41, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x04, 0x07,
  0xC1, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x08, 0x00,
  0xF8, 0x20, 0x00, 0x70, 0x80, 0x00, 0xE2, 0x00, 0x01, 0xC8, 0x00, 0x03,
  0x20, 0x00, 0x0E, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x68, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x68, 0x00, 0x01, 0xA0, 0x00, 0x0C, 0x80, 0x00,
  0x32, 0x00, 0x01, 0x88, 0x00, 0x0E, 0x20, 0x00, 0xF0, 0x80, 0x0F, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xFF, 0xFE, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3E, 0x0F, 0xE0,
  0x78, 0x00, 0x70, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x58,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x13, 0x00, 0x00, 0x09, 0xC0, 0x00, 0x04,
  0x60, 0x00, 0x02, 0x18, 0x00, 0x01, 0x07, 0x00, 0x00, 0x81, 0xC0, 0x00,
  0xC0, 0x7F, 0x0F, 0xE0, 0x0F, 0xFF, 0xC0, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0xFF, 0x9F, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x3F, 0xE0,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x01, 0xD0, 0x73, 0xFC, 0x3E,
  0x00, 0x80, 0x00, 0x68, 0x00, 0x0C, 0x80, 0x01, 0x88, 0x00, 0x38, 0x80,
  0x07, 0x08, 0x00, 0xE0, 0x80, 0x0C, 0x08, 0x01, 0x80, 0x80, 0x30, 0x08,
  0x06, 0x00, 0x80, 0xE0, 0x08, 0x1C, 0x00, 0x83, 0x80, 0x08, 0x30, 0x00,
  0x86, 0x00, 0x08, 0xE0, 0x00, 0x9B, 0x00, 0x0B, 0xB8, 0x00, 0xB1, 0x80,
  0x0E, 0x0C, 0x00, 0xC0, 0xC0, 0x08, 0x06, 0x00, 0x80, 0x70, 0x08, 0x03,
  0x00, 0x80, 0x18, 0x08, 0x01, 0xC0, 0x80, 0x0C, 0x08, 0x00, 0x60, 0x80,
  0x07, 0x08, 0x00, 0x30, 0x80, 0x01, 0x88, 0x00, 0x1C, 0x80, 0x00, 0xC8,
  0x00, 0x06, 0x80, 0x00, 0x70, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x60, 0x00, 0x00, 0xFB, 0x00, 0x00, 0x0D, 0xD8, 0x00, 0x00,
  0x6E, 0x60, 0x00, 0x02, 0x73, 0x00, 0x00, 0x33, 0x88, 0x00, 0x01, 0x9C,
  0x60, 0x00, 0x08, 0xE3, 0x00, 0x00, 0xC7, 0x0C, 0x00, 0x06, 0x38, 0x60,
  0x00, 0x61, 0xC3, 0x00, 0x03, 0x0E, 0x0C, 0x00, 0x18, 0x70, 0x60, 0x01,
  0x83, 0x83, 0x00, 0x0C, 0x1C, 0x0C, 0x00, 0x40, 0xE0, 0x60, 0x06, 0x07,
  0x01, 0x80, 0x30, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x01,
  0x80, 0xC0, 0x70, 0x0C, 0x0C, 0x03, 0x80, 0x60, 0x60, 0x1C, 0x01, 0x83,
  0x00, 0xE0, 0x0C, 0x30, 0x07, 0x00, 0x61, 0x80, 0x38, 0x01, 0x88, 0x01,
  0xC0, 0x0C, 0xC0, 0x0E, 0x00, 0x36, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xB0, 0x00, 0x0E,
  0x60, 0x00, 0x39, 0x80, 0x00, 0xE3, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x18,
  0x00, 0x38, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x81, 0x80, 0x0E, 0x06, 0x00,
  0x38, 0x0C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x60, 0x0E, 0x00, 0xC0, 0x38,
  0x03, 0x00, 0xE0, 0x06, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x30, 0x38, 0x00,
  0x60, 0xE0, 0x01, 0x83, 0x80, 0x03, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x18,
  0xE0, 0x00, 0x73, 0x80, 0x00, 0xCE, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x38, 0x0E,
  0x00, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x87, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x08, 0x00, 0xE2, 0x00, 0x0C, 0x80, 0x01,
  0xA0, 0x00, 0x68, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x68, 0x00, 0x1A, 0x00,
  0x0E, 0x80, 0x03, 0x20, 0x03, 0x88, 0x1F, 0xC3, 0xFF, 0xC0, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x00,
  0xE0, 0x38, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x30,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x06, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0x87, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x80, 0x0F, 0x08, 0x00, 0x30, 0x80,
  0x01, 0x88, 0x00, 0x18, 0x80, 0x00, 0xC8, 0x00, 0x0C, 0x80, 0x00, 0xC8,
  0x00, 0x0C, 0x80, 0x00, 0xC8, 0x00, 0x0C, 0x80, 0x00, 0xC8, 0x00, 0x18,
  0x80, 0x01, 0x88, 0x00, 0x30, 0x80, 0x06, 0x08, 0x03, 0xC0, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x80, 0x70, 0x08, 0x03, 0x00, 0x80, 0x18, 0x08, 0x01,
  0x80, 0x80, 0x0C, 0x08, 0x00, 0xC0, 0x80, 0x06, 0x08, 0x00, 0x60, 0x80,
  0x03, 0x08, 0x00, 0x38, 0x80, 0x01, 0x88, 0x00, 0x1C, 0x80, 0x00, 0xC8,
  0x00, 0x06, 0x80, 0x00, 0x70, 0x03, 0xFF, 0x80, 0xF8, 0x7E, 0x1C, 0x00,
  0x43, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0xC0, 0x03, 0x8F, 0xE1, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x26, 0x00, 0x00, 0xCC, 0x00, 0x01,
  0x8C, 0x00, 0x06, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x1F, 0x07, 0xC0,
  0x0F, 0xFE, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x98, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x10, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00,
  0xC0, 0x18, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x61, 0x80,
  0x00, 0x10, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x68, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xD8, 0x00, 0x1C, 0x00, 0x06, 0xC0, 0x00, 0xA0, 0x00, 0x66,
  0x00, 0x0D, 0x80, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x18, 0xC0, 0x03, 0x60,
  0x00, 0xC6, 0x00, 0x1B, 0x00, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x61, 0x80,
  0x0C, 0x60, 0x03, 0x06, 0x00, 0x63, 0x00, 0x18, 0x30, 0x03, 0x08, 0x01,
  0x81, 0x80, 0x30, 0x60, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x60, 0x30, 0x0C,
  0x18, 0x03, 0x01, 0x80, 0x60, 0x40, 0x30, 0x0C, 0x02, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x18, 0x0C, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x0C, 0x0C, 0x02,
  0x06, 0x00, 0x60, 0x40, 0x18, 0x30, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x0C,
  0x30, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x10, 0xC0, 0x03, 0x08, 0x00, 0xC6,
  0x00, 0x18, 0xC0, 0x06, 0x30, 0x00, 0x66, 0x00, 0x31, 0x80, 0x03, 0x30,
  0x00, 0x98, 0x00, 0x19, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x36, 0x00,
  0x02, 0xC0, 0x01, 0xB0, 0x00, 0x1E, 0x00, 0x05, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x1C, 0xC0, 0x00, 0x61, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00,
  0x60, 0x30, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x01, 0x80,
  0x0C, 0x06, 0x00, 0x18, 0x30, 0x00, 0x61, 0xC0, 0x00, 0xC6, 0x00, 0x01,
  0xB0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1B, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x03,
  0x0C, 0x00, 0x0C, 0x70, 0x00, 0x19, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x0D, 0x80, 0x00, 0x66, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x30,
  0x00, 0x30, 0x60, 0x01, 0x81, 0x80, 0x06, 0x07, 0x00, 0x38, 0x0C, 0x00,
  0xC0, 0x30, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x03, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x00, 0xCC, 0x00, 0x03,
  0x30, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFC, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xB0, 0x00, 0x08, 0xC0,
  0x00, 0xC6, 0x00, 0x04, 0x18, 0x00, 0x60, 0xC0, 0x02, 0x03, 0x00, 0x30,
  0x18, 0x01, 0x00, 0x60, 0x18, 0x03, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x60,
  0xC0, 0x01, 0x86, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x00, 0x01, 0xB0, 0x00,
  0x07, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x07, 0xFC, 0x1F, 0x8F, 0x04, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x0F, 0xF0, 0x7F, 0xF8, 0xF0, 0x0C, 0xE0, 0x06,
  0xC0, 0x03, 0x60, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1D, 0x80, 0x1E, 0xE0, 0x19, 0x38, 0x38, 0x8F, 0xF8, 0x40,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x61, 0xFE, 0x0C, 0xF0, 0xF1, 0xB8, 0x07, 0x34, 0x00, 0x67,
  0x80, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x06, 0xE0, 0x00, 0xDE, 0x00, 0x33, 0x60, 0x0C, 0x67,
  0x07, 0x8C, 0x7F, 0xC0, 0x03, 0xFF, 0x0F, 0x87, 0x1C, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x0F, 0x07, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x83, 0xFC,
  0x30, 0xF0, 0xE6, 0x30, 0x06, 0xCC, 0x00, 0x7B, 0x80, 0x07, 0x60, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3B, 0x00, 0x07,
  0x60, 0x00, 0xE6, 0x00, 0x3C, 0xE0, 0x0D, 0x8F, 0x07, 0x30, 0x7F, 0x82,
  0x07, 0xF8, 0x03, 0xC7, 0x81, 0x80, 0x70, 0xC0, 0x0C, 0x70, 0x01, 0x98,
  0x00, 0x66, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x02, 0x0F, 0x07, 0x81, 0xFF, 0xC0, 0x01,
  0xFC, 0x1E, 0x10, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x07, 0xFC, 0x61, 0xE1, 0xCC, 0x60, 0x0D, 0x98,
  0x00, 0xF6, 0x00, 0x0E, 0xC0, 0x01, 0xD8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x76, 0x00, 0x0E, 0xC0, 0x01, 0xCC, 0x00, 0x59, 0xC0,
  0x1B, 0x1E, 0x0E, 0x60, 0xFF, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x39, 0x00, 0x0E, 0x38, 0x03, 0x83, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x0F, 0xF0, 0xCF, 0x1E, 0x36, 0x00, 0xCD, 0x00, 0x1B, 0xC0, 0x06, 0xE0,
  0x00, 0xB8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x5B,
  0xE0, 0x00, 0x03, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB,
  0x60, 0x01, 0x01, 0x80, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x70, 0x33, 0xF0, 0xF0, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0xEC, 0x00, 0xE6, 0x00,
  0x63, 0x00, 0x61, 0x80, 0x60, 0xC0, 0x60, 0x60, 0x70, 0x30, 0x30, 0x18,
  0x30, 0x0C, 0x30, 0x06, 0x30, 0x03, 0x1C, 0x01, 0x9E, 0x00, 0xD9, 0x80,
  0x78, 0xE0, 0x38, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x01, 0x83, 0x00,
  0x61, 0x80, 0x30, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x01, 0x98, 0x00, 0x6C,
  0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC7, 0xF8, 0x1F, 0xE3, 0x38, 0x70, 0xE3, 0xCD, 0x80, 0xE6, 0x01, 0xBC,
  0x01, 0xB0, 0x07, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x00,
  0x07, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0xC0, 0x03, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x0C,
  0x00, 0x10, 0xC3, 0xFC, 0x33, 0xC7, 0x8D, 0x80, 0x33, 0x40, 0x06, 0xE0,
  0x01, 0xB8, 0x00, 0x2E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x30, 0x07, 0xFC, 0x00, 0xF0, 0xF0, 0x18, 0x03, 0x83, 0x00, 0x1C, 0x70,
  0x00, 0xC6, 0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00,
  0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0C, 0x30, 0x01, 0x81, 0x80,
  0x38, 0x0F, 0x0F, 0x00, 0x7F, 0xC0, 0xC3, 0xFC, 0x18, 0xE1, 0xE3, 0x30,
  0x0E, 0x6C, 0x00, 0xCF, 0x00, 0x0D, 0xC0, 0x01, 0xB8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0D, 0xE0, 0x01, 0xB4, 0x00,
  0x66, 0xE0, 0x1C, 0xCF, 0x0F, 0x18, 0x7F, 0x83, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF8,
  0x61, 0xE3, 0xCC, 0x60, 0x0D, 0x98, 0x00, 0xB6, 0x00, 0x0E, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x76, 0x00, 0x0E,
  0xC0, 0x03, 0xCC, 0x00, 0x59, 0xC0, 0x1B, 0x1E, 0x0E, 0x60, 0xFF, 0x0C,
  0x02, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0xC3, 0xFC, 0xF7, 0xDC, 0x0D, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x0F, 0xFC, 0x3C, 0x1F, 0x70, 0x02, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x80, 0x0E, 0xF8, 0x3C, 0x7F, 0xF0, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x10, 0x7F, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xB6, 0x00,
  0x6D, 0xC0, 0x33, 0x3C, 0x38, 0xC7, 0xFC, 0x30, 0xC0, 0x00, 0x6C, 0x00,
  0x0D, 0x80, 0x01, 0xB0, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00,
  0x60, 0x80, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x60, 0x20, 0x0C, 0x06, 0x01,
  0x80, 0xC0, 0x60, 0x08, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x60, 0x02, 0x0C,
  0x00, 0x61, 0x80, 0x0C, 0x60, 0x00, 0x8C, 0x00, 0x19, 0x00, 0x03, 0x60,
  0x00, 0x2C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xC0, 0x03,
  0x00, 0x0F, 0x00, 0x0C, 0x00, 0x2C, 0x00, 0x78, 0x01, 0x90, 0x01, 0xE0,
  0x06, 0x60, 0x05, 0x80, 0x19, 0x80, 0x32, 0x00, 0x46, 0x00, 0xCC, 0x03,
  0x0C, 0x03, 0x30, 0x0C, 0x30, 0x08, 0xC0, 0x30, 0xC0, 0x61, 0x80, 0x83,
  0x01, 0x86, 0x06, 0x06, 0x06, 0x18, 0x18, 0x18, 0x30, 0x20, 0x60, 0x60,
  0xC0, 0xC1, 0x01, 0x83, 0x03, 0x0C, 0x03, 0x08, 0x0C, 0x30, 0x0C, 0x60,
  0x18, 0xC0, 0x31, 0x80, 0x62, 0x00, 0xC6, 0x01, 0x98, 0x01, 0xB0, 0x02,
  0x60, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x34, 0x00, 0x28, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0xCE, 0x00, 0x38, 0xC0, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x30,
  0x18, 0x0C, 0x03, 0x83, 0x00, 0x30, 0x60, 0x03, 0x18, 0x00, 0x63, 0x00,
  0x06, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x6C, 0x00,
  0x0D, 0x80, 0x03, 0x18, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x06, 0x03, 0x01,
  0xC0, 0x60, 0x30, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x00, 0xDC,
  0x00, 0x1C, 0xC0, 0x00, 0x76, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0C,
  0x30, 0x00, 0xC3, 0x00, 0x0C, 0x10, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01,
  0x80, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x02, 0x00, 0x60,
  0x60, 0x06, 0x06, 0x00, 0x20, 0x40, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x01,
  0x08, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x09, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x78, 0x0F, 0xC0, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x0F, 0x80,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x07, 0xC0, 0x0E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x07, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0F, 0x80,
  0x1C, 0x03, 0x80, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x1E, 0x07, 0xC0, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xFE, 0x00, 0x78, 0x3C, 0x07, 0x80, 0x7F, 0xE8, 0x00, 0x7C,
  0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 35, 11, 4, -35 },
  { 15, 10, 13, 16, 3, -35 },
  { 32, 26, 35, 28, 1, -35 },
  { 146, 18, 40, 25, 3, -37 },
  { 236, 30, 35, 35, 3, -35 },
  { 368, 26, 36, 29, 2, -36 },
  { 485, 2, 13, 9, 3, -35 },
  { 489, 9, 43, 13, 2, -35 },
  { 538, 9, 43, 13, 2, -35 },
  { 587, 18, 17, 23, 3, -37 },
  { 626, 21, 23, 25, 2, -29 },
  { 687, 5, 11, 10, 2, -5 },
  { 694, 11, 2, 15, 2, -14 },
  { 697, 3, 3, 11, 4, -3 },
  { 699, 15, 35, 16, 1, -35 },
  { 765, 19, 36, 25, 3, -36 },
  { 851, 11, 35, 25, 4, -35 },
  { 900, 20, 35, 25, 2, -35 },
  { 988, 20, 35, 25, 2, -35 },
  { 1076, 23, 35, 25, 1, -35 },
  { 1177, 19, 35, 25, 3, -35 },
  { 1261, 19, 36, 25, 3, -35 },
  { 1347, 20, 35, 25, 2, -35 },
  { 1435, 19, 35, 25, 3, -35 },
  { 1519, 20, 36, 25, 2, -35 },
  { 1609, 3, 26, 11, 4, -26 },
  { 1619, 5, 32, 10, 2, -26 },
  { 1639, 21, 21, 25, 2, -28 },
  { 1695, 21, 12, 25, 2, -23 },
  { 1727, 21, 21, 25, 2, -28 },
  { 1783, 15, 35, 18, 1, -35 },
  { 1849, 33, 40, 38, 3, -35 },
  { 2014, 25, 35, 25, 0, -35 },
  { 2124, 20, 35, 27, 5, -35 },
  { 2212, 22, 35, 27, 3, -35 },
  { 2309, 22, 35, 30, 5, -35 },
  { 2406, 16, 35, 24, 5, -35 },
  { 2476, 16, 35, 22, 5, -35 },
  { 2546, 25, 36, 32, 3, -36 },
  { 2659, 22, 35, 31, 5, -35 },
  { 2756, 9, 35, 13, 2, -35 },
  { 2796, 11, 44, 11, -4, -35 },
  { 2857, 20, 35, 25, 5, -35 },
  { 2945, 16, 35, 22, 5, -35 },
  { 3015, 29, 35, 38, 5, -35 },
  { 3142, 22, 35, 31, 5, -35 },
  { 3239, 27, 36, 33, 3, -36 },
  { 3361, 18, 35, 25, 5, -35 },
  { 3440, 27, 44, 33, 3, -36 },
  { 3589, 20, 35, 26, 5, -35 },
  { 3677, 20, 35, 24, 2, -35 },
  { 3765, 22, 35, 22, 0, -35 },
  { 3862, 23, 35, 31, 4, -35 },
  { 3963, 25, 35, 25, 0, -35 },
  { 4073, 37, 35, 39, 1, -35 },
  { 4235, 22, 35, 22, 0, -35 },
  { 4332, 22, 35, 22, 0, -35 },
  { 4429, 20, 35, 24, 2, -35 },
  { 4517, 10, 43, 15, 4, -35 },
  { 4571, 15, 35, 16, 1, -35 },
  { 4637, 10, 43, 15, 1, -35 },
  { 4691, 21, 20, 25, 2, -35 },
  { 4744, 20, 2, 20, 0, 4 },
  { 4749, 8, 7, 12, 2, -37 },
  { 4756, 17, 26, 23, 2, -26 },
  { 4812, 19, 37, 26, 4, -37 },
  { 4900, 16, 26, 20, 3, -26 },
  { 4952, 19, 37, 26, 3, -37 },
  { 5040, 18, 26, 24, 3, -26 },
  { 5099, 14, 37, 13, 1, -37 },
  { 5164, 19, 38, 26, 3, -26 },
  { 5255, 18, 37, 26, 4, -37 },
  { 5339, 3, 36, 10, 4, -36 },
  { 5353, 9, 48, 10, -2, -36 },
  { 5407, 17, 37, 21, 4, -37 },
  { 5486, 2, 37, 10, 4, -37 },
  { 5496, 30, 26, 38, 4, -26 },
  { 5594, 18, 26, 26, 4, -26 },
  { 5653, 20, 26, 25, 3, -26 },
  { 5718, 19, 37, 26, 4, -26 },
  { 5806, 19, 37, 26, 3, -26 },
  { 5894, 12, 26, 17, 4, -26 },
  { 5933, 16, 26, 20, 2, -26 },
  { 5985, 12, 32, 14, 1, -32 },
  { 6033, 18, 26, 26, 4, -26 },
  { 6092, 19, 26, 19, 0, -26 },
  { 6154, 30, 26, 31, 1, -26 },
  { 6252, 19, 26, 21, 1, -26 },
  { 6314, 20, 38, 20, 0, -26 },
  { 6409, 15, 26, 19, 2, -26 },
  { 6458, 13, 43, 17, 2, -35 },
  { 6528, 2, 49, 24, 11, -37 },
  { 6541, 13, 43, 17, 2, -35 },
  { 6611, 21, 5, 25, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight49pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT49PT7B_H_
