#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT21PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE2, 0x99, 0x99, 0x90, 0x08, 0x41, 0x10, 0x22, 0x04, 0x47,
  0xFE, 0x11, 0x02, 0x20, 0x88, 0x11, 0x1F, 0xFC, 0x44, 0x08, 0x81, 0x10,
  0x42, 0x08, 0x80, 0x08, 0x3C, 0x4B, 0x88, 0x88, 0x88, 0x88, 0x68, 0x18,
  0x0E, 0x09, 0x09, 0x09, 0x09, 0xCE, 0x38, 0x08, 0x70, 0x64, 0x42, 0x22,
  0x21, 0x11, 0x08, 0x88, 0x44, 0x82, 0x25, 0xD1, 0x51, 0x72, 0x88, 0x24,
  0x41, 0x22, 0x11, 0x10, 0x88, 0x88, 0x44, 0x41, 0xC0, 0x3C, 0x04, 0x41,
  0x08, 0x21, 0x02, 0x20, 0x48, 0x06, 0x01, 0x40, 0x44, 0x30, 0x4A, 0x09,
  0x40, 0xA8, 0x08, 0x82, 0x8F, 0x88, 0xF8, 0x12, 0x44, 0x48, 0x88, 0x88,
  0x88, 0x88, 0x44, 0x23, 0x84, 0x42, 0x22, 0x11, 0x11, 0x11, 0x22, 0x24,
  0x48, 0x10, 0x10, 0x10, 0xF7, 0x18, 0x24, 0x24, 0x42, 0x08, 0x04, 0x02,
  0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x00, 0x5A, 0x80, 0xF8, 0x80,
  0x02, 0x08, 0x10, 0x20, 0x81, 0x04, 0x08, 0x10, 0x40, 0x81, 0x04, 0x08,
  0x20, 0x00, 0x3E, 0x21, 0x10, 0x50, 0x28, 0x14, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x50, 0x24, 0x12, 0x10, 0xF0, 0x13, 0xD9, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x10, 0x7C, 0x82, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x20, 0x40, 0xFF, 0x7E, 0x82, 0x01, 0x01, 0x01, 0x02,
  0x04, 0x3C, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFE, 0x01, 0x00, 0xC0,
  0x50, 0x14, 0x09, 0x02, 0x41, 0x10, 0x84, 0x21, 0x10, 0x4F, 0xFC, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x7F, 0x40, 0x40, 0x40, 0x40, 0x40, 0x7C, 0x03,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0xFC, 0x1F, 0x10, 0x10, 0x08, 0x04,
  0x04, 0x02, 0xF9, 0x82, 0x81, 0x40, 0x60, 0x30, 0x14, 0x12, 0x08, 0xF8,
  0xFF, 0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02,
  0x02, 0x01, 0x00, 0x80, 0x80, 0x3E, 0x20, 0xA0, 0x50, 0x24, 0x12, 0x10,
  0xD0, 0x78, 0x42, 0x40, 0xA0, 0x30, 0x18, 0x12, 0x08, 0xF8, 0x3C, 0x42,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x7D, 0x01, 0x01, 0x01, 0x02, 0x02,
  0x7C, 0x80, 0x20, 0x40, 0x00, 0x16, 0xA0, 0x01, 0x83, 0x06, 0x0C, 0x08,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x30, 0x60, 0xC0, 0x80, 0x00, 0xF8,
  0x10, 0x41, 0x04, 0x10, 0x84, 0x20, 0x84, 0x00, 0x00, 0x06, 0x00, 0x07,
  0xE0, 0x60, 0x42, 0x00, 0x90, 0x01, 0x43, 0xC6, 0x11, 0x18, 0x84, 0x62,
  0x11, 0x88, 0x46, 0x21, 0x18, 0x84, 0x62, 0x31, 0x47, 0x39, 0x00, 0x02,
  0x00, 0x04, 0x08, 0x0F, 0xC0, 0x04, 0x01, 0x40, 0x28, 0x05, 0x01, 0x10,
  0x22, 0x04, 0x41, 0x08, 0x20, 0x87, 0xF1, 0x02, 0x20, 0x24, 0x05, 0x00,
  0xA0, 0x08, 0xFE, 0x40, 0xA0, 0x50, 0x28, 0x14, 0x0A, 0x09, 0xFC, 0x81,
  0x40, 0x60, 0x30, 0x18, 0x14, 0x0B, 0xF8, 0x0F, 0xCC, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x08,
  0x01, 0xFC, 0xFC, 0x20, 0xC8, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x0A, 0x02, 0x80, 0xA0, 0xCF, 0xC0, 0xFF, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x7F, 0x81, 0x02, 0x04, 0x08, 0x10, 0x3F, 0x80, 0xFF,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x7F, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x00, 0x0F, 0xE6, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x1E,
  0x80, 0x30, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x60, 0x43, 0xF8, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x02, 0xF4, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0xF0, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0xB8, 0x81,
  0x41, 0x21, 0x11, 0x88, 0x84, 0x82, 0x81, 0xA0, 0x90, 0x44, 0x21, 0x10,
  0x88, 0x24, 0x0A, 0x06, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x3F, 0x80, 0x80, 0x1C, 0x01, 0xC0, 0x3A, 0x03,
  0xA0, 0x3A, 0x05, 0x90, 0x59, 0x09, 0x90, 0x98, 0x89, 0x89, 0x18, 0x91,
  0x85, 0x18, 0x61, 0x82, 0x10, 0x80, 0xE0, 0x70, 0x34, 0x1A, 0x0C, 0x86,
  0x23, 0x11, 0x84, 0xC2, 0x60, 0xB0, 0x38, 0x1C, 0x06, 0x02, 0x1F, 0x82,
  0x04, 0x40, 0x24, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x14, 0x02, 0x40, 0x22, 0x04, 0x1F, 0x80, 0xFC, 0x82, 0x81,
  0x81, 0x81, 0x81, 0x82, 0x86, 0xF8, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x1F, 0x82, 0x04, 0x40, 0x24, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x14, 0x02, 0x40, 0x22, 0x04, 0x1F, 0x80, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0xFC, 0x41, 0x20, 0x50, 0x28, 0x14, 0x0A,
  0x09, 0xE8, 0x88, 0x42, 0x21, 0x10, 0x48, 0x24, 0x0A, 0x06, 0x3F, 0x40,
  0x80, 0x80, 0x80, 0x40, 0x20, 0x1C, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01,
  0xFE, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0x80, 0x90, 0x23,
  0xF0, 0x80, 0x70, 0x09, 0x01, 0x20, 0x44, 0x08, 0x41, 0x08, 0x21, 0x08,
  0x11, 0x02, 0x20, 0x48, 0x05, 0x00, 0xA0, 0x18, 0x01, 0x00, 0x80, 0x81,
  0x40, 0x81, 0x41, 0x41, 0x41, 0x41, 0x41, 0x42, 0x22, 0x42, 0x22, 0x22,
  0x22, 0x22, 0x22, 0x24, 0x12, 0x24, 0x14, 0x14, 0x14, 0x14, 0x14, 0x18,
  0x08, 0x18, 0x08, 0x08, 0x40, 0x90, 0x22, 0x10, 0x88, 0x12, 0x05, 0x00,
  0xC0, 0x30, 0x0C, 0x04, 0x82, 0x20, 0x84, 0x41, 0x10, 0x28, 0x0C, 0x80,
  0xA0, 0x50, 0x44, 0x22, 0x21, 0x10, 0x50, 0x28, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0xFF, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x03, 0xFE, 0xF8, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x80, 0x81, 0x01, 0x02, 0x04, 0x04,
  0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0x80, 0xF1, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x1F, 0x08, 0x0A, 0x05, 0x04, 0x42, 0x22, 0x09,
  0x05, 0x01, 0x80, 0x80, 0xFF, 0x88, 0x80, 0x7C, 0x04, 0x08, 0x10, 0x6F,
  0x60, 0xC1, 0x83, 0x0D, 0xE8, 0x80, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC2,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC2, 0xBC, 0x3E, 0x81, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x40, 0x80, 0xF8, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x3F, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x3F, 0x3E,
  0x42, 0x41, 0x81, 0x81, 0xFE, 0x80, 0x80, 0x40, 0x40, 0x3F, 0x1E, 0x40,
  0x81, 0x02, 0x1F, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x3F, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01,
  0x01, 0x01, 0x81, 0x7E, 0x81, 0x02, 0x04, 0x08, 0x1F, 0xA0, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x8F, 0xFE, 0x10, 0x00, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x2E, 0x81, 0x02, 0x04, 0x08, 0x30, 0xA2,
  0x48, 0x91, 0x43, 0x84, 0x88, 0x91, 0x21, 0x41, 0xFF, 0xFF, 0xFD, 0xF4,
  0x30, 0x60, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x82,
  0x0C, 0x10, 0x60, 0x82, 0xFD, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x08, 0x3E, 0x20, 0xA0, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x41,
  0x20, 0x8F, 0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xC2, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3F, 0x41, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFC,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x20, 0x7F, 0x02, 0x04, 0x06, 0x03, 0x01,
  0x01, 0x02, 0x0B, 0xF0, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0xF0, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0D,
  0xE8, 0x81, 0x81, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x18, 0x18, 0x08,
  0x82, 0x0A, 0x18, 0x50, 0xC2, 0x8A, 0x24, 0x49, 0x12, 0x48, 0xA2, 0x45,
  0x14, 0x28, 0x60, 0x83, 0x04, 0x18, 0x41, 0x11, 0x08, 0x82, 0x81, 0x40,
  0x40, 0x50, 0x28, 0x22, 0x20, 0xB0, 0x60, 0x81, 0x41, 0x41, 0x42, 0x22,
  0x22, 0x24, 0x14, 0x14, 0x18, 0x08, 0x08, 0x10, 0x10, 0x20, 0xE0, 0xFC,
  0x10, 0x82, 0x10, 0x42, 0x10, 0x42, 0x0F, 0xC0, 0x19, 0x08, 0x42, 0x10,
  0x84, 0x46, 0x08, 0x42, 0x10, 0x84, 0x20, 0xC0, 0xFF, 0xFF, 0xF8, 0xC0,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x10, 0x71, 0x08, 0x20, 0x82, 0x08, 0x23,
  0x80, 0xF8, 0x83, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 15, 5, 2, -15 },
  { 3, 4, 5, 7, 1, -15 },
  { 6, 11, 15, 12, 0, -15 },
  { 27, 8, 17, 11, 1, -16 },
  { 44, 13, 15, 15, 1, -15 },
  { 69, 11, 15, 13, 1, -15 },
  { 90, 1, 5, 4, 1, -15 },
  { 91, 4, 18, 6, 1, -15 },
  { 100, 4, 18, 6, 1, -15 },
  { 109, 8, 8, 10, 1, -16 },
  { 117, 9, 9, 11, 1, -12 },
  { 128, 2, 5, 4, 1, -2 },
  { 130, 5, 1, 6, 1, -6 },
  { 131, 1, 1, 5, 2, -1 },
  { 132, 7, 15, 7, 0, -15 },
  { 146, 9, 15, 11, 1, -15 },
  { 163, 4, 15, 11, 2, -15 },
  { 171, 8, 15, 11, 1, -15 },
  { 186, 8, 15, 11, 1, -15 },
  { 201, 10, 15, 11, 0, -15 },
  { 220, 8, 15, 11, 1, -15 },
  { 235, 9, 15, 11, 1, -15 },
  { 252, 9, 15, 11, 1, -15 },
  { 269, 9, 15, 11, 1, -15 },
  { 286, 8, 15, 11, 1, -15 },
  { 301, 1, 11, 5, 2, -11 },
  { 303, 2, 14, 5, 1, -11 },
  { 307, 9, 9, 11, 1, -12 },
  { 318, 9, 5, 11, 1, -10 },
  { 324, 9, 9, 11, 1, -12 },
  { 335, 6, 15, 8, 1, -15 },
  { 347, 14, 17, 16, 1, -15 },
  { 377, 11, 15, 11, 0, -15 },
  { 398, 9, 15, 12, 2, -15 },
  { 415, 10, 15, 11, 1, -15 },
  { 434, 10, 15, 13, 2, -15 },
  { 453, 7, 15, 10, 2, -15 },
  { 467, 7, 15, 9, 2, -15 },
  { 481, 11, 15, 14, 1, -15 },
  { 502, 9, 15, 13, 2, -15 },
  { 519, 4, 15, 6, 1, -15 },
  { 527, 5, 19, 5, -2, -15 },
  { 539, 9, 15, 11, 2, -15 },
  { 556, 7, 15, 9, 2, -15 },
  { 570, 12, 15, 16, 2, -15 },
  { 593, 9, 15, 13, 2, -15 },
  { 610, 12, 15, 14, 1, -15 },
  { 633, 8, 15, 11, 2, -15 },
  { 648, 12, 19, 14, 1, -15 },
  { 677, 9, 15, 11, 2, -15 },
  { 694, 8, 15, 10, 1, -15 },
  { 709, 9, 15, 10, 0, -15 },
  { 726, 10, 15, 13, 2, -15 },
  { 745, 11, 15, 11, 0, -15 },
  { 766, 16, 15, 17, 0, -15 },
  { 796, 10, 15, 10, 0, -15 },
  { 815, 9, 15, 9, 0, -15 },
  { 832, 9, 15, 10, 1, -15 },
  { 849, 4, 18, 7, 2, -15 },
  { 858, 7, 15, 7, 0, -15 },
  { 872, 4, 18, 7, 1, -15 },
  { 881, 9, 9, 11, 1, -15 },
  { 892, 8, 1, 8, 0, 2 },
  { 893, 3, 3, 5, 1, -16 },
  { 895, 7, 11, 10, 1, -11 },
  { 905, 8, 16, 11, 2, -16 },
  { 921, 7, 11, 9, 1, -11 },
  { 931, 8, 16, 11, 1, -16 },
  { 947, 8, 11, 10, 1, -11 },
  { 958, 7, 16, 6, 0, -16 },
  { 972, 8, 16, 11, 1, -11 },
  { 988, 7, 16, 11, 2, -16 },
  { 1002, 1, 15, 4, 2, -15 },
  { 1004, 4, 20, 4, -1, -15 },
  { 1014, 7, 16, 9, 2, -16 },
  { 1028, 1, 16, 4, 2, -16 },
  { 1030, 13, 11, 16, 2, -11 },
  { 1048, 7, 11, 11, 2, -11 },
  { 1058, 9, 11, 11, 1, -11 },
  { 1071, 8, 16, 11, 2, -11 },
  { 1087, 8, 16, 11, 1, -11 },
  { 1103, 5, 11, 7, 2, -11 },
  { 1110, 7, 11, 9, 1, -11 },
  { 1120, 6, 14, 6, 0, -14 },
  { 1131, 7, 11, 11, 2, -11 },
  { 1141, 8, 11, 8, 0, -11 },
  { 1152, 13, 11, 13, 0, -11 },
  { 1170, 9, 11, 9, 0, -11 },
  { 1183, 8, 16, 8, 0, -11 },
  { 1199, 6, 11, 8, 1, -11 },
  { 1208, 5, 18, 7, 1, -15 },
  { 1220, 1, 21, 10, 5, -16 },
  { 1223, 6, 18, 7, 1, -15 },
  { 1237, 9, 2, 11, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight21pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT21PT7B_H_
