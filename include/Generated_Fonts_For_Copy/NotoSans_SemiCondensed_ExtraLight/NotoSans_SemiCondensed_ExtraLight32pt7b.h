#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT32PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight32pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x40, 0x00, 0xF8, 0xC7, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x02, 0x0C, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08,
  0x06, 0x08, 0x04, 0x08, 0x04, 0x18, 0x7F, 0xFF, 0x04, 0x10, 0x04, 0x10,
  0x0C, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x20, 0x08, 0x20, 0xFF, 0xFE,
  0x08, 0x20, 0x10, 0x20, 0x10, 0x20, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40,
  0x30, 0x40, 0x04, 0x00, 0x40, 0x3F, 0xC6, 0x42, 0xC4, 0x08, 0x40, 0x84,
  0x08, 0x40, 0x84, 0x0C, 0x40, 0x64, 0x03, 0xC0, 0x0E, 0x00, 0x58, 0x04,
  0x60, 0x43, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x28, 0x46, 0xFF,
  0x80, 0x40, 0x04, 0x00, 0x40, 0x3C, 0x03, 0x04, 0x60, 0x20, 0xC2, 0x04,
  0x08, 0x20, 0x40, 0x83, 0x0C, 0x08, 0x30, 0x80, 0x81, 0x18, 0x08, 0x11,
  0x00, 0x83, 0x30, 0x08, 0x32, 0x38, 0x82, 0x24, 0x4C, 0x24, 0x82, 0x46,
  0x48, 0x23, 0xC8, 0x82, 0x00, 0x88, 0x20, 0x11, 0x82, 0x01, 0x18, 0x30,
  0x20, 0x82, 0x02, 0x08, 0x20, 0x40, 0x82, 0x04, 0x08, 0x20, 0x80, 0xC4,
  0x08, 0x07, 0xC0, 0x0F, 0x80, 0x08, 0x60, 0x08, 0x10, 0x04, 0x0C, 0x02,
  0x06, 0x01, 0x03, 0x00, 0x81, 0x00, 0x61, 0x80, 0x10, 0x80, 0x05, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x02, 0x30, 0x02, 0x0C, 0x1A, 0x02, 0x09, 0x00,
  0x84, 0x80, 0x26, 0x40, 0x1A, 0x20, 0x07, 0x10, 0x03, 0x8C, 0x03, 0x43,
  0x03, 0x10, 0xFE, 0x06, 0xFA, 0xAA, 0x04, 0x21, 0x84, 0x30, 0x82, 0x18,
  0x41, 0x04, 0x10, 0xC3, 0x0C, 0x30, 0x41, 0x04, 0x10, 0x61, 0x82, 0x0C,
  0x10, 0x60, 0x81, 0xC1, 0x02, 0x0C, 0x10, 0x60, 0x82, 0x08, 0x30, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0xC2, 0x08, 0x21, 0x84, 0x30, 0x86, 0x30,
  0x04, 0x00, 0x40, 0x04, 0x08, 0x41, 0xE4, 0xF1, 0xF0, 0x06, 0x00, 0xA0,
  0x11, 0x03, 0x08, 0x60, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x3F, 0xFF, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x24, 0xB4, 0x94, 0xFF,
  0xDC, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x10, 0x08, 0x0C, 0x04, 0x02,
  0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x60, 0x20, 0x10, 0x10, 0x08, 0x0C,
  0x04, 0x02, 0x00, 0x1F, 0x81, 0x86, 0x08, 0x18, 0x80, 0x44, 0x03, 0x60,
  0x0A, 0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x05, 0x00, 0x38, 0x01,
  0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x16, 0x00, 0x90, 0x0C, 0x80, 0x46,
  0x06, 0x18, 0x60, 0x7E, 0x00, 0x06, 0x1C, 0x5B, 0x3C, 0x70, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x80, 0x3F, 0x86, 0x0C, 0x80, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0xFF,
  0xF0, 0x1F, 0xC3, 0x83, 0x30, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0xF0, 0x3F, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x60,
  0x31, 0xFF, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x80, 0x05, 0x00, 0x12,
  0x00, 0x64, 0x00, 0x88, 0x03, 0x10, 0x04, 0x20, 0x10, 0x40, 0x60, 0x80,
  0x81, 0x02, 0x02, 0x0C, 0x04, 0x10, 0x08, 0x40, 0x10, 0xFF, 0xFE, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x7F,
  0xE6, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x05, 0xF0, 0x7B, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x28, 0x0C, 0x7F, 0x80, 0x07, 0xE0,
  0x60, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x7C, 0x2C, 0x19, 0x40, 0x6C, 0x01, 0x40, 0x0A, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x00, 0xD0, 0x04, 0x80, 0x26, 0x03, 0x18, 0x30, 0x7F, 0x00,
  0xFF, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x00, 0x1F, 0x81, 0x83, 0x10, 0x09, 0x80, 0x6C, 0x01, 0x60, 0x0B,
  0x00, 0xC8, 0x04, 0x20, 0x60, 0xC6, 0x03, 0xC0, 0x1F, 0x03, 0x0C, 0x30,
  0x33, 0x00, 0xD0, 0x02, 0x80, 0x1C, 0x00, 0xE0, 0x05, 0x00, 0x2C, 0x03,
  0x30, 0x30, 0x7F, 0x00, 0x1F, 0x82, 0x0C, 0x40, 0x6C, 0x02, 0x80, 0x38,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x3C, 0x03, 0x60, 0xD3,
  0xF9, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x04, 0x00, 0xC0,
  0x18, 0x7E, 0x00, 0x5C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x27, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x22, 0x64, 0x44, 0x80, 0x00, 0x04, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x40,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x08, 0x00, 0x00, 0x7E, 0x20, 0x60, 0x08, 0x02, 0x00, 0xC0,
  0x30, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x20, 0x10, 0x08, 0x06, 0x01, 0x00,
  0x40, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x7C,
  0x00, 0x1C, 0x38, 0x03, 0x00, 0x30, 0x30, 0x00, 0xC3, 0x00, 0x03, 0x10,
  0x00, 0x09, 0x00, 0x00, 0x68, 0x1F, 0xC1, 0xC1, 0x82, 0x0C, 0x08, 0x10,
  0x60, 0x80, 0x83, 0x04, 0x04, 0x18, 0x20, 0x20, 0xC1, 0x03, 0x06, 0x08,
  0x18, 0x30, 0x40, 0xC1, 0x82, 0x06, 0x1C, 0x18, 0x50, 0xA0, 0x7C, 0x78,
  0x80, 0x81, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x06, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x50, 0x00, 0x28, 0x00, 0x24, 0x00, 0x11, 0x00, 0x08, 0x80, 0x08, 0x40,
  0x04, 0x10, 0x02, 0x08, 0x02, 0x04, 0x01, 0x03, 0x00, 0x80, 0x80, 0xFF,
  0xC0, 0x7F, 0xF0, 0x20, 0x08, 0x20, 0x04, 0x10, 0x03, 0x08, 0x00, 0x88,
  0x00, 0x44, 0x00, 0x36, 0x00, 0x0A, 0x00, 0x06, 0xFF, 0x84, 0x07, 0x20,
  0x0D, 0x00, 0x28, 0x01, 0x40, 0x0E, 0x00, 0x70, 0x02, 0x80, 0x14, 0x01,
  0x3F, 0xF1, 0xFF, 0x88, 0x03, 0x40, 0x0A, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x03, 0x40, 0x33, 0xFE, 0x00, 0x03, 0xFE,
  0x1C, 0x08, 0x60, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x81, 0xFF, 0x00, 0xFF, 0x01, 0x03, 0xC2, 0x00, 0xC4,
  0x00, 0xC8, 0x00, 0x90, 0x00, 0xA0, 0x01, 0x40, 0x03, 0x80, 0x07, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x02,
  0x80, 0x05, 0x00, 0x0A, 0x00, 0x24, 0x00, 0xC8, 0x03, 0x10, 0x1C, 0x3F,
  0xE0, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x03, 0xFF, 0x7F, 0xE8, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x3F, 0xF8, 0xFF, 0xF0,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x7F, 0xEF, 0xFD, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x00, 0x03, 0xFE, 0x07, 0x01, 0x86, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x07, 0xFC, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x03, 0x40, 0x01, 0xA0, 0x00, 0xD8, 0x00, 0x66, 0x00,
  0x31, 0x80, 0x18, 0x60, 0x0C, 0x1F, 0xF8, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x13, 0xE0, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0xFE,
  0xE0, 0x80, 0x1C, 0x01, 0xA0, 0x19, 0x00, 0x88, 0x08, 0x40, 0x82, 0x0C,
  0x10, 0xC0, 0x8C, 0x04, 0x40, 0x26, 0x01, 0x58, 0x0C, 0x40, 0x61, 0x02,
  0x0C, 0x10, 0x20, 0x80, 0x84, 0x06, 0x20, 0x11, 0x00, 0xC8, 0x03, 0x40,
  0x0A, 0x00, 0x60, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x3F, 0xF8, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x03, 0xD0, 0x00, 0x5A, 0x00, 0x0B, 0x20,
  0x02, 0x64, 0x00, 0x4C, 0xC0, 0x09, 0x88, 0x02, 0x31, 0x00, 0x46, 0x30,
  0x18, 0xC2, 0x02, 0x18, 0x40, 0x43, 0x0C, 0x18, 0x60, 0x82, 0x0C, 0x10,
  0x41, 0x81, 0x10, 0x30, 0x22, 0x06, 0x06, 0x40, 0xC0, 0x50, 0x18, 0x0A,
  0x03, 0x01, 0xC0, 0x60, 0x10, 0x08, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x1D,
  0x00, 0x3B, 0x00, 0x72, 0x00, 0xE2, 0x01, 0xC6, 0x03, 0x84, 0x07, 0x0C,
  0x0E, 0x08, 0x1C, 0x18, 0x38, 0x18, 0x70, 0x10, 0xE0, 0x31, 0xC0, 0x23,
  0x80, 0x67, 0x00, 0x4E, 0x00, 0x5C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0x80, 0x07, 0xF0, 0x03, 0x03, 0x01, 0x00, 0x60, 0x80, 0x0C, 0x60,
  0x01, 0x10, 0x00, 0x6C, 0x00, 0x0B, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00,
  0x28, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x0B,
  0x00, 0x02, 0xC0, 0x00, 0x90, 0x00, 0x66, 0x00, 0x10, 0x80, 0x0C, 0x30,
  0x06, 0x07, 0x03, 0x00, 0x7F, 0x80, 0xFF, 0x08, 0x1C, 0x80, 0x68, 0x02,
  0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x28, 0x0C,
  0xFF, 0x88, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x00, 0x07, 0xF0, 0x03, 0x03, 0x01, 0x00, 0x60,
  0x80, 0x0C, 0x60, 0x01, 0x10, 0x00, 0x6C, 0x00, 0x0B, 0x00, 0x02, 0x80,
  0x00, 0xA0, 0x00, 0x28, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00, 0x90, 0x00, 0x66, 0x00, 0x10,
  0x80, 0x0C, 0x30, 0x06, 0x07, 0x03, 0x00, 0x7F, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0xFF, 0x04, 0x1E, 0x20,
  0x19, 0x00, 0x68, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x34, 0x01,
  0x20, 0x19, 0x03, 0x8F, 0xF0, 0x41, 0x82, 0x04, 0x10, 0x10, 0x80, 0xC4,
  0x02, 0x20, 0x19, 0x00, 0x48, 0x03, 0x40, 0x0A, 0x00, 0x60, 0x1F, 0xE7,
  0x03, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x28, 0x0C, 0xFF, 0x80, 0xFF, 0xFC, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0A,
  0x00, 0x16, 0x00, 0x66, 0x00, 0x86, 0x06, 0x07, 0xF8, 0x00, 0x80, 0x01,
  0xC0, 0x03, 0x40, 0x02, 0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x20, 0x04,
  0x30, 0x0C, 0x10, 0x08, 0x10, 0x08, 0x18, 0x18, 0x08, 0x10, 0x08, 0x10,
  0x0C, 0x30, 0x04, 0x20, 0x04, 0x20, 0x06, 0x60, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x80, 0x10, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x18, 0x02, 0xC0, 0x28, 0x02, 0x40, 0x28, 0x02, 0x40,
  0x24, 0x06, 0x40, 0x24, 0x04, 0x60, 0x64, 0x04, 0x20, 0x44, 0x04, 0x20,
  0x42, 0x0C, 0x20, 0x42, 0x08, 0x30, 0xC2, 0x08, 0x10, 0x82, 0x08, 0x10,
  0x81, 0x18, 0x10, 0x81, 0x10, 0x19, 0x81, 0x10, 0x09, 0x01, 0x10, 0x09,
  0x00, 0xB0, 0x09, 0x00, 0xA0, 0x0F, 0x00, 0xA0, 0x06, 0x00, 0xA0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x40, 0x04, 0x40, 0x18, 0x80, 0x20, 0x80,
  0x81, 0x83, 0x01, 0x04, 0x03, 0x18, 0x02, 0x20, 0x06, 0xC0, 0x05, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x28, 0x00, 0xD0, 0x01, 0x10, 0x06, 0x30, 0x08,
  0x20, 0x30, 0x60, 0x40, 0x41, 0x00, 0xC6, 0x00, 0x88, 0x01, 0xB0, 0x01,
  0x80, 0xC0, 0x05, 0x00, 0x34, 0x00, 0x88, 0x06, 0x20, 0x10, 0xC0, 0x41,
  0x02, 0x06, 0x08, 0x08, 0x60, 0x31, 0x00, 0x4C, 0x01, 0xA0, 0x03, 0x80,
  0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x7F, 0xF8, 0x00, 0x20, 0x01, 0x00,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0F, 0xFF, 0xC0, 0xFE,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x80, 0x40, 0x30, 0x08,
  0x04, 0x03, 0x00, 0x80, 0x40, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x60,
  0x10, 0x08, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x0C, 0x02, 0xFC, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x7F, 0x01, 0x00, 0x0C, 0x00, 0x28,
  0x01, 0x20, 0x04, 0x40, 0x21, 0x00, 0x82, 0x04, 0x08, 0x30, 0x10, 0x80,
  0x46, 0x00, 0x90, 0x02, 0xC0, 0x04, 0xFF, 0xF8, 0xC0, 0x81, 0x02, 0x04,
  0x1F, 0xC2, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x1F,
  0x1E, 0x32, 0x03, 0x40, 0x34, 0x03, 0xC0, 0x3C, 0x03, 0x40, 0x76, 0x0B,
  0x3F, 0x10, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x09, 0xF8, 0xA0, 0x4C, 0x02, 0xC0, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0xC0, 0x2C, 0x06, 0xA0,
  0xC9, 0xF8, 0x0F, 0xCC, 0x16, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC1, 0x1F, 0xC0,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x11, 0xF9,
  0x30, 0x56, 0x03, 0x40, 0x3C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x34, 0x03, 0x20, 0x51, 0xF9,
  0x1F, 0x83, 0x0C, 0x60, 0x64, 0x02, 0xC0, 0x38, 0x01, 0x80, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x02,
  0x1F, 0xE0, 0x07, 0xC2, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x03, 0xFC,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x1F, 0x93, 0x05, 0x60,
  0x34, 0x03, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x1C, 0x03, 0x40, 0x32, 0x05, 0x1F, 0x90, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x03, 0x80, 0x67, 0xBC, 0x0F, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0xFC, 0xA0, 0xD8, 0x0F,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xF0, 0x05, 0x55, 0x55, 0x55,
  0x54, 0x18, 0xC0, 0x00, 0x00, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x11, 0xDB, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x03, 0x81, 0xA0, 0x48, 0x22, 0x10,
  0x8C, 0x26, 0x09, 0x82, 0xA0, 0xCC, 0x21, 0x08, 0x22, 0x0C, 0x81, 0x20,
  0x28, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0x9F, 0x0F, 0xD4, 0x32, 0x0F, 0x03,
  0x80, 0xC0, 0x30, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02,
  0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04,
  0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x20, 0x9F,
  0x94, 0x1B, 0x01, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x1F,
  0xC1, 0x83, 0x18, 0x0C, 0x80, 0x2C, 0x01, 0x40, 0x0E, 0x00, 0x70, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x3C, 0x01, 0x20, 0x09, 0x80, 0xC6,
  0x0C, 0x1F, 0xC0, 0x9F, 0x8B, 0x04, 0xC0, 0x2C, 0x03, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x03,
  0xC0, 0x2A, 0x0C, 0x9F, 0x88, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x1F, 0x93, 0x05, 0x60, 0x34, 0x03, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x03,
  0x40, 0x36, 0x05, 0x1F, 0x90, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x9F, 0xA0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1F, 0xCC, 0x09, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x30, 0x01, 0x00,
  0x30, 0x02, 0x00, 0xC0, 0x14, 0x06, 0x7F, 0x80, 0x10, 0x10, 0x10, 0x10,
  0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x18, 0x0F, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x34, 0x03, 0x40, 0x56, 0x0D, 0x3F, 0x90, 0x80, 0x1A, 0x00, 0x90, 0x04,
  0x80, 0x42, 0x02, 0x10, 0x10, 0x81, 0x02, 0x08, 0x10, 0x40, 0x84, 0x02,
  0x20, 0x11, 0x00, 0x90, 0x06, 0x80, 0x14, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x20, 0x14, 0x06, 0x01, 0x40, 0x50, 0x26, 0x05, 0x02, 0x20, 0x50, 0x22,
  0x09, 0x82, 0x20, 0x88, 0x43, 0x08, 0x84, 0x11, 0x88, 0x41, 0x10, 0x44,
  0x11, 0x04, 0x81, 0x90, 0x48, 0x0A, 0x06, 0x80, 0xA0, 0x28, 0x0A, 0x03,
  0x00, 0xE0, 0x30, 0x04, 0x03, 0x00, 0xC0, 0x34, 0x06, 0x60, 0x42, 0x0C,
  0x10, 0x81, 0x90, 0x0B, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x09, 0x01, 0x18,
  0x30, 0x82, 0x0C, 0x60, 0x44, 0x02, 0x80, 0x30, 0xC0, 0x1A, 0x00, 0x90,
  0x04, 0xC0, 0x62, 0x02, 0x10, 0x10, 0xC1, 0x82, 0x08, 0x10, 0x40, 0xC6,
  0x02, 0x20, 0x11, 0x00, 0xD8, 0x02, 0x80, 0x14, 0x00, 0xE0, 0x02, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x16, 0x00, 0xE0,
  0x00, 0x7F, 0xC0, 0x10, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x04,
  0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x04, 0x01, 0x00, 0xFF, 0xC0, 0x01,
  0x83, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x03,
  0x01, 0x03, 0x83, 0x80, 0x20, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x03, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x18, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x40, 0x3C, 0x0E, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x08, 0x04, 0x06, 0x1C, 0x00, 0x3C, 0x05, 0x9C, 0x18, 0x0F,
  0x80,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 23, 7, 2, -23 },
  { 10, 6, 8, 11, 2, -23 },
  { 16, 16, 23, 18, 1, -23 },
  { 62, 12, 26, 16, 2, -24 },
  { 101, 20, 23, 23, 2, -23 },
  { 159, 17, 23, 19, 2, -23 },
  { 208, 2, 8, 6, 2, -23 },
  { 210, 6, 28, 9, 1, -23 },
  { 231, 6, 28, 9, 1, -23 },
  { 252, 12, 11, 15, 2, -24 },
  { 269, 14, 15, 16, 1, -19 },
  { 296, 3, 8, 6, 1, -4 },
  { 299, 8, 1, 10, 1, -9 },
  { 300, 3, 2, 7, 2, -2 },
  { 301, 9, 23, 11, 1, -23 },
  { 327, 13, 23, 16, 2, -23 },
  { 365, 7, 23, 16, 3, -23 },
  { 386, 12, 23, 16, 2, -23 },
  { 421, 13, 23, 16, 1, -23 },
  { 459, 15, 23, 16, 1, -23 },
  { 503, 12, 23, 16, 2, -23 },
  { 538, 13, 23, 16, 2, -23 },
  { 576, 13, 23, 16, 2, -23 },
  { 614, 13, 23, 16, 2, -23 },
  { 652, 12, 23, 16, 2, -23 },
  { 687, 3, 17, 7, 2, -17 },
  { 694, 4, 21, 7, 1, -17 },
  { 705, 14, 15, 16, 1, -19 },
  { 732, 14, 8, 16, 1, -15 },
  { 746, 14, 15, 16, 1, -19 },
  { 773, 10, 23, 12, 1, -23 },
  { 802, 21, 26, 25, 2, -23 },
  { 871, 17, 23, 17, 0, -23 },
  { 920, 13, 23, 18, 3, -23 },
  { 958, 15, 23, 17, 2, -23 },
  { 1002, 15, 23, 20, 3, -23 },
  { 1046, 11, 23, 16, 3, -23 },
  { 1078, 11, 23, 14, 3, -23 },
  { 1110, 17, 23, 21, 2, -23 },
  { 1159, 14, 23, 20, 3, -23 },
  { 1200, 5, 23, 9, 2, -23 },
  { 1215, 6, 29, 7, -2, -23 },
  { 1237, 13, 23, 16, 3, -23 },
  { 1275, 11, 23, 14, 3, -23 },
  { 1307, 19, 23, 25, 3, -23 },
  { 1362, 15, 23, 20, 3, -23 },
  { 1406, 18, 23, 21, 2, -23 },
  { 1458, 12, 23, 16, 3, -23 },
  { 1493, 18, 28, 21, 2, -23 },
  { 1556, 13, 23, 17, 3, -23 },
  { 1594, 12, 23, 16, 2, -23 },
  { 1629, 14, 23, 15, 0, -23 },
  { 1670, 15, 23, 20, 3, -23 },
  { 1714, 16, 23, 16, 0, -23 },
  { 1760, 24, 23, 26, 1, -23 },
  { 1829, 15, 23, 15, 0, -23 },
  { 1873, 14, 23, 14, 0, -23 },
  { 1914, 14, 23, 16, 1, -23 },
  { 1955, 6, 28, 10, 3, -23 },
  { 1976, 9, 23, 11, 1, -23 },
  { 2002, 6, 28, 10, 1, -23 },
  { 2023, 14, 13, 16, 1, -23 },
  { 2046, 13, 1, 13, 0, 3 },
  { 2048, 6, 5, 8, 1, -24 },
  { 2052, 12, 17, 15, 1, -17 },
  { 2078, 12, 24, 17, 3, -24 },
  { 2114, 10, 17, 13, 2, -17 },
  { 2136, 12, 24, 17, 2, -24 },
  { 2172, 12, 17, 16, 2, -17 },
  { 2198, 10, 24, 8, 0, -24 },
  { 2228, 12, 25, 17, 2, -17 },
  { 2266, 11, 24, 17, 3, -24 },
  { 2299, 2, 23, 7, 2, -23 },
  { 2305, 5, 31, 7, -1, -23 },
  { 2325, 10, 24, 14, 3, -24 },
  { 2355, 1, 24, 6, 3, -24 },
  { 2358, 19, 17, 25, 3, -17 },
  { 2399, 11, 17, 17, 3, -17 },
  { 2423, 13, 17, 17, 2, -17 },
  { 2451, 12, 24, 17, 3, -17 },
  { 2487, 12, 24, 17, 2, -17 },
  { 2523, 8, 17, 11, 3, -17 },
  { 2540, 11, 17, 13, 1, -17 },
  { 2564, 8, 21, 9, 0, -21 },
  { 2585, 12, 17, 17, 2, -17 },
  { 2611, 13, 17, 13, 0, -17 },
  { 2639, 20, 17, 21, 0, -17 },
  { 2682, 12, 17, 14, 1, -17 },
  { 2708, 13, 25, 13, 0, -17 },
  { 2749, 10, 17, 12, 1, -17 },
  { 2771, 9, 28, 11, 1, -23 },
  { 2803, 1, 32, 15, 7, -24 },
  { 2807, 9, 28, 11, 1, -23 },
  { 2839, 14, 3, 16, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight32pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT32PT7B_H_
