#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_SemiCondensed_ExtraLight
// Headers: 67

#include "NotoSans_SemiCondensed_ExtraLight6pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight7pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight8pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight9pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight10pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight11pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight12pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight13pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight14pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight15pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight16pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight17pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight18pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight19pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight20pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight21pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight22pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight23pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight24pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight25pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight26pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight27pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight28pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight29pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight30pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight31pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight32pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight33pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight34pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight35pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight36pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight37pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight38pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight39pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight40pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight41pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight42pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight43pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight44pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight45pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight46pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight47pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight48pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight49pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight50pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight51pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight52pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight53pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight54pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight55pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight56pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight57pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight58pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight59pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight60pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight61pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight62pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight63pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight64pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight65pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight66pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight67pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight68pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight69pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight70pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight71pt7b.h"
#include "NotoSans_SemiCondensed_ExtraLight72pt7b.h"
