#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT42PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight42pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xA4, 0x92, 0x49, 0x24, 0x90, 0x00, 0x3F,
  0xC0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x83, 0x83, 0x83, 0x83,
  0x00, 0xC0, 0x40, 0x03, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x20, 0x30, 0x00,
  0x80, 0x80, 0x02, 0x02, 0x00, 0x18, 0x08, 0x00, 0x60, 0x20, 0x01, 0x01,
  0x81, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x40, 0x40, 0x03, 0x01, 0x00,
  0x0C, 0x04, 0x00, 0x30, 0x30, 0x00, 0x80, 0xC0, 0x02, 0x02, 0x00, 0x08,
  0x08, 0x00, 0x60, 0x20, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x10, 0x18,
  0x00, 0x40, 0x60, 0x01, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x30, 0x10, 0x00,
  0xC0, 0xC0, 0x02, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x20, 0x20, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x0F, 0xFC, 0x3D, 0x8E, 0x31, 0x82, 0x61,
  0x80, 0xC1, 0x80, 0xC1, 0x80, 0xC1, 0x80, 0xC1, 0x80, 0xC1, 0x80, 0x61,
  0x80, 0x61, 0x80, 0x39, 0x80, 0x0F, 0x80, 0x03, 0x80, 0x01, 0xF0, 0x01,
  0xBC, 0x01, 0x8E, 0x01, 0x87, 0x01, 0x83, 0x01, 0x81, 0x01, 0x81, 0x01,
  0x81, 0x01, 0x81, 0x01, 0x83, 0x01, 0x82, 0x81, 0x8E, 0xFF, 0xFC, 0x1F,
  0xE0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x1F, 0x00, 0x18, 0x0C, 0x60,
  0x04, 0x06, 0x0C, 0x03, 0x01, 0x03, 0x00, 0x80, 0x40, 0x40, 0x60, 0x30,
  0x10, 0x10, 0x0C, 0x06, 0x0C, 0x03, 0x01, 0x83, 0x00, 0xC0, 0x60, 0x80,
  0x30, 0x18, 0x60, 0x0C, 0x06, 0x10, 0x03, 0x01, 0x8C, 0x00, 0xC0, 0x42,
  0x3F, 0x10, 0x11, 0x98, 0x64, 0x0C, 0x44, 0x09, 0x83, 0x33, 0x03, 0x31,
  0x88, 0xC0, 0xC7, 0xC6, 0x20, 0x30, 0x01, 0x08, 0x04, 0x00, 0xC2, 0x01,
  0x00, 0x20, 0x80, 0x40, 0x18, 0x20, 0x10, 0x04, 0x08, 0x04, 0x03, 0x02,
  0x01, 0x00, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x04,
  0x01, 0x02, 0x03, 0x00, 0x61, 0x81, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x00,
  0x38, 0x60, 0x00, 0x80, 0xC0, 0x06, 0x01, 0x00, 0x18, 0x06, 0x00, 0x60,
  0x18, 0x01, 0x80, 0x60, 0x06, 0x01, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x30,
  0x00, 0xC1, 0x80, 0x01, 0x8C, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x30, 0x00, 0x38, 0x60, 0x08, 0xC0, 0xC0, 0x26, 0x01,
  0x81, 0x90, 0x03, 0x06, 0xC0, 0x0C, 0x13, 0x00, 0x18, 0xCC, 0x00, 0x32,
  0x30, 0x00, 0x78, 0xC0, 0x00, 0xC1, 0x00, 0x07, 0x86, 0x00, 0x36, 0x0C,
  0x01, 0xCC, 0x3C, 0x1C, 0x18, 0x3F, 0xE0, 0x30, 0xFF, 0xFE, 0xA8, 0x03,
  0x06, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x60, 0x60, 0x40, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x40, 0x60, 0x60, 0x60, 0x30, 0x30, 0x10, 0x18, 0x0C, 0x0C, 0x06, 0x03,
  0xC0, 0x81, 0x81, 0x83, 0x03, 0x06, 0x04, 0x0C, 0x18, 0x10, 0x30, 0x60,
  0xC1, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x83, 0x06, 0x08, 0x10,
  0x60, 0xC1, 0x06, 0x0C, 0x30, 0x41, 0x86, 0x08, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xC1, 0x82, 0xF9, 0x9F, 0x0F,
  0xF0, 0x01, 0x80, 0x03, 0xC0, 0x02, 0x40, 0x04, 0x20, 0x0C, 0x30, 0x18,
  0x18, 0x10, 0x08, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x33, 0x66,
  0x66, 0x4C, 0xC8, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0x07, 0xF0, 0x06, 0x0E, 0x06, 0x03, 0x06, 0x00,
  0xC3, 0x00, 0x31, 0x00, 0x19, 0x80, 0x04, 0xC0, 0x02, 0x40, 0x01, 0xA0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x34, 0x00,
  0x1A, 0x00, 0x0D, 0x80, 0x04, 0xC0, 0x06, 0x20, 0x03, 0x18, 0x01, 0x0C,
  0x01, 0x83, 0x01, 0x80, 0xE1, 0x80, 0x3F, 0x80, 0x01, 0x83, 0xC3, 0x63,
  0x37, 0x1F, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0F, 0xF0, 0x1C, 0x1C, 0x18, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0,
  0x3C, 0x0E, 0x38, 0x03, 0x90, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x3F, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x90, 0x01, 0xCF, 0x03, 0xC3,
  0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0A, 0x00, 0x01, 0xA0,
  0x00, 0x32, 0x00, 0x03, 0x20, 0x00, 0x62, 0x00, 0x0C, 0x20, 0x00, 0xC2,
  0x00, 0x18, 0x20, 0x01, 0x02, 0x00, 0x30, 0x20, 0x06, 0x02, 0x00, 0x40,
  0x20, 0x0C, 0x02, 0x01, 0x80, 0x20, 0x10, 0x02, 0x03, 0x00, 0x20, 0x60,
  0x02, 0x06, 0x00, 0x20, 0xC0, 0x02, 0x0F, 0xFF, 0xFF, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x7F, 0xFC, 0x7F, 0xFC, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xDF, 0xE0, 0xFF, 0xF8, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x80,
  0x1C, 0xE0, 0x78, 0x7F, 0xE0, 0x01, 0xFE, 0x01, 0xC0, 0x81, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x7F, 0x82, 0x60, 0x71, 0x60,
  0x0D, 0xE0, 0x06, 0xE0, 0x01, 0xF0, 0x00, 0xD0, 0x00, 0x68, 0x00, 0x14,
  0x00, 0x0A, 0x00, 0x05, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0x98, 0x00,
  0x8C, 0x00, 0xC3, 0x00, 0xC0, 0xE0, 0xC0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x07, 0xF8, 0x0E, 0x0E, 0x0C, 0x01, 0x84, 0x00, 0x66, 0x00, 0x33,
  0x00, 0x09, 0x80, 0x04, 0xC0, 0x06, 0x60, 0x03, 0x10, 0x01, 0x8C, 0x01,
  0x83, 0x01, 0x80, 0xE3, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x1C, 0x70, 0x18,
  0x0C, 0x18, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xA0, 0x00, 0xD8, 0x00, 0xC6, 0x00,
  0xC1, 0xC0, 0xC0, 0x7F, 0xC0, 0x0F, 0xF0, 0x0E, 0x0C, 0x0C, 0x03, 0x0C,
  0x00, 0xC6, 0x00, 0x22, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x02, 0xC0, 0x01,
  0x60, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1A, 0x00, 0x1D, 0x80,
  0x0E, 0x60, 0x0B, 0x38, 0x19, 0x87, 0xF8, 0xC0, 0x40, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x07, 0x04, 0x07, 0x01, 0xFE, 0x00, 0xFD, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x77, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x36, 0x66, 0x64, 0xCC, 0x80, 0x00, 0x00, 0x80, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x00,
  0x7F, 0xC7, 0x07, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x31, 0x00, 0x7F,
  0x81, 0x98, 0x06, 0x04, 0x04, 0xC0, 0x60, 0x20, 0x24, 0x06, 0x01, 0x01,
  0xA0, 0x20, 0x08, 0x0F, 0x03, 0x00, 0x40, 0x78, 0x18, 0x06, 0x03, 0xC0,
  0x80, 0x30, 0x1E, 0x04, 0x01, 0x80, 0xF0, 0x20, 0x0C, 0x07, 0x81, 0x80,
  0x60, 0x2C, 0x0C, 0x03, 0x01, 0x60, 0x60, 0x38, 0x19, 0x01, 0x81, 0x40,
  0x88, 0x0E, 0x1B, 0x0C, 0x60, 0x3F, 0x0F, 0xC3, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x01, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x16, 0x00, 0x00, 0x48, 0x00, 0x03, 0x30, 0x00, 0x08, 0xC0,
  0x00, 0x21, 0x00, 0x01, 0x86, 0x00, 0x04, 0x18, 0x00, 0x10, 0x20, 0x00,
  0xC0, 0xC0, 0x02, 0x03, 0x00, 0x08, 0x04, 0x00, 0x60, 0x18, 0x01, 0x80,
  0x60, 0x04, 0x00, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x02, 0x00, 0x10,
  0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x00, 0x02, 0x0C, 0x00, 0x0C, 0x30,
  0x00, 0x30, 0x80, 0x00, 0x46, 0x00, 0x01, 0x98, 0x00, 0x06, 0xC0, 0x00,
  0x0B, 0x00, 0x00, 0x30, 0xFF, 0xF0, 0x60, 0xFE, 0x30, 0x03, 0x98, 0x00,
  0x6C, 0x00, 0x36, 0x00, 0x0B, 0x00, 0x05, 0x80, 0x02, 0xC0, 0x01, 0x60,
  0x01, 0xB0, 0x00, 0xD8, 0x00, 0xCC, 0x00, 0xC6, 0x07, 0xC3, 0xFF, 0xC1,
  0x80, 0x38, 0xC0, 0x07, 0x60, 0x01, 0xB0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xB0,
  0x00, 0xD8, 0x01, 0xCC, 0x0F, 0xC7, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3C,
  0x0F, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x60, 0x0F, 0xFC, 0xFF,
  0xE0, 0x0C, 0x3F, 0xC0, 0xC0, 0x0E, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x8C,
  0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x04, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0,
  0x01, 0x8C, 0x00, 0x18, 0xC0, 0x07, 0x0C, 0x00, 0xE0, 0xC3, 0xF8, 0x0F,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x07, 0x80, 0xF0, 0x70, 0x00, 0x43, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x01, 0xFF, 0xC0, 0x07, 0xFD, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x58, 0x00, 0x01, 0x60, 0x00, 0x05, 0x80, 0x00,
  0x12, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x18, 0x00, 0x04, 0x60, 0x00, 0x10,
  0xC0, 0x00, 0x41, 0xC0, 0x01, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xC0, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xC0, 0xFE,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x9F, 0xC0, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x01, 0x80, 0xD0, 0xCF, 0xC0, 0xC0, 0x03, 0xE0, 0x01,
  0xB0, 0x01, 0x98, 0x01, 0x8C, 0x01, 0x86, 0x01, 0x83, 0x01, 0xC1, 0x80,
  0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x06,
  0x70, 0x03, 0x78, 0x01, 0xE6, 0x00, 0xE1, 0x80, 0x60, 0xC0, 0x30, 0x30,
  0x18, 0x0C, 0x0C, 0x06, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x30, 0xC0,
  0x0C, 0x60, 0x06, 0x30, 0x01, 0x98, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x0C,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE8,
  0x00, 0x00, 0xF6, 0x00, 0x00, 0xFB, 0x00, 0x00, 0x7C, 0x80, 0x00, 0x2E,
  0x60, 0x00, 0x37, 0x30, 0x00, 0x13, 0x88, 0x00, 0x19, 0xC6, 0x00, 0x0C,
  0xE3, 0x00, 0x04, 0x70, 0xC0, 0x06, 0x38, 0x60, 0x03, 0x1C, 0x10, 0x01,
  0x0E, 0x0C, 0x01, 0x87, 0x06, 0x00, 0x83, 0x81, 0x00, 0x41, 0xC0, 0xC0,
  0x60, 0xE0, 0x60, 0x20, 0x70, 0x10, 0x30, 0x38, 0x0C, 0x18, 0x1C, 0x02,
  0x08, 0x0E, 0x01, 0x8C, 0x07, 0x00, 0xC6, 0x03, 0x80, 0x22, 0x01, 0xC0,
  0x1B, 0x00, 0xE0, 0x0D, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C,
  0x00, 0xC0, 0x0C, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xD8, 0x00,
  0x3B, 0x00, 0x07, 0x30, 0x00, 0xE2, 0x00, 0x1C, 0x60, 0x03, 0x86, 0x00,
  0x70, 0xC0, 0x0E, 0x0C, 0x01, 0xC1, 0x80, 0x38, 0x18, 0x07, 0x01, 0x80,
  0xE0, 0x30, 0x1C, 0x03, 0x03, 0x80, 0x60, 0x70, 0x06, 0x0E, 0x00, 0x41,
  0xC0, 0x0C, 0x38, 0x00, 0xC7, 0x00, 0x18, 0xE0, 0x01, 0x9C, 0x00, 0x33,
  0x80, 0x03, 0x70, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0x81, 0xE0, 0x06, 0x00, 0x70,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x04,
  0x20, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x02,
  0x40, 0x00, 0x02, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02,
  0x60, 0x00, 0x02, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x20, 0x00, 0x06,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x38,
  0x06, 0x00, 0x70, 0x03, 0x81, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xC3,
  0xF8, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0xC0,
  0x04, 0xC0, 0x1C, 0xC0, 0x78, 0xFF, 0xE0, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0x81, 0xE0, 0x06, 0x00, 0x70, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x20, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x02, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03,
  0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0x60, 0x00, 0x02, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x20, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x70, 0x03, 0x81, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0xFF, 0xC0, 0x7F, 0xFC, 0x30, 0x07, 0x18, 0x00, 0xCC, 0x00, 0x66, 0x00,
  0x13, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0x98,
  0x00, 0xCC, 0x00, 0x66, 0x00, 0x63, 0x00, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0,
  0x60, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x03, 0x06, 0x00, 0x83, 0x00,
  0x61, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0x6C,
  0x00, 0x36, 0x00, 0x0C, 0x07, 0xFE, 0x1C, 0x0F, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E,
  0xE0, 0x3C, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x48, 0x00, 0x19, 0x80, 0x06, 0x18, 0x01, 0xC1, 0xC0,
  0xF0, 0x1F, 0xF8, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xD0, 0x00, 0x04,
  0xC0, 0x00, 0x66, 0x00, 0x03, 0x10, 0x00, 0x10, 0xC0, 0x01, 0x86, 0x00,
  0x0C, 0x10, 0x00, 0x40, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x10, 0x01, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x10, 0x04, 0x00, 0xC0, 0x60, 0x06, 0x03,
  0x00, 0x10, 0x10, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x10, 0x40, 0x00,
  0xC6, 0x00, 0x06, 0x30, 0x00, 0x11, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0,
  0x00, 0x16, 0x00, 0x00, 0xA0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x02, 0xC0, 0x03, 0x80, 0x02, 0x40,
  0x03, 0x80, 0x06, 0x60, 0x02, 0xC0, 0x06, 0x60, 0x02, 0xC0, 0x04, 0x60,
  0x06, 0x40, 0x04, 0x20, 0x06, 0x40, 0x0C, 0x30, 0x04, 0x60, 0x0C, 0x30,
  0x04, 0x60, 0x08, 0x30, 0x0C, 0x20, 0x18, 0x10, 0x0C, 0x20, 0x18, 0x18,
  0x08, 0x30, 0x18, 0x18, 0x08, 0x30, 0x10, 0x18, 0x18, 0x10, 0x30, 0x08,
  0x18, 0x10, 0x30, 0x0C, 0x10, 0x18, 0x30, 0x0C, 0x10, 0x18, 0x20, 0x0C,
  0x30, 0x08, 0x60, 0x04, 0x30, 0x08, 0x60, 0x06, 0x20, 0x0C, 0x60, 0x06,
  0x20, 0x0C, 0x40, 0x06, 0x60, 0x04, 0xC0, 0x02, 0x60, 0x04, 0xC0, 0x03,
  0x40, 0x06, 0xC0, 0x03, 0x40, 0x06, 0x80, 0x03, 0xC0, 0x02, 0x80, 0x01,
  0xC0, 0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80, 0x03, 0x00, 0x60,
  0x00, 0x66, 0x00, 0x18, 0xC0, 0x02, 0x0C, 0x00, 0xC1, 0x80, 0x30, 0x18,
  0x06, 0x01, 0x01, 0x80, 0x30, 0x30, 0x02, 0x0C, 0x00, 0x61, 0x80, 0x04,
  0x60, 0x00, 0xC8, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xB0, 0x00, 0x32, 0x00, 0x04, 0x60, 0x01, 0x86, 0x00, 0x60,
  0xC0, 0x0C, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x18, 0x03, 0x02, 0x00,
  0x30, 0xC0, 0x06, 0x30, 0x00, 0x66, 0x00, 0x05, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0x68, 0x00, 0x19, 0x80, 0x03, 0x10, 0x00, 0xC3, 0x00, 0x18, 0x20,
  0x02, 0x06, 0x00, 0xC0, 0xC0, 0x10, 0x0C, 0x06, 0x01, 0x80, 0x80, 0x18,
  0x30, 0x03, 0x06, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0x4C, 0x00, 0x0D,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0xFF, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x7F, 0xFF, 0xF8, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0xC8, 0x00, 0x19, 0x80, 0x06,
  0x10, 0x00, 0xC3, 0x00, 0x30, 0x20, 0x04, 0x06, 0x01, 0x80, 0x40, 0x20,
  0x0C, 0x0C, 0x00, 0x81, 0x00, 0x18, 0x60, 0x01, 0x08, 0x00, 0x33, 0x00,
  0x02, 0xC0, 0x00, 0x60, 0xFF, 0xFF, 0x80, 0xC0, 0xC0, 0x81, 0x81, 0x81,
  0x80, 0x80, 0x01, 0x80, 0x7F, 0xC3, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x0F, 0xC3, 0xFF, 0x38,
  0x05, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0x40, 0x15, 0xC1, 0x93, 0xFC, 0x40, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x70, 0x31, 0xFE, 0x19, 0x81, 0x8D, 0x00, 0x67, 0x80,
  0x1B, 0x80, 0x0D, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x5C, 0x00, 0x6F, 0x00, 0x26, 0x80, 0x33, 0x30,
  0x71, 0x8F, 0xF0, 0x00, 0x60, 0x1F, 0xF0, 0xE0, 0x46, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x38, 0x10, 0x7F, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0xE0, 0xC3, 0xFE, 0x63, 0x81, 0xB3, 0x00, 0x79,
  0x80, 0x1D, 0x80, 0x0E, 0xC0, 0x03, 0x40, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xA0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x73, 0x00, 0x39, 0x80, 0x24,
  0x70, 0x72, 0x0F, 0xE1, 0x00, 0xC0, 0x07, 0xF8, 0x1C, 0x1C, 0x10, 0x06,
  0x30, 0x06, 0x60, 0x02, 0x60, 0x03, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x01, 0x0E, 0x06,
  0x07, 0xFC, 0x01, 0xF8, 0x1C, 0x41, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x3F, 0xF0, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x01, 0xC0, 0x07, 0xFC, 0xC7, 0x03,
  0x66, 0x00, 0xF3, 0x00, 0x3B, 0x00, 0x1D, 0x80, 0x06, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x40, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xE6, 0x00,
  0x73, 0x00, 0x58, 0xE0, 0xCC, 0x3F, 0xC6, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x19, 0x00, 0x18,
  0xFC, 0xF8, 0x0F, 0xF0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC1,
  0xC0, 0xC7, 0xF8, 0xCC, 0x0C, 0xD0, 0x06, 0xE0, 0x06, 0xE0, 0x02, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFD, 0x00, 0x00,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x80, 0x0E, 0x1C, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xAE, 0x78, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x36, 0x00, 0xCC, 0x03, 0x18, 0x0C, 0x30, 0x30,
  0x60, 0x40, 0xC1, 0x81, 0x86, 0x03, 0x18, 0x06, 0x70, 0x0D, 0xB0, 0x1A,
  0x60, 0x3C, 0x60, 0x70, 0x40, 0xC0, 0xC1, 0x80, 0xC3, 0x01, 0x86, 0x01,
  0x8C, 0x01, 0x98, 0x03, 0x30, 0x03, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x18, 0x33, 0xFC, 0x3F, 0xCD, 0x81,
  0x98, 0x1B, 0x40, 0x24, 0x03, 0xE0, 0x0E, 0x00, 0xF8, 0x03, 0x80, 0x1C,
  0x00, 0x60, 0x07, 0x00, 0x10, 0x01, 0xC0, 0x04, 0x00, 0x70, 0x01, 0x00,
  0x1C, 0x00, 0x40, 0x07, 0x00, 0x10, 0x01, 0xC0, 0x04, 0x00, 0x70, 0x01,
  0x00, 0x1C, 0x00, 0x40, 0x07, 0x00, 0x10, 0x01, 0xC0, 0x04, 0x00, 0x70,
  0x01, 0x00, 0x1C, 0x00, 0x40, 0x07, 0x00, 0x10, 0x01, 0xC0, 0x04, 0x00,
  0x70, 0x01, 0x00, 0x1C, 0x00, 0x40, 0x04, 0x01, 0xC0, 0xC7, 0xF8, 0xCC,
  0x0C, 0xD0, 0x06, 0xE0, 0x06, 0xE0, 0x02, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0xFE, 0x01, 0xC0, 0xE0,
  0xC0, 0x18, 0x30, 0x03, 0x18, 0x00, 0x46, 0x00, 0x19, 0x00, 0x06, 0xC0,
  0x00, 0xB0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x2C, 0x00, 0x09, 0x00, 0x02, 0x40, 0x01, 0x98, 0x00, 0x66, 0x00, 0x10,
  0xC0, 0x0C, 0x18, 0x06, 0x07, 0x07, 0x00, 0x7F, 0x80, 0x00, 0xE0, 0x63,
  0xFC, 0x33, 0x03, 0x1B, 0x00, 0xCF, 0x00, 0x37, 0x00, 0x1B, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xB8,
  0x00, 0xDE, 0x00, 0x6D, 0x80, 0x66, 0x60, 0xE3, 0x1F, 0xE1, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x07, 0xFC,
  0xC7, 0x03, 0x66, 0x00, 0xF3, 0x00, 0x3B, 0x00, 0x1D, 0x80, 0x06, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x40, 0x01, 0xB0, 0x01, 0xD8, 0x00,
  0xE6, 0x00, 0xF3, 0x00, 0x58, 0xE0, 0xCC, 0x3F, 0xC6, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x98, 0xFF, 0x30, 0x68,
  0x0F, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x00, 0x03, 0x01, 0xFF, 0xDC, 0x06, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x38,
  0x01, 0xF0, 0x39, 0xFF, 0x00, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C,
  0x0F, 0xFC, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10,
  0x06, 0x01, 0xC4, 0x3F, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0D, 0x80, 0x2B, 0x00, 0xD3, 0x83, 0x23, 0xFC, 0x40, 0xC0, 0x01,
  0xA0, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x42, 0x00, 0x61, 0x80, 0x30, 0xC0,
  0x10, 0x20, 0x18, 0x18, 0x0C, 0x0C, 0x04, 0x02, 0x06, 0x01, 0x83, 0x00,
  0xC1, 0x00, 0x21, 0x80, 0x18, 0xC0, 0x0C, 0x40, 0x02, 0x60, 0x01, 0xB0,
  0x00, 0xD0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x80, 0x0C, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x68, 0x02, 0xC0, 0x24, 0x01, 0x60,
  0x13, 0x01, 0x90, 0x19, 0x80, 0xC8, 0x0C, 0x40, 0x46, 0x04, 0x20, 0x63,
  0x02, 0x18, 0x30, 0x83, 0x0C, 0x10, 0x61, 0x82, 0x18, 0x30, 0x81, 0x8C,
  0x18, 0x40, 0xC6, 0x04, 0x60, 0x62, 0x03, 0x30, 0x13, 0x01, 0x90, 0x0D,
  0x80, 0x48, 0x06, 0x80, 0x2C, 0x03, 0x40, 0x1E, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0xE0, 0x07, 0x60, 0x06, 0x30, 0x0C,
  0x10, 0x08, 0x18, 0x18, 0x0C, 0x30, 0x0C, 0x30, 0x06, 0x60, 0x02, 0x40,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0x60, 0x04, 0x20,
  0x0C, 0x30, 0x18, 0x18, 0x10, 0x18, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x06,
  0xC0, 0x03, 0xC0, 0x01, 0xB0, 0x00, 0x98, 0x00, 0xC4, 0x00, 0x63, 0x00,
  0x21, 0x80, 0x30, 0x40, 0x18, 0x30, 0x08, 0x18, 0x0C, 0x04, 0x06, 0x03,
  0x02, 0x01, 0x83, 0x00, 0x41, 0x80, 0x30, 0x80, 0x18, 0xC0, 0x04, 0x60,
  0x02, 0x20, 0x01, 0xB0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x1C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x02, 0x70, 0x01, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFC, 0x00, 0xF0,
  0x1E, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x07,
  0x80, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x1F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x1F, 0x00, 0x30, 0x06, 0x00, 0x40,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x78, 0x03, 0x81, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x60, 0x78, 0x0C, 0x00, 0x1E, 0x00, 0xBF, 0xC0,
  0x70, 0x3C, 0xF0, 0x07, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 30, 9, 3, -30 },
  { 13, 8, 11, 14, 3, -30 },
  { 24, 22, 30, 24, 1, -30 },
  { 107, 16, 34, 21, 2, -32 },
  { 175, 26, 30, 30, 2, -30 },
  { 273, 22, 30, 25, 2, -30 },
  { 356, 2, 11, 7, 3, -30 },
  { 359, 8, 37, 11, 2, -30 },
  { 396, 7, 37, 11, 2, -30 },
  { 429, 16, 15, 20, 2, -32 },
  { 459, 17, 20, 21, 2, -25 },
  { 502, 4, 10, 8, 2, -5 },
  { 507, 10, 1, 13, 1, -12 },
  { 509, 3, 3, 9, 3, -3 },
  { 511, 12, 30, 14, 1, -30 },
  { 556, 17, 30, 21, 2, -30 },
  { 620, 9, 30, 21, 4, -30 },
  { 654, 17, 30, 21, 2, -30 },
  { 718, 17, 30, 21, 2, -30 },
  { 782, 20, 30, 21, 1, -30 },
  { 857, 16, 30, 21, 3, -30 },
  { 917, 17, 30, 21, 2, -30 },
  { 981, 17, 30, 21, 2, -30 },
  { 1045, 17, 30, 21, 2, -30 },
  { 1109, 17, 30, 21, 2, -30 },
  { 1173, 3, 22, 9, 3, -22 },
  { 1182, 4, 27, 9, 2, -22 },
  { 1196, 17, 18, 21, 2, -24 },
  { 1235, 17, 10, 21, 2, -20 },
  { 1257, 17, 18, 21, 2, -24 },
  { 1296, 13, 30, 15, 1, -30 },
  { 1345, 29, 34, 33, 2, -30 },
  { 1469, 22, 30, 22, 0, -30 },
  { 1552, 17, 30, 23, 4, -30 },
  { 1616, 20, 30, 23, 2, -30 },
  { 1691, 20, 30, 26, 4, -30 },
  { 1766, 14, 30, 21, 4, -30 },
  { 1819, 14, 30, 19, 4, -30 },
  { 1872, 22, 30, 27, 2, -30 },
  { 1955, 19, 30, 27, 4, -30 },
  { 2027, 7, 30, 11, 2, -30 },
  { 2054, 9, 37, 9, -3, -30 },
  { 2096, 17, 30, 21, 4, -30 },
  { 2160, 14, 30, 19, 4, -30 },
  { 2213, 25, 30, 33, 4, -30 },
  { 2307, 19, 30, 27, 4, -30 },
  { 2379, 24, 30, 28, 2, -30 },
  { 2469, 16, 30, 22, 4, -30 },
  { 2529, 24, 37, 28, 2, -30 },
  { 2640, 17, 30, 22, 4, -30 },
  { 2704, 16, 30, 21, 2, -30 },
  { 2764, 19, 30, 19, 0, -30 },
  { 2836, 19, 30, 27, 4, -30 },
  { 2908, 21, 30, 21, 0, -30 },
  { 2987, 32, 30, 34, 1, -30 },
  { 3107, 19, 30, 19, 0, -30 },
  { 3179, 19, 30, 19, 0, -30 },
  { 3251, 18, 30, 20, 1, -30 },
  { 3319, 8, 37, 13, 4, -30 },
  { 3356, 12, 30, 14, 1, -30 },
  { 3401, 9, 37, 13, 1, -30 },
  { 3443, 19, 17, 21, 1, -30 },
  { 3484, 17, 1, 17, 0, 4 },
  { 3487, 7, 7, 10, 2, -32 },
  { 3494, 14, 23, 20, 2, -23 },
  { 3535, 17, 32, 22, 3, -32 },
  { 3603, 14, 23, 18, 2, -23 },
  { 3644, 17, 32, 22, 2, -32 },
  { 3712, 16, 23, 20, 2, -23 },
  { 3758, 13, 32, 11, 0, -32 },
  { 3810, 17, 33, 22, 2, -23 },
  { 3881, 16, 32, 22, 3, -32 },
  { 3945, 3, 30, 9, 3, -30 },
  { 3957, 7, 40, 9, -1, -30 },
  { 3992, 15, 32, 18, 3, -32 },
  { 4052, 2, 32, 8, 3, -32 },
  { 4060, 26, 23, 33, 3, -23 },
  { 4135, 16, 23, 22, 3, -23 },
  { 4181, 18, 23, 22, 2, -23 },
  { 4233, 17, 33, 22, 3, -23 },
  { 4304, 17, 33, 22, 2, -23 },
  { 4375, 11, 23, 14, 3, -23 },
  { 4407, 13, 23, 17, 2, -23 },
  { 4445, 10, 28, 12, 1, -28 },
  { 4480, 15, 22, 22, 3, -22 },
  { 4522, 17, 22, 17, 0, -22 },
  { 4569, 25, 22, 27, 1, -22 },
  { 4638, 16, 22, 18, 1, -22 },
  { 4682, 17, 32, 17, 0, -22 },
  { 4750, 13, 22, 16, 2, -22 },
  { 4786, 12, 37, 15, 1, -30 },
  { 4842, 2, 42, 20, 9, -32 },
  { 4853, 11, 37, 15, 2, -30 },
  { 4904, 17, 4, 21, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight42pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT42PT7B_H_
