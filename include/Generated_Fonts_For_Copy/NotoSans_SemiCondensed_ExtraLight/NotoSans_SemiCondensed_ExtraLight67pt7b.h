#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT67PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight67pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xEF, 0x7F, 0xEE, 0x20, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0x00, 0x06,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x03, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x07, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x03,
  0x80, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x07, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xE0, 0x03,
  0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x70, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00,
  0x60, 0x03, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x30, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x70, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3C, 0x30, 0x3C,
  0x1C, 0x0C, 0x01, 0x0E, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0x30,
  0x00, 0x60, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x80,
  0x30, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x01,
  0xC0, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x0F, 0x03, 0x00, 0x01, 0xE0, 0xC0,
  0x00, 0x3E, 0x30, 0x00, 0x03, 0xEC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x1F, 0x00,
  0x00, 0xC1, 0xE0, 0x00, 0x30, 0x3C, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x00,
  0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x00, 0xC0, 0x03,
  0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0,
  0x03, 0x00, 0x70, 0x00, 0xC0, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x0C, 0x07,
  0x10, 0x03, 0x03, 0xC7, 0xC0, 0xC3, 0xE1, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xC0,
  0x07, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x80,
  0x70, 0x00, 0x70, 0x01, 0x80, 0x18, 0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00,
  0x30, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x0E, 0x00, 0x0C, 0x00,
  0x30, 0x06, 0x00, 0x06, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x01, 0xC0, 0x00,
  0x60, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x00,
  0x60, 0x60, 0x00, 0x0C, 0x00, 0x30, 0x70, 0x7F, 0x06, 0x00, 0x38, 0x30,
  0x7F, 0xC3, 0x80, 0x1C, 0x38, 0x70, 0x71, 0xC0, 0x0C, 0x18, 0x70, 0x1C,
  0x60, 0x06, 0x1C, 0x30, 0x06, 0x38, 0x07, 0x0C, 0x38, 0x03, 0x8C, 0x03,
  0x0E, 0x1C, 0x00, 0xC7, 0x03, 0x86, 0x0C, 0x00, 0x61, 0xFF, 0x87, 0x06,
  0x00, 0x38, 0x7F, 0x83, 0x07, 0x00, 0x1C, 0x06, 0x03, 0x83, 0x80, 0x0E,
  0x00, 0x01, 0x81, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0xE0, 0x01, 0x80, 0x00,
  0xC0, 0x70, 0x00, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x60, 0x00, 0x70, 0x1C,
  0x00, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x18, 0x00, 0x38, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0x03, 0x00, 0x70,
  0x03, 0x80, 0x01, 0xC0, 0x70, 0x01, 0x80, 0x00, 0x70, 0x70, 0x01, 0xC0,
  0x00, 0x1E, 0xF8, 0x00, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x70, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x0C, 0x1C, 0x01, 0xE0, 0x01,
  0xC3, 0xC0, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x01, 0xC7, 0x00, 0x03,
  0x80, 0x18, 0x70, 0x00, 0x1C, 0x03, 0x86, 0x00, 0x00, 0xE0, 0x38, 0x60,
  0x00, 0x07, 0x03, 0x0E, 0x00, 0x00, 0x78, 0x70, 0xE0, 0x00, 0x03, 0x86,
  0x0E, 0x00, 0x00, 0x1C, 0xE0, 0xE0, 0x00, 0x00, 0xFC, 0x0E, 0x00, 0x00,
  0x07, 0xC0, 0x60, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x70,
  0x00, 0x00, 0xFC, 0x03, 0x80, 0x00, 0x1C, 0xE0, 0x3C, 0x00, 0x03, 0x87,
  0x01, 0xE0, 0x00, 0xF0, 0x38, 0x0F, 0x80, 0x3E, 0x01, 0xC0, 0x7F, 0xFF,
  0xC0, 0x1E, 0x01, 0xFF, 0xE0, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x40, 0x0C,
  0x01, 0xBC, 0x06, 0x03, 0xFF, 0xC3, 0x0F, 0xE1, 0xFD, 0xBF, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x38, 0x1C, 0x00,
  0x38, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x3C, 0x00, 0xF0, 0x0C, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x71, 0xC6, 0x38, 0xE3, 0x8C, 0x71, 0xC6, 0x18, 0xE3, 0x0C,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x6F, 0xFF, 0xF2, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x03, 0x80, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x38, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x60,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x0E, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x60, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0xC0, 0x3B, 0x03, 0xCC,
  0x1E, 0x70, 0xF1, 0xC7, 0x07, 0x78, 0x1F, 0xC0, 0x76, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xC0, 0x3C, 0x07, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0x1C, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x1F,
  0x80, 0x3E, 0x07, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x10, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x71, 0x80, 0x00, 0x3C,
  0x3E, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x18,
  0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0x70,
  0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x80, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x03, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF2, 0x00, 0x00,
  0x78, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x80, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x07, 0xFE, 0x01, 0xC3, 0xFF, 0xF0, 0x38, 0xF0, 0x0F, 0x87,
  0x38, 0x00, 0x70, 0xEC, 0x00, 0x07, 0x1F, 0x00, 0x00, 0x73, 0xE0, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x70, 0x1E, 0x00, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x07, 0x18, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0xE0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x03, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0xE0, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x0E,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xD0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x06, 0x30, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x37, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x79, 0x80, 0x00, 0x1F, 0x38,
  0x00, 0x03, 0xE3, 0x80, 0x00, 0xDC, 0x78, 0x00, 0x73, 0x87, 0x80, 0x1C,
  0x70, 0x7F, 0xFF, 0x0E, 0x03, 0xFF, 0x81, 0xC0, 0x07, 0x80, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x08, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0x20, 0x0E, 0x1E,
  0x1F, 0x1E, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38,
  0x38, 0x30, 0x30, 0x70, 0x60, 0x60, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x01,
  0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0x80, 0x7C, 0x40, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x3F,
  0xF0, 0x01, 0xC6, 0x00, 0x07, 0xFF, 0xE0, 0x0E, 0x70, 0x00, 0xF8, 0x07,
  0x00, 0x33, 0x80, 0x0F, 0x00, 0x30, 0x01, 0x98, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x7E, 0x00, 0x70, 0x00, 0x60, 0x03,
  0xF0, 0x03, 0x80, 0x03, 0x00, 0x1F, 0x00, 0x18, 0x00, 0x18, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0x1E, 0x00,
  0x60, 0x00, 0x30, 0x00, 0xF0, 0x03, 0x00, 0x01, 0x80, 0x07, 0x80, 0x18,
  0x00, 0x0C, 0x00, 0x7C, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0xE0, 0x06, 0x00,
  0x07, 0x00, 0x1F, 0x00, 0x30, 0x00, 0x38, 0x00, 0xF8, 0x01, 0x80, 0x01,
  0xC0, 0x06, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x36, 0x00, 0x70, 0x00, 0xF0,
  0x03, 0xB0, 0x01, 0x80, 0x07, 0x80, 0x19, 0xC0, 0x0E, 0x00, 0x6C, 0x01,
  0xCE, 0x00, 0x70, 0x03, 0x30, 0x0C, 0x70, 0x01, 0xC0, 0x71, 0xC0, 0xE1,
  0x80, 0x07, 0xFF, 0x07, 0xFE, 0x0E, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x70,
  0x00, 0x3C, 0x00, 0x38, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x18, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x18,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x18, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0E, 0x00,
  0x01, 0xF0, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x1E, 0x0E, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0xE0, 0x00, 0x7E, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x1F, 0x0E, 0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0xC0, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x80, 0x1F,
  0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0xE0, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x3E, 0x00, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x1C,
  0x03, 0xE0, 0x00, 0x00, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0x01, 0xC0,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1E, 0x00, 0xF3, 0xFF, 0x8F, 0xFC,
  0x1F, 0xC0, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x0F,
  0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xE0, 0x3C,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x0E, 0x3E, 0x00, 0x00, 0xE7, 0xF0, 0x00, 0x0E, 0x77,
  0x00, 0x00, 0xEE, 0x38, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0xF8, 0x1C, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x1E,
  0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x78, 0x0E,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1B, 0xFC, 0x00, 0x00,
  0x00, 0x3B, 0xEC, 0x00, 0x00, 0x00, 0x3B, 0xEE, 0x00, 0x00, 0x00, 0x33,
  0xEE, 0x00, 0x00, 0x00, 0x73, 0xE7, 0x00, 0x00, 0x00, 0x63, 0xE7, 0x00,
  0x00, 0x00, 0x63, 0xE3, 0x00, 0x00, 0x00, 0xE3, 0xE3, 0x80, 0x00, 0x00,
  0xC3, 0xE3, 0x80, 0x00, 0x01, 0xC3, 0xE1, 0x80, 0x00, 0x01, 0xC3, 0xE1,
  0xC0, 0x00, 0x01, 0x83, 0xE1, 0xC0, 0x00, 0x03, 0x83, 0xE0, 0xC0, 0x00,
  0x03, 0x83, 0xE0, 0xE0, 0x00, 0x03, 0x03, 0xE0, 0x60, 0x00, 0x07, 0x03,
  0xE0, 0x70, 0x00, 0x06, 0x03, 0xE0, 0x70, 0x00, 0x06, 0x03, 0xE0, 0x30,
  0x00, 0x0E, 0x03, 0xE0, 0x38, 0x00, 0x0C, 0x03, 0xE0, 0x38, 0x00, 0x1C,
  0x03, 0xE0, 0x18, 0x00, 0x1C, 0x03, 0xE0, 0x1C, 0x00, 0x18, 0x03, 0xE0,
  0x1C, 0x00, 0x38, 0x03, 0xE0, 0x0C, 0x00, 0x38, 0x03, 0xE0, 0x0E, 0x00,
  0x30, 0x03, 0xE0, 0x06, 0x00, 0x70, 0x03, 0xE0, 0x07, 0x00, 0x60, 0x03,
  0xE0, 0x07, 0x00, 0x60, 0x03, 0xE0, 0x03, 0x00, 0xE0, 0x03, 0xE0, 0x03,
  0x80, 0xC0, 0x03, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0xE0, 0x01, 0x81, 0xC0,
  0x03, 0xE0, 0x01, 0xC1, 0x80, 0x03, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0xE0,
  0x00, 0xC3, 0x80, 0x03, 0xE0, 0x00, 0xE3, 0x00, 0x03, 0xE0, 0x00, 0x67,
  0x00, 0x03, 0xE0, 0x00, 0x76, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFB, 0x80, 0x00, 0x03, 0xF7,
  0x00, 0x00, 0x07, 0xE7, 0x00, 0x00, 0x0F, 0xCE, 0x00, 0x00, 0x1F, 0x8E,
  0x00, 0x00, 0x3F, 0x0E, 0x00, 0x00, 0x7E, 0x1C, 0x00, 0x00, 0xFC, 0x1C,
  0x00, 0x01, 0xF8, 0x38, 0x00, 0x03, 0xF0, 0x38, 0x00, 0x07, 0xE0, 0x38,
  0x00, 0x0F, 0xC0, 0x70, 0x00, 0x1F, 0x80, 0x70, 0x00, 0x3F, 0x00, 0xE0,
  0x00, 0x7E, 0x00, 0xE0, 0x00, 0xFC, 0x01, 0xC0, 0x01, 0xF8, 0x01, 0xC0,
  0x03, 0xF0, 0x01, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x03, 0x80,
  0x1F, 0x80, 0x07, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x7E, 0x00, 0x07, 0x00,
  0xFC, 0x00, 0x0E, 0x01, 0xF8, 0x00, 0x0E, 0x03, 0xF0, 0x00, 0x1C, 0x07,
  0xE0, 0x00, 0x1C, 0x0F, 0xC0, 0x00, 0x38, 0x1F, 0x80, 0x00, 0x38, 0x3F,
  0x00, 0x00, 0x38, 0x7E, 0x00, 0x00, 0x70, 0xFC, 0x00, 0x00, 0x71, 0xF8,
  0x00, 0x00, 0xE3, 0xF0, 0x00, 0x00, 0xE7, 0xE0, 0x00, 0x00, 0xEF, 0xC0,
  0x00, 0x01, 0xDF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x0B, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x1C, 0x00, 0x0F, 0x8E, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0xF8,
  0x70, 0x1F, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x0E,
  0x18, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x03,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x0B, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x0E, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x18, 0xE0, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x0E, 0x00,
  0x07, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0xE0,
  0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0x87, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x30, 0x00, 0x07, 0x8F, 0x80, 0x07, 0xC3, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00,
  0x38, 0x06, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x0D,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x0E, 0x38, 0x00,
  0x03, 0x98, 0x00, 0x01, 0x83, 0x00, 0x00, 0x73, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x0C, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x8E, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x70, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0E,
  0x03, 0x80, 0x01, 0x83, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x30, 0x70, 0x00,
  0x38, 0x0E, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x01, 0xC0, 0xC0,
  0x01, 0xC0, 0x1C, 0x00, 0x30, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x06, 0x03,
  0x80, 0x06, 0x00, 0x70, 0x01, 0xC0, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x38,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xC0, 0x1C, 0x00, 0xC0, 0x03, 0x80, 0x38, 0x01, 0x80, 0x18, 0x00, 0x30,
  0x07, 0x00, 0x30, 0x07, 0x00, 0x07, 0x00, 0xC0, 0x07, 0x00, 0xE0, 0x00,
  0xE0, 0x18, 0x00, 0xE0, 0x18, 0x00, 0x1C, 0x07, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x80, 0xE0, 0x01, 0x80, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x38, 0x1C,
  0x00, 0x07, 0x03, 0x00, 0x07, 0x03, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x60,
  0x60, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0xC3, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0x60, 0x00, 0x38, 0x60, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x63, 0x80, 0x00, 0x0C, 0x60,
  0x00, 0x0E, 0x70, 0x00, 0x01, 0xCC, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x19, 0x80, 0x00, 0x03, 0x70, 0x00, 0x03, 0x70, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x1C, 0x0C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x60, 0x03, 0x80, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x03, 0x86, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x70, 0x03, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x18,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x18, 0x03, 0x80, 0x00, 0x70, 0x0C, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x03, 0x81, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x1C, 0x30, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x0E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0x07, 0xC0, 0xE0, 0x01, 0xC1, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x3F, 0xFE, 0x03,
  0xFF, 0xFC, 0x1F, 0x80, 0x18, 0xF8, 0x00, 0x33, 0xC0, 0x00, 0x6F, 0x00,
  0x00, 0xDC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0D, 0xB8, 0x00, 0x1B, 0x78, 0x00, 0xE6, 0x78, 0x03, 0x8C,
  0x7F, 0xFE, 0x18, 0x7F, 0xF0, 0x30, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x01, 0xFF, 0x00, 0xE0, 0xFF, 0xF8, 0x1C, 0x7E, 0x0F, 0x83, 0x9E, 0x00,
  0x78, 0x73, 0x00, 0x07, 0x8E, 0xC0, 0x00, 0x71, 0xF8, 0x00, 0x07, 0x3E,
  0x00, 0x00, 0x67, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x1B, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xDE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0x7C, 0x00,
  0x00, 0xCF, 0x80, 0x00, 0x39, 0xF8, 0x00, 0x0E, 0x3B, 0x00, 0x01, 0xC7,
  0x30, 0x00, 0xF0, 0xE3, 0x80, 0x3C, 0x1C, 0x3F, 0xFF, 0x03, 0x83, 0xFF,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x3F,
  0x87, 0xC1, 0xE0, 0x01, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x30, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x01, 0xFE, 0x03, 0x01, 0xFF, 0xE0, 0xC1, 0xF8, 0x3C, 0x30, 0xF0, 0x03,
  0x8C, 0x78, 0x00, 0x33, 0x1C, 0x00, 0x06, 0xCE, 0x00, 0x01, 0xB7, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70, 0x00,
  0x03, 0xCE, 0x00, 0x01, 0xB3, 0xC0, 0x00, 0xCC, 0x78, 0x00, 0x73, 0x0F,
  0x00, 0x38, 0xC1, 0xFF, 0xFC, 0x30, 0x1F, 0xFC, 0x0C, 0x00, 0x78, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0x07,
  0x01, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x60, 0x00,
  0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x01, 0x98, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x01, 0x03, 0xE0, 0x07, 0x80, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x07,
  0xFF, 0x00, 0xF0, 0x20, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x30, 0x7E,
  0x0F, 0x8C, 0x3C, 0x00, 0x73, 0x1E, 0x00, 0x0C, 0xC7, 0x00, 0x01, 0xB3,
  0x80, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0F, 0x70,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0xB3, 0x80, 0x00, 0x6C, 0x70, 0x00, 0x33,
  0x1E, 0x00, 0x1C, 0xC3, 0xC0, 0x1E, 0x30, 0x7F, 0xFF, 0x0C, 0x07, 0xFF,
  0x03, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x71, 0x00, 0x00, 0x38, 0x70, 0x00, 0x3E, 0x1F, 0xC0, 0x7F, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x7F, 0x80, 0xE0, 0xFF, 0xF0, 0x71, 0xF0,
  0x7E, 0x39, 0xE0, 0x07, 0x1C, 0xC0, 0x01, 0xCE, 0xC0, 0x00, 0x77, 0xC0,
  0x00, 0x3B, 0xE0, 0x00, 0x0D, 0xE0, 0x00, 0x06, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xE0, 0x4F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x80,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x21,
  0xE7, 0xF8, 0xFC, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x02, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xC7, 0x00,
  0x07, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x03,
  0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0xE0, 0x07, 0x01, 0x80,
  0x0E, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x71, 0xF0, 0x00,
  0xE3, 0x70, 0x01, 0xCC, 0x60, 0x03, 0xB8, 0xE0, 0x07, 0xE0, 0xE0, 0x0F,
  0x81, 0xC0, 0x1E, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0,
  0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x38, 0x7F, 0xF0, 0x0F,
  0xFF, 0x0E, 0x3C, 0x1F, 0x07, 0xC3, 0xE3, 0x9C, 0x01, 0xC3, 0x80, 0x3C,
  0xEC, 0x00, 0x39, 0xC0, 0x07, 0xBB, 0x00, 0x06, 0x60, 0x00, 0xEF, 0x80,
  0x01, 0xF0, 0x00, 0x1B, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x38, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x07,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x38, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x3F, 0xC0, 0x70, 0x7F, 0xF8, 0x38, 0xF8, 0x3F, 0x1C, 0xF0, 0x03,
  0xCE, 0x60, 0x00, 0xE7, 0x60, 0x00, 0x3B, 0xE0, 0x00, 0x1D, 0xF0, 0x00,
  0x06, 0xF0, 0x00, 0x03, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0x83, 0xF0, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x38, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x07,
  0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x18, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x1C, 0x1F, 0xFF, 0x03, 0x87, 0xC1, 0xF0, 0x71, 0xC0, 0x0F, 0x0E,
  0x60, 0x00, 0xF1, 0xD8, 0x00, 0x0E, 0x3B, 0x00, 0x00, 0xE7, 0xC0, 0x00,
  0x0C, 0xF8, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0x78,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1B, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xEF, 0x80, 0x00, 0x19,
  0xF0, 0x00, 0x07, 0x3B, 0x00, 0x01, 0xC7, 0x70, 0x00, 0x38, 0xE7, 0x00,
  0x0E, 0x1C, 0x78, 0x07, 0x83, 0x87, 0xFF, 0xE0, 0x70, 0x7F, 0xF0, 0x0E,
  0x01, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFE,
  0x0C, 0x0F, 0xC1, 0xE1, 0x83, 0xC0, 0x0E, 0x30, 0xF0, 0x00, 0x66, 0x3C,
  0x00, 0x06, 0xC7, 0x00, 0x00, 0xD9, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x01,
  0xE6, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x03, 0x98, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x06, 0xC7,
  0x00, 0x00, 0xD8, 0xF0, 0x00, 0x33, 0x0F, 0x00, 0x0E, 0x60, 0xF0, 0x07,
  0x9C, 0x0F, 0xFF, 0xC3, 0x80, 0x7F, 0xF0, 0x70, 0x01, 0xF0, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x7F, 0xF0, 0xFF, 0xF8, 0xFD, 0xFC, 0xF0, 0x0E, 0x60,
  0x07, 0x60, 0x03, 0xB0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xFF,
  0xC1, 0xF8, 0x1F, 0x8F, 0x00, 0x04, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x80,
  0x00, 0x73, 0xC0, 0x07, 0x8F, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x03, 0xF0,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x03,
  0xC0, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x1B, 0x78, 0x00, 0x3B, 0x3C, 0x00,
  0x73, 0x1E, 0x00, 0xE3, 0x0F, 0xFF, 0xC3, 0x07, 0xFF, 0x03, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x19, 0xC0,
  0x00, 0x0E, 0x30, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x70,
  0x60, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x07, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0xE0, 0x38, 0x00, 0x30, 0x0E, 0x00, 0x1C, 0x01, 0x80, 0x07, 0x00, 0x70,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x00, 0xE0, 0x0C, 0x00,
  0x38, 0x07, 0x00, 0x06, 0x01, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x18,
  0x00, 0x0C, 0x0E, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x18,
  0x70, 0x00, 0x07, 0x18, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x0C, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x80, 0x00, 0xCE, 0x00,
  0x07, 0xC0, 0x00, 0x67, 0x00, 0x03, 0x70, 0x00, 0x73, 0x80, 0x01, 0xB8,
  0x00, 0x38, 0xC0, 0x00, 0xCC, 0x00, 0x18, 0x70, 0x00, 0xE6, 0x00, 0x0C,
  0x38, 0x00, 0x63, 0x80, 0x0E, 0x1C, 0x00, 0x31, 0xC0, 0x07, 0x06, 0x00,
  0x38, 0x60, 0x03, 0x03, 0x80, 0x1C, 0x38, 0x01, 0x81, 0xC0, 0x0C, 0x1C,
  0x01, 0xC0, 0x60, 0x06, 0x06, 0x00, 0xE0, 0x30, 0x07, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0xE0, 0x38, 0x03, 0x01,
  0xC0, 0x30, 0x1C, 0x01, 0x80, 0xE0, 0x18, 0x0C, 0x00, 0xE0, 0x60, 0x0E,
  0x06, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x18, 0x38, 0x01, 0x83, 0x80,
  0x0C, 0x18, 0x00, 0xE1, 0x80, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x03, 0x8E,
  0x00, 0x18, 0xE0, 0x00, 0xC7, 0x00, 0x0C, 0x70, 0x00, 0x63, 0x00, 0x07,
  0x30, 0x00, 0x39, 0x80, 0x03, 0x98, 0x00, 0x1D, 0xC0, 0x00, 0xDC, 0x00,
  0x06, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0x60, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x03, 0xCE, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x01,
  0xC0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x01, 0x80, 0x70,
  0x00, 0x70, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x03,
  0x80, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x00, 0x60,
  0x70, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x18,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x06, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0, 0x38,
  0x00, 0x38, 0x03, 0x00, 0x07, 0x00, 0x60, 0x00, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x30,
  0x07, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0C, 0x07, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x03, 0x07, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x37, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x87, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x08, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0x7C, 0xFE, 0x00, 0x3E, 0x00, 0xF8, 0x0F,
  0xC0, 0x03, 0xFF, 0xE8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0C, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 49, 15, 5, -48 },
  { 32, 12, 17, 22, 5, -48 },
  { 58, 34, 48, 38, 2, -48 },
  { 262, 26, 55, 34, 3, -51 },
  { 441, 41, 50, 49, 4, -49 },
  { 698, 36, 50, 40, 3, -49 },
  { 923, 2, 17, 12, 5, -48 },
  { 928, 12, 59, 18, 3, -48 },
  { 1017, 13, 59, 18, 2, -48 },
  { 1113, 25, 24, 32, 3, -51 },
  { 1188, 28, 31, 34, 3, -39 },
  { 1297, 6, 16, 13, 3, -7 },
  { 1309, 16, 2, 20, 2, -19 },
  { 1313, 4, 6, 14, 5, -5 },
  { 1316, 20, 48, 22, 1, -48 },
  { 1436, 26, 50, 34, 4, -49 },
  { 1599, 14, 48, 34, 6, -48 },
  { 1683, 27, 49, 34, 3, -49 },
  { 1849, 27, 50, 34, 3, -49 },
  { 2018, 32, 48, 34, 1, -48 },
  { 2210, 26, 49, 34, 4, -48 },
  { 2370, 27, 50, 34, 4, -49 },
  { 2539, 27, 48, 34, 3, -48 },
  { 2701, 27, 50, 34, 3, -49 },
  { 2870, 27, 50, 34, 3, -49 },
  { 3039, 4, 37, 14, 5, -36 },
  { 3058, 8, 45, 14, 2, -36 },
  { 3103, 28, 30, 34, 3, -39 },
  { 3208, 28, 16, 34, 3, -32 },
  { 3264, 28, 30, 34, 3, -39 },
  { 3369, 20, 50, 24, 2, -49 },
  { 3494, 45, 54, 52, 4, -48 },
  { 3798, 35, 48, 35, 0, -48 },
  { 4008, 28, 48, 37, 6, -48 },
  { 4176, 31, 50, 37, 4, -49 },
  { 4370, 32, 48, 42, 6, -48 },
  { 4562, 23, 48, 33, 6, -48 },
  { 4700, 23, 48, 30, 6, -48 },
  { 4838, 35, 50, 44, 4, -49 },
  { 5057, 30, 48, 42, 6, -48 },
  { 5237, 12, 48, 18, 3, -48 },
  { 5309, 14, 60, 15, -5, -48 },
  { 5414, 28, 48, 34, 6, -48 },
  { 5582, 23, 48, 30, 6, -48 },
  { 5720, 40, 48, 52, 6, -48 },
  { 5960, 31, 48, 43, 6, -48 },
  { 6146, 37, 50, 45, 4, -49 },
  { 6378, 25, 48, 35, 6, -48 },
  { 6528, 37, 60, 45, 4, -49 },
  { 6806, 28, 48, 35, 6, -48 },
  { 6974, 26, 50, 33, 3, -49 },
  { 7137, 30, 48, 30, 0, -48 },
  { 7317, 31, 49, 42, 6, -48 },
  { 7507, 34, 48, 34, 0, -48 },
  { 7711, 51, 48, 54, 1, -48 },
  { 8017, 31, 48, 31, 0, -48 },
  { 8203, 30, 48, 30, 0, -48 },
  { 8383, 28, 48, 33, 2, -48 },
  { 8551, 13, 59, 21, 6, -48 },
  { 8647, 20, 48, 22, 1, -48 },
  { 8767, 13, 59, 21, 2, -48 },
  { 8863, 30, 27, 34, 2, -48 },
  { 8965, 27, 2, 27, 0, 6 },
  { 8972, 11, 10, 17, 3, -51 },
  { 8986, 23, 37, 31, 3, -36 },
  { 9093, 27, 52, 36, 5, -51 },
  { 9269, 22, 37, 28, 4, -36 },
  { 9371, 26, 52, 36, 4, -51 },
  { 9540, 25, 37, 33, 4, -36 },
  { 9656, 20, 51, 18, 1, -51 },
  { 9784, 26, 52, 36, 4, -36 },
  { 9953, 25, 51, 35, 5, -51 },
  { 10113, 4, 49, 14, 5, -49 },
  { 10138, 11, 65, 14, -2, -49 },
  { 10228, 23, 51, 28, 5, -51 },
  { 10375, 3, 51, 14, 5, -51 },
  { 10395, 42, 36, 52, 5, -36 },
  { 10584, 25, 36, 35, 5, -36 },
  { 10697, 27, 37, 35, 4, -36 },
  { 10822, 27, 52, 36, 5, -36 },
  { 10998, 27, 52, 36, 3, -36 },
  { 11174, 17, 36, 23, 5, -36 },
  { 11251, 22, 37, 27, 3, -36 },
  { 11353, 17, 45, 19, 1, -44 },
  { 11449, 24, 36, 35, 5, -35 },
  { 11557, 26, 35, 27, 0, -35 },
  { 11671, 41, 35, 43, 1, -35 },
  { 11851, 26, 35, 29, 1, -35 },
  { 11965, 27, 51, 27, 0, -35 },
  { 12138, 22, 35, 26, 2, -35 },
  { 12235, 19, 59, 23, 2, -48 },
  { 12376, 2, 67, 32, 15, -51 },
  { 12393, 18, 59, 23, 3, -48 },
  { 12526, 28, 7, 34, 3, -27 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight67pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT67PT7B_H_
