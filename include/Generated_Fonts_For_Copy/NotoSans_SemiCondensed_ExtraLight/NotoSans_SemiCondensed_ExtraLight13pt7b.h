#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT13PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xFC, 0x14, 0x49, 0xF9, 0x22, 0x9F, 0xCA, 0x24, 0x48,
  0x27, 0xA9, 0x4A, 0x38, 0xA5, 0x2F, 0x88, 0xE4, 0xA4, 0xA8, 0xAE, 0xB9,
  0x59, 0x29, 0x29, 0x46, 0x71, 0x22, 0x43, 0x06, 0x12, 0xA3, 0x44, 0xF6,
  0xE0, 0x6A, 0xAA, 0xA4, 0xC8, 0x92, 0x49, 0x2B, 0x00, 0x22, 0xF6, 0x90,
  0x21, 0x09, 0xF2, 0x10, 0x58, 0xE0, 0x80, 0x11, 0x22, 0x24, 0x44, 0x80,
  0xF4, 0x63, 0x18, 0xC6, 0x31, 0x70, 0x74, 0x92, 0x49, 0x20, 0xF0, 0x42,
  0x21, 0x11, 0x10, 0xF8, 0xF0, 0x42, 0x27, 0x04, 0x21, 0xF0, 0x08, 0x62,
  0x8A, 0x4A, 0x2F, 0xC2, 0x08, 0xF4, 0x21, 0xE0, 0x84, 0x21, 0xF0, 0x74,
  0x21, 0xE8, 0xC6, 0x31, 0x70, 0xF8, 0x44, 0x22, 0x10, 0x88, 0x40, 0xF4,
  0x62, 0xA7, 0x46, 0x31, 0xF0, 0xF4, 0x63, 0x19, 0xB4, 0x22, 0xE0, 0x82,
  0x40, 0x05, 0x80, 0x09, 0x91, 0x06, 0x0C, 0xF8, 0x3E, 0x82, 0x0C, 0x13,
  0x60, 0xF1, 0x11, 0x24, 0x40, 0x40, 0x3E, 0x20, 0xA7, 0x54, 0x9A, 0x4D,
  0x26, 0x95, 0x34, 0x80, 0x3E, 0x00, 0x10, 0x50, 0xA1, 0x44, 0x8F, 0x91,
  0x42, 0x82, 0xFA, 0x18, 0x62, 0xFA, 0x18, 0x61, 0xF8, 0x7E, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x7C, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x61, 0xF8, 0xFC,
  0x21, 0x0F, 0x42, 0x10, 0xF8, 0xFC, 0x21, 0x0F, 0x42, 0x10, 0x80, 0x7F,
  0x02, 0x04, 0x08, 0xF0, 0x60, 0xC1, 0x7E, 0x86, 0x18, 0x61, 0xFE, 0x18,
  0x61, 0x84, 0xEA, 0xAA, 0xC0, 0x24, 0x92, 0x49, 0x27, 0x80, 0x8A, 0x4A,
  0x30, 0xA2, 0x49, 0x22, 0x8C, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0x81,
  0xC1, 0xC3, 0xA3, 0xA5, 0xA5, 0x99, 0x99, 0x89, 0x87, 0x1A, 0x69, 0x96,
  0x58, 0xE3, 0x84, 0x7D, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0x78, 0xFC,
  0x63, 0x1F, 0x42, 0x10, 0x80, 0x7D, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC2,
  0x78, 0x10, 0x10, 0xFA, 0x28, 0xA2, 0xF2, 0x49, 0x22, 0x8C, 0xFC, 0x21,
  0x83, 0x04, 0x21, 0xF0, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x78, 0x87, 0x09, 0x12, 0x24, 0x85, 0x0A,
  0x08, 0x10, 0x84, 0x63, 0x14, 0xC5, 0x2A, 0x52, 0x94, 0xA3, 0x28, 0x84,
  0x21, 0x00, 0xC5, 0x23, 0x0C, 0x10, 0xC4, 0x92, 0x84, 0x85, 0x24, 0x8C,
  0x30, 0x82, 0x08, 0x20, 0x7C, 0x20, 0x84, 0x10, 0x84, 0x10, 0xFC, 0xF2,
  0x49, 0x24, 0x93, 0x80, 0x84, 0x44, 0x22, 0x21, 0x10, 0xE4, 0x92, 0x49,
  0x27, 0x80, 0x10, 0xA4, 0x91, 0x84, 0xF8, 0xB0, 0xF1, 0x17, 0x99, 0xF0,
  0x84, 0x21, 0xE8, 0xC6, 0x31, 0x8F, 0x80, 0x78, 0x88, 0x88, 0x70, 0x08,
  0x42, 0xF8, 0xC6, 0x31, 0x8F, 0xC0, 0x74, 0x63, 0xF8, 0x41, 0xE0, 0x34,
  0x4E, 0x44, 0x44, 0x44, 0x7C, 0x63, 0x18, 0xC7, 0xE1, 0x0F, 0x80, 0x84,
  0x21, 0xE8, 0xC6, 0x31, 0x8C, 0x40, 0xBF, 0x80, 0x45, 0x55, 0x57, 0x88,
  0x89, 0xAA, 0xEA, 0x99, 0xFF, 0xC0, 0xF7, 0x89, 0x89, 0x89, 0x89, 0x89,
  0x89, 0xF4, 0x63, 0x18, 0xC6, 0x20, 0x74, 0x63, 0x18, 0xC5, 0xC0, 0xF4,
  0x63, 0x18, 0xC7, 0xD0, 0x84, 0x00, 0x7C, 0x63, 0x18, 0xC7, 0xE1, 0x08,
  0x40, 0xF2, 0x49, 0x20, 0x7C, 0x10, 0x60, 0x87, 0xC0, 0x4B, 0xA4, 0x92,
  0x60, 0x8C, 0x63, 0x18, 0xC7, 0xE0, 0x8C, 0x52, 0xA5, 0x10, 0x80, 0x89,
  0x89, 0x59, 0x55, 0x66, 0x22, 0x22, 0x8A, 0x4C, 0x43, 0x26, 0x20, 0x8C,
  0x52, 0xA5, 0x10, 0x84, 0x26, 0x00, 0x78, 0x84, 0x44, 0x23, 0xE0, 0x32,
  0x22, 0x2C, 0x22, 0x22, 0x30, 0xFF, 0xF8, 0xC9, 0x24, 0x52, 0x4A, 0x00,
  0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 2, 3, 4, 1, -9 },
  { 4, 7, 9, 7, 0, -9 },
  { 12, 5, 11, 7, 1, -10 },
  { 19, 8, 9, 9, 1, -9 },
  { 28, 7, 9, 8, 1, -9 },
  { 36, 1, 3, 2, 1, -9 },
  { 37, 2, 11, 3, 1, -9 },
  { 40, 3, 11, 3, 0, -9 },
  { 45, 4, 5, 6, 1, -10 },
  { 48, 5, 6, 7, 1, -8 },
  { 52, 2, 3, 3, 0, -1 },
  { 53, 3, 1, 4, 0, -4 },
  { 54, 1, 1, 3, 1, -1 },
  { 55, 4, 9, 4, 0, -9 },
  { 60, 5, 9, 7, 1, -9 },
  { 66, 3, 9, 7, 1, -9 },
  { 70, 5, 9, 7, 1, -9 },
  { 76, 5, 9, 7, 1, -9 },
  { 82, 6, 9, 7, 0, -9 },
  { 89, 5, 9, 7, 1, -9 },
  { 95, 5, 9, 7, 1, -9 },
  { 101, 5, 9, 7, 1, -9 },
  { 107, 5, 9, 7, 1, -9 },
  { 113, 5, 9, 7, 1, -9 },
  { 119, 1, 7, 3, 1, -7 },
  { 120, 2, 9, 3, 0, -7 },
  { 123, 5, 6, 7, 1, -8 },
  { 127, 5, 3, 7, 1, -6 },
  { 129, 5, 6, 7, 1, -8 },
  { 133, 4, 9, 5, 0, -9 },
  { 138, 9, 10, 10, 1, -9 },
  { 150, 7, 9, 7, 0, -9 },
  { 158, 6, 9, 7, 1, -9 },
  { 165, 6, 9, 7, 1, -9 },
  { 172, 6, 9, 8, 1, -9 },
  { 179, 5, 9, 6, 1, -9 },
  { 185, 5, 9, 6, 1, -9 },
  { 191, 7, 9, 8, 1, -9 },
  { 199, 6, 9, 8, 1, -9 },
  { 206, 2, 9, 4, 1, -9 },
  { 209, 3, 11, 3, -1, -9 },
  { 214, 6, 9, 7, 1, -9 },
  { 221, 5, 9, 6, 1, -9 },
  { 227, 8, 9, 10, 1, -9 },
  { 236, 6, 9, 8, 1, -9 },
  { 243, 7, 9, 9, 1, -9 },
  { 251, 5, 9, 7, 1, -9 },
  { 257, 7, 11, 9, 1, -9 },
  { 267, 6, 9, 7, 1, -9 },
  { 274, 5, 9, 6, 1, -9 },
  { 280, 6, 9, 6, 0, -9 },
  { 287, 6, 9, 8, 1, -9 },
  { 294, 7, 9, 7, 0, -9 },
  { 302, 10, 9, 10, 0, -9 },
  { 314, 6, 9, 6, 0, -9 },
  { 321, 6, 9, 6, 0, -9 },
  { 328, 6, 9, 6, 0, -9 },
  { 335, 3, 11, 4, 1, -9 },
  { 340, 4, 9, 4, 0, -9 },
  { 345, 3, 11, 4, 0, -9 },
  { 350, 6, 5, 7, 0, -9 },
  { 354, 5, 1, 5, 0, 1 },
  { 355, 2, 2, 3, 1, -10 },
  { 356, 4, 7, 6, 1, -7 },
  { 360, 5, 10, 7, 1, -10 },
  { 367, 4, 7, 5, 1, -7 },
  { 371, 5, 10, 7, 1, -10 },
  { 378, 5, 7, 6, 1, -7 },
  { 383, 4, 10, 3, 0, -10 },
  { 388, 5, 10, 7, 1, -7 },
  { 395, 5, 10, 7, 1, -10 },
  { 402, 1, 9, 3, 1, -9 },
  { 404, 2, 12, 3, 0, -9 },
  { 407, 4, 10, 5, 1, -10 },
  { 412, 1, 10, 3, 1, -10 },
  { 414, 8, 7, 10, 1, -7 },
  { 421, 5, 7, 7, 1, -7 },
  { 426, 5, 7, 7, 1, -7 },
  { 431, 5, 10, 7, 1, -7 },
  { 438, 5, 10, 7, 1, -7 },
  { 445, 3, 7, 4, 1, -7 },
  { 448, 5, 7, 5, 0, -7 },
  { 453, 3, 9, 4, 0, -9 },
  { 457, 5, 7, 7, 1, -7 },
  { 462, 5, 7, 5, 0, -7 },
  { 467, 8, 7, 8, 0, -7 },
  { 474, 5, 7, 6, 0, -7 },
  { 479, 5, 10, 5, 0, -7 },
  { 486, 5, 7, 5, 0, -7 },
  { 491, 4, 11, 5, 0, -9 },
  { 497, 1, 13, 6, 3, -10 },
  { 499, 3, 11, 5, 1, -9 },
  { 504, 5, 1, 7, 1, -5 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight13pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT13PT7B_H_
