#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT57PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight57pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x07, 0xFF, 0x70, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x2C, 0x05, 0x80, 0xB0, 0x10, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x30, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x40, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x10, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x30, 0x02, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xE0, 0x7C, 0xC7, 0xC3, 0x83, 0x03,
  0x1C, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x30,
  0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x38, 0x0C,
  0x00, 0x60, 0x30, 0x01, 0xC0, 0xC0, 0x03, 0x83, 0x00, 0x07, 0x8C, 0x00,
  0x0F, 0xB0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x37, 0xC0, 0x00, 0xC7, 0x80, 0x03, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0x70, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00,
  0xC0, 0xCC, 0x03, 0x0E, 0x3F, 0x8D, 0xF0, 0x7F, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x30, 0x03, 0xFC, 0x00, 0x06, 0x00, 0xE0, 0xC0, 0x01,
  0x80, 0x18, 0x0C, 0x00, 0x30, 0x06, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x30,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x0C, 0x03, 0x00, 0x18, 0x01, 0x80, 0x60, 0x03, 0x00, 0x30, 0x18, 0x00,
  0x60, 0x06, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0xE0, 0x01, 0x80, 0x18, 0x18,
  0x00, 0x30, 0x03, 0x07, 0x00, 0x06, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x0C,
  0x18, 0x3E, 0x18, 0x01, 0x86, 0x1F, 0xE1, 0x80, 0x30, 0xC7, 0x0E, 0x30,
  0x0C, 0x30, 0xC0, 0xE6, 0x01, 0x86, 0x30, 0x0C, 0x60, 0x71, 0x86, 0x01,
  0x8E, 0x0C, 0x30, 0xC0, 0x18, 0xFF, 0x0C, 0x30, 0x03, 0x0F, 0xC1, 0x86,
  0x00, 0x60, 0x00, 0x60, 0xC0, 0x0C, 0x00, 0x0C, 0x18, 0x01, 0x80, 0x03,
  0x03, 0x00, 0x30, 0x00, 0x60, 0x60, 0x06, 0x00, 0x18, 0x0C, 0x00, 0xC0,
  0x03, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x30, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x60, 0x03, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x70, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x07, 0x01, 0x80, 0x30,
  0x00, 0x60, 0x60, 0x06, 0x00, 0x07, 0x1C, 0x01, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x01, 0x80, 0x38, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x30,
  0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x70, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x06, 0x00, 0xE0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x01, 0xC0, 0xE0, 0x01, 0x8E, 0x01, 0x80, 0x0C, 0x30, 0x03,
  0x00, 0x31, 0x80, 0x0E, 0x00, 0xC6, 0x00, 0x1C, 0x03, 0x38, 0x00, 0x38,
  0x18, 0xC0, 0x00, 0x70, 0x63, 0x00, 0x00, 0xC3, 0x8C, 0x00, 0x01, 0x8C,
  0x30, 0x00, 0x07, 0x70, 0xC0, 0x00, 0x0F, 0x83, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x78, 0x18, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x1C, 0xC0, 0xE0,
  0x00, 0xE3, 0x81, 0xC0, 0x0F, 0x07, 0x03, 0xFF, 0xF0, 0x0E, 0x07, 0xFF,
  0x00, 0x1C, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0,
  0x60, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x00,
  0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0,
  0x38, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80,
  0x70, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30,
  0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x02, 0x00, 0x80, 0x3E, 0x04, 0x07, 0xFC, 0x21, 0xF8, 0x7D, 0x7C,
  0x00, 0x7F, 0x00, 0x00, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0xC6, 0x00, 0x06,
  0x30, 0x00, 0x60, 0xC0, 0x06, 0x03, 0x00, 0x70, 0x1C, 0x07, 0x00, 0x70,
  0x18, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x0C,
  0x71, 0x86, 0x18, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF7, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1C, 0x07, 0x00, 0x70,
  0x07, 0x01, 0xC0, 0x07, 0x03, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00,
  0x66, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xB8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x66, 0x00,
  0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0x70, 0x00,
  0x18, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x60, 0xC0, 0x01, 0x81, 0xC0, 0x07,
  0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x70, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x07, 0x01, 0xF0, 0x3B, 0x07, 0x30, 0xE3,
  0x3C, 0x37, 0x03, 0xE0, 0x34, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xC0,
  0x3C, 0x1C, 0x00, 0x38, 0x20, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFE,
  0x00, 0x7F, 0xFE, 0x07, 0xC0, 0x1E, 0x3C, 0x00, 0x38, 0xC0, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x3A, 0x00, 0x01, 0xCE, 0x00, 0x1E, 0x3F, 0xC7, 0xF0,
  0x3F, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x03, 0x30, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x07, 0x18,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x60, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0xC0, 0x18, 0x00, 0x38, 0x03, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x03, 0x80, 0x06, 0x00,
  0x60, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x07, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x60, 0x30, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x18, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x62, 0x00, 0x03, 0x8E, 0x00, 0x3C,
  0x3F, 0x9F, 0xC0, 0x3F, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xF0, 0x07, 0x80, 0x20, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x7F, 0x00, 0xC7, 0xFF,
  0x81, 0x9E, 0x03, 0xC7, 0x70, 0x01, 0xCF, 0x80, 0x01, 0x9F, 0x00, 0x03,
  0xBC, 0x00, 0x03, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0xE1, 0xC0, 0x01, 0x81, 0x80, 0x07, 0x01, 0xC0,
  0x1C, 0x01, 0xF1, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x30, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x38, 0x03, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x86, 0x00,
  0x03, 0x1C, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x1C, 0xC0, 0x00,
  0x39, 0x80, 0x00, 0x73, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x87, 0x00, 0x07,
  0x06, 0x00, 0x1C, 0x07, 0x00, 0x70, 0x07, 0x01, 0xC0, 0x07, 0x8F, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0xF0, 0x70, 0x03,
  0x80, 0x78, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x38, 0xE0, 0x00, 0x39, 0x80,
  0x00, 0x37, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x33, 0x00, 0x00, 0x67, 0x00, 0x01, 0x87, 0x00, 0x07, 0x07, 0x00, 0x3C,
  0x07, 0xE3, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x01, 0xE0, 0x3C, 0x06, 0x00, 0x38, 0x30, 0x00, 0x71, 0xC0,
  0x00, 0xC6, 0x00, 0x03, 0x98, 0x00, 0x06, 0xE0, 0x00, 0x1B, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x36, 0x00,
  0x01, 0xD8, 0x00, 0x0F, 0x70, 0x00, 0x3C, 0xE0, 0x01, 0xB1, 0xC0, 0x1C,
  0xC3, 0xFF, 0xE3, 0x03, 0xFE, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x0E, 0x3F, 0x80, 0x3F,
  0xF8, 0x00, 0x1E, 0x00, 0x00, 0x27, 0xFF, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x70, 0x08, 0x73, 0xCF,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x71, 0x86, 0x38, 0xE3, 0x0C, 0x31, 0xC6, 0x18,
  0x63, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xFE, 0x38,
  0x07, 0x90, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x87,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x07,
  0xFC, 0x01, 0x86, 0x00, 0x3F, 0xFC, 0x01, 0x9C, 0x00, 0xE0, 0x18, 0x03,
  0x30, 0x03, 0x80, 0x30, 0x06, 0x60, 0x0E, 0x00, 0x60, 0x0C, 0xC0, 0x18,
  0x00, 0xC0, 0x1F, 0x80, 0x70, 0x01, 0x80, 0x1E, 0x00, 0xC0, 0x03, 0x00,
  0x3C, 0x01, 0x80, 0x06, 0x00, 0x78, 0x03, 0x00, 0x0C, 0x00, 0xF0, 0x06,
  0x00, 0x18, 0x01, 0xE0, 0x1C, 0x00, 0x30, 0x03, 0xC0, 0x38, 0x00, 0x60,
  0x0F, 0x80, 0x70, 0x01, 0xC0, 0x1B, 0x00, 0x60, 0x03, 0x80, 0x36, 0x00,
  0xC0, 0x07, 0x00, 0x6C, 0x01, 0x80, 0x0E, 0x00, 0xD8, 0x03, 0x00, 0x3C,
  0x03, 0x38, 0x07, 0x00, 0x58, 0x06, 0x30, 0x07, 0x01, 0x98, 0x18, 0x60,
  0x07, 0x0E, 0x38, 0x70, 0xC0, 0x07, 0xF8, 0x3F, 0xC1, 0xC0, 0x03, 0xC0,
  0x1E, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x40, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x03, 0xFD,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0x80, 0x00, 0xE0, 0x0C, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x18, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0x0F, 0xF0, 0xC0, 0x00,
  0x78, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00,
  0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0, 0x07, 0xC0, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0xF0, 0xC0, 0x00, 0x38, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x38, 0xC0, 0x01, 0xF0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x0F,
  0x80, 0x1C, 0x07, 0x80, 0x01, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x0C, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x03, 0x00, 0x3F, 0x80, 0x60, 0x00, 0x7C, 0x0C, 0x00,
  0x03, 0xC1, 0x80, 0x00, 0x3C, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03,
  0x98, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x07, 0x0C, 0x00,
  0x03, 0xC1, 0x80, 0x00, 0xF0, 0x30, 0x01, 0xF8, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEC, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEC, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x78, 0x00, 0x06, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x70, 0x00,
  0x00, 0x30, 0xE0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x07, 0x80, 0x00,
  0x0C, 0x0F, 0x00, 0x00, 0x30, 0x0F, 0x00, 0x03, 0xC0, 0x1F, 0xF7, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0xFF, 0xFF,
  0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF,
  0xFF, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0C, 0x83, 0xCF, 0xF8, 0xFE, 0x00, 0xC0, 0x00, 0x0E, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0xE0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x80, 0xC0, 0x07,
  0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x30,
  0x00, 0xC0, 0x70, 0x00, 0xC0, 0xE0, 0x00, 0xC1, 0xC0, 0x00, 0xC3, 0x80,
  0x00, 0xC7, 0x80, 0x00, 0xC7, 0xC0, 0x00, 0xCC, 0xE0, 0x00, 0xD8, 0x60,
  0x00, 0xF0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x03,
  0x00, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00,
  0xE0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x38, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x60, 0x00, 0x00, 0x0F, 0xD8, 0x00,
  0x00, 0x03, 0xF7, 0x00, 0x00, 0x01, 0xBC, 0xC0, 0x00, 0x00, 0x6F, 0x30,
  0x00, 0x00, 0x3B, 0xCE, 0x00, 0x00, 0x0C, 0xF1, 0x80, 0x00, 0x03, 0x3C,
  0x60, 0x00, 0x01, 0x8F, 0x1C, 0x00, 0x00, 0x63, 0xC3, 0x00, 0x00, 0x18,
  0xF0, 0xC0, 0x00, 0x0C, 0x3C, 0x18, 0x00, 0x03, 0x0F, 0x06, 0x00, 0x01,
  0xC3, 0xC1, 0xC0, 0x00, 0x60, 0xF0, 0x30, 0x00, 0x18, 0x3C, 0x0C, 0x00,
  0x0E, 0x0F, 0x03, 0x80, 0x03, 0x03, 0xC0, 0x60, 0x00, 0xC0, 0xF0, 0x18,
  0x00, 0x60, 0x3C, 0x07, 0x00, 0x18, 0x0F, 0x00, 0xC0, 0x06, 0x03, 0xC0,
  0x30, 0x03, 0x00, 0xF0, 0x06, 0x00, 0xC0, 0x3C, 0x01, 0x80, 0x70, 0x0F,
  0x00, 0x70, 0x18, 0x03, 0xC0, 0x0C, 0x06, 0x00, 0xF0, 0x03, 0x03, 0x80,
  0x3C, 0x00, 0xE0, 0xC0, 0x0F, 0x00, 0x18, 0x30, 0x03, 0xC0, 0x06, 0x18,
  0x00, 0xF0, 0x01, 0xC6, 0x00, 0x3C, 0x00, 0x31, 0x80, 0x0F, 0x00, 0x0C,
  0xC0, 0x03, 0xC0, 0x01, 0xB0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0xC0,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xD8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x0F, 0x38,
  0x00, 0x03, 0xC6, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x0F,
  0x06, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x30, 0x00, 0x3C, 0x0E, 0x00,
  0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x30, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x01,
  0x80, 0x0F, 0x00, 0x70, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x80, 0x3C,
  0x00, 0x70, 0x0F, 0x00, 0x0C, 0x03, 0xC0, 0x03, 0x80, 0xF0, 0x00, 0x60,
  0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x60, 0xF0, 0x00,
  0x1C, 0x3C, 0x00, 0x03, 0x0F, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x18, 0xF0,
  0x00, 0x03, 0x3C, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1B, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xF0,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x70, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x60, 0x03, 0x80, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x0C, 0x01, 0xFC, 0x30, 0x00,
  0x78, 0xC0, 0x00, 0x73, 0x00, 0x00, 0xCC, 0x00, 0x03, 0xB0, 0x00, 0x06,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0xEC, 0x00, 0x07, 0x30, 0x00, 0x1C, 0xC0, 0x01, 0xE3,
  0x00, 0x3F, 0x0F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0E, 0x30,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x60, 0x03,
  0x80, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0xC0, 0x3F, 0xC0, 0xC0, 0x01, 0xE0, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xE0, 0xC0, 0x07, 0xC0, 0xFF, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x06,
  0x00, 0xC0, 0x07, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x80, 0xC0, 0x01,
  0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x01, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE1, 0xF0, 0x07, 0x8F, 0x00, 0x02, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xCC, 0x00, 0x1E, 0x3F, 0xEF, 0xF0,
  0x3F, 0xFF, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x67, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0x07, 0x00, 0x03, 0x80, 0xF0, 0x03, 0xC0, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0xE0, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0x60, 0x00, 0x38, 0x03, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x06, 0x01, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x06, 0x1C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0x66, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x60,
  0x00, 0x0F, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0x30, 0x00,
  0x1B, 0x00, 0x00, 0xC3, 0x00, 0x01, 0xB8, 0x00, 0x1C, 0x30, 0x00, 0x19,
  0x80, 0x01, 0xC3, 0x80, 0x03, 0x18, 0x00, 0x18, 0x18, 0x00, 0x31, 0x80,
  0x01, 0x81, 0x80, 0x03, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x30, 0xC0, 0x03,
  0x81, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x00,
  0xC0, 0x06, 0x0E, 0x00, 0x70, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x60, 0x06, 0x00, 0x60, 0x0C,
  0x07, 0x00, 0xE0, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x70, 0x1C, 0x03,
  0x00, 0xC0, 0x03, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x03, 0x81,
  0xC0, 0x03, 0x01, 0x80, 0x18, 0x18, 0x00, 0x38, 0x38, 0x01, 0x81, 0x80,
  0x01, 0x83, 0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x01, 0xC3, 0x80, 0x01,
  0x83, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0xC3, 0x00, 0x00, 0xC6,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0xE7, 0x00, 0x00, 0xC6, 0x00,
  0x06, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x66, 0x00, 0x00, 0x6C, 0x00, 0x06,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x6C, 0x00, 0x03, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x30, 0x70, 0x00, 0x1C,
  0x0C, 0x00, 0x06, 0x03, 0x80, 0x03, 0x80, 0x60, 0x00, 0xC0, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x00, 0xE0, 0x0C, 0x00, 0x18, 0x07, 0x00, 0x07,
  0x01, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x71, 0x80, 0x00, 0x18, 0x70, 0x00,
  0x0E, 0x0C, 0x00, 0x03, 0x03, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x1C,
  0x00, 0x30, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x18, 0x03, 0x80,
  0x03, 0x00, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x18, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0x39, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x81, 0x80, 0x00, 0xE0,
  0x70, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x03, 0x80, 0x06, 0x00, 0x60, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0xE0, 0x18, 0x00, 0x18,
  0x06, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x70, 0x00,
  0x06, 0x18, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0D, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01,
  0x86, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x06,
  0x0E, 0x00, 0x03, 0x86, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x1C,
  0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0xC0, 0x00, 0xF8,
  0x01, 0xFF, 0xE0, 0xFC, 0x1E, 0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x3F, 0xF8, 0x3F, 0xF3,
  0x1E, 0x00, 0x67, 0x00, 0x0D, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xF0, 0x01, 0xB7, 0x00, 0x66, 0x7C, 0x78, 0xC7, 0xFE, 0x08,
  0x1C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x7C, 0x03, 0x0F, 0xFE, 0x0C, 0x78, 0x7C, 0x33, 0x00, 0x38, 0xD8, 0x00,
  0x73, 0xC0, 0x00, 0xCF, 0x00, 0x03, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1B,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x06, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0xCF, 0x00,
  0x07, 0x36, 0x00, 0x38, 0xCC, 0x01, 0xC2, 0x1F, 0x7E, 0x08, 0x3F, 0xF0,
  0x00, 0x0C, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xFC, 0x0F, 0x87, 0x87, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x02,
  0x0F, 0xEF, 0xC0, 0x7F, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x07, 0xC0, 0x60, 0x7F, 0xE0, 0xC1,
  0xE0, 0xF1, 0x87, 0x00, 0x73, 0x1C, 0x00, 0x66, 0x70, 0x00, 0x6C, 0xC0,
  0x00, 0x5B, 0x80, 0x00, 0xF6, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xD8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x3B,
  0x00, 0x00, 0x77, 0x00, 0x01, 0xE6, 0x00, 0x02, 0xCE, 0x00, 0x0D, 0x8E,
  0x00, 0x33, 0x1E, 0x00, 0xE6, 0x0F, 0x8F, 0x8C, 0x0F, 0xFC, 0x18, 0x00,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0x78, 0x7C, 0x03, 0x80,
  0x38, 0x1C, 0x00, 0x60, 0xE0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0xB8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x1F, 0xDF,
  0xE0, 0x1F, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xC0, 0x78,
  0xC0, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x03,
  0xFF, 0xE1, 0xFF, 0xF0, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFF, 0x0C, 0x1F, 0x0F,
  0x18, 0x70, 0x03, 0x31, 0xC0, 0x03, 0x67, 0x00, 0x07, 0xCC, 0x00, 0x07,
  0xB8, 0x00, 0x0F, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xB0, 0x00,
  0x07, 0x70, 0x00, 0x1E, 0x60, 0x00, 0x2C, 0xE0, 0x00, 0xF8, 0xE0, 0x03,
  0x70, 0xE0, 0x0C, 0xE0, 0xF9, 0xF1, 0xC0, 0xFF, 0xC3, 0x80, 0x30, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x60, 0x01, 0xE0, 0xFC, 0x1F, 0x80, 0xFF, 0xFC, 0x00, 0x1F,
  0x80, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x78, 0x0C, 0x3F,
  0xF0, 0xC7, 0x87, 0xCC, 0xC0, 0x1C, 0xD8, 0x00, 0xEF, 0x00, 0x06, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x30, 0xEF, 0xF6, 0x00, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x03,
  0x80, 0xF0, 0x3C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x0C, 0x8F, 0x3F, 0x87, 0x80, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x03, 0xB0, 0x00, 0xE6, 0x00, 0x38, 0xC0, 0x06,
  0x18, 0x01, 0x83, 0x00, 0x70, 0x60, 0x1C, 0x0C, 0x07, 0x01, 0x80, 0xC0,
  0x30, 0x30, 0x06, 0x0C, 0x00, 0xC3, 0x80, 0x18, 0xE0, 0x03, 0x1E, 0x00,
  0x66, 0xC0, 0x0D, 0x8C, 0x01, 0xE1, 0xC0, 0x38, 0x18, 0x07, 0x03, 0x80,
  0xC0, 0x38, 0x18, 0x03, 0x03, 0x00, 0x70, 0x60, 0x06, 0x0C, 0x00, 0x61,
  0x80, 0x0E, 0x30, 0x00, 0xC6, 0x00, 0x1C, 0xC0, 0x01, 0x98, 0x00, 0x1B,
  0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x78, 0x10, 0x7F, 0xC0, 0x7F, 0xC2, 0x3C,
  0x3C, 0x3C, 0x3E, 0x6E, 0x01, 0xC6, 0x01, 0xCD, 0x80, 0x19, 0x80, 0x1D,
  0xE0, 0x03, 0xE0, 0x01, 0xB8, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x07, 0x80,
  0x01, 0x80, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x03,
  0xC0, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x03, 0x00,
  0x01, 0xE0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x01,
  0x80, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x03, 0xC0,
  0x00, 0xC0, 0x00, 0x78, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01,
  0xE0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x01, 0x80,
  0x00, 0xF0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x7C, 0x08, 0x3F, 0xF0, 0x87,
  0x87, 0xCC, 0xC0, 0x1E, 0xD8, 0x00, 0xEF, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x30,
  0x00, 0x3C, 0x00, 0x03, 0xFF, 0x80, 0x07, 0x83, 0xE0, 0x0E, 0x00, 0x70,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x0C,
  0x60, 0x00, 0x0E, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x06,
  0xE0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0C,
  0x70, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x30,
  0x0E, 0x00, 0xF0, 0x07, 0xEF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00,
  0x00, 0x7C, 0x02, 0x0F, 0xFE, 0x0C, 0x78, 0x7C, 0x33, 0x80, 0x38, 0xD8,
  0x00, 0x73, 0x40, 0x00, 0xCF, 0x00, 0x03, 0xB8, 0x00, 0x06, 0xE0, 0x00,
  0x1B, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x06, 0xE0, 0x00, 0x1B, 0xC0, 0x00, 0xCF,
  0x00, 0x07, 0x36, 0x00, 0x38, 0xCE, 0x01, 0xE3, 0x1F, 0x7F, 0x0C, 0x3F,
  0xF0, 0x30, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xFE, 0x0C, 0x1E, 0x0F, 0x18, 0x70, 0x07,
  0x31, 0xC0, 0x06, 0x67, 0x00, 0x06, 0xCC, 0x00, 0x07, 0xB8, 0x00, 0x0F,
  0x60, 0x00, 0x0E, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xB0, 0x00, 0x0F, 0x70, 0x00,
  0x1E, 0x60, 0x00, 0x6C, 0xE0, 0x00, 0xF8, 0xE0, 0x03, 0x71, 0xE0, 0x0C,
  0xE1, 0xF9, 0xF1, 0xC0, 0xFF, 0xC3, 0x80, 0x18, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0xF3, 0x0F, 0xFC,
  0x79, 0xB3, 0x00, 0xD8, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xF0, 0x7C, 0x1F, 0x1C, 0x00,
  0x23, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x40, 0x00, 0xEE, 0x00, 0x39,
  0xFE, 0x7E, 0x0F, 0xFF, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0xCC,
  0x0F, 0xF0, 0x06, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xEC, 0x00, 0x07, 0x60, 0x00, 0x7B, 0x80, 0x02,
  0xCC, 0x00, 0x36, 0x78, 0x07, 0x31, 0xFB, 0xF1, 0x83, 0xFE, 0x0C, 0x01,
  0x00, 0x00, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x01, 0xDC, 0x00,
  0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x06, 0x00, 0x0C,
  0x18, 0x00, 0x70, 0x70, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x38, 0x0E,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x01, 0xC0, 0x60, 0x03, 0x01,
  0x80, 0x0C, 0x0E, 0x00, 0x38, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x87, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x80, 0x00, 0xCC, 0x00, 0x01,
  0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1B, 0x80, 0x03,
  0x80, 0x03, 0x30, 0x00, 0xD8, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x0C, 0xC0,
  0x03, 0x60, 0x03, 0x1C, 0x00, 0x6E, 0x00, 0x61, 0x80, 0x18, 0xC0, 0x0C,
  0x30, 0x03, 0x18, 0x01, 0x87, 0x00, 0x63, 0x00, 0x60, 0x60, 0x1C, 0x30,
  0x0C, 0x0C, 0x03, 0x06, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x30, 0x38, 0x0C,
  0x1C, 0x0C, 0x03, 0x03, 0x01, 0x81, 0x80, 0x60, 0x60, 0x30, 0x30, 0x0C,
  0x0C, 0x06, 0x06, 0x01, 0xC3, 0x80, 0xE1, 0x80, 0x18, 0x60, 0x0C, 0x30,
  0x03, 0x0C, 0x01, 0x86, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x0E, 0x60, 0x03,
  0x30, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x03, 0x70,
  0x01, 0xD8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0xE3, 0x80, 0x07, 0x07, 0x00, 0x18,
  0x0C, 0x00, 0xE0, 0x38, 0x03, 0x00, 0x60, 0x1C, 0x01, 0xC0, 0xE0, 0x03,
  0x83, 0x00, 0x06, 0x1C, 0x00, 0x1C, 0x60, 0x00, 0x33, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x61, 0xC0, 0x03, 0x83, 0x00, 0x1C,
  0x0E, 0x00, 0x60, 0x18, 0x03, 0x80, 0x30, 0x0C, 0x00, 0xE0, 0x60, 0x01,
  0x83, 0x80, 0x07, 0x0C, 0x00, 0x0E, 0x70, 0x00, 0x1B, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x19, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xE3,
  0x00, 0x01, 0x87, 0x00, 0x03, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x1C,
  0x00, 0x30, 0x18, 0x00, 0xE0, 0x30, 0x01, 0x80, 0x70, 0x03, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x18, 0x01, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x01,
  0x80, 0x07, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x01, 0x1E, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x7C, 0x03, 0xE0, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x78, 0x00, 0x7E, 0x00,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x0F, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xC0, 0x07, 0x83, 0xE0, 0x1E, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0x80, 0x00,
  0x08, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 41, 13, 4, -41 },
  { 22, 11, 15, 19, 4, -41 },
  { 43, 30, 41, 32, 1, -41 },
  { 197, 22, 46, 29, 3, -43 },
  { 324, 35, 42, 41, 3, -41 },
  { 508, 30, 42, 34, 3, -41 },
  { 666, 2, 15, 10, 4, -41 },
  { 670, 10, 50, 15, 3, -41 },
  { 733, 11, 50, 15, 2, -41 },
  { 802, 21, 20, 27, 3, -43 },
  { 855, 23, 26, 29, 3, -33 },
  { 930, 6, 13, 11, 2, -6 },
  { 940, 13, 2, 17, 2, -16 },
  { 944, 4, 4, 12, 4, -4 },
  { 946, 17, 41, 19, 1, -41 },
  { 1034, 23, 42, 29, 3, -41 },
  { 1155, 12, 41, 29, 5, -41 },
  { 1217, 22, 41, 29, 3, -41 },
  { 1330, 22, 42, 29, 3, -41 },
  { 1446, 27, 41, 29, 1, -41 },
  { 1585, 22, 42, 29, 4, -41 },
  { 1701, 23, 42, 29, 3, -41 },
  { 1822, 23, 41, 29, 3, -41 },
  { 1940, 23, 42, 29, 3, -41 },
  { 2061, 22, 42, 29, 3, -41 },
  { 2177, 4, 31, 12, 4, -31 },
  { 2193, 6, 38, 12, 2, -31 },
  { 2222, 23, 25, 29, 3, -33 },
  { 2294, 23, 14, 29, 3, -27 },
  { 2335, 23, 25, 29, 3, -33 },
  { 2407, 17, 41, 21, 2, -41 },
  { 2495, 39, 46, 45, 3, -41 },
  { 2720, 29, 41, 29, 0, -41 },
  { 2869, 24, 41, 32, 5, -41 },
  { 2992, 26, 42, 31, 3, -41 },
  { 3129, 27, 41, 35, 5, -41 },
  { 3268, 20, 41, 28, 5, -41 },
  { 3371, 20, 41, 25, 5, -41 },
  { 3474, 30, 42, 37, 3, -41 },
  { 3632, 26, 41, 36, 5, -41 },
  { 3766, 10, 41, 16, 3, -41 },
  { 3818, 12, 51, 13, -4, -41 },
  { 3895, 24, 41, 29, 5, -41 },
  { 4018, 20, 41, 26, 5, -41 },
  { 4121, 34, 41, 45, 5, -41 },
  { 4296, 26, 41, 36, 5, -41 },
  { 4430, 32, 42, 38, 3, -41 },
  { 4598, 22, 41, 29, 5, -41 },
  { 4711, 32, 51, 38, 3, -41 },
  { 4915, 24, 41, 30, 5, -41 },
  { 5038, 22, 42, 28, 3, -41 },
  { 5154, 25, 41, 26, 0, -41 },
  { 5283, 26, 42, 36, 5, -41 },
  { 5420, 29, 41, 29, 0, -41 },
  { 5569, 44, 41, 46, 1, -41 },
  { 5795, 26, 41, 26, 0, -41 },
  { 5929, 26, 41, 26, 0, -41 },
  { 6063, 24, 41, 28, 2, -41 },
  { 6186, 11, 50, 18, 5, -41 },
  { 6255, 17, 41, 19, 1, -41 },
  { 6343, 11, 50, 18, 2, -41 },
  { 6412, 25, 23, 29, 2, -41 },
  { 6484, 23, 2, 23, 0, 5 },
  { 6490, 10, 9, 14, 2, -44 },
  { 6502, 19, 32, 27, 3, -31 },
  { 6578, 22, 44, 30, 5, -43 },
  { 6699, 19, 32, 24, 3, -31 },
  { 6775, 23, 44, 30, 3, -43 },
  { 6902, 22, 32, 28, 3, -31 },
  { 6990, 17, 44, 15, 1, -44 },
  { 7084, 23, 45, 30, 3, -31 },
  { 7214, 20, 43, 30, 5, -43 },
  { 7322, 4, 41, 12, 4, -41 },
  { 7343, 10, 55, 12, -2, -41 },
  { 7412, 19, 43, 24, 5, -43 },
  { 7515, 2, 43, 12, 5, -43 },
  { 7526, 35, 31, 44, 5, -31 },
  { 7662, 20, 31, 30, 5, -31 },
  { 7740, 24, 32, 30, 3, -31 },
  { 7836, 22, 44, 30, 5, -31 },
  { 7957, 23, 44, 30, 3, -31 },
  { 8084, 14, 31, 20, 5, -31 },
  { 8139, 19, 32, 23, 2, -31 },
  { 8215, 14, 39, 16, 1, -38 },
  { 8284, 21, 31, 30, 4, -30 },
  { 8366, 22, 30, 23, 0, -30 },
  { 8449, 35, 30, 37, 1, -30 },
  { 8581, 22, 30, 24, 1, -30 },
  { 8664, 23, 44, 23, 0, -30 },
  { 8791, 18, 30, 22, 2, -30 },
  { 8859, 15, 50, 20, 2, -41 },
  { 8953, 2, 57, 27, 13, -43 },
  { 8968, 16, 50, 20, 2, -41 },
  { 9068, 23, 6, 29, 3, -23 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight57pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT57PT7B_H_
