#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT53PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight53pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x6E, 0xFE, 0xC1, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x2C, 0x0B, 0x02, 0xC0,
  0xB0, 0x20, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x10, 0x06,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x04, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x20, 0x0C, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x60, 0x08, 0x00, 0x06, 0x00, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x06, 0x01, 0x80, 0x00, 0x40, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0,
  0x18, 0x00, 0x0C, 0x01, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x80, 0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18,
  0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x60,
  0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x04, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x60, 0x0C,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x08, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x3F,
  0xE0, 0x0F, 0xFF, 0xC3, 0xC6, 0x1E, 0x70, 0x60, 0x46, 0x06, 0x00, 0xC0,
  0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x0C,
  0x06, 0x00, 0xC0, 0x60, 0x0E, 0x06, 0x00, 0x70, 0x60, 0x03, 0x86, 0x00,
  0x1E, 0x60, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0x00, 0x06, 0x38, 0x00, 0x61, 0xC0, 0x06, 0x06, 0x00, 0x60, 0x70, 0x06,
  0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00,
  0x60, 0x30, 0x06, 0x06, 0x00, 0x60, 0x68, 0x06, 0x1C, 0xF8, 0x67, 0x87,
  0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0x1C, 0x70, 0x00, 0x40, 0x0C,
  0x18, 0x00, 0x60, 0x0C, 0x06, 0x00, 0x30, 0x06, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0x30, 0x0C, 0x00,
  0xC0, 0x18, 0x0C, 0x00, 0x60, 0x0C, 0x06, 0x00, 0x30, 0x06, 0x06, 0x00,
  0x18, 0x03, 0x03, 0x00, 0x0C, 0x01, 0x83, 0x00, 0x06, 0x00, 0xC1, 0x80,
  0x03, 0x00, 0x61, 0x80, 0x01, 0x80, 0x30, 0xC3, 0xF0, 0xC0, 0x18, 0xC3,
  0xBC, 0x60, 0x18, 0x63, 0x03, 0x18, 0x0C, 0x61, 0x81, 0x8C, 0x06, 0x31,
  0x80, 0x63, 0x06, 0x10, 0xC0, 0x31, 0xC7, 0x18, 0x60, 0x18, 0x7E, 0x0C,
  0x20, 0x0C, 0x00, 0x0C, 0x30, 0x02, 0x00, 0x06, 0x18, 0x01, 0x80, 0x06,
  0x0C, 0x00, 0xC0, 0x03, 0x06, 0x00, 0x60, 0x03, 0x03, 0x00, 0x30, 0x01,
  0x81, 0x80, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x00, 0xC0, 0x20, 0x0C, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x06, 0x01, 0x80,
  0x30, 0x01, 0x81, 0x80, 0x30, 0x00, 0xC0, 0xC0, 0x18, 0x00, 0x39, 0xC0,
  0x18, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01,
  0xC0, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00,
  0x18, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xC0,
  0x18, 0x00, 0x06, 0x03, 0x80, 0x00, 0x60, 0x70, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x81, 0xC0,
  0x0C, 0x70, 0x0E, 0x00, 0xC6, 0x00, 0x70, 0x0C, 0xE0, 0x03, 0x00, 0xCC,
  0x00, 0x18, 0x18, 0xC0, 0x00, 0xC1, 0x8C, 0x00, 0x0E, 0x30, 0xC0, 0x00,
  0x73, 0x0C, 0x00, 0x03, 0xE0, 0xC0, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x1E, 0x06, 0x00, 0x03, 0x70, 0x70, 0x00, 0x63, 0x83, 0x80,
  0x1C, 0x1C, 0x1F, 0x1F, 0x80, 0xC0, 0x7F, 0xE0, 0x07, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03,
  0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x70, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0,
  0x38, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C,
  0x07, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x70, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x30, 0x10, 0x0F, 0xC2, 0x0F, 0x3E, 0x4F, 0x80, 0x7F,
  0x80, 0x03, 0x80, 0x00, 0x58, 0x00, 0x19, 0x00, 0x06, 0x30, 0x01, 0x83,
  0x00, 0x70, 0x30, 0x0C, 0x07, 0x03, 0x00, 0x60, 0x20, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x18,
  0xCE, 0x73, 0x18, 0xCE, 0x63, 0x19, 0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0x7F,
  0xF0, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x3E, 0xF8, 0x03, 0x80,
  0xE0, 0x38, 0x03, 0x81, 0x80, 0x0E, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x8C,
  0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0D, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x19,
  0x80, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0x60, 0xC0, 0x06, 0x07, 0x00,
  0x30, 0x1C, 0x07, 0x00, 0x78, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x60, 0x3C,
  0x0F, 0x83, 0xB0, 0xE6, 0x70, 0xDC, 0x1F, 0x03, 0x40, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x07, 0xFC, 0x00, 0xFD, 0xF8, 0x3E, 0x00, 0xE0, 0xC0, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x0E,
  0x00, 0x71, 0xE0, 0x01, 0xC4, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xA0,
  0x00, 0x19, 0xC0, 0x03, 0xCF, 0xE0, 0xF8, 0x0F, 0xFF, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x1C, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x18, 0x00,
  0x06, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x01, 0x80, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xE0, 0x03, 0x00, 0x60, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x30, 0x00, 0x30, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x3E, 0x00, 0x7F, 0xFF, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x20, 0x00, 0x71, 0xC0, 0x07, 0x0F, 0xC3,
  0xF0, 0x1F, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x3F,
  0xE0, 0xC7, 0xFF, 0x86, 0x70, 0x0E, 0x36, 0x00, 0x19, 0xA0, 0x00, 0x6F,
  0x00, 0x03, 0x70, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0,
  0x00, 0x0D, 0x80, 0x00, 0x66, 0x00, 0x07, 0x30, 0x00, 0x31, 0xC0, 0x03,
  0x87, 0x00, 0x18, 0x1C, 0x03, 0x80, 0x78, 0x78, 0x01, 0xFF, 0x80, 0x01,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0x00, 0x70, 0x70, 0x01, 0xC3, 0x00, 0x06, 0x30, 0x00, 0x39, 0x80, 0x00,
  0xCC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xE0,
  0x00, 0xC3, 0x00, 0x06, 0x1C, 0x00, 0x60, 0x70, 0x07, 0x01, 0xE0, 0xE0,
  0x03, 0xDE, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0x1C, 0x00, 0xE0,
  0x38, 0x0C, 0x00, 0xE0, 0xC0, 0x03, 0x8C, 0x00, 0x0E, 0x60, 0x00, 0x36,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x33, 0x00, 0x01, 0x9C,
  0x00, 0x18, 0x70, 0x03, 0x81, 0xF0, 0x78, 0x03, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0x00, 0xE0, 0x60, 0x03, 0x87,
  0x00, 0x0C, 0x30, 0x00, 0x33, 0x80, 0x01, 0x98, 0x00, 0x0E, 0xC0, 0x00,
  0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x03,
  0xD8, 0x00, 0x16, 0xE0, 0x01, 0xB3, 0x80, 0x39, 0x8F, 0x07, 0x98, 0x1F,
  0xF0, 0xC0, 0x08, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x03,
  0x07, 0xC0, 0x1F, 0xF8, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xB0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x38, 0xF3, 0x86, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x86, 0x38, 0xE3, 0x0C, 0x31, 0x86, 0x18, 0x43, 0x0C, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xFE, 0x18, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x0F, 0xF0, 0x06, 0x70, 0x03, 0xFF,
  0x80, 0x66, 0x00, 0x70, 0x18, 0x06, 0x60, 0x0C, 0x01, 0x80, 0x66, 0x01,
  0x80, 0x18, 0x03, 0xC0, 0x18, 0x01, 0x80, 0x3C, 0x03, 0x00, 0x18, 0x03,
  0xC0, 0x30, 0x01, 0x80, 0x3C, 0x03, 0x00, 0x18, 0x03, 0xC0, 0x30, 0x01,
  0x80, 0x3C, 0x02, 0x00, 0x18, 0x03, 0xC0, 0x20, 0x01, 0x80, 0x3C, 0x02,
  0x00, 0x18, 0x03, 0xC0, 0x30, 0x03, 0x80, 0x6C, 0x03, 0x00, 0x38, 0x06,
  0xC0, 0x30, 0x03, 0x80, 0x6C, 0x03, 0x00, 0x78, 0x04, 0xC0, 0x18, 0x05,
  0x80, 0xCC, 0x01, 0xC0, 0xCC, 0x18, 0x60, 0x0F, 0xF8, 0xFF, 0x06, 0x00,
  0x7F, 0x07, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x04, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x06, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x01,
  0x80, 0x30, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x06, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x1C,
  0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x0C, 0x00, 0x3C, 0x30, 0x00,
  0x38, 0xC0, 0x00, 0x73, 0x00, 0x00, 0xCC, 0x00, 0x03, 0xB0, 0x00, 0x06,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x0E, 0xC0,
  0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x38, 0xC0, 0x03,
  0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x30, 0x00, 0xF0, 0xC0, 0x00, 0xE3,
  0x00, 0x00, 0xCC, 0x00, 0x03, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0xCC,
  0x00, 0x0E, 0x30, 0x00, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xE0, 0x03, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x01, 0x00,
  0xFC, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x30, 0x01, 0xF0, 0x18, 0x00, 0x3C, 0x0C, 0x00, 0x07, 0x06,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x71, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x06,
  0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x73, 0x00, 0x00, 0x31, 0x80, 0x00, 0x38,
  0xC0, 0x00, 0x38, 0x60, 0x00, 0x38, 0x30, 0x00, 0x78, 0x18, 0x00, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFB, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xB0, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0xE0, 0x3C, 0x00,
  0x02, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x07, 0x80,
  0x00, 0x30, 0x1E, 0x00, 0x07, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xC6, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x07, 0xF7, 0xFC, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x1D, 0xFF, 0x3F, 0xC0, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x38, 0xC0, 0x01, 0xC3,
  0x00, 0x0E, 0x0C, 0x00, 0x70, 0x30, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00,
  0x70, 0x0C, 0x03, 0x80, 0x30, 0x1C, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x00,
  0x0C, 0x18, 0x00, 0x30, 0xE0, 0x00, 0xC7, 0x00, 0x03, 0x3E, 0x00, 0x0D,
  0xD8, 0x00, 0x36, 0x70, 0x00, 0xF0, 0xE0, 0x03, 0x81, 0x80, 0x0C, 0x07,
  0x00, 0x30, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x0C, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0xC0, 0x07, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0x70, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1B, 0xF8, 0x00, 0x00, 0x1B, 0xD8, 0x00, 0x00, 0x1B, 0xD8, 0x00, 0x00,
  0x33, 0xCC, 0x00, 0x00, 0x33, 0xCC, 0x00, 0x00, 0x63, 0xCC, 0x00, 0x00,
  0x63, 0xC6, 0x00, 0x00, 0x63, 0xC6, 0x00, 0x00, 0xC3, 0xC7, 0x00, 0x00,
  0xC3, 0xC3, 0x00, 0x00, 0xC3, 0xC3, 0x00, 0x01, 0x83, 0xC3, 0x80, 0x01,
  0x83, 0xC1, 0x80, 0x01, 0x83, 0xC1, 0x80, 0x03, 0x03, 0xC0, 0xC0, 0x03,
  0x03, 0xC0, 0xC0, 0x06, 0x03, 0xC0, 0xC0, 0x06, 0x03, 0xC0, 0x60, 0x06,
  0x03, 0xC0, 0x60, 0x0C, 0x03, 0xC0, 0x70, 0x0C, 0x03, 0xC0, 0x30, 0x0C,
  0x03, 0xC0, 0x30, 0x18, 0x03, 0xC0, 0x18, 0x18, 0x03, 0xC0, 0x18, 0x38,
  0x03, 0xC0, 0x18, 0x30, 0x03, 0xC0, 0x0C, 0x30, 0x03, 0xC0, 0x0C, 0x60,
  0x03, 0xC0, 0x0C, 0x60, 0x03, 0xC0, 0x06, 0x60, 0x03, 0xC0, 0x06, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xD8, 0x00, 0x03, 0xDC,
  0x00, 0x03, 0xCC, 0x00, 0x03, 0xC6, 0x00, 0x03, 0xC7, 0x00, 0x03, 0xC3,
  0x00, 0x03, 0xC3, 0x80, 0x03, 0xC1, 0x80, 0x03, 0xC0, 0xC0, 0x03, 0xC0,
  0xC0, 0x03, 0xC0, 0x60, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0x30, 0x03, 0xC0,
  0x38, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x0C, 0x03, 0xC0, 0x0E, 0x03, 0xC0,
  0x06, 0x03, 0xC0, 0x07, 0x03, 0xC0, 0x03, 0x03, 0xC0, 0x01, 0x83, 0xC0,
  0x01, 0xC3, 0xC0, 0x00, 0xC3, 0xC0, 0x00, 0xE3, 0xC0, 0x00, 0x63, 0xC0,
  0x00, 0x73, 0xC0, 0x00, 0x33, 0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0xC0, 0x0F, 0x8C, 0x00, 0x3C, 0xC0, 0x00, 0xCC, 0x00, 0x0E,
  0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x6C, 0x00,
  0x06, 0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x03, 0x8C, 0x00, 0xF0, 0xFF,
  0xFE, 0x0F, 0xFF, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x0C, 0x00, 0xF8, 0x30, 0x00, 0x70, 0xC0, 0x00,
  0xE3, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x33,
  0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00,
  0x01, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00, 0x07,
  0x0C, 0x00, 0x78, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0x00, 0xE0, 0x0C,
  0x01, 0x80, 0x30, 0x07, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x38, 0x0C, 0x00,
  0x60, 0x30, 0x01, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0xE3, 0x00, 0x01, 0x8C, 0x00, 0x07, 0x30,
  0x00, 0x0C, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x70, 0x03, 0xFF, 0x80, 0xFF,
  0xFF, 0x1C, 0x00, 0x63, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC8,
  0x00, 0x3C, 0xFC, 0x3F, 0x07, 0xFF, 0xE0, 0x00, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x38, 0x00,
  0x18, 0x1E, 0x00, 0x78, 0x0F, 0xC7, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x18,
  0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x18, 0x03, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x06, 0x18, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x60, 0x00, 0x3C, 0x00, 0x07, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x70,
  0x00, 0x36, 0x00, 0x06, 0x30, 0x00, 0x26, 0x00, 0x06, 0x30, 0x00, 0x66,
  0x00, 0x0E, 0x30, 0x00, 0x66, 0x00, 0x0C, 0x30, 0x00, 0x67, 0x00, 0x0C,
  0x18, 0x00, 0x63, 0x00, 0x0C, 0x18, 0x00, 0xC3, 0x00, 0x1C, 0x18, 0x00,
  0xC3, 0x00, 0x18, 0x18, 0x00, 0xC3, 0x80, 0x18, 0x0C, 0x00, 0xC1, 0x80,
  0x18, 0x0C, 0x01, 0x81, 0x80, 0x38, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x0C,
  0x01, 0x81, 0xC0, 0x30, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x06, 0x03, 0x00,
  0xC0, 0x70, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0xE0, 0x60,
  0x03, 0x03, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x60, 0xE0, 0x03, 0x06,
  0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x70, 0xC0, 0x01, 0x86, 0x00, 0x30,
  0xC0, 0x01, 0x8C, 0x00, 0x31, 0xC0, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x01,
  0x8C, 0x00, 0x39, 0x80, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x00, 0xD8, 0x00,
  0x1B, 0x80, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x1B, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x30,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x18, 0x0C,
  0x00, 0x38, 0x06, 0x00, 0x30, 0x07, 0x00, 0x70, 0x03, 0x00, 0x60, 0x03,
  0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0xC1, 0x80, 0x00, 0xC1, 0x80, 0x00,
  0x63, 0x00, 0x00, 0x63, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x63, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x01,
  0x81, 0x80, 0x01, 0x80, 0xC0, 0x03, 0x00, 0xE0, 0x07, 0x00, 0x60, 0x06,
  0x00, 0x70, 0x0E, 0x00, 0x30, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x1C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x18, 0x00, 0x18, 0x1C,
  0x00, 0x30, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x03, 0x00, 0xC0, 0x03, 0x01, 0xC0, 0x01, 0x81, 0x80, 0x01,
  0x83, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF, 0xC0, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xF0, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x81,
  0x80, 0x06, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06,
  0x01, 0x80, 0x0C, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x38, 0x00, 0x18,
  0x60, 0x00, 0x31, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x30, 0x1C,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x00, 0x60, 0x00, 0xFF,
  0xC0, 0x7E, 0x3E, 0x0C, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0xFF, 0xC1, 0xFF, 0xF8, 0x78, 0x03, 0x38, 0x00,
  0x66, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0x60, 0x01, 0x6C, 0x00, 0x6C, 0xC0, 0x19,
  0x9F, 0x0E, 0x30, 0xFF, 0x86, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0xF0, 0x0C, 0x3F, 0xF0, 0x63, 0xC3, 0xC3, 0x30, 0x07, 0x1B,
  0x00, 0x0C, 0xD0, 0x00, 0x77, 0x80, 0x01, 0xB8, 0x00, 0x0D, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xBC, 0x00, 0x0D, 0xA0, 0x00, 0xCD, 0x80, 0x0E, 0x66, 0x00, 0xE3,
  0x1E, 0x3E, 0x18, 0x7F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x7F,
  0xF0, 0x7C, 0x38, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x04, 0x1F, 0x1F, 0x03,
  0xFF, 0x80, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x30,
  0x3F, 0xE1, 0x87, 0xC3, 0x8C, 0x70, 0x06, 0x67, 0x00, 0x1B, 0x30, 0x00,
  0x7B, 0x80, 0x03, 0xD8, 0x00, 0x0E, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x3B, 0x00, 0x01, 0xD8, 0x00, 0x1E,
  0x60, 0x00, 0xF3, 0x80, 0x0D, 0x8E, 0x00, 0xCC, 0x3C, 0x1C, 0x60, 0xFF,
  0xC3, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xE0, 0x0F, 0x8F, 0x01,
  0xC0, 0x18, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x70, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0x6E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x60,
  0x7C, 0x7E, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x10, 0x03, 0xFC, 0x0F,
  0x08, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x1F, 0xFE, 0x3F, 0xFC, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x1F, 0xF0, 0xC3, 0xE1, 0xE6, 0x38, 0x03, 0x33, 0x80,
  0x0D, 0x98, 0x00, 0x3D, 0xC0, 0x00, 0xEC, 0x00, 0x07, 0x60, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x1D, 0x80, 0x00,
  0xEC, 0x00, 0x0F, 0x30, 0x00, 0x59, 0xC0, 0x06, 0xC7, 0x00, 0x66, 0x1E,
  0x0E, 0x30, 0x7F, 0xE1, 0x80, 0x20, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x31, 0x80, 0x07, 0x0F, 0x80, 0xF0, 0x1F, 0xFF, 0x00,
  0x1F, 0xC0, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0x0C,
  0x78, 0xF8, 0xCC, 0x01, 0xCD, 0x80, 0x0C, 0xD0, 0x00, 0x6F, 0x00, 0x06,
  0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xA0, 0x00, 0x03, 0x6D,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x80, 0x03, 0x81,
  0xC0, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x86, 0x7F, 0x1E, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x01, 0xB0, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x38, 0xC0, 0x1C, 0x30, 0x06,
  0x0C, 0x03, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x30, 0x70, 0x0C, 0x18, 0x03,
  0x0C, 0x00, 0xC7, 0x80, 0x33, 0x60, 0x0D, 0x8C, 0x03, 0x63, 0x80, 0xF0,
  0x60, 0x38, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0x60, 0xC0, 0x1C, 0x30, 0x03,
  0x0C, 0x00, 0x63, 0x00, 0x1C, 0xC0, 0x03, 0x30, 0x00, 0xEC, 0x00, 0x1B,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x20, 0x00, 0xC0, 0x61, 0xFE, 0x03, 0xFE, 0x31, 0xC3, 0x83, 0x87,
  0x99, 0x80, 0x63, 0x00, 0xED, 0x80, 0x3B, 0x00, 0x37, 0x80, 0x0D, 0x00,
  0x1F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x03, 0xE0, 0x00, 0xC0,
  0x01, 0xF0, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x78, 0x00, 0x18,
  0x00, 0x3C, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x03,
  0x00, 0x07, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x00, 0xC0, 0x01, 0xE0, 0x00,
  0x60, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x78, 0x00, 0x18, 0x00, 0x3C, 0x00,
  0x0C, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x07, 0x80,
  0x01, 0x80, 0x03, 0xC0, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0x60, 0x00, 0xF0,
  0x00, 0x30, 0x00, 0x78, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x0C, 0x1F, 0xF0, 0xC7, 0x8F, 0x8C, 0xC0, 0x1C, 0xD8, 0x00,
  0xCD, 0x00, 0x06, 0xF0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00,
  0x07, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x0F, 0xFC, 0x00, 0xF8, 0x78, 0x07, 0x00, 0x70,
  0x38, 0x00, 0x60, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x18, 0x00, 0x0E, 0x60,
  0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xE0, 0x00, 0x19, 0x80,
  0x00, 0x66, 0x00, 0x03, 0x9C, 0x00, 0x0C, 0x30, 0x00, 0x70, 0x60, 0x03,
  0x81, 0xC0, 0x1C, 0x03, 0xF3, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x06, 0x0F, 0xF8, 0x31, 0xE1, 0xE1, 0x9C, 0x03, 0x8C, 0x80,
  0x06, 0x6C, 0x00, 0x3B, 0xC0, 0x00, 0xDE, 0x00, 0x06, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xDE, 0x00, 0x06, 0xD8, 0x00, 0x66, 0xC0, 0x07, 0x33, 0x80, 0x71, 0x8F,
  0x9F, 0x0C, 0x3F, 0xE0, 0x60, 0x10, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x1F, 0xF0, 0xC3, 0xE1, 0xC6, 0x38, 0x03, 0x33, 0x80,
  0x0D, 0x98, 0x00, 0x3D, 0xC0, 0x01, 0xEC, 0x00, 0x07, 0x60, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1D, 0x80, 0x00,
  0xEC, 0x00, 0x0F, 0x30, 0x00, 0x59, 0xC0, 0x06, 0xC7, 0x00, 0x66, 0x1E,
  0x1E, 0x30, 0x7F, 0xC1, 0x80, 0x20, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x66, 0x1F, 0xF1, 0xFF, 0x98, 0x0D, 0x80, 0x68, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x07, 0xFF, 0x87, 0x83, 0xE7, 0x00, 0x26, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xF0, 0x01, 0xDF, 0x87, 0xC3,
  0xFF, 0xC0, 0x08, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xF8, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x40,
  0xFE, 0x00, 0x80, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3B, 0x00, 0x0F,
  0x70, 0x03, 0x67, 0x00, 0xE4, 0x78, 0xF8, 0x87, 0xFC, 0x10, 0x0C, 0x00,
  0xC0, 0x00, 0x1B, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00,
  0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x83, 0x00, 0x18, 0x18, 0x00, 0xC0,
  0xC0, 0x06, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x01,
  0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00,
  0xC1, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x60,
  0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x02, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x03, 0x60, 0x03, 0xC0, 0x06, 0x60, 0x03, 0x60, 0x06, 0x60, 0x03,
  0x60, 0x06, 0x70, 0x06, 0x60, 0x06, 0x30, 0x06, 0x60, 0x0C, 0x30, 0x06,
  0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x38, 0x0C, 0x30, 0x0C, 0x18, 0x0C,
  0x18, 0x18, 0x18, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x18,
  0x18, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30,
  0x0C, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x40,
  0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x71, 0x80, 0x03, 0x0E,
  0x00, 0x30, 0x30, 0x01, 0x81, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x18, 0x0C,
  0x00, 0xE0, 0xC0, 0x03, 0x0E, 0x00, 0x0C, 0x60, 0x00, 0x67, 0x00, 0x01,
  0xB0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1B, 0x00,
  0x01, 0xD8, 0x00, 0x0C, 0x60, 0x00, 0xC3, 0x80, 0x0E, 0x0C, 0x00, 0x60,
  0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x03, 0x00, 0x38, 0x38, 0x00, 0xC1,
  0x80, 0x03, 0x18, 0x00, 0x1D, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1B, 0x00,
  0x00, 0xD8, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x30,
  0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00,
  0x30, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x00,
  0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C,
  0x00, 0x18, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x1B, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x02,
  0x18, 0x00, 0x1F, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x03, 0xF0,
  0x1E, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x0F, 0x80,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x03, 0xF0, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xC0,
  0x0F, 0x00, 0xF0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0,
  0x7E, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x02, 0xFF, 0xE0, 0x0F, 0x80, 0xF0,
  0x74, 0x00, 0x7F, 0xC8, 0x00, 0x1E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 38, 12, 4, -38 },
  { 20, 10, 14, 17, 4, -38 },
  { 38, 28, 38, 30, 1, -38 },
  { 171, 20, 43, 27, 3, -40 },
  { 279, 33, 39, 38, 3, -38 },
  { 440, 28, 39, 32, 3, -38 },
  { 577, 2, 14, 9, 4, -38 },
  { 581, 10, 46, 14, 2, -38 },
  { 639, 10, 46, 14, 2, -38 },
  { 697, 19, 19, 25, 3, -40 },
  { 743, 23, 25, 27, 2, -31 },
  { 815, 5, 13, 10, 2, -6 },
  { 824, 12, 2, 16, 2, -15 },
  { 827, 3, 4, 11, 4, -4 },
  { 829, 16, 38, 18, 1, -38 },
  { 905, 21, 38, 27, 3, -38 },
  { 1005, 11, 38, 27, 5, -38 },
  { 1058, 21, 38, 27, 3, -38 },
  { 1158, 21, 39, 27, 2, -38 },
  { 1261, 25, 38, 27, 1, -38 },
  { 1380, 21, 39, 27, 3, -38 },
  { 1483, 21, 39, 27, 3, -38 },
  { 1586, 21, 38, 27, 3, -38 },
  { 1686, 21, 39, 27, 3, -38 },
  { 1789, 21, 39, 27, 3, -38 },
  { 1892, 3, 28, 11, 4, -28 },
  { 1903, 6, 35, 11, 2, -28 },
  { 1930, 23, 24, 27, 2, -31 },
  { 1999, 23, 13, 27, 2, -25 },
  { 2037, 23, 24, 27, 2, -31 },
  { 2106, 17, 38, 19, 1, -38 },
  { 2187, 36, 43, 42, 3, -38 },
  { 2381, 27, 38, 27, 0, -38 },
  { 2510, 22, 38, 29, 5, -38 },
  { 2615, 24, 39, 29, 3, -38 },
  { 2732, 25, 38, 33, 5, -38 },
  { 2851, 18, 38, 26, 5, -38 },
  { 2937, 18, 38, 24, 5, -38 },
  { 3023, 28, 39, 34, 3, -38 },
  { 3160, 24, 38, 34, 5, -38 },
  { 3274, 9, 38, 14, 3, -38 },
  { 3317, 11, 47, 12, -4, -38 },
  { 3382, 22, 38, 27, 5, -38 },
  { 3487, 18, 38, 24, 5, -38 },
  { 3573, 32, 38, 42, 5, -38 },
  { 3725, 24, 38, 34, 5, -38 },
  { 3839, 29, 39, 36, 3, -38 },
  { 3981, 20, 38, 27, 5, -38 },
  { 4076, 29, 47, 36, 3, -38 },
  { 4247, 22, 38, 28, 5, -38 },
  { 4352, 20, 39, 26, 3, -38 },
  { 4450, 24, 38, 24, 0, -38 },
  { 4564, 24, 39, 34, 5, -38 },
  { 4681, 27, 38, 27, 0, -38 },
  { 4810, 40, 38, 42, 1, -38 },
  { 5000, 24, 38, 24, 0, -38 },
  { 5114, 24, 38, 24, 0, -38 },
  { 5228, 22, 38, 26, 2, -38 },
  { 5333, 11, 46, 17, 4, -38 },
  { 5397, 16, 38, 18, 1, -38 },
  { 5473, 10, 46, 17, 2, -38 },
  { 5531, 23, 22, 27, 2, -38 },
  { 5595, 21, 2, 21, 0, 5 },
  { 5601, 9, 9, 13, 2, -41 },
  { 5612, 19, 30, 25, 2, -29 },
  { 5684, 21, 41, 28, 4, -40 },
  { 5792, 18, 30, 22, 3, -29 },
  { 5860, 21, 41, 28, 3, -40 },
  { 5968, 20, 30, 26, 3, -29 },
  { 6043, 15, 41, 14, 1, -41 },
  { 6120, 21, 42, 28, 3, -29 },
  { 6231, 20, 40, 28, 4, -40 },
  { 6331, 3, 38, 11, 4, -38 },
  { 6346, 9, 51, 11, -2, -38 },
  { 6404, 18, 40, 22, 4, -40 },
  { 6494, 2, 40, 11, 4, -40 },
  { 6504, 33, 29, 41, 4, -29 },
  { 6624, 20, 29, 28, 4, -29 },
  { 6697, 22, 30, 28, 3, -29 },
  { 6780, 21, 41, 28, 4, -29 },
  { 6888, 21, 41, 28, 3, -29 },
  { 6996, 13, 29, 18, 4, -29 },
  { 7044, 17, 30, 22, 2, -29 },
  { 7108, 13, 36, 15, 1, -35 },
  { 7167, 19, 29, 28, 4, -28 },
  { 7236, 21, 28, 21, 0, -28 },
  { 7310, 32, 28, 34, 1, -28 },
  { 7422, 21, 28, 23, 1, -28 },
  { 7496, 21, 41, 21, 0, -28 },
  { 7604, 17, 28, 21, 2, -28 },
  { 7664, 14, 46, 18, 2, -38 },
  { 7745, 2, 53, 26, 12, -40 },
  { 7759, 14, 46, 18, 2, -38 },
  { 7840, 23, 5, 27, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight53pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT53PT7B_H_
