#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT7PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xF0, 0x6F, 0x6F, 0xA0, 0xF9, 0x3E, 0xD6, 0xBA, 0x55, 0x80,
  0x66, 0x4B, 0xF0, 0xC0, 0x6A, 0x90, 0x95, 0x60, 0xCC, 0x5D, 0x00, 0xC0,
  0xC0, 0x80, 0x56, 0x80, 0xF6, 0xDE, 0xF8, 0xE4, 0xAE, 0xE5, 0x1E, 0x2E,
  0xF2, 0xF1, 0x9E, 0x73, 0xDE, 0xE4, 0xA4, 0xF5, 0x5E, 0xF7, 0x96, 0x90,
  0x98, 0x71, 0x80, 0xE0, 0xC7, 0x00, 0xD6, 0x80, 0x7D, 0xF7, 0xBA, 0x38,
  0x44, 0xAE, 0x90, 0xF7, 0x5E, 0x78, 0x88, 0x70, 0xF6, 0xDC, 0xEE, 0xC0,
  0xEE, 0x80, 0x78, 0xA9, 0x70, 0xB7, 0xDA, 0xEA, 0xC0, 0x55, 0x70, 0xD2,
  0x6A, 0xAA, 0xC0, 0x99, 0xBB, 0xD0, 0xB6, 0xFA, 0x79, 0x99, 0x70, 0xFE,
  0x80, 0x79, 0x99, 0x71, 0xD7, 0x6A, 0xF1, 0x1E, 0xE9, 0x24, 0xB6, 0xDE,
  0x9A, 0xA4, 0x40, 0xAD, 0x6E, 0x95, 0x00, 0xA9, 0x5A, 0xB5, 0x24, 0xE5,
  0x2E, 0xFC, 0xA5, 0x40, 0xD5, 0x70, 0x4E, 0x80, 0xE0, 0x80, 0x47, 0xF0,
  0xBF, 0xC0, 0x72, 0x70, 0x2E, 0xDE, 0x77, 0x70, 0xFA, 0x80, 0x76, 0xF2,
  0xC0, 0xBF, 0xC0, 0x78, 0xFE, 0xBA, 0xC0, 0xF8, 0xFD, 0xDD, 0xFF, 0x76,
  0xF0, 0xFF, 0xA0, 0x76, 0xF2, 0x40, 0xF0, 0xF1, 0xF0, 0xBA, 0xC0, 0xFF,
  0xB7, 0x20, 0xBB, 0xF5, 0xA9, 0x50, 0xB7, 0x25, 0x00, 0xD7, 0x57, 0x50,
  0xFE, 0xD5, 0x70, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 5, 2, 0, -5 },
  { 2, 2, 2, 2, 0, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 3, 5, 4, 0, -5 },
  { 8, 5, 5, 5, 0, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 2, 1, 0, -5 },
  { 16, 2, 6, 2, 0, -5 },
  { 18, 2, 6, 2, 0, -5 },
  { 20, 3, 2, 3, 0, -5 },
  { 21, 3, 3, 4, 0, -4 },
  { 23, 1, 2, 1, 0, -1 },
  { 24, 2, 1, 2, 0, -2 },
  { 25, 1, 1, 2, 0, -1 },
  { 26, 2, 5, 2, 0, -5 },
  { 28, 3, 5, 4, 0, -5 },
  { 30, 1, 5, 4, 1, -5 },
  { 31, 3, 5, 4, 0, -5 },
  { 33, 3, 5, 4, 0, -5 },
  { 35, 3, 5, 4, 0, -5 },
  { 37, 3, 5, 4, 0, -5 },
  { 39, 3, 5, 4, 0, -5 },
  { 41, 3, 5, 4, 0, -5 },
  { 43, 3, 5, 4, 0, -5 },
  { 45, 3, 5, 4, 0, -5 },
  { 47, 1, 4, 2, 0, -4 },
  { 48, 1, 5, 2, 0, -4 },
  { 49, 3, 3, 4, 0, -4 },
  { 51, 3, 1, 4, 0, -3 },
  { 52, 3, 3, 4, 0, -4 },
  { 54, 2, 5, 3, 0, -5 },
  { 56, 5, 6, 5, 0, -5 },
  { 60, 4, 5, 4, 0, -5 },
  { 63, 3, 5, 4, 1, -5 },
  { 65, 4, 5, 4, 0, -5 },
  { 68, 3, 5, 4, 1, -5 },
  { 70, 2, 5, 3, 1, -5 },
  { 72, 2, 5, 3, 1, -5 },
  { 74, 4, 5, 5, 0, -5 },
  { 77, 3, 5, 4, 1, -5 },
  { 79, 2, 5, 2, 0, -5 },
  { 81, 2, 6, 2, -1, -5 },
  { 83, 3, 5, 4, 1, -5 },
  { 85, 2, 5, 3, 1, -5 },
  { 87, 4, 5, 5, 1, -5 },
  { 90, 3, 5, 4, 1, -5 },
  { 92, 4, 5, 5, 0, -5 },
  { 95, 2, 5, 4, 1, -5 },
  { 97, 4, 6, 5, 0, -5 },
  { 100, 3, 5, 4, 1, -5 },
  { 102, 3, 5, 3, 0, -5 },
  { 104, 3, 5, 3, 0, -5 },
  { 106, 3, 5, 4, 1, -5 },
  { 108, 4, 5, 4, 0, -5 },
  { 111, 5, 5, 6, 0, -5 },
  { 115, 3, 5, 3, 0, -5 },
  { 117, 3, 5, 3, 0, -5 },
  { 119, 3, 5, 3, 0, -5 },
  { 121, 1, 6, 2, 1, -5 },
  { 122, 2, 5, 2, 0, -5 },
  { 124, 2, 6, 2, 0, -5 },
  { 126, 3, 3, 4, 0, -5 },
  { 128, 3, 1, 3, 0, 0 },
  { 129, 1, 1, 2, 0, -5 },
  { 130, 3, 4, 3, 0, -4 },
  { 132, 2, 5, 4, 1, -5 },
  { 134, 3, 4, 3, 0, -4 },
  { 136, 3, 5, 4, 0, -5 },
  { 138, 3, 4, 3, 0, -4 },
  { 140, 2, 5, 2, 0, -5 },
  { 142, 3, 6, 4, 0, -4 },
  { 145, 2, 5, 4, 1, -5 },
  { 147, 1, 5, 1, 0, -5 },
  { 148, 1, 7, 1, 0, -5 },
  { 149, 2, 5, 3, 1, -5 },
  { 151, 1, 5, 1, 0, -5 },
  { 152, 4, 4, 5, 1, -4 },
  { 154, 2, 4, 4, 1, -4 },
  { 155, 3, 4, 4, 0, -4 },
  { 157, 2, 6, 4, 1, -4 },
  { 159, 3, 6, 4, 0, -4 },
  { 162, 1, 4, 2, 1, -4 },
  { 163, 3, 4, 3, 0, -4 },
  { 165, 2, 5, 2, 0, -5 },
  { 167, 2, 4, 4, 1, -4 },
  { 168, 3, 4, 3, 0, -4 },
  { 170, 4, 4, 4, 0, -4 },
  { 172, 3, 4, 3, 0, -4 },
  { 174, 3, 6, 3, 0, -4 },
  { 177, 2, 4, 3, 0, -4 },
  { 178, 2, 6, 2, 0, -5 },
  { 180, 1, 7, 3, 1, -5 },
  { 181, 2, 6, 2, 0, -5 },
  { 183, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight7pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT7PT7B_H_
