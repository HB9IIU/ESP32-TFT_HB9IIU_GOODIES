#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT60PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight60pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE6, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xE0, 0xE0,
  0x7E, 0x07, 0xE0, 0x6E, 0x06, 0xE0, 0x6E, 0x06, 0xC0, 0x6C, 0x06, 0xC0,
  0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x64, 0x06, 0x40, 0x64, 0x06, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x1C, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x03, 0x80, 0x00,
  0x38, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFE, 0x03, 0xE4, 0x7F, 0x0E,
  0x08, 0x0C, 0x38, 0x10, 0x00, 0xE0, 0x20, 0x01, 0x80, 0x40, 0x07, 0x00,
  0x80, 0x0E, 0x01, 0x00, 0x18, 0x02, 0x00, 0x30, 0x04, 0x00, 0x70, 0x08,
  0x00, 0xE0, 0x10, 0x00, 0xC0, 0x20, 0x01, 0xC0, 0x40, 0x01, 0xC0, 0x80,
  0x01, 0xC1, 0x00, 0x01, 0xE2, 0x00, 0x01, 0xF4, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x4F, 0x80, 0x00, 0x87, 0x80,
  0x01, 0x03, 0x80, 0x02, 0x03, 0x80, 0x04, 0x03, 0x80, 0x08, 0x07, 0x00,
  0x10, 0x06, 0x00, 0x20, 0x0C, 0x00, 0x40, 0x18, 0x00, 0x80, 0x30, 0x01,
  0x00, 0x60, 0x02, 0x00, 0xC0, 0x04, 0x03, 0x80, 0x08, 0x0E, 0x80, 0x10,
  0x39, 0xC0, 0x20, 0xE3, 0xFE, 0x5F, 0x81, 0xFF, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x0F, 0xE0, 0x00, 0x0C, 0x00, 0xF7, 0x80, 0x00, 0xC0, 0x0E, 0x0E, 0x00,
  0x06, 0x00, 0x60, 0x38, 0x00, 0x60, 0x07, 0x00, 0xC0, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x18,
  0x00, 0xE0, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x60, 0x01, 0x80, 0x0C, 0x07, 0x00, 0x0C, 0x00, 0x60, 0x30, 0x00,
  0x60, 0x03, 0x03, 0x80, 0x03, 0x00, 0x18, 0x18, 0x00, 0x18, 0x00, 0xC1,
  0xC0, 0x00, 0xC0, 0x06, 0x0C, 0x00, 0x07, 0x00, 0x30, 0x60, 0xFC, 0x18,
  0x01, 0x86, 0x1F, 0xF0, 0xC0, 0x1C, 0x30, 0xC1, 0xC6, 0x00, 0xC3, 0x0C,
  0x07, 0x38, 0x06, 0x18, 0x60, 0x18, 0xC0, 0x71, 0x86, 0x00, 0xC7, 0x07,
  0x0C, 0x30, 0x07, 0x1F, 0xF0, 0xC1, 0x80, 0x18, 0x7F, 0x06, 0x0C, 0x00,
  0xC0, 0x00, 0x60, 0xE0, 0x06, 0x00, 0x03, 0x06, 0x00, 0x30, 0x00, 0x38,
  0x30, 0x01, 0x80, 0x01, 0x81, 0x80, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x60,
  0x00, 0xC0, 0x60, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x18, 0x00, 0x60, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x07, 0x00,
  0xC0, 0x0C, 0x00, 0x18, 0x0E, 0x00, 0x60, 0x00, 0xE0, 0x60, 0x06, 0x00,
  0x03, 0xCE, 0x00, 0x30, 0x00, 0x0F, 0xE0, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x30, 0x00, 0x06, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x0E, 0x06, 0x00, 0x0C, 0x1C, 0x07, 0x00, 0x0C, 0x38, 0x03, 0x80, 0x0C,
  0x70, 0x01, 0xC0, 0x1C, 0x60, 0x00, 0xE0, 0x18, 0xE0, 0x00, 0x70, 0x18,
  0xE0, 0x00, 0x30, 0x38, 0xC0, 0x00, 0x38, 0x30, 0xC0, 0x00, 0x1C, 0x70,
  0xC0, 0x00, 0x0E, 0x60, 0xC0, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0xE0,
  0x70, 0x00, 0x0E, 0x70, 0x38, 0x00, 0x3C, 0x38, 0x1E, 0x00, 0x78, 0x1C,
  0x0F, 0xFF, 0xE0, 0x0C, 0x03, 0xFF, 0x80, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0xFF, 0xFF, 0xF6, 0xDB, 0x6C, 0x92, 0x00, 0xE0, 0x38, 0x06, 0x01, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x70, 0x06, 0x00, 0x70, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18,
  0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60,
  0x1C, 0x07, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0xF0, 0x30, 0x1F, 0xF0, 0x43, 0xF1, 0xF9, 0x7E,
  0x00, 0x7F, 0xC0, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0xC0, 0x00,
  0x31, 0x80, 0x01, 0x87, 0x00, 0x0C, 0x0E, 0x00, 0x70, 0x18, 0x03, 0x80,
  0x70, 0x1C, 0x00, 0xE0, 0x10, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x71, 0xC7, 0x18, 0x63, 0x8E, 0x30, 0xC7, 0x18, 0x61, 0x8C, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0x70, 0x0C, 0x00, 0x38,
  0x1C, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0E,
  0x30, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x06, 0x70, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x1C, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x07, 0x80, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x18, 0x03,
  0xC0, 0x3E, 0x03, 0xB0, 0x79, 0x87, 0x8C, 0x70, 0x67, 0x03, 0xF0, 0x1B,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x03, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x3E, 0x01, 0xE0, 0x78, 0x00, 0x70, 0x20, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7C, 0x00,
  0xF0, 0xF0, 0x00, 0x78, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x80, 0x00, 0x38, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x07, 0x00, 0x60, 0x00, 0x30, 0x03,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x38, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x07, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC3, 0xE0, 0x01, 0xFF, 0xFE, 0x03, 0xFC,
  0xFE, 0x02, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x40, 0x00, 0x78, 0xE0,
  0x01, 0xE1, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0x80, 0x20, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x83, 0xFF, 0x03, 0x0F, 0xFF, 0x86, 0x78, 0x07, 0x8D, 0xC0, 0x03, 0x9B,
  0x00, 0x03, 0xBC, 0x00, 0x03, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x06, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x1B, 0x80, 0x00, 0x73, 0x00, 0x00, 0xC7, 0x00, 0x03,
  0x86, 0x00, 0x06, 0x0E, 0x00, 0x1C, 0x0F, 0x00, 0xF0, 0x0F, 0xCF, 0xC0,
  0x07, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0x00, 0x70,
  0x1C, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0E,
  0x70, 0x00, 0x06, 0x70, 0x00, 0x06, 0x70, 0x00, 0x06, 0x70, 0x00, 0x06,
  0x70, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x0F, 0x00, 0x70, 0x07, 0x81, 0xE0, 0x01, 0xE3, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x80, 0x03, 0x83, 0xE0,
  0x0F, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0E,
  0x70, 0x00, 0x06, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x06, 0x30, 0x00, 0x0E,
  0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x78, 0x07, 0xE7, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0E, 0x01, 0xE0,
  0x1C, 0x00, 0x70, 0x38, 0x00, 0x38, 0x30, 0x00, 0x18, 0x70, 0x00, 0x1C,
  0x60, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x0F, 0x70, 0x00, 0x0B, 0x30, 0x00, 0x1B, 0x38, 0x00, 0x37,
  0x1E, 0x00, 0xE7, 0x0F, 0xCF, 0xC7, 0x03, 0xFF, 0x06, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x3E, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xF4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x1C, 0x38, 0x78, 0xE0, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x38, 0x60, 0xC3, 0x86, 0x0C,
  0x18, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x3F, 0xFF, 0x8E, 0x00, 0xF2, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x18, 0x07,
  0x00, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x70, 0x00, 0x61, 0xC0, 0x03, 0xFF, 0xC0,
  0x18, 0xC0, 0x03, 0xC1, 0xE0, 0x0C, 0x60, 0x03, 0x80, 0x30, 0x06, 0x70,
  0x03, 0x00, 0x18, 0x03, 0x30, 0x03, 0x80, 0x0C, 0x01, 0xD8, 0x01, 0x80,
  0x0E, 0x00, 0x6C, 0x01, 0x80, 0x07, 0x00, 0x36, 0x00, 0xC0, 0x03, 0x80,
  0x1F, 0x00, 0x60, 0x01, 0x80, 0x0F, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x80,
  0x30, 0x00, 0x60, 0x03, 0xC0, 0x18, 0x00, 0x30, 0x01, 0xE0, 0x0C, 0x00,
  0x18, 0x00, 0xF0, 0x06, 0x00, 0x0C, 0x00, 0xF8, 0x03, 0x00, 0x06, 0x00,
  0x6C, 0x01, 0xC0, 0x03, 0x00, 0x37, 0x00, 0xE0, 0x03, 0x80, 0x1B, 0x80,
  0x30, 0x01, 0xC0, 0x1C, 0xC0, 0x18, 0x01, 0xB0, 0x0C, 0x60, 0x0E, 0x00,
  0xD8, 0x0E, 0x30, 0x03, 0x80, 0xCE, 0x0E, 0x18, 0x00, 0xFF, 0xC3, 0xFE,
  0x06, 0x00, 0x3F, 0xC0, 0xFE, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x40, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x70, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x38, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03,
  0x80, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x01, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x38,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0x07, 0xF0, 0xC0, 0x00, 0x78,
  0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x78, 0xC0, 0x00, 0x1C,
  0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x78,
  0xC0, 0x01, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x03, 0xE0, 0x07, 0x81, 0xE0, 0x00, 0x20, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xE8, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xC0, 0x0F, 0xE0,
  0x0C, 0x00, 0x0F, 0x80, 0xC0, 0x00, 0x3C, 0x0C, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x3C, 0x0C, 0x00, 0x0F, 0x80, 0xC0, 0x07,
  0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x03,
  0xE0, 0x1E, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x0E,
  0x03, 0xE0, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C,
  0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x39, 0xFF, 0xCF, 0xF8, 0x1E, 0x00, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x38, 0xC0, 0x00,
  0x70, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x01, 0xC0, 0xC0, 0x03,
  0x80, 0xC0, 0x07, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x1C,
  0x00, 0xC0, 0x38, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0xE0, 0x00, 0xC1, 0xC0,
  0x00, 0xC3, 0x80, 0x00, 0xC3, 0x80, 0x00, 0xC7, 0x80, 0x00, 0xCF, 0xC0,
  0x00, 0xDC, 0xE0, 0x00, 0xF8, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x30,
  0x00, 0xC0, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E,
  0x00, 0xC0, 0x07, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x80, 0xC0, 0x01,
  0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0x70, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xB0, 0x00, 0x00, 0x06, 0xF6, 0x00, 0x00,
  0x00, 0xDE, 0xE0, 0x00, 0x00, 0x3B, 0xCC, 0x00, 0x00, 0x06, 0x79, 0x80,
  0x00, 0x00, 0xCF, 0x38, 0x00, 0x00, 0x31, 0xE3, 0x00, 0x00, 0x06, 0x3C,
  0x70, 0x00, 0x01, 0xC7, 0x86, 0x00, 0x00, 0x30, 0xF0, 0xC0, 0x00, 0x06,
  0x1E, 0x1C, 0x00, 0x01, 0xC3, 0xC1, 0x80, 0x00, 0x30, 0x78, 0x30, 0x00,
  0x06, 0x0F, 0x07, 0x00, 0x01, 0xC1, 0xE0, 0x60, 0x00, 0x30, 0x3C, 0x0E,
  0x00, 0x0E, 0x07, 0x81, 0xC0, 0x01, 0x80, 0xF0, 0x18, 0x00, 0x30, 0x1E,
  0x03, 0x80, 0x0E, 0x03, 0xC0, 0x30, 0x01, 0x80, 0x78, 0x06, 0x00, 0x30,
  0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x0C, 0x01, 0x80, 0x3C, 0x01, 0x80,
  0x30, 0x07, 0x80, 0x38, 0x0C, 0x00, 0xF0, 0x03, 0x01, 0x80, 0x1E, 0x00,
  0x70, 0x70, 0x03, 0xC0, 0x0E, 0x0C, 0x00, 0x78, 0x00, 0xC1, 0x80, 0x0F,
  0x00, 0x1C, 0x70, 0x01, 0xE0, 0x01, 0x8C, 0x00, 0x3C, 0x00, 0x31, 0x80,
  0x07, 0x80, 0x07, 0x70, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x1E, 0x60, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x78, 0xC0,
  0x00, 0x0F, 0x1C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x18, 0x00, 0x07,
  0x83, 0x80, 0x00, 0xF0, 0x30, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x78, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x0C, 0x00, 0x3C,
  0x01, 0xC0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x38,
  0x03, 0xC0, 0x03, 0x00, 0x78, 0x00, 0x70, 0x0F, 0x00, 0x06, 0x01, 0xE0,
  0x00, 0xE0, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xC0, 0xF0, 0x00, 0x1C,
  0x1E, 0x00, 0x01, 0x83, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x67, 0x80, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0xDE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x06, 0x38, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1E,
  0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0C, 0x01, 0xFC, 0x30, 0x00, 0x78, 0xC0,
  0x00, 0x73, 0x00, 0x00, 0xEC, 0x00, 0x03, 0xB0, 0x00, 0x06, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x6C, 0x00, 0x03, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x73, 0x00, 0x07,
  0x8C, 0x00, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3C, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00,
  0x0D, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x0E, 0x60,
  0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0xC0, 0x1F, 0xC0, 0xC0, 0x01, 0xE0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x01, 0xE0, 0xC0, 0x07, 0xC0,
  0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0xC0, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x80,
  0xC0, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xE0,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x38,
  0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x07, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x3C, 0x00, 0x70,
  0xE0, 0x00, 0x23, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x40, 0x00, 0x3C, 0xE0, 0x00,
  0xF1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x0B, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x1C, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x1F, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x07, 0x00,
  0x03, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x06, 0x00, 0x18, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x30, 0x03, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x76, 0x00, 0x00, 0x78, 0x00, 0x01, 0x98, 0x00, 0x01,
  0xE0, 0x00, 0x06, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0xDC, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x30,
  0x00, 0x0C, 0x38, 0x00, 0x0C, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x73, 0x00,
  0x01, 0xC1, 0x80, 0x01, 0x8E, 0x00, 0x06, 0x06, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x1C, 0x00, 0x18, 0x60, 0x00, 0xE0, 0x30, 0x00, 0xE1, 0x80, 0x03,
  0x80, 0xC0, 0x03, 0x07, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30,
  0x0E, 0x00, 0x30, 0x30, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0xC0, 0x07, 0x00,
  0x60, 0x06, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x07,
  0x00, 0x60, 0x18, 0x03, 0x80, 0x0C, 0x03, 0x80, 0x60, 0x0E, 0x00, 0x30,
  0x0C, 0x01, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x03, 0x80,
  0xC0, 0x0C, 0x07, 0x00, 0x06, 0x07, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x18,
  0x00, 0xE0, 0x60, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x01, 0xC1, 0x80,
  0x06, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x38, 0x00,
  0x70, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x00, 0xE3, 0x00, 0x03,
  0x1C, 0x00, 0x01, 0x9C, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x70, 0x00, 0x39,
  0x80, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x00, 0x76, 0x00, 0x01, 0xB8,
  0x00, 0x01, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x1B, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x38, 0x60, 0x00, 0x06, 0x0E, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0x80,
  0x38, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x03, 0x80, 0x07, 0x00,
  0x60, 0x00, 0x60, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x1C, 0x38, 0x00, 0x01, 0x86, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x06, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0E,
  0x07, 0x00, 0x01, 0x80, 0x60, 0x00, 0x70, 0x0E, 0x00, 0x0C, 0x00, 0xC0,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x01, 0x80, 0x18, 0x00, 0x38, 0x07, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x07,
  0x18, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x06, 0x06, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x38, 0x0C, 0x00, 0x06, 0x01, 0xC0, 0x01, 0xC0,
  0x18, 0x00, 0x30, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x07, 0x00,
  0x70, 0x00, 0x60, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xC0, 0x60, 0x00,
  0x1C, 0x1C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x06, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xC0, 0x18,
  0x00, 0x38, 0x03, 0x80, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x30,
  0x00, 0x60, 0x0E, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x1C,
  0x0C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x38, 0x60, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70,
  0x06, 0x00, 0xC0, 0x10, 0x03, 0xFF, 0x01, 0xFF, 0xF8, 0x3C, 0x01, 0xC1,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0x80, 0x33, 0xC0,
  0x03, 0x70, 0x00, 0x36, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0x60, 0x01, 0xB7, 0x80, 0x73, 0x3F, 0x3E, 0x10, 0xFF, 0xC1,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0xFF, 0x80,
  0xC3, 0xFF, 0xE0, 0xC7, 0x00, 0xF0, 0xCC, 0x00, 0x78, 0xD8, 0x00, 0x38,
  0xD0, 0x00, 0x1C, 0xF0, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06,
  0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0C,
  0xF0, 0x00, 0x0C, 0xF0, 0x00, 0x1C, 0xD8, 0x00, 0x38, 0xDC, 0x00, 0x70,
  0xCE, 0x00, 0xF0, 0xC7, 0xFF, 0xC0, 0xC1, 0xFF, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x07, 0xC0, 0x30, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x01, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0xFF, 0x83, 0x03, 0xFF, 0xC3, 0x07,
  0x80, 0xE3, 0x0E, 0x00, 0x33, 0x1C, 0x00, 0x1B, 0x38, 0x00, 0x0B, 0x38,
  0x00, 0x0F, 0x30, 0x00, 0x07, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x07, 0x30, 0x00, 0x0F, 0x38,
  0x00, 0x0F, 0x18, 0x00, 0x1B, 0x1C, 0x00, 0x33, 0x0F, 0x00, 0x73, 0x07,
  0xF7, 0xC3, 0x01, 0xFF, 0x83, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x1E, 0x03, 0x80, 0x70, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x00,
  0x03, 0x0E, 0x00, 0x07, 0x18, 0x00, 0x06, 0x70, 0x00, 0x0C, 0xC0, 0x00,
  0x1D, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x40, 0xE0, 0x03, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xF0,
  0x1E, 0x08, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x03, 0xFF, 0xC3, 0xFF, 0xF0, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xFF, 0x83, 0x03, 0xFF, 0xE3, 0x07, 0x80, 0x73,
  0x0E, 0x00, 0x33, 0x1C, 0x00, 0x1B, 0x38, 0x00, 0x0F, 0x30, 0x00, 0x0F,
  0x30, 0x00, 0x07, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x07, 0x70, 0x00, 0x07, 0x30, 0x00, 0x0F, 0x38, 0x00, 0x0B,
  0x18, 0x00, 0x1B, 0x1C, 0x00, 0x33, 0x0F, 0x00, 0x63, 0x07, 0xE7, 0xC3,
  0x01, 0xFF, 0x83, 0x00, 0x10, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x20, 0x00, 0x38,
  0x3C, 0x00, 0xF0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x0F, 0xF8, 0x30, 0xFF, 0xF0, 0xC7, 0x00, 0xE3, 0x30, 0x01, 0xCD, 0x80,
  0x03, 0xB4, 0x00, 0x0E, 0xF0, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x70, 0x27, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x00, 0x80, 0x70, 0x3C, 0x0F, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x1C,
  0xFF, 0x3F, 0x80, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x01, 0xCC, 0x00, 0x38,
  0xC0, 0x07, 0x0C, 0x00, 0xE0, 0xC0, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x38,
  0x0C, 0x07, 0x00, 0xC0, 0xE0, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x38,
  0x00, 0xC7, 0x80, 0x0C, 0xEC, 0x00, 0xCC, 0xE0, 0x0D, 0x86, 0x00, 0xF0,
  0x70, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x0C, 0x01, 0xC0, 0xC0, 0x0C, 0x0C,
  0x00, 0xE0, 0xC0, 0x07, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x8C, 0x00, 0x18,
  0xC0, 0x00, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0xFE,
  0x00, 0xFF, 0x06, 0x3F, 0xFC, 0x1F, 0xFE, 0x33, 0x80, 0xE1, 0xC0, 0x79,
  0xB8, 0x03, 0x9C, 0x00, 0xED, 0x80, 0x0E, 0xC0, 0x03, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x03, 0xE0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0xFF, 0x83, 0x0F, 0xFF, 0x0C, 0x70, 0x0E, 0x33, 0x00,
  0x1C, 0xD8, 0x00, 0x3B, 0x40, 0x00, 0xEF, 0x00, 0x01, 0xB8, 0x00, 0x06,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x01, 0xC1, 0xC0, 0x00,
  0x70, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x30, 0x00,
  0x01, 0x98, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x06, 0x70, 0x00, 0x07,
  0x18, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0x80, 0xE0, 0x01,
  0xC0, 0x38, 0x03, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0xFF, 0x80, 0xC3, 0xFF, 0xE0, 0xC7, 0x00, 0xF0, 0xCE,
  0x00, 0x78, 0xD8, 0x00, 0x38, 0xD8, 0x00, 0x1C, 0xF0, 0x00, 0x0C, 0xF0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x0C, 0xD0, 0x00, 0x1C, 0xD8,
  0x00, 0x38, 0xCC, 0x00, 0x70, 0xCF, 0x00, 0xF0, 0xC7, 0xFF, 0xE0, 0xC1,
  0xFF, 0x80, 0xC0, 0x18, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x83, 0x03,
  0xFF, 0xC3, 0x07, 0x80, 0xE3, 0x0E, 0x00, 0x33, 0x1C, 0x00, 0x1B, 0x38,
  0x00, 0x0B, 0x30, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0x38, 0x00, 0x1B, 0x38, 0x00, 0x1B, 0x1C, 0x00, 0x33, 0x0F,
  0x00, 0xE3, 0x07, 0xEF, 0xC3, 0x03, 0xFF, 0x83, 0x00, 0x7C, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xC1, 0xFF, 0x87, 0xFB, 0x1C, 0x06, 0x60, 0x0D, 0x80, 0x1A,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xFE, 0x1E, 0x00, 0xE3, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x80, 0x00, 0xEE, 0x00, 0x1C, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0xF0,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x7D,
  0xC0, 0x7F, 0x80, 0x18, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x1E, 0xC0, 0x01, 0xB7, 0x00, 0x1D, 0x9C, 0x01, 0xCC, 0x7F,
  0xFC, 0x61, 0xFF, 0x83, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x1C, 0x00,
  0x38, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x0E, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xC0, 0x03, 0x00,
  0xC0, 0x03, 0x01, 0xC0, 0x03, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0x83,
  0x80, 0x01, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC7, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x3F,
  0x00, 0x03, 0x80, 0x01, 0xB8, 0x00, 0x1C, 0x00, 0x0C, 0xC0, 0x01, 0xF0,
  0x00, 0x66, 0x00, 0x0D, 0x80, 0x07, 0x38, 0x00, 0x6C, 0x00, 0x31, 0xC0,
  0x03, 0x70, 0x01, 0x86, 0x00, 0x39, 0x80, 0x0C, 0x30, 0x01, 0x8C, 0x00,
  0xE1, 0xC0, 0x0C, 0x60, 0x06, 0x0E, 0x00, 0xE3, 0x80, 0x30, 0x30, 0x06,
  0x0C, 0x01, 0x81, 0x80, 0x30, 0x60, 0x1C, 0x0E, 0x01, 0x83, 0x00, 0xC0,
  0x30, 0x1C, 0x1C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03,
  0x03, 0x80, 0x70, 0x70, 0x1C, 0x18, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x0C,
  0x18, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x18, 0x70, 0x03, 0x8E, 0x00, 0xE3,
  0x00, 0x0C, 0x60, 0x03, 0x18, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x03, 0x38,
  0x00, 0xEE, 0x00, 0x1D, 0x80, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x03, 0x60, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x0E, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x60, 0xC0, 0x01, 0xC1, 0xC0,
  0x03, 0x01, 0xC0, 0x0E, 0x01, 0x80, 0x38, 0x03, 0x80, 0x60, 0x03, 0x81,
  0xC0, 0x03, 0x03, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x60,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xB8, 0x00, 0x07, 0x38, 0x00, 0x1C, 0x30, 0x00,
  0x30, 0x70, 0x00, 0xE0, 0x60, 0x01, 0x80, 0x60, 0x07, 0x00, 0xE0, 0x1C,
  0x00, 0xC0, 0x30, 0x01, 0xC0, 0xE0, 0x01, 0xC3, 0x80, 0x01, 0x86, 0x00,
  0x03, 0x9C, 0x00, 0x03, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x60, 0x00,
  0x07, 0x70, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x38, 0x00,
  0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x0C, 0x00,
  0x18, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x30, 0x06, 0x00, 0x30, 0x06, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x80,
  0xC0, 0x01, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x01, 0xC1, 0x80, 0x00, 0xC1,
  0x80, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x63, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x3F,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0xBF, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x03, 0xFB, 0xE8,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 43, 13, 5, -43 },
  { 23, 12, 16, 20, 4, -43 },
  { 47, 32, 43, 34, 1, -43 },
  { 219, 23, 49, 30, 3, -46 },
  { 360, 37, 44, 43, 3, -43 },
  { 564, 32, 45, 36, 3, -44 },
  { 744, 3, 16, 11, 4, -43 },
  { 750, 11, 52, 16, 3, -43 },
  { 822, 11, 52, 16, 2, -43 },
  { 894, 22, 22, 29, 3, -46 },
  { 955, 25, 28, 31, 3, -35 },
  { 1043, 6, 15, 12, 2, -7 },
  { 1055, 14, 2, 18, 2, -17 },
  { 1059, 3, 4, 13, 5, -4 },
  { 1061, 18, 43, 20, 1, -43 },
  { 1158, 24, 45, 30, 3, -44 },
  { 1293, 13, 43, 30, 5, -43 },
  { 1363, 24, 43, 30, 3, -43 },
  { 1492, 24, 44, 30, 3, -43 },
  { 1624, 29, 43, 30, 1, -43 },
  { 1780, 23, 44, 30, 4, -43 },
  { 1907, 23, 44, 30, 4, -43 },
  { 2034, 24, 43, 30, 3, -43 },
  { 2163, 24, 44, 30, 3, -43 },
  { 2295, 24, 44, 30, 3, -43 },
  { 2427, 3, 32, 13, 5, -32 },
  { 2439, 7, 40, 13, 2, -32 },
  { 2474, 25, 27, 31, 3, -35 },
  { 2559, 25, 14, 31, 3, -28 },
  { 2603, 25, 27, 31, 3, -35 },
  { 2688, 18, 43, 22, 2, -43 },
  { 2785, 41, 49, 47, 3, -43 },
  { 3037, 31, 43, 31, 0, -43 },
  { 3204, 24, 43, 33, 6, -43 },
  { 3333, 27, 44, 33, 4, -43 },
  { 3482, 28, 43, 37, 6, -43 },
  { 3633, 20, 43, 29, 6, -43 },
  { 3741, 20, 43, 27, 6, -43 },
  { 3849, 31, 45, 39, 4, -44 },
  { 4024, 26, 43, 38, 6, -43 },
  { 4164, 10, 43, 16, 3, -43 },
  { 4218, 13, 54, 13, -5, -43 },
  { 4306, 24, 43, 30, 6, -43 },
  { 4435, 20, 43, 27, 6, -43 },
  { 4543, 35, 43, 47, 6, -43 },
  { 4732, 27, 43, 38, 6, -43 },
  { 4878, 33, 45, 40, 4, -44 },
  { 5064, 22, 43, 31, 6, -43 },
  { 5183, 33, 54, 40, 4, -44 },
  { 5406, 24, 43, 31, 6, -43 },
  { 5535, 23, 44, 29, 3, -43 },
  { 5662, 27, 43, 27, 0, -43 },
  { 5808, 28, 44, 38, 5, -43 },
  { 5962, 30, 43, 30, 0, -43 },
  { 6124, 46, 43, 48, 1, -43 },
  { 6372, 27, 43, 28, 0, -43 },
  { 6518, 27, 43, 27, 0, -43 },
  { 6664, 25, 43, 29, 2, -43 },
  { 6799, 12, 52, 19, 5, -43 },
  { 6877, 18, 43, 20, 1, -43 },
  { 6974, 12, 52, 19, 2, -43 },
  { 7052, 27, 25, 31, 2, -43 },
  { 7137, 24, 2, 24, 0, 5 },
  { 7143, 10, 10, 15, 2, -46 },
  { 7156, 20, 33, 28, 3, -32 },
  { 7239, 24, 47, 32, 5, -46 },
  { 7380, 20, 33, 25, 3, -32 },
  { 7463, 24, 47, 32, 3, -46 },
  { 7604, 23, 33, 29, 3, -32 },
  { 7699, 18, 46, 16, 1, -46 },
  { 7803, 24, 46, 32, 3, -32 },
  { 7941, 22, 46, 31, 5, -46 },
  { 8068, 4, 44, 12, 4, -44 },
  { 8090, 10, 58, 12, -2, -44 },
  { 8163, 20, 46, 25, 5, -46 },
  { 8278, 2, 46, 12, 5, -46 },
  { 8290, 37, 32, 47, 5, -32 },
  { 8438, 22, 32, 31, 5, -32 },
  { 8526, 25, 33, 31, 3, -32 },
  { 8630, 24, 46, 32, 5, -32 },
  { 8768, 24, 46, 32, 3, -32 },
  { 8906, 15, 32, 21, 5, -32 },
  { 8966, 20, 33, 25, 2, -32 },
  { 9049, 15, 40, 17, 1, -39 },
  { 9124, 21, 33, 31, 5, -32 },
  { 9211, 24, 32, 24, 0, -32 },
  { 9307, 37, 32, 38, 1, -32 },
  { 9455, 23, 32, 26, 1, -32 },
  { 9547, 24, 47, 24, 0, -32 },
  { 9688, 19, 32, 23, 2, -32 },
  { 9764, 16, 52, 21, 2, -43 },
  { 9868, 2, 61, 29, 13, -46 },
  { 9884, 17, 52, 21, 2, -43 },
  { 9995, 25, 6, 31, 3, -24 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight60pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT60PT7B_H_
