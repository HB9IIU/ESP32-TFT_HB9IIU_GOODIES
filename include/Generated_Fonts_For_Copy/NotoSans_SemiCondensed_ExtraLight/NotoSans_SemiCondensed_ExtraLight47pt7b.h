#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT47PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight47pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xD8, 0x00,
  0x07, 0xFC, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xD0, 0x68, 0x14, 0x08, 0x00, 0x20, 0x10, 0x00, 0x30, 0x08, 0x00,
  0x18, 0x04, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x02, 0x01, 0x80,
  0x01, 0x00, 0x80, 0x01, 0x80, 0x40, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x30,
  0x00, 0x30, 0x18, 0x07, 0xFF, 0xFF, 0xF0, 0x08, 0x04, 0x00, 0x0C, 0x02,
  0x00, 0x06, 0x01, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x80,
  0x60, 0x00, 0x40, 0x30, 0x00, 0x60, 0x10, 0x00, 0x30, 0x08, 0x00, 0x18,
  0x0C, 0x03, 0xFF, 0xFF, 0xF8, 0x04, 0x03, 0x00, 0x02, 0x01, 0x80, 0x03,
  0x00, 0x80, 0x01, 0x80, 0x40, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00,
  0x20, 0x18, 0x00, 0x10, 0x0C, 0x00, 0x08, 0x04, 0x00, 0x0C, 0x02, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xF0, 0x38, 0x87, 0x0C, 0x10, 0x03, 0x02, 0x00, 0x60,
  0x40, 0x08, 0x08, 0x03, 0x01, 0x00, 0x60, 0x20, 0x04, 0x04, 0x00, 0xC0,
  0x80, 0x18, 0x10, 0x01, 0x82, 0x00, 0x1C, 0x40, 0x01, 0xE8, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x05, 0xE0, 0x00, 0x8E, 0x00, 0x10, 0x60, 0x02,
  0x06, 0x00, 0x40, 0xC0, 0x08, 0x08, 0x01, 0x01, 0x80, 0x20, 0x30, 0x04,
  0x04, 0x00, 0x81, 0x80, 0x10, 0x30, 0x02, 0x0C, 0x60, 0x47, 0x0F, 0xFF,
  0xC0, 0x3F, 0xE0, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x0F, 0x80, 0x03, 0x00, 0x77, 0x00, 0x08, 0x03, 0x06, 0x00, 0x60,
  0x08, 0x18, 0x01, 0x00, 0x60, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x20, 0x04,
  0x03, 0x01, 0x80, 0x10, 0x0C, 0x04, 0x00, 0x40, 0x30, 0x30, 0x03, 0x00,
  0x40, 0xC0, 0x0C, 0x01, 0x06, 0x00, 0x30, 0x04, 0x18, 0x00, 0x40, 0x30,
  0xC0, 0x01, 0x00, 0xC3, 0x06, 0x04, 0x03, 0x18, 0x7E, 0x18, 0x0C, 0x63,
  0x0C, 0x60, 0x23, 0x18, 0x30, 0x81, 0x8C, 0x40, 0x63, 0x06, 0x23, 0x01,
  0x87, 0x71, 0x8C, 0x02, 0x0F, 0x84, 0x30, 0x08, 0x00, 0x30, 0xC0, 0x20,
  0x00, 0x82, 0x00, 0xC0, 0x06, 0x08, 0x03, 0x00, 0x10, 0x20, 0x0C, 0x00,
  0xC0, 0x80, 0x30, 0x02, 0x03, 0x00, 0x80, 0x18, 0x0C, 0x02, 0x00, 0x60,
  0x30, 0x18, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x01, 0x01, 0x80, 0x60, 0x06,
  0x0C, 0x01, 0x80, 0x0C, 0x70, 0x0C, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0x40, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x10, 0x03, 0x00, 0x08, 0x01,
  0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60,
  0xE0, 0x00, 0x18, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x63,
  0x00, 0xC0, 0x33, 0x00, 0x30, 0x11, 0x80, 0x1C, 0x18, 0x80, 0x06, 0x0C,
  0xC0, 0x01, 0x84, 0x60, 0x00, 0x66, 0x30, 0x00, 0x1E, 0x18, 0x00, 0x07,
  0x06, 0x00, 0x03, 0x83, 0x00, 0x03, 0xC0, 0xC0, 0x03, 0x30, 0x70, 0x07,
  0x0C, 0x1F, 0x0F, 0x03, 0x03, 0xFE, 0x00, 0xC0, 0xFF, 0xFF, 0xF5, 0x40,
  0x01, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x30, 0x30, 0x18, 0x08,
  0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x80, 0xC0,
  0xC0, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x02,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x01, 0x01, 0x01, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18,
  0x30, 0x30, 0x60, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x04, 0x0F, 0xF1, 0x1F, 0x0F, 0xFC,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x04, 0xC0, 0x03, 0x10, 0x01, 0x86, 0x00,
  0xC0, 0xC0, 0x30, 0x18, 0x18, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF,
  0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x33, 0x33, 0x66, 0x66, 0xCC, 0x80, 0xFF, 0xFF, 0xFC, 0xDF,
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xC0, 0xE0, 0xE0, 0x1C, 0x30, 0x03,
  0x18, 0x00, 0x66, 0x00, 0x19, 0x00, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x34,
  0x00, 0x09, 0x80, 0x06, 0x60, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x30, 0x60,
  0x18, 0x0F, 0x3C, 0x01, 0xFE, 0x00, 0x00, 0xC0, 0x70, 0x3C, 0x1B, 0x1C,
  0xCE, 0x37, 0x0F, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x03, 0xF8, 0x03, 0xFF, 0x80, 0xE0, 0x1C, 0x30, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF8,
  0x03, 0xFF, 0xC1, 0xE0, 0x1C, 0x70, 0x01, 0xC4, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x01, 0xE0,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x64,
  0x00, 0x18, 0xF8, 0x1E, 0x07, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00,
  0x01, 0x98, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x01, 0x86, 0x00, 0x04,
  0x18, 0x00, 0x30, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x30, 0x18,
  0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x18, 0x06,
  0x00, 0x60, 0x30, 0x01, 0x80, 0x80, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00,
  0x60, 0xFF, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x40, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x32, 0x00, 0x18, 0xF0, 0x3C, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0xF0, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x81, 0xC0, 0x31, 0xFF, 0x06, 0x60, 0x38,
  0xD8, 0x03, 0x9E, 0x00, 0x33, 0x80, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D,
  0x80, 0x00, 0xB0, 0x00, 0x16, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x09,
  0x00, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0x60,
  0xC0, 0x18, 0x0E, 0x0E, 0x00, 0xFF, 0x80, 0x01, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xC0,
  0x70, 0x0E, 0x0C, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x01, 0x98, 0x00, 0x33,
  0x00, 0x02, 0x60, 0x00, 0xC4, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xC1,
  0x80, 0x38, 0x1C, 0x0E, 0x01, 0xC3, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0xF3, 0x80, 0x38, 0x1C, 0x0C, 0x01, 0xC3, 0x00, 0x1C, 0xC0, 0x01, 0x98,
  0x00, 0x1B, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x01, 0xA0,
  0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00, 0x31, 0xC0, 0x0C, 0x1E,
  0x0F, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x70, 0x1C, 0x18,
  0x01, 0x83, 0x00, 0x18, 0xC0, 0x01, 0x18, 0x00, 0x32, 0x00, 0x06, 0xC0,
  0x00, 0x58, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xD8, 0x00, 0x1B, 0x00, 0x07, 0x60, 0x00, 0xE6, 0x00, 0x2C, 0x60,
  0x1D, 0x87, 0x9E, 0x30, 0x7F, 0x86, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x20, 0x78, 0x07, 0xFC,
  0x00, 0x18, 0x00, 0x00, 0xDF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x37, 0xC0, 0x31, 0xCE, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x18, 0xC6, 0x63, 0x18, 0x8C, 0x62, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x1F, 0xC1, 0xFF, 0xE1, 0x00, 0xE0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x06, 0x30, 0x01, 0xFC, 0x02, 0x30, 0x07, 0xFE, 0x03,
  0x20, 0x0C, 0x06, 0x03, 0x60, 0x18, 0x06, 0x03, 0x60, 0x30, 0x06, 0x01,
  0x60, 0x30, 0x06, 0x01, 0x40, 0x20, 0x06, 0x01, 0x40, 0x60, 0x06, 0x01,
  0x40, 0x60, 0x06, 0x01, 0xC0, 0x60, 0x06, 0x01, 0xC0, 0x60, 0x04, 0x01,
  0xC0, 0x60, 0x04, 0x03, 0x40, 0x60, 0x0C, 0x03, 0x40, 0x60, 0x0C, 0x03,
  0x40, 0x20, 0x0E, 0x02, 0x60, 0x30, 0x1E, 0x06, 0x60, 0x18, 0x33, 0x0C,
  0x60, 0x1F, 0xE3, 0xF8, 0x20, 0x07, 0x80, 0xF0, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x01, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x62, 0x00, 0x00, 0x63, 0x00, 0x00, 0x43, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01,
  0x80, 0xC0, 0x01, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x08, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x20,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0xC0, 0x0F, 0x8C, 0x00, 0x18,
  0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x04, 0xC0, 0x00, 0xCC, 0x00,
  0x18, 0xC0, 0x03, 0x8C, 0x07, 0xE0, 0xFF, 0xFC, 0x0C, 0x00, 0xF0, 0xC0,
  0x01, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x06,
  0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x01, 0xCC, 0x00, 0x38, 0xFF, 0xFF,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0xE0, 0x06, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x01, 0x03, 0xF0, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x0C, 0x01, 0xF0, 0x30, 0x00, 0xF0, 0xC0, 0x00, 0xE3, 0x00,
  0x01, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x0E, 0xC0, 0x00, 0x1B, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0,
  0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x8C, 0x00, 0x1C, 0x30, 0x01,
  0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xFE, 0x03, 0xC0, 0x0F, 0x07, 0x00, 0x02, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x70, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x07, 0x80, 0x03, 0x01,
  0xF0, 0x3F, 0x00, 0x7F, 0xFC, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0xC7,
  0xBF, 0x80, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x01, 0xCC, 0x00, 0x18,
  0xC0, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x0C, 0x01, 0xC0, 0xC0, 0x38,
  0x0C, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x38,
  0x00, 0xC7, 0x00, 0x0C, 0xF0, 0x00, 0xCF, 0x80, 0x0D, 0x98, 0x00, 0xF0,
  0xC0, 0x0E, 0x0C, 0x00, 0xC0, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x01, 0x80, 0xC0, 0x1C, 0x0C, 0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x70,
  0xC0, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x01, 0xCC, 0x00, 0x0C, 0xC0, 0x00,
  0x6C, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x05, 0xD8, 0x00, 0x00, 0xDD, 0x80, 0x00, 0x0D, 0xD8, 0x00, 0x00, 0x9C,
  0xC0, 0x00, 0x19, 0xCC, 0x00, 0x01, 0x9C, 0x40, 0x00, 0x31, 0xC6, 0x00,
  0x03, 0x1C, 0x60, 0x00, 0x21, 0xC2, 0x00, 0x06, 0x1C, 0x30, 0x00, 0x61,
  0xC3, 0x00, 0x04, 0x1C, 0x18, 0x00, 0xC1, 0xC1, 0x80, 0x0C, 0x1C, 0x18,
  0x01, 0x81, 0xC0, 0xC0, 0x18, 0x1C, 0x0C, 0x01, 0x81, 0xC0, 0x40, 0x30,
  0x1C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x20, 0x1C, 0x03, 0x06, 0x01, 0xC0,
  0x30, 0x60, 0x1C, 0x03, 0x04, 0x01, 0xC0, 0x18, 0xC0, 0x1C, 0x01, 0x8C,
  0x01, 0xC0, 0x19, 0x80, 0x1C, 0x00, 0xD8, 0x01, 0xC0, 0x0D, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xD8, 0x00, 0x0F,
  0x60, 0x00, 0x3C, 0xC0, 0x00, 0xF3, 0x00, 0x03, 0xC6, 0x00, 0x0F, 0x1C,
  0x00, 0x3C, 0x30, 0x00, 0xF0, 0x60, 0x03, 0xC1, 0x80, 0x0F, 0x03, 0x00,
  0x3C, 0x0C, 0x00, 0xF0, 0x18, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C,
  0x01, 0x80, 0xF0, 0x06, 0x03, 0xC0, 0x0C, 0x0F, 0x00, 0x18, 0x3C, 0x00,
  0x60, 0xF0, 0x00, 0xC3, 0xC0, 0x03, 0x0F, 0x00, 0x06, 0x3C, 0x00, 0x1C,
  0xF0, 0x00, 0x33, 0xC0, 0x00, 0x6F, 0x00, 0x01, 0xBC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x70, 0x07, 0x80, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x0C,
  0x0E, 0x00, 0x01, 0x83, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00,
  0x01, 0x18, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0xC0, 0x1C, 0x00, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0xFE, 0x0C, 0x01, 0xE3, 0x00, 0x1C, 0xC0, 0x01, 0xB0, 0x00,
  0x6C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x0E, 0xC0,
  0x07, 0x30, 0x03, 0x8F, 0xFF, 0xC3, 0xFF, 0x80, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x70,
  0x07, 0x80, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xB0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0xE0,
  0x03, 0xE1, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0xC0, 0x1E, 0x0C, 0x00, 0x70, 0xC0, 0x01, 0x8C, 0x00, 0x18,
  0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00,
  0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00,
  0x30, 0xC0, 0x06, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C,
  0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x8C, 0x00, 0x18,
  0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0x01, 0xFE,
  0x01, 0xFF, 0xF8, 0x70, 0x03, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x64,
  0x00, 0x18, 0xFC, 0x1E, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0xC0, 0x00, 0xC3,
  0x00, 0x07, 0x07, 0x00, 0x38, 0x0F, 0x03, 0xC0, 0x0F, 0xFC, 0x00, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x10,
  0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x30, 0x08, 0x00, 0x30, 0x0C,
  0x00, 0x30, 0x0C, 0x00, 0x60, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x02, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x80, 0x03,
  0x01, 0x80, 0x01, 0x81, 0x80, 0x01, 0x81, 0x00, 0x01, 0x83, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0xC2, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06,
  0x00, 0x02, 0xC0, 0x00, 0xE0, 0x00, 0x66, 0x00, 0x0E, 0x00, 0x06, 0x60,
  0x00, 0xB0, 0x00, 0x66, 0x00, 0x0B, 0x00, 0x04, 0x60, 0x01, 0xB0, 0x00,
  0xC3, 0x00, 0x19, 0x00, 0x0C, 0x30, 0x01, 0x98, 0x00, 0xC3, 0x00, 0x11,
  0x80, 0x08, 0x30, 0x03, 0x18, 0x01, 0x81, 0x80, 0x30, 0x80, 0x18, 0x18,
  0x03, 0x0C, 0x01, 0x81, 0x80, 0x20, 0xC0, 0x10, 0x18, 0x06, 0x0C, 0x03,
  0x00, 0xC0, 0x60, 0x40, 0x30, 0x0C, 0x06, 0x06, 0x03, 0x00, 0xC0, 0x40,
  0x60, 0x20, 0x0C, 0x0C, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x20, 0x60, 0x06,
  0x0C, 0x03, 0x06, 0x00, 0x60, 0x80, 0x30, 0x40, 0x06, 0x18, 0x03, 0x0C,
  0x00, 0x31, 0x80, 0x10, 0xC0, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x31, 0x00,
  0x18, 0x80, 0x03, 0x30, 0x01, 0x98, 0x00, 0x13, 0x00, 0x09, 0x80, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0x1A, 0x00, 0x0D, 0x00, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x19, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00,
  0xC1, 0x80, 0x06, 0x06, 0x00, 0x60, 0x30, 0x03, 0x00, 0xC0, 0x30, 0x03,
  0x01, 0x80, 0x18, 0x18, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0xC0,
  0x00, 0x66, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0xC3, 0x00,
  0x04, 0x18, 0x00, 0x60, 0x60, 0x06, 0x03, 0x00, 0x30, 0x0C, 0x03, 0x00,
  0x60, 0x18, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0xC0, 0x00, 0xCE,
  0x00, 0x06, 0x60, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x06, 0x18, 0x00, 0x30,
  0x60, 0x03, 0x03, 0x00, 0x18, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0xC0, 0x0C, 0x06, 0x00, 0x30, 0x30, 0x01, 0x83, 0x00, 0x06, 0x18, 0x00,
  0x31, 0x80, 0x00, 0x8C, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0x80, 0xC0, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0xFF, 0xFF,
  0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0xFF, 0xC0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x0D, 0x00,
  0x01, 0x98, 0x00, 0x18, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x40, 0x06, 0x06,
  0x00, 0x60, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x18, 0x01, 0x81, 0x80,
  0x08, 0x30, 0x00, 0xC3, 0x00, 0x04, 0x60, 0x00, 0x66, 0x00, 0x06, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x60, 0x30,
  0x38, 0x18, 0x0C, 0x06, 0x03, 0x0F, 0xF8, 0x3E, 0x3C, 0x10, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x01, 0xFF, 0x0F, 0x81, 0x38, 0x01, 0x70, 0x01, 0x60,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x60,
  0x05, 0x60, 0x09, 0x38, 0x39, 0x1F, 0xE1, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x63, 0xFC, 0x0C,
  0xF1, 0xE1, 0xB0, 0x0E, 0x3C, 0x00, 0xE7, 0x00, 0x0C, 0xE0, 0x00, 0xD8,
  0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x00, 0xB0,
  0x00, 0x16, 0x00, 0x03, 0xC0, 0x00, 0x58, 0x00, 0x0B, 0x00, 0x03, 0x60,
  0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB8, 0x00, 0x67, 0x00, 0x0C, 0xB0,
  0x03, 0x13, 0x00, 0xE2, 0x38, 0x78, 0x43, 0xFC, 0x00, 0x03, 0xFE, 0x1F,
  0x1C, 0x70, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0F, 0x03, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x81, 0xFE,
  0x30, 0xF0, 0xE6, 0x38, 0x06, 0xC6, 0x00, 0x79, 0x80, 0x07, 0x30, 0x00,
  0xEC, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x68, 0x00, 0x0D, 0x00, 0x01,
  0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x39, 0x80, 0x05,
  0x38, 0x01, 0xA3, 0x80, 0x64, 0x38, 0x18, 0x83, 0xFE, 0x10, 0x07, 0xF8,
  0x07, 0x1E, 0x06, 0x01, 0x86, 0x00, 0x66, 0x00, 0x33, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x02, 0x3C,
  0x0E, 0x07, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x3F,
  0xF0, 0xFF, 0xC0, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x03, 0xFC, 0x21, 0xE1, 0xC4,
  0x70, 0x0D, 0x8C, 0x00, 0xF3, 0x00, 0x0E, 0x60, 0x01, 0xD8, 0x00, 0x1B,
  0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xD0, 0x00, 0x1A, 0x00, 0x03, 0x60, 0x00, 0x6C,
  0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x73, 0x00, 0x0E, 0x70, 0x03, 0xC7,
  0x00, 0xD8, 0x70, 0x73, 0x07, 0xFC, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xC4, 0x00, 0x70, 0xF8, 0x7C, 0x07, 0xFE, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0xFF, 0x0C, 0xE1,
  0xE6, 0xC0, 0x33, 0xC0, 0x0D, 0xC0, 0x06, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x30, 0x7D, 0x80, 0x00, 0x0D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6C, 0x03, 0x07, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x8E, 0xFC,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x06,
  0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x70, 0xC0, 0x60, 0xC0, 0xC0,
  0xC1, 0x80, 0xC3, 0x00, 0xC6, 0x00, 0xC6, 0x00, 0xCE, 0x00, 0xDB, 0x00,
  0xF1, 0x80, 0xE1, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x30,
  0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xF0, 0x3F,
  0xC4, 0x71, 0xC3, 0x8F, 0x26, 0x03, 0x30, 0x1D, 0x60, 0x0B, 0x00, 0x6E,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0x40, 0x03, 0xC0, 0x02, 0x00, 0x1E, 0x00, 0x10, 0x00, 0xF0, 0x00, 0x80,
  0x07, 0x80, 0x04, 0x00, 0x3C, 0x00, 0x20, 0x01, 0xE0, 0x01, 0x00, 0x0F,
  0x00, 0x08, 0x00, 0x78, 0x00, 0x40, 0x03, 0xC0, 0x02, 0x00, 0x1E, 0x00,
  0x10, 0x00, 0xF0, 0x00, 0x80, 0x07, 0x80, 0x04, 0x00, 0x3C, 0x00, 0x20,
  0x01, 0xE0, 0x01, 0x00, 0x0F, 0x00, 0x08, 0x00, 0x78, 0x00, 0x40, 0x03,
  0xC0, 0x02, 0x00, 0x18, 0x83, 0xF8, 0x47, 0x0F, 0x26, 0x01, 0xD6, 0x00,
  0x6A, 0x00, 0x37, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xFC,
  0x00, 0x70, 0xF0, 0x1C, 0x03, 0x81, 0x80, 0x0C, 0x30, 0x00, 0xC3, 0x00,
  0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x36, 0x00, 0x03, 0x40,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x60, 0x00, 0x36,
  0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x06,
  0x30, 0x00, 0xC1, 0x80, 0x0C, 0x1C, 0x01, 0x80, 0xF0, 0x70, 0x03, 0xFE,
  0x00, 0x83, 0xF8, 0x11, 0xE3, 0xC2, 0x60, 0x1C, 0x48, 0x01, 0xCA, 0x00,
  0x19, 0xC0, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00,
  0x0B, 0x00, 0x01, 0x60, 0x00, 0x2C, 0x00, 0x07, 0x80, 0x00, 0xB0, 0x00,
  0x16, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x70, 0x00,
  0xCE, 0x00, 0x19, 0xE0, 0x07, 0x36, 0x01, 0xC6, 0x70, 0xF0, 0xC7, 0xF8,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0xFC, 0x21, 0xE1, 0xC4, 0x70, 0x0D, 0x8C, 0x00,
  0xF3, 0x00, 0x0E, 0x60, 0x01, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00,
  0x68, 0x00, 0x0D, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1A, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01,
  0xB0, 0x00, 0x73, 0x00, 0x0E, 0x60, 0x03, 0xC6, 0x00, 0xD8, 0x70, 0x73,
  0x07, 0xFC, 0x60, 0x08, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x87, 0xF1, 0xEE, 0x60, 0x78, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x00, 0x0F, 0xF8, 0x78, 0x7D, 0xC0, 0x0B, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x03, 0x78,
  0x1C, 0x7F, 0xF0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x3F,
  0xFF, 0xFF, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x1C, 0x41, 0xF8, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x2D, 0x80, 0x36, 0x70,
  0x73, 0x1F, 0xE1, 0x80, 0xC0, 0x00, 0x68, 0x00, 0x19, 0x80, 0x03, 0x30,
  0x00, 0x42, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x40, 0x80, 0x18, 0x18,
  0x03, 0x03, 0x00, 0x40, 0x20, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x40, 0x08,
  0x18, 0x01, 0x83, 0x00, 0x30, 0x40, 0x06, 0x18, 0x00, 0x63, 0x00, 0x0C,
  0x40, 0x01, 0x98, 0x00, 0x1B, 0x00, 0x03, 0x40, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x1E, 0x00, 0x38, 0x01, 0xB0,
  0x01, 0xC0, 0x0D, 0x80, 0x1A, 0x00, 0x66, 0x00, 0xD0, 0x02, 0x30, 0x06,
  0xC0, 0x31, 0x80, 0x26, 0x01, 0x84, 0x03, 0x10, 0x0C, 0x30, 0x18, 0xC0,
  0x41, 0x80, 0x86, 0x06, 0x0C, 0x0C, 0x30, 0x30, 0x20, 0x60, 0x81, 0x81,
  0x83, 0x06, 0x08, 0x0C, 0x10, 0x30, 0xC0, 0x61, 0x80, 0x86, 0x01, 0x0C,
  0x06, 0x30, 0x0C, 0x40, 0x31, 0x00, 0x66, 0x01, 0x98, 0x03, 0x30, 0x04,
  0xC0, 0x09, 0x80, 0x36, 0x00, 0x68, 0x01, 0xA0, 0x03, 0xC0, 0x0D, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xE0,
  0x01, 0xD8, 0x00, 0x63, 0x00, 0x30, 0x60, 0x0C, 0x18, 0x06, 0x03, 0x03,
  0x00, 0xC0, 0xC0, 0x18, 0x60, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x3B, 0x00, 0x0C, 0xC0, 0x06,
  0x18, 0x01, 0x86, 0x00, 0xC0, 0xC0, 0x60, 0x18, 0x18, 0x06, 0x0C, 0x00,
  0xC3, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x6C, 0x00,
  0x19, 0x80, 0x03, 0x30, 0x00, 0x63, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00,
  0x60, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0x30, 0x18, 0x06, 0x03,
  0x00, 0x40, 0x60, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x10, 0x60, 0x03, 0x18,
  0x00, 0x63, 0x00, 0x04, 0x60, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x01, 0x60,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x02, 0x70, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFE,
  0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x10, 0x1F,
  0x03, 0x80, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0xF0, 0x0F, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x40,
  0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x3C, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x80, 0x7C, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x38, 0x07, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x01, 0xC0,
  0xF0, 0x78, 0x03, 0xFE, 0x00, 0x03, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 34, 10, 4, -34 },
  { 14, 9, 13, 15, 3, -34 },
  { 29, 25, 34, 27, 1, -34 },
  { 136, 19, 39, 24, 2, -36 },
  { 229, 30, 34, 34, 2, -34 },
  { 357, 25, 34, 28, 2, -34 },
  { 464, 2, 13, 8, 3, -34 },
  { 468, 9, 41, 13, 2, -34 },
  { 515, 8, 41, 13, 2, -34 },
  { 556, 18, 17, 22, 2, -36 },
  { 595, 20, 22, 24, 2, -28 },
  { 650, 4, 11, 9, 2, -5 },
  { 656, 11, 2, 14, 2, -14 },
  { 659, 3, 3, 10, 4, -3 },
  { 661, 14, 34, 16, 1, -34 },
  { 721, 18, 34, 24, 3, -34 },
  { 798, 10, 34, 24, 4, -34 },
  { 841, 19, 34, 24, 2, -34 },
  { 922, 19, 34, 24, 2, -34 },
  { 1003, 22, 34, 24, 1, -34 },
  { 1097, 18, 34, 24, 3, -34 },
  { 1174, 19, 35, 24, 3, -34 },
  { 1258, 19, 34, 24, 2, -34 },
  { 1339, 19, 34, 24, 2, -34 },
  { 1420, 19, 35, 24, 2, -34 },
  { 1504, 3, 25, 10, 4, -25 },
  { 1514, 5, 31, 10, 2, -25 },
  { 1534, 20, 21, 24, 2, -27 },
  { 1587, 20, 11, 24, 2, -22 },
  { 1615, 20, 21, 24, 2, -27 },
  { 1668, 15, 34, 17, 1, -34 },
  { 1732, 32, 37, 37, 2, -33 },
  { 1880, 24, 34, 24, 0, -34 },
  { 1982, 20, 34, 26, 4, -34 },
  { 2067, 21, 34, 26, 3, -34 },
  { 2157, 22, 34, 29, 4, -34 },
  { 2251, 16, 34, 23, 4, -34 },
  { 2319, 16, 34, 21, 4, -34 },
  { 2387, 24, 34, 31, 3, -34 },
  { 2489, 21, 34, 30, 4, -34 },
  { 2579, 8, 34, 13, 2, -34 },
  { 2613, 10, 42, 10, -4, -34 },
  { 2666, 20, 34, 24, 4, -34 },
  { 2751, 16, 34, 21, 4, -34 },
  { 2819, 28, 34, 37, 4, -34 },
  { 2938, 22, 34, 30, 4, -34 },
  { 3032, 26, 34, 32, 3, -34 },
  { 3143, 18, 34, 24, 4, -34 },
  { 3220, 26, 42, 32, 3, -34 },
  { 3357, 20, 34, 25, 4, -34 },
  { 3442, 19, 34, 23, 2, -34 },
  { 3523, 21, 34, 21, 0, -34 },
  { 3613, 22, 34, 30, 4, -34 },
  { 3707, 24, 34, 24, 0, -34 },
  { 3809, 36, 34, 38, 1, -34 },
  { 3962, 21, 34, 22, 0, -34 },
  { 4052, 21, 34, 21, 0, -34 },
  { 4142, 19, 34, 23, 2, -34 },
  { 4223, 9, 41, 15, 4, -34 },
  { 4270, 14, 34, 16, 1, -34 },
  { 4330, 10, 41, 15, 1, -34 },
  { 4382, 20, 20, 24, 2, -34 },
  { 4432, 19, 2, 19, 0, 4 },
  { 4437, 8, 8, 12, 2, -36 },
  { 4445, 16, 25, 22, 2, -25 },
  { 4495, 19, 36, 25, 4, -36 },
  { 4581, 15, 25, 20, 3, -25 },
  { 4628, 19, 36, 25, 2, -36 },
  { 4714, 17, 25, 23, 3, -25 },
  { 4768, 14, 36, 12, 1, -36 },
  { 4831, 19, 36, 25, 2, -25 },
  { 4917, 17, 36, 25, 4, -36 },
  { 4994, 3, 34, 10, 3, -34 },
  { 5007, 8, 45, 10, -2, -34 },
  { 5052, 16, 36, 20, 4, -36 },
  { 5124, 2, 36, 10, 4, -36 },
  { 5133, 29, 25, 37, 4, -25 },
  { 5224, 17, 25, 25, 4, -25 },
  { 5278, 20, 25, 24, 2, -25 },
  { 5341, 19, 36, 25, 4, -25 },
  { 5427, 19, 36, 25, 2, -25 },
  { 5513, 11, 25, 16, 4, -25 },
  { 5548, 15, 25, 19, 2, -25 },
  { 5595, 11, 31, 14, 1, -31 },
  { 5638, 17, 25, 25, 4, -25 },
  { 5692, 19, 25, 19, 0, -25 },
  { 5752, 29, 25, 30, 1, -25 },
  { 5843, 18, 25, 20, 1, -25 },
  { 5900, 19, 36, 19, 0, -25 },
  { 5986, 15, 25, 18, 2, -25 },
  { 6033, 12, 41, 16, 2, -34 },
  { 6095, 2, 48, 23, 10, -36 },
  { 6107, 13, 41, 16, 2, -34 },
  { 6174, 20, 5, 24, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight47pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT47PT7B_H_
