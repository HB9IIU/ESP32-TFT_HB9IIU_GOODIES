#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT59PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight59pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDB, 0x6D, 0xB6,
  0xDB, 0x00, 0x00, 0x3F, 0xFC, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30,
  0x02, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x03, 0x00, 0x30, 0x07, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x80, 0x18, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30, 0x07, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x03, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xFE, 0x07, 0x8C, 0x1E, 0x1C, 0x18, 0x0C, 0x70, 0x30, 0x00, 0xC0,
  0x60, 0x03, 0x80, 0xC0, 0x07, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x06,
  0x00, 0x30, 0x0C, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0x60,
  0x01, 0xC0, 0xC0, 0x01, 0xC1, 0x80, 0x01, 0xE3, 0x00, 0x01, 0xF6, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x6F, 0x80,
  0x00, 0xC7, 0x80, 0x01, 0x83, 0xC0, 0x03, 0x03, 0x80, 0x06, 0x03, 0x80,
  0x0C, 0x03, 0x00, 0x18, 0x07, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x70, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C,
  0x07, 0x00, 0x18, 0x1C, 0xE0, 0x30, 0x71, 0xFE, 0x6F, 0xC0, 0xFF, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xC0,
  0x07, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x70, 0x00, 0x60, 0x03, 0x01, 0x80,
  0x03, 0x00, 0x30, 0x06, 0x00, 0x30, 0x01, 0x80, 0x30, 0x01, 0x80, 0x0C,
  0x01, 0x80, 0x18, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x60, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x0C, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x03, 0x03, 0x00, 0x03, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x06, 0x0C, 0x00, 0x06, 0x00, 0x70,
  0xE0, 0xF0, 0x38, 0x03, 0x86, 0x1F, 0xE0, 0xC0, 0x18, 0x71, 0xC3, 0x86,
  0x00, 0xC3, 0x0C, 0x0E, 0x30, 0x06, 0x38, 0xC0, 0x30, 0xC0, 0x61, 0x86,
  0x01, 0xC7, 0x07, 0x0C, 0x30, 0x06, 0x1C, 0x70, 0xC3, 0x00, 0x30, 0x7F,
  0x06, 0x18, 0x01, 0x80, 0xE0, 0x60, 0xC0, 0x0C, 0x00, 0x03, 0x06, 0x00,
  0x70, 0x00, 0x30, 0x30, 0x03, 0x80, 0x01, 0x81, 0x80, 0x0C, 0x00, 0x18,
  0x0C, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x07, 0x00, 0x0C, 0x03, 0x00, 0x38,
  0x00, 0x60, 0x18, 0x01, 0xC0, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x03, 0x80, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x01,
  0xC0, 0x06, 0x01, 0xC0, 0x0C, 0x00, 0x38, 0x0C, 0x00, 0xE0, 0x00, 0xC0,
  0xE0, 0x06, 0x00, 0x03, 0x8E, 0x00, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x60, 0x06, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x01,
  0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x1C, 0x70, 0x07, 0x00, 0x31, 0xC0, 0x06, 0x00, 0x63,
  0x00, 0x0E, 0x00, 0xCE, 0x00, 0x0E, 0x03, 0x9C, 0x00, 0x0E, 0x06, 0x30,
  0x00, 0x0E, 0x0C, 0x60, 0x00, 0x0E, 0x30, 0xC0, 0x00, 0x0C, 0x61, 0x80,
  0x00, 0x1D, 0x83, 0x00, 0x00, 0x1F, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x3C, 0x0C, 0x00, 0x00, 0xDC, 0x1C, 0x00, 0x07, 0x98, 0x1C, 0x00,
  0x1E, 0x38, 0x1E, 0x00, 0xF0, 0x38, 0x1F, 0xFF, 0xC0, 0x38, 0x0F, 0xFE,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x00, 0xFF, 0x6D, 0xB6, 0xDB, 0x6D, 0xB0,
  0x00, 0xE0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80,
  0x30, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x80, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00,
  0x60, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x10, 0x0C, 0x02, 0xF0, 0x30, 0x3D, 0xF8,
  0xC7, 0xE0, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xA0,
  0x00, 0x0C, 0xC0, 0x00, 0x61, 0x80, 0x03, 0x83, 0x00, 0x1C, 0x0E, 0x00,
  0x60, 0x18, 0x03, 0x80, 0x70, 0x1C, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x71, 0xC7, 0x18,
  0x63, 0x8E, 0x30, 0xC7, 0x18, 0x61, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x77, 0xF7, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xC3, 0xE0, 0x07, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x18, 0x38, 0x00,
  0x1C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0, 0x00,
  0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x38, 0x03, 0xC0, 0x7E, 0x07, 0x70, 0x73, 0x87, 0x1C, 0xF0,
  0xEE, 0x07, 0xE0, 0x3A, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xFF, 0x00, 0x7E, 0x1F, 0x01, 0xE0, 0x07, 0x07, 0x00, 0x07,
  0x04, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0x1F, 0x83, 0xC0,
  0x07, 0x8E, 0x00, 0x07, 0x08, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x40, 0x00, 0x3C, 0xE0, 0x00, 0xF1,
  0xFF, 0x7F, 0x80, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x30,
  0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x01, 0xC0,
  0x01, 0xC0, 0x1C, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x1C,
  0x01, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xDF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x20, 0x00, 0x38, 0x70, 0x01, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFE,
  0x38, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x7F, 0x80, 0x61, 0xFF,
  0xE0, 0x63, 0xC0, 0xF0, 0x66, 0x00, 0x38, 0x6C, 0x00, 0x1C, 0x78, 0x00,
  0x0C, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x70, 0x00, 0x07, 0x30, 0x00,
  0x07, 0x30, 0x00, 0x06, 0x38, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x1C, 0x00,
  0x1C, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x78, 0x03, 0xF7, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x03, 0xFF, 0xC0, 0x07, 0xC3, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x03, 0xC3, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xC7, 0xC0, 0x07, 0x01, 0xE0, 0x1E, 0x00,
  0x70, 0x38, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x60, 0x00,
  0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x1E, 0x00,
  0x78, 0x0F, 0xE7, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0x3F, 0x00, 0xF0, 0x07, 0x01, 0x80, 0x07,
  0x06, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0D,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x76, 0x00, 0x01, 0xEE, 0x00,
  0x03, 0xCE, 0x00, 0x0D, 0x8E, 0x00, 0x73, 0x0F, 0x03, 0xC6, 0x0F, 0xFF,
  0x0C, 0x07, 0xF0, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x79, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x3C, 0x00, 0x00, 0x27, 0xF7, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x77, 0xF7, 0x08, 0x71, 0xC7,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x71, 0xC7, 0x18, 0x63, 0x8E, 0x30, 0xC3, 0x18,
  0x61, 0x8C, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x1F,
  0xFE, 0x0F, 0xC7, 0xE3, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x3F, 0xE0, 0x06, 0x30, 0x00, 0xFF, 0xF0, 0x06, 0x30, 0x01, 0xC0, 0x30,
  0x06, 0x70, 0x03, 0x80, 0x30, 0x07, 0x60, 0x07, 0x00, 0x30, 0x03, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x60, 0x0C, 0x00, 0x30, 0x03, 0xE0, 0x0C, 0x00,
  0x30, 0x03, 0xE0, 0x1C, 0x00, 0x30, 0x03, 0xC0, 0x18, 0x00, 0x30, 0x03,
  0xC0, 0x18, 0x00, 0x30, 0x03, 0xC0, 0x18, 0x00, 0x30, 0x03, 0xC0, 0x18,
  0x00, 0x30, 0x03, 0xC0, 0x18, 0x00, 0x70, 0x03, 0xC0, 0x18, 0x00, 0x70,
  0x03, 0xC0, 0x18, 0x00, 0x70, 0x07, 0xC0, 0x18, 0x00, 0x70, 0x06, 0xE0,
  0x1C, 0x00, 0xF0, 0x06, 0xE0, 0x0C, 0x00, 0xF0, 0x0E, 0x60, 0x0E, 0x01,
  0xB0, 0x0C, 0x60, 0x07, 0x03, 0x98, 0x1C, 0x60, 0x07, 0xCF, 0x1E, 0xF8,
  0x70, 0x01, 0xFE, 0x0F, 0xE0, 0x30, 0x00, 0x60, 0x01, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x30, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x38, 0x06, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x0D, 0xC0, 0x00, 0x00, 0x1C, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x38,
  0x00, 0x3E, 0x1C, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x19, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x1C, 0x70, 0x00,
  0x1C, 0x38, 0x00, 0x7C, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0x00,
  0x07, 0xC3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x70,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x73, 0x80, 0x00, 0xF1, 0xC0, 0x03, 0xF0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0x9F, 0xF0, 0x0F, 0x00, 0x06, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x60, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1E, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xE0, 0x01,
  0xF8, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E,
  0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x3F, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDC, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFE, 0x0F, 0xF8,
  0x03, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x40, 0x78, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x0F, 0xFF, 0xB0, 0x00, 0x1F, 0xFF, 0x60, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x01, 0x80, 0xF0, 0x00, 0x03, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0C, 0xFF, 0xDF, 0xE0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x1C, 0xFF, 0x8F, 0xF0,
  0x10, 0x00, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x38, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x03, 0x83, 0x80, 0x03, 0x81,
  0xC0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x81, 0xC0,
  0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xF0,
  0x00, 0x1C, 0xF8, 0x00, 0x0E, 0xEE, 0x00, 0x07, 0x63, 0x80, 0x03, 0xE0,
  0xC0, 0x01, 0xE0, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x38,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x03,
  0x80, 0x06, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x30,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x87, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x07, 0x70, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1B, 0xFC, 0x00, 0x00, 0x01, 0xBE, 0xC0, 0x00,
  0x00, 0x33, 0xEC, 0x00, 0x00, 0x03, 0x7E, 0xE0, 0x00, 0x00, 0x37, 0xE6,
  0x00, 0x00, 0x06, 0x7E, 0x60, 0x00, 0x00, 0x67, 0xE7, 0x00, 0x00, 0x0E,
  0x7E, 0x30, 0x00, 0x00, 0xC7, 0xE3, 0x80, 0x00, 0x0C, 0x7E, 0x18, 0x00,
  0x01, 0xC7, 0xE1, 0x80, 0x00, 0x18, 0x7E, 0x1C, 0x00, 0x01, 0x87, 0xE0,
  0xC0, 0x00, 0x30, 0x7E, 0x0C, 0x00, 0x03, 0x07, 0xE0, 0xE0, 0x00, 0x70,
  0x7E, 0x06, 0x00, 0x06, 0x07, 0xE0, 0x60, 0x00, 0x60, 0x7E, 0x07, 0x00,
  0x0E, 0x07, 0xE0, 0x30, 0x00, 0xC0, 0x7E, 0x03, 0x80, 0x0C, 0x07, 0xE0,
  0x18, 0x01, 0xC0, 0x7E, 0x01, 0x80, 0x18, 0x07, 0xE0, 0x1C, 0x01, 0x80,
  0x7E, 0x00, 0xC0, 0x30, 0x07, 0xE0, 0x0C, 0x03, 0x00, 0x7E, 0x00, 0xE0,
  0x70, 0x07, 0xE0, 0x06, 0x06, 0x00, 0x7E, 0x00, 0x60, 0x60, 0x07, 0xE0,
  0x07, 0x0E, 0x00, 0x7E, 0x00, 0x30, 0xC0, 0x07, 0xE0, 0x03, 0x8C, 0x00,
  0x7E, 0x00, 0x19, 0xC0, 0x07, 0xE0, 0x01, 0x98, 0x00, 0x7E, 0x00, 0x1D,
  0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x07, 0xE0,
  0x00, 0xF0, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xD8, 0x00, 0x00, 0xFB, 0x80, 0x00, 0x1F, 0x30, 0x00, 0x03, 0xE7,
  0x00, 0x00, 0x7C, 0x60, 0x00, 0x0F, 0x8E, 0x00, 0x01, 0xF0, 0xE0, 0x00,
  0x3E, 0x0C, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0xF8, 0x18, 0x00, 0x1F, 0x03,
  0x80, 0x03, 0xE0, 0x38, 0x00, 0x7C, 0x03, 0x00, 0x0F, 0x80, 0x70, 0x01,
  0xF0, 0x06, 0x00, 0x3E, 0x00, 0xE0, 0x07, 0xC0, 0x0E, 0x00, 0xF8, 0x01,
  0xC0, 0x1F, 0x00, 0x1C, 0x03, 0xE0, 0x01, 0x80, 0x7C, 0x00, 0x38, 0x0F,
  0x80, 0x03, 0x01, 0xF0, 0x00, 0x70, 0x3E, 0x00, 0x07, 0x07, 0xC0, 0x00,
  0x60, 0xF8, 0x00, 0x0E, 0x1F, 0x00, 0x00, 0xC3, 0xE0, 0x00, 0x1C, 0x7C,
  0x00, 0x01, 0xCF, 0x80, 0x00, 0x19, 0xF0, 0x00, 0x03, 0xBE, 0x00, 0x00,
  0x37, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x07,
  0x80, 0x01, 0xC0, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x03, 0x80, 0x0F, 0x87, 0x00, 0x07, 0x8E, 0x00, 0x03, 0x9C, 0x00,
  0x03, 0x38, 0x00, 0x07, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x0D, 0xC0, 0x00,
  0x1B, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x0F, 0x1C, 0x00, 0x7C, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00,
  0x19, 0xC0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x01, 0xC0, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x38, 0x00, 0xF8, 0x1C, 0x00, 0x0E,
  0x0E, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00,
  0x18, 0xE0, 0x00, 0x0C, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x31, 0xC0,
  0x00, 0x18, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01,
  0xC0, 0x18, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0xC0,
  0x1C, 0x00, 0x70, 0x0E, 0x00, 0x18, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x03,
  0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x38, 0x38, 0x00,
  0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x39, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x3F, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0x8F, 0xF0, 0xF0, 0x00, 0xE3,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0xE0, 0x01, 0xF1, 0xFF, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0x38, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC0,
  0x78, 0x00, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x06, 0x00, 0x60, 0x00, 0x38, 0x01, 0x80,
  0x00, 0xE0, 0x07, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x1C, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x0E, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x0E,
  0x18, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x63, 0x80, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x67, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x18, 0x00, 0x06, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0x36, 0x00, 0x01, 0x86, 0x00, 0x01, 0xB8, 0x00,
  0x0C, 0x38, 0x00, 0x18, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC6, 0x00, 0x07,
  0x06, 0x00, 0x06, 0x30, 0x00, 0x30, 0x30, 0x00, 0x31, 0xC0, 0x01, 0x81,
  0xC0, 0x03, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x30, 0x00, 0xE0, 0x30,
  0x00, 0xC1, 0x80, 0x06, 0x01, 0x80, 0x06, 0x0E, 0x00, 0x30, 0x0E, 0x00,
  0x60, 0x30, 0x01, 0x80, 0x30, 0x03, 0x01, 0x80, 0x1C, 0x01, 0x80, 0x18,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x70, 0x06, 0x00, 0x70, 0x0C, 0x01,
  0x80, 0x30, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x0C, 0x03, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x18, 0x03, 0x80, 0xC0, 0x03, 0x81, 0x80, 0x0C, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x60, 0x70, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00,
  0x03, 0x03, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x60, 0xC0, 0x00,
  0x61, 0x80, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x60, 0x00, 0xE3, 0x00, 0x00, 0xE7, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30,
  0x00, 0x19, 0xC0, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x00, 0xCC, 0x00,
  0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0C, 0x01, 0xC0, 0x03,
  0x80, 0x18, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x30, 0x03, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x1C, 0x30, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x39, 0x80, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0x83, 0x80, 0x00, 0x70, 0x30, 0x00,
  0x0C, 0x07, 0x00, 0x03, 0x80, 0x60, 0x00, 0x60, 0x0E, 0x00, 0x18, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0x80, 0x38, 0x00, 0x38, 0x06,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0E,
  0x38, 0x00, 0x03, 0x06, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x60, 0x30, 0x00,
  0x38, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x01, 0xC0, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x00, 0xE0, 0x0C, 0x00, 0x18, 0x07, 0x00,
  0x07, 0x01, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x38, 0x30, 0x00, 0x06, 0x1C,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0xFF, 0xFF, 0xFC, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x1C, 0x60, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x83, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x70, 0x18, 0x00, 0x18, 0x06, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x60, 0x01, 0x80, 0x38, 0x00, 0x30, 0x0C,
  0x00, 0x0C, 0x07, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xF0,
  0x3F, 0x07, 0xC1, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x1F, 0xF0, 0x3F, 0xFF, 0x0F,
  0xC0, 0x33, 0xC0, 0x03, 0x78, 0x00, 0x36, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFE, 0x00, 0x1B, 0x60, 0x01, 0xB7, 0x00, 0x73, 0x3F, 0x3E,
  0x31, 0xFF, 0x83, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x0F, 0xC0, 0x30, 0xFF,
  0xE0, 0x63, 0xE1, 0xF0, 0xCE, 0x00, 0xF1, 0xB0, 0x00, 0x73, 0x60, 0x00,
  0xE7, 0x80, 0x00, 0xEE, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xB8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xB8, 0x00, 0x07, 0x78, 0x00,
  0x0C, 0xD8, 0x00, 0x39, 0xB0, 0x00, 0xE3, 0x38, 0x03, 0x86, 0x3F, 0x7E,
  0x0C, 0x3F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFF,
  0x03, 0xF0, 0xF0, 0x70, 0x01, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x01, 0x03, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x7E, 0x07,
  0x01, 0xFF, 0x87, 0x07, 0xC1, 0xE7, 0x0E, 0x00, 0x77, 0x1C, 0x00, 0x37,
  0x18, 0x00, 0x1F, 0x38, 0x00, 0x0F, 0x30, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0x30, 0x00, 0x1B, 0x38, 0x00, 0x1B, 0x1C, 0x00, 0x33,
  0x0E, 0x00, 0x63, 0x07, 0xE7, 0xC3, 0x03, 0xFF, 0x83, 0x00, 0x18, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0x0F, 0x00, 0x78, 0x07, 0x01,
  0xC0, 0x07, 0x03, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x70,
  0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0xDC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x41,
  0xE0, 0x03, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x70, 0x20, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0x7E, 0x00, 0x03, 0xFF, 0x04, 0x1F, 0x0F, 0x88, 0x70, 0x03, 0xB1, 0xC0,
  0x03, 0x63, 0x00, 0x03, 0xCE, 0x00, 0x03, 0x98, 0x00, 0x07, 0x70, 0x00,
  0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x70, 0x00, 0x0E, 0xE0,
  0x00, 0x1C, 0xC0, 0x00, 0x79, 0xC0, 0x00, 0xB1, 0xC0, 0x03, 0x61, 0xC0,
  0x1C, 0xC1, 0xFB, 0xF1, 0x80, 0xFF, 0x83, 0x00, 0x10, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x80, 0x00, 0xE1, 0xE0, 0x07, 0x83, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x3F,
  0x03, 0x0F, 0xFE, 0x18, 0xF0, 0x78, 0xCE, 0x00, 0xE6, 0xC0, 0x03, 0xB4,
  0x00, 0x0D, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x6F,
  0xFF, 0x20, 0x00, 0x00, 0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x01, 0x80, 0xF0,
  0x3C, 0x0F, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x03, 0x80, 0xE0, 0x73, 0xF8, 0xFC, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0xEC, 0x00,
  0x1C, 0xC0, 0x03, 0x8C, 0x00, 0x70, 0xC0, 0x0E, 0x0C, 0x00, 0xC0, 0xC0,
  0x18, 0x0C, 0x03, 0x80, 0xC0, 0x70, 0x0C, 0x0E, 0x00, 0xC0, 0xC0, 0x0C,
  0x18, 0x00, 0xC3, 0x80, 0x0C, 0x78, 0x00, 0xCF, 0xC0, 0x0C, 0xCC, 0x00,
  0xD8, 0xE0, 0x0F, 0x07, 0x00, 0xE0, 0x30, 0x0E, 0x03, 0x80, 0xC0, 0x18,
  0x0C, 0x01, 0xC0, 0xC0, 0x0E, 0x0C, 0x00, 0x60, 0xC0, 0x07, 0x0C, 0x00,
  0x30, 0xC0, 0x01, 0x8C, 0x00, 0x1C, 0xC0, 0x00, 0xCC, 0x00, 0x0E, 0xC0,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x3C, 0x0C, 0x3F, 0xF0, 0x1F, 0xF8, 0xC7,
  0x07, 0x87, 0x83, 0xCC, 0xC0, 0x38, 0xE0, 0x0E, 0xD8, 0x01, 0xCC, 0x00,
  0x6F, 0x00, 0x0D, 0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x00, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00,
  0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06,
  0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0,
  0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00,
  0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06,
  0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0,
  0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00,
  0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x7C, 0x06, 0x1F, 0xFC, 0x31, 0xE0, 0xF1, 0x9C, 0x01,
  0xCD, 0x80, 0x07, 0x68, 0x00, 0x1B, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xC1, 0xF0, 0x0E,
  0x00, 0x78, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x30,
  0x00, 0x06, 0x70, 0x00, 0x06, 0x60, 0x00, 0x07, 0x60, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60,
  0x00, 0x07, 0x70, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x18,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0x70, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x7E, 0x01, 0x83, 0xFF, 0x03, 0x1F,
  0x0F, 0x86, 0x70, 0x07, 0x8C, 0xC0, 0x03, 0x9B, 0x00, 0x03, 0x3C, 0x00,
  0x07, 0x78, 0x00, 0x06, 0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x06, 0xE0, 0x00, 0x0D, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x66, 0xC0,
  0x01, 0xCD, 0xC0, 0x07, 0x19, 0xC0, 0x1C, 0x31, 0xFB, 0xF0, 0x60, 0xFF,
  0xC0, 0xC0, 0x10, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x04,
  0x1F, 0x0F, 0x88, 0x70, 0x03, 0xB1, 0xC0, 0x03, 0x67, 0x00, 0x03, 0xCE,
  0x00, 0x03, 0x98, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xC0, 0x00, 0x0D, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xD8, 0x00, 0x01,
  0xB0, 0x00, 0x07, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xC0, 0x00, 0x79,
  0xC0, 0x01, 0xB1, 0xC0, 0x03, 0x61, 0xC0, 0x1C, 0xC1, 0xFB, 0xF1, 0x81,
  0xFF, 0x83, 0x00, 0x38, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0xFB, 0x0F, 0xFC, 0x7D,
  0xF3, 0x80, 0xD8, 0x03, 0x60, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0x07, 0xE3, 0xC0,
  0x04, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x80, 0x00, 0xEE, 0x00, 0x3C, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x01,
  0xC0, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF9, 0xC0, 0xFF, 0x80, 0x10, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x76, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x60,
  0x00, 0x3D, 0xC0, 0x00, 0xB7, 0x00, 0x06, 0xCE, 0x00, 0x33, 0x1C, 0x01,
  0x8C, 0x3F, 0xFC, 0x30, 0x7F, 0xE0, 0xC0, 0x18, 0x00, 0xE0, 0x00, 0x06,
  0xC0, 0x00, 0x1D, 0x80, 0x00, 0x33, 0x80, 0x00, 0x63, 0x00, 0x01, 0xC6,
  0x00, 0x03, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x30, 0x38,
  0x00, 0x60, 0x30, 0x01, 0xC0, 0x60, 0x03, 0x00, 0xE0, 0x06, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x30, 0x03, 0x80, 0x60, 0x03, 0x01, 0xC0, 0x06, 0x03,
  0x00, 0x0E, 0x06, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x30, 0x00, 0x38, 0x60,
  0x00, 0x31, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xDC, 0x00,
  0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x07,
  0xE0, 0x00, 0xF0, 0x00, 0x66, 0x00, 0x0F, 0x00, 0x06, 0x60, 0x00, 0xD8,
  0x00, 0x67, 0x00, 0x1D, 0x80, 0x0E, 0x30, 0x01, 0x98, 0x00, 0xC3, 0x00,
  0x19, 0xC0, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0xC3, 0x80, 0x38, 0xC0, 0x1C,
  0x18, 0x03, 0x0C, 0x01, 0x81, 0x80, 0x30, 0xE0, 0x18, 0x18, 0x07, 0x06,
  0x01, 0x81, 0xC0, 0x60, 0x60, 0x38, 0x0C, 0x06, 0x07, 0x03, 0x00, 0xC0,
  0x60, 0x30, 0x30, 0x0C, 0x0E, 0x03, 0x03, 0x00, 0xE0, 0xC0, 0x30, 0x70,
  0x06, 0x0C, 0x03, 0x86, 0x00, 0x61, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x01,
  0x86, 0x00, 0x71, 0x80, 0x18, 0xE0, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x33,
  0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x0D, 0xC0,
  0x01, 0xB0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x1C, 0x60, 0x00, 0x30, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0x80, 0xC0,
  0x06, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x30, 0x01, 0x80, 0xE0, 0x03, 0x81,
  0x80, 0x03, 0x06, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x30, 0x00, 0x06, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xDC, 0x00, 0x03, 0x98, 0x00, 0x0E, 0x38, 0x00, 0x18, 0x30, 0x00,
  0x70, 0x30, 0x01, 0xC0, 0x70, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x18,
  0x00, 0xE0, 0x70, 0x00, 0xC1, 0xC0, 0x01, 0xC3, 0x00, 0x01, 0x8E, 0x00,
  0x03, 0xB8, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x70,
  0x00, 0x0E, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x0C,
  0x00, 0x30, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07,
  0x00, 0xE0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x81, 0xC0, 0x01,
  0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xC3, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0x00, 0x7F, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x3F, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x07, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0xF8, 0x01, 0xC0, 0x1F,
  0x07, 0x80, 0x07, 0xFE, 0x80, 0x01, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 42, 13, 5, -42 },
  { 17, 11, 15, 19, 4, -42 },
  { 38, 31, 42, 33, 1, -42 },
  { 201, 23, 48, 30, 3, -45 },
  { 339, 37, 44, 43, 3, -43 },
  { 543, 31, 44, 35, 3, -43 },
  { 714, 3, 15, 11, 4, -42 },
  { 720, 11, 51, 16, 3, -42 },
  { 791, 11, 51, 16, 2, -42 },
  { 862, 22, 21, 28, 3, -45 },
  { 920, 24, 28, 30, 3, -35 },
  { 1004, 6, 15, 12, 2, -7 },
  { 1016, 14, 2, 18, 2, -17 },
  { 1020, 4, 4, 13, 4, -4 },
  { 1022, 18, 42, 20, 1, -42 },
  { 1117, 24, 44, 30, 3, -43 },
  { 1249, 13, 42, 30, 5, -42 },
  { 1318, 23, 43, 30, 3, -43 },
  { 1442, 23, 44, 30, 3, -43 },
  { 1569, 28, 42, 30, 1, -42 },
  { 1716, 23, 43, 30, 4, -42 },
  { 1840, 24, 44, 30, 3, -43 },
  { 1972, 24, 42, 30, 3, -42 },
  { 2098, 24, 44, 30, 3, -43 },
  { 2230, 23, 44, 30, 3, -43 },
  { 2357, 4, 32, 13, 4, -32 },
  { 2373, 6, 40, 13, 2, -32 },
  { 2403, 24, 26, 30, 3, -34 },
  { 2481, 24, 14, 30, 3, -28 },
  { 2523, 24, 26, 30, 3, -34 },
  { 2601, 18, 43, 22, 2, -43 },
  { 2698, 40, 48, 46, 3, -42 },
  { 2938, 31, 42, 31, 0, -42 },
  { 3101, 25, 42, 33, 5, -42 },
  { 3233, 28, 44, 32, 3, -43 },
  { 3387, 28, 42, 37, 5, -42 },
  { 3534, 21, 42, 29, 5, -42 },
  { 3645, 21, 42, 26, 5, -42 },
  { 3756, 31, 44, 38, 3, -43 },
  { 3927, 27, 42, 37, 5, -42 },
  { 4069, 10, 42, 16, 3, -42 },
  { 4122, 12, 53, 13, -4, -42 },
  { 4202, 25, 42, 30, 5, -42 },
  { 4334, 20, 42, 27, 5, -42 },
  { 4439, 36, 42, 46, 5, -42 },
  { 4628, 27, 42, 38, 5, -42 },
  { 4770, 33, 44, 40, 3, -43 },
  { 4952, 23, 42, 30, 5, -42 },
  { 5073, 33, 53, 40, 3, -43 },
  { 5292, 25, 42, 31, 5, -42 },
  { 5424, 23, 44, 29, 3, -43 },
  { 5551, 26, 42, 27, 0, -42 },
  { 5688, 27, 43, 37, 5, -42 },
  { 5834, 30, 42, 30, 0, -42 },
  { 5992, 45, 42, 47, 1, -42 },
  { 6229, 27, 42, 27, 0, -42 },
  { 6371, 26, 42, 26, 0, -42 },
  { 6508, 25, 42, 29, 2, -42 },
  { 6640, 12, 51, 18, 5, -42 },
  { 6717, 18, 42, 20, 1, -42 },
  { 6812, 11, 51, 18, 2, -42 },
  { 6883, 26, 24, 30, 2, -42 },
  { 6961, 24, 2, 24, 0, 5 },
  { 6967, 10, 9, 15, 2, -45 },
  { 6979, 20, 33, 28, 3, -32 },
  { 7062, 23, 46, 31, 5, -45 },
  { 7195, 20, 33, 25, 3, -32 },
  { 7278, 24, 46, 31, 3, -45 },
  { 7416, 23, 33, 29, 3, -32 },
  { 7511, 17, 45, 16, 1, -45 },
  { 7607, 23, 46, 31, 3, -32 },
  { 7740, 21, 45, 31, 5, -45 },
  { 7859, 4, 43, 12, 4, -43 },
  { 7881, 10, 57, 12, -2, -43 },
  { 7953, 20, 45, 25, 5, -45 },
  { 8066, 2, 45, 12, 5, -45 },
  { 8078, 36, 32, 46, 5, -32 },
  { 8222, 21, 32, 31, 5, -32 },
  { 8306, 24, 33, 31, 3, -32 },
  { 8405, 23, 46, 31, 5, -32 },
  { 8538, 23, 46, 31, 3, -32 },
  { 8671, 14, 32, 20, 5, -32 },
  { 8727, 20, 33, 24, 2, -32 },
  { 8810, 15, 40, 17, 1, -39 },
  { 8885, 22, 32, 31, 4, -31 },
  { 8973, 23, 31, 23, 0, -31 },
  { 9063, 36, 31, 38, 1, -31 },
  { 9203, 23, 31, 25, 1, -31 },
  { 9293, 24, 45, 24, 0, -31 },
  { 9428, 19, 31, 23, 2, -31 },
  { 9502, 16, 51, 20, 2, -42 },
  { 9604, 2, 60, 28, 13, -45 },
  { 9619, 16, 51, 20, 2, -42 },
  { 9721, 24, 6, 30, 3, -24 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight59pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT59PT7B_H_
