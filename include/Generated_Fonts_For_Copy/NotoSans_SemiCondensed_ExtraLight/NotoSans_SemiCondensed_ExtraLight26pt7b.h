#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT26PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight26pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xA0, 0x3C, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x04,
  0x20, 0x21, 0x02, 0x08, 0x10, 0x80, 0x84, 0x04, 0x23, 0xFF, 0xE1, 0x08,
  0x10, 0x40, 0x84, 0x04, 0x20, 0x21, 0x0F, 0xFF, 0x08, 0x40, 0x82, 0x04,
  0x20, 0x21, 0x01, 0x08, 0x08, 0x40, 0x04, 0x01, 0x03, 0xF9, 0x91, 0x44,
  0x21, 0x08, 0x41, 0x10, 0x44, 0x0D, 0x00, 0xC0, 0x1C, 0x04, 0xC1, 0x10,
  0x44, 0x11, 0x04, 0x41, 0x3F, 0xF8, 0x10, 0x04, 0x01, 0x00, 0x38, 0x08,
  0x44, 0x08, 0x44, 0x10, 0x42, 0x10, 0x82, 0x20, 0x82, 0x20, 0x82, 0x40,
  0x82, 0x40, 0x42, 0x9E, 0x44, 0x91, 0x44, 0xA1, 0x39, 0x21, 0x01, 0x21,
  0x02, 0x21, 0x02, 0x21, 0x04, 0x21, 0x04, 0x21, 0x08, 0x11, 0x08, 0x1E,
  0x0E, 0x00, 0x46, 0x02, 0x08, 0x08, 0x20, 0x20, 0x80, 0x82, 0x01, 0x18,
  0x04, 0xC0, 0x0E, 0x00, 0x70, 0x02, 0x20, 0x10, 0x42, 0x41, 0x8A, 0x02,
  0x28, 0x05, 0x20, 0x0C, 0x40, 0x71, 0x83, 0x23, 0xF0, 0xC0, 0xFE, 0x08,
  0x8C, 0x46, 0x21, 0x08, 0x84, 0x21, 0x08, 0x42, 0x10, 0x42, 0x10, 0x42,
  0x08, 0x60, 0x82, 0x10, 0x42, 0x08, 0x42, 0x10, 0x42, 0x10, 0x84, 0x22,
  0x10, 0x84, 0x42, 0x22, 0x00, 0x04, 0x01, 0x00, 0x42, 0x11, 0x77, 0x83,
  0x00, 0xA0, 0x48, 0x21, 0x08, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x41, 0xFF, 0xC1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x69,
  0x29, 0x00, 0xFC, 0xB0, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x30, 0x20, 0x20, 0x40, 0x40, 0xC0, 0x0E,
  0x06, 0x30, 0x82, 0x20, 0x24, 0x04, 0x80, 0x90, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x14, 0x02, 0x80, 0xD0, 0x12, 0x02, 0x20, 0x44, 0x10,
  0x7C, 0x00, 0x04, 0x33, 0x59, 0x84, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x40, 0x1E, 0x0C, 0x31, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x40, 0x18,
  0x06, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFF, 0x80, 0x1E, 0x0C, 0x32, 0x03,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x03, 0x03, 0xC0, 0x06, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x18, 0x02, 0x00, 0x50, 0x11, 0xFC, 0x00, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x28, 0x04, 0x80, 0x48, 0x08, 0x81, 0x08, 0x10,
  0x82, 0x08, 0x40, 0x84, 0x08, 0x80, 0x8F, 0xFF, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x7F, 0x90, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0xFE, 0x00, 0x60, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x02,
  0x00, 0xA0, 0x4F, 0xE0, 0x07, 0x86, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x02, 0x00, 0xBF, 0x30, 0x28, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x40, 0x90, 0x63, 0xF0, 0xFF, 0xE0, 0x04, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x00, 0x0F, 0x06, 0x11, 0x01, 0x20,
  0x24, 0x04, 0x80, 0x98, 0x11, 0x84, 0x1B, 0x01, 0xC0, 0xC6, 0x30, 0x24,
  0x05, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x4C, 0x18, 0x7E, 0x00, 0x1E, 0x04,
  0x31, 0x02, 0x20, 0x28, 0x05, 0x00, 0xA0, 0x0C, 0x03, 0x40, 0x68, 0x14,
  0x86, 0x8F, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x21, 0xF8,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x6C, 0x00, 0x00, 0x00, 0x34, 0x94, 0x80,
  0x00, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x40, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x00, 0x00, 0x78, 0x86, 0x02, 0x01, 0x01, 0x01, 0x02,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x20, 0x00, 0x00, 0x00, 0x20, 0x30,
  0x00, 0x60, 0x01, 0xE7, 0x00, 0x80, 0x20, 0x40, 0x04, 0x20, 0x00, 0x88,
  0x00, 0x24, 0x1F, 0x85, 0x08, 0x21, 0x42, 0x08, 0x61, 0x02, 0x18, 0x40,
  0x86, 0x10, 0x21, 0x84, 0x18, 0x61, 0x06, 0x14, 0x22, 0x89, 0x0F, 0x9C,
  0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x07, 0xF8, 0x00,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x0A, 0x00, 0x48, 0x02, 0x40, 0x22, 0x01,
  0x08, 0x08, 0x40, 0x82, 0x04, 0x08, 0x3F, 0xC2, 0x02, 0x10, 0x08, 0x80,
  0x48, 0x02, 0x40, 0x0E, 0x00, 0x60, 0x02, 0xFC, 0x10, 0x72, 0x01, 0x40,
  0x28, 0x03, 0x00, 0x60, 0x14, 0x02, 0x81, 0x9F, 0xE2, 0x03, 0x40, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x50, 0x1B, 0xFC, 0x00, 0x07, 0xC3,
  0x04, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x3F,
  0x80, 0xF8, 0x04, 0x1C, 0x20, 0x11, 0x00, 0x48, 0x03, 0x40, 0x0A, 0x00,
  0x50, 0x02, 0x80, 0x14, 0x00, 0x60, 0x07, 0x00, 0x28, 0x01, 0x40, 0x0A,
  0x00, 0x50, 0x04, 0x80, 0x64, 0x06, 0x3F, 0xC0, 0xFF, 0xC0, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F, 0xE0, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x3F, 0xE0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0xF0, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x00, 0x07, 0xE0, 0xC0, 0xCC, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x7F, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x28, 0x01, 0x60, 0x09, 0x80, 0x43, 0xFC, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x1F, 0xFF, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x3E, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x86, 0xEC, 0x80, 0x30, 0x0A, 0x02, 0x40,
  0x88, 0x31, 0x0C, 0x21, 0x04, 0x40, 0x90, 0x15, 0x03, 0x30, 0x42, 0x08,
  0x21, 0x06, 0x20, 0x44, 0x04, 0x80, 0xD0, 0x0A, 0x00, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0xE0, 0xC0, 0x03, 0xC0, 0x03,
  0xA0, 0x03, 0xA0, 0x05, 0xA0, 0x05, 0x90, 0x05, 0x90, 0x09, 0x90, 0x09,
  0x88, 0x11, 0x88, 0x11, 0x84, 0x11, 0x84, 0x21, 0x84, 0x21, 0x82, 0x21,
  0x82, 0x41, 0x82, 0x41, 0x81, 0x41, 0x81, 0x81, 0x81, 0x81, 0x80, 0x1C,
  0x01, 0xA0, 0x1A, 0x01, 0x90, 0x19, 0x01, 0x88, 0x18, 0xC1, 0x84, 0x18,
  0x21, 0x82, 0x18, 0x11, 0x81, 0x98, 0x09, 0x80, 0x58, 0x05, 0x80, 0x38,
  0x03, 0x80, 0x10, 0x0F, 0x80, 0x61, 0x82, 0x01, 0x10, 0x06, 0xC0, 0x0A,
  0x00, 0x28, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x28, 0x00, 0x90, 0x02, 0x40, 0x10, 0xC0, 0x81, 0xFC,
  0x00, 0xFC, 0x20, 0xC8, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0xE0, 0x6F, 0xF2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x00, 0x07, 0x80, 0x61, 0x82, 0x01, 0x10, 0x06, 0xC0, 0x0A, 0x00, 0x28,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x28, 0x00, 0x90, 0x02, 0x40, 0x10, 0xC0, 0x81, 0xFC, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x03, 0x00, 0xF8, 0x10, 0xF2, 0x03, 0x40, 0x28,
  0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x90, 0x23, 0xF8, 0x41, 0x08, 0x21,
  0x02, 0x20, 0x64, 0x04, 0x80, 0xD0, 0x0A, 0x00, 0x80, 0x0F, 0x0C, 0x34,
  0x01, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x30, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x60, 0x2F, 0xF0, 0xFF, 0xF0, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x14, 0x01, 0x40, 0x22, 0x06, 0x1F, 0xC0, 0x80, 0x0C, 0x00, 0x50, 0x04,
  0x80, 0x24, 0x01, 0x10, 0x10, 0x80, 0x84, 0x04, 0x10, 0x40, 0x82, 0x04,
  0x10, 0x11, 0x00, 0x88, 0x04, 0x40, 0x14, 0x00, 0xA0, 0x05, 0x00, 0x28,
  0x00, 0x80, 0x80, 0x40, 0x30, 0x08, 0x06, 0x03, 0x00, 0xC0, 0x50, 0x14,
  0x0A, 0x04, 0x81, 0x40, 0x90, 0x48, 0x12, 0x08, 0x86, 0x21, 0x10, 0x84,
  0x22, 0x10, 0x88, 0x42, 0x11, 0x04, 0xC1, 0x20, 0x90, 0x24, 0x12, 0x05,
  0x02, 0x40, 0xA0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x00,
  0x40, 0x34, 0x02, 0x20, 0x42, 0x04, 0x10, 0x81, 0x08, 0x09, 0x00, 0xD0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x90, 0x09, 0x01, 0x08, 0x10, 0x82, 0x04,
  0x60, 0x64, 0x02, 0x80, 0x30, 0x80, 0x14, 0x02, 0x40, 0x26, 0x04, 0x20,
  0x42, 0x08, 0x10, 0x81, 0x10, 0x09, 0x00, 0xA0, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xFF, 0xE0,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x10, 0x03, 0xFF,
  0x80, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x43, 0xE0, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10,
  0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0x01, 0xF8,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x87, 0xE0, 0x04, 0x00, 0xC0, 0x28, 0x04, 0x81, 0x10, 0x21, 0x08, 0x21,
  0x02, 0x40, 0x48, 0x06, 0x00, 0x80, 0xFF, 0xE0, 0x84, 0x21, 0x3E, 0x20,
  0x80, 0x20, 0x10, 0x08, 0x04, 0x3E, 0x61, 0x40, 0xC0, 0x60, 0x30, 0x34,
  0x1B, 0xF4, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x09, 0xF2, 0x82,
  0xC0, 0xF0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x70,
  0x3A, 0x0A, 0x7C, 0x0F, 0x98, 0x08, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x08, 0x02, 0x00, 0xFC, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x47, 0xC9, 0x05, 0x60, 0x68, 0x0D, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0x60, 0x0A, 0x01, 0x40, 0x68, 0x0C, 0x82, 0x8F, 0x90, 0x1F,
  0x0C, 0x26, 0x0D, 0x01, 0x40, 0x70, 0x1F, 0xFE, 0x00, 0x80, 0x10, 0x04,
  0x01, 0x00, 0x20, 0x47, 0xF0, 0x0F, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFC,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x1F, 0x24, 0x15, 0x01, 0xA0, 0x34, 0x03, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x28, 0x05, 0x01, 0xA0, 0x32, 0x0A, 0x3E, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x09, 0x03, 0x3F, 0xC0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x09, 0xF2, 0x86, 0xC0, 0xB0, 0x28, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC7, 0xFF, 0xE0, 0x11, 0x00, 0x01,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xE0, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x07, 0x06, 0x82, 0x42, 0x22, 0x12, 0x0B,
  0x05, 0x43, 0x31, 0x08, 0x82, 0x41, 0x20, 0x50, 0x10, 0xFF, 0xFF, 0xF0,
  0x9E, 0x3E, 0xA1, 0x43, 0xC1, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81,
  0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81,
  0x80, 0x81, 0x80, 0x81, 0x9F, 0x28, 0x6C, 0x0B, 0x02, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x1F, 0x04,
  0x11, 0x81, 0x20, 0x14, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x28, 0x05,
  0x00, 0xA0, 0x22, 0x0C, 0x3F, 0x00, 0x9F, 0x28, 0x2C, 0x0F, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x03, 0xA0, 0xA7, 0xC8,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x1F, 0x26, 0x15, 0x81, 0xA0,
  0x34, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x28, 0x0D, 0x01, 0xA0, 0x32,
  0x0A, 0x3E, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x9F,
  0x43, 0x06, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x00,
  0x3F, 0x20, 0xA0, 0x10, 0x08, 0x02, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x80,
  0x20, 0x28, 0x17, 0xF0, 0x20, 0x40, 0x87, 0xF2, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x18, 0x1E, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x14, 0x1B, 0xF4, 0x80,
  0x70, 0x14, 0x0D, 0x02, 0x40, 0x88, 0x62, 0x10, 0x84, 0x13, 0x04, 0x81,
  0x20, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x81, 0x40, 0x81, 0x41, 0x41, 0x41,
  0x41, 0x41, 0x42, 0x22, 0x42, 0x22, 0x22, 0x22, 0x22, 0x12, 0x24, 0x14,
  0x14, 0x14, 0x14, 0x14, 0x14, 0x08, 0x18, 0x08, 0x08, 0x80, 0x90, 0x64,
  0x10, 0x88, 0x32, 0x05, 0x00, 0x80, 0x30, 0x14, 0x08, 0x82, 0x21, 0x04,
  0xC0, 0xA0, 0x30, 0x80, 0x50, 0x14, 0x05, 0x02, 0x20, 0x88, 0x22, 0x10,
  0x44, 0x11, 0x04, 0x80, 0xA0, 0x28, 0x0C, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x02, 0x01, 0x03, 0x80, 0xFF, 0x01, 0x02, 0x02, 0x04, 0x0C, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x80, 0xFF, 0x02, 0x18, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x86, 0x06, 0x06, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0xC0, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x20, 0x30, 0x83, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x38, 0x00, 0x7C, 0x30, 0x78,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 19, 6, 2, -19 },
  { 6, 5, 7, 9, 2, -19 },
  { 11, 13, 19, 15, 1, -19 },
  { 42, 10, 22, 13, 1, -20 },
  { 70, 16, 19, 19, 1, -19 },
  { 108, 14, 19, 16, 1, -19 },
  { 142, 1, 7, 5, 2, -19 },
  { 143, 5, 23, 7, 1, -19 },
  { 158, 5, 23, 7, 1, -19 },
  { 173, 10, 10, 12, 1, -20 },
  { 186, 11, 12, 13, 1, -15 },
  { 203, 3, 6, 5, 1, -3 },
  { 206, 6, 1, 8, 1, -8 },
  { 207, 2, 2, 6, 2, -2 },
  { 208, 8, 19, 9, 0, -19 },
  { 227, 11, 19, 13, 1, -19 },
  { 254, 6, 19, 13, 2, -19 },
  { 269, 11, 19, 13, 1, -19 },
  { 296, 11, 19, 13, 1, -19 },
  { 323, 12, 19, 13, 1, -19 },
  { 352, 10, 19, 13, 2, -19 },
  { 376, 10, 19, 13, 2, -19 },
  { 400, 11, 19, 13, 1, -19 },
  { 427, 11, 19, 13, 1, -19 },
  { 454, 11, 19, 13, 1, -19 },
  { 481, 2, 14, 6, 2, -14 },
  { 485, 3, 17, 6, 1, -14 },
  { 492, 11, 11, 13, 1, -15 },
  { 508, 11, 6, 13, 1, -12 },
  { 517, 11, 11, 13, 1, -15 },
  { 533, 8, 19, 9, 1, -19 },
  { 552, 18, 21, 20, 1, -19 },
  { 600, 13, 19, 13, 0, -19 },
  { 631, 11, 19, 14, 2, -19 },
  { 658, 11, 19, 14, 2, -19 },
  { 685, 13, 19, 16, 2, -19 },
  { 716, 9, 19, 13, 2, -19 },
  { 738, 9, 19, 12, 2, -19 },
  { 760, 13, 19, 17, 2, -19 },
  { 791, 12, 19, 16, 2, -19 },
  { 820, 5, 19, 7, 1, -19 },
  { 832, 5, 24, 6, -2, -19 },
  { 847, 11, 19, 13, 2, -19 },
  { 874, 9, 19, 12, 2, -19 },
  { 896, 16, 19, 20, 2, -19 },
  { 934, 12, 19, 17, 2, -19 },
  { 963, 14, 19, 17, 2, -19 },
  { 997, 10, 19, 13, 2, -19 },
  { 1021, 14, 23, 17, 2, -19 },
  { 1062, 11, 19, 14, 2, -19 },
  { 1089, 10, 19, 13, 1, -19 },
  { 1113, 12, 19, 12, 0, -19 },
  { 1142, 12, 19, 16, 2, -19 },
  { 1171, 13, 19, 13, 0, -19 },
  { 1202, 19, 19, 21, 1, -19 },
  { 1248, 12, 19, 12, 0, -19 },
  { 1277, 12, 19, 12, 0, -19 },
  { 1306, 11, 19, 13, 1, -19 },
  { 1333, 5, 23, 8, 2, -19 },
  { 1348, 8, 19, 9, 0, -19 },
  { 1367, 5, 23, 8, 1, -19 },
  { 1382, 11, 11, 13, 1, -19 },
  { 1398, 11, 1, 10, 0, 2 },
  { 1400, 4, 4, 6, 1, -20 },
  { 1402, 9, 14, 12, 1, -14 },
  { 1418, 10, 20, 14, 2, -20 },
  { 1443, 9, 14, 11, 1, -14 },
  { 1459, 11, 20, 14, 1, -20 },
  { 1487, 10, 14, 13, 1, -14 },
  { 1505, 8, 20, 7, 0, -20 },
  { 1525, 11, 20, 14, 1, -14 },
  { 1553, 10, 20, 14, 2, -20 },
  { 1578, 1, 19, 5, 2, -19 },
  { 1581, 4, 25, 5, -1, -19 },
  { 1594, 9, 20, 11, 2, -20 },
  { 1617, 1, 20, 5, 2, -20 },
  { 1620, 16, 14, 20, 2, -14 },
  { 1648, 10, 14, 14, 2, -14 },
  { 1666, 11, 14, 14, 1, -14 },
  { 1686, 10, 20, 14, 2, -14 },
  { 1711, 11, 20, 14, 1, -14 },
  { 1739, 7, 14, 9, 2, -14 },
  { 1752, 9, 14, 11, 1, -14 },
  { 1768, 7, 17, 7, 0, -17 },
  { 1783, 9, 14, 14, 2, -14 },
  { 1799, 10, 14, 10, 0, -14 },
  { 1817, 16, 14, 17, 0, -14 },
  { 1845, 10, 14, 11, 1, -14 },
  { 1863, 10, 20, 10, 0, -14 },
  { 1888, 8, 14, 10, 1, -14 },
  { 1902, 7, 23, 9, 1, -19 },
  { 1923, 1, 26, 13, 6, -20 },
  { 1927, 7, 23, 9, 1, -19 },
  { 1948, 11, 2, 13, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight26pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT26PT7B_H_
