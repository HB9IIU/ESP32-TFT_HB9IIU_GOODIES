#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT20PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xC4, 0x99, 0x99, 0x90, 0x08, 0x81, 0x10, 0x22, 0x04, 0x47,
  0xFE, 0x22, 0x04, 0x40, 0x88, 0x11, 0x1F, 0xF8, 0x44, 0x11, 0x02, 0x20,
  0x44, 0x00, 0x10, 0x3E, 0x50, 0x90, 0x90, 0x90, 0x50, 0x30, 0x1C, 0x12,
  0x11, 0x11, 0x11, 0xD6, 0x38, 0x10, 0x70, 0x48, 0x88, 0x88, 0x88, 0x90,
  0x89, 0x08, 0xA6, 0x8A, 0x95, 0x51, 0x25, 0x10, 0x91, 0x09, 0x10, 0x91,
  0x10, 0x93, 0x0E, 0x18, 0x04, 0x81, 0x08, 0x21, 0x04, 0x20, 0x48, 0x06,
  0x01, 0x80, 0x48, 0x50, 0x8A, 0x09, 0x40, 0xC8, 0x09, 0x03, 0x1F, 0x98,
  0xF8, 0x34, 0x44, 0x88, 0x88, 0x88, 0x88, 0x84, 0x42, 0x30, 0x89, 0x12,
  0x49, 0x24, 0x92, 0x52, 0x80, 0x10, 0x23, 0x49, 0xE1, 0x84, 0x91, 0x00,
  0x08, 0x08, 0x08, 0x08, 0xFF, 0x08, 0x08, 0x08, 0x08, 0x08, 0x6A, 0x80,
  0xF0, 0x80, 0x04, 0x10, 0x82, 0x08, 0x41, 0x04, 0x20, 0x82, 0x10, 0x42,
  0x00, 0x18, 0x26, 0x42, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x41, 0x42, 0x3C, 0x35, 0x91, 0x11, 0x11, 0x11, 0x11, 0x11, 0xFC,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40,
  0xFF, 0xFE, 0x02, 0x01, 0x01, 0x02, 0x06, 0x38, 0x06, 0x01, 0x01, 0x01,
  0x01, 0x02, 0xFC, 0x03, 0x00, 0xC0, 0x50, 0x24, 0x09, 0x04, 0x42, 0x10,
  0x84, 0x41, 0x20, 0x47, 0xFC, 0x04, 0x01, 0x00, 0x40, 0x7E, 0x40, 0x40,
  0x40, 0x40, 0x78, 0x46, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0xFC, 0x1F,
  0x20, 0x40, 0x40, 0x80, 0x9C, 0xE2, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42,
  0x3E, 0xFF, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x7E, 0x41, 0x81, 0x81, 0x42, 0x24, 0x18, 0x66, 0x41,
  0x81, 0x81, 0x81, 0x41, 0x3E, 0x7C, 0x82, 0x81, 0x81, 0x81, 0x81, 0x83,
  0x45, 0x39, 0x01, 0x02, 0x02, 0x04, 0x78, 0xC0, 0x20, 0x50, 0x00, 0x1A,
  0xA0, 0x01, 0x03, 0x0C, 0x30, 0xC0, 0x60, 0x18, 0x06, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x40, 0x30, 0x0E, 0x01, 0x02, 0x0C, 0x30, 0xC0, 0xF8,
  0x10, 0x41, 0x08, 0x21, 0x08, 0x41, 0x00, 0x00, 0x01, 0x00, 0x0F, 0xE0,
  0x40, 0x42, 0x00, 0x90, 0x02, 0x47, 0xCA, 0x21, 0x18, 0x84, 0x62, 0x11,
  0x88, 0x46, 0x22, 0x28, 0x8C, 0xA1, 0xCC, 0x40, 0x01, 0x00, 0x03, 0x04,
  0x03, 0xE0, 0x04, 0x03, 0x00, 0xA0, 0x48, 0x12, 0x04, 0x42, 0x10, 0x84,
  0x3F, 0x90, 0x24, 0x09, 0x01, 0x80, 0x60, 0x10, 0xFE, 0x82, 0x81, 0x81,
  0x81, 0x82, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x1F, 0x90,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02,
  0x00, 0xFC, 0xFE, 0x40, 0xA0, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x28, 0x27, 0xE0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x3F,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x1F, 0xC0, 0xFF, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x7E, 0x81, 0x02, 0x04, 0x08, 0x10, 0x00, 0x07, 0x03, 0x18, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x83, 0xF0, 0x06, 0x00, 0xA0,
  0x14, 0x02, 0x40, 0x47, 0xF0, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07,
  0xFF, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0xE9, 0x24, 0x92,
  0x49, 0x25, 0xC0, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x93, 0x00, 0x83, 0x84, 0x84, 0x88, 0x90, 0xA0, 0xE0, 0x90, 0x88,
  0x88, 0x84, 0x82, 0x82, 0x81, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x1F, 0xC0, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x05,
  0xA0, 0x5A, 0x09, 0x90, 0x99, 0x09, 0x91, 0x18, 0x91, 0x89, 0x18, 0xA1,
  0x86, 0x18, 0x41, 0x80, 0xE0, 0x70, 0x34, 0x19, 0x0C, 0x86, 0x23, 0x11,
  0x84, 0xC2, 0x60, 0xB0, 0x38, 0x1C, 0x04, 0x06, 0x03, 0x30, 0x81, 0x20,
  0x24, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xA0, 0x14,
  0x04, 0x40, 0x87, 0xE0, 0xFD, 0x06, 0x0C, 0x18, 0x30, 0x61, 0xFC, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x00, 0x06, 0x03, 0x30, 0x81, 0x20, 0x14, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xA0, 0x14, 0x04, 0x40,
  0x87, 0xE0, 0x08, 0x01, 0x00, 0x18, 0xFC, 0x82, 0x82, 0x82, 0x82, 0x82,
  0x84, 0xF8, 0x88, 0x84, 0x84, 0x82, 0x82, 0x81, 0x7F, 0x80, 0x80, 0x80,
  0x80, 0x40, 0x38, 0x04, 0x02, 0x01, 0x01, 0x01, 0x02, 0xFC, 0xFF, 0x84,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x14, 0x11, 0xF0, 0x80, 0x60, 0x14, 0x09, 0x02, 0x40,
  0x88, 0x42, 0x10, 0x84, 0x12, 0x04, 0x81, 0x20, 0x30, 0x0C, 0x03, 0x00,
  0x81, 0x81, 0x41, 0x82, 0x41, 0x82, 0x41, 0x82, 0x42, 0x42, 0x22, 0x44,
  0x22, 0x44, 0x22, 0x44, 0x24, 0x24, 0x14, 0x28, 0x14, 0x28, 0x14, 0x28,
  0x08, 0x10, 0x08, 0x10, 0xC0, 0xA0, 0x88, 0x84, 0x41, 0x40, 0x60, 0x20,
  0x18, 0x14, 0x11, 0x08, 0x88, 0x24, 0x14, 0x04, 0x80, 0xA0, 0x90, 0x44,
  0x42, 0x20, 0xA0, 0x50, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0xFF, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40,
  0x80, 0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x81,
  0x04, 0x08, 0x20, 0x81, 0x04, 0x10, 0x20, 0x81, 0x04, 0x10, 0xF1, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x18, 0x0A, 0x09, 0x04, 0x84,
  0x22, 0x12, 0x05, 0x03, 0xFF, 0x88, 0x80, 0x38, 0x88, 0x08, 0x10, 0x27,
  0xF0, 0xC1, 0x83, 0x0D, 0xE8, 0x80, 0x80, 0x80, 0x80, 0xB8, 0xC6, 0x82,
  0x82, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0xFC, 0x1E, 0xC1, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x80, 0x80, 0xF8, 0x01, 0x01, 0x01, 0x01, 0x3D, 0x43,
  0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x3C, 0x42, 0x42,
  0x81, 0x81, 0xFF, 0x80, 0x80, 0x80, 0x40, 0x3E, 0x1C, 0x82, 0x08, 0xF8,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x00, 0x3D, 0x43, 0x41, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x82, 0x7C,
  0x81, 0x02, 0x04, 0x0B, 0x98, 0xA0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0x80, 0x70, 0x55, 0x55, 0x54, 0x13, 0x00, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x2E, 0x82, 0x08, 0x20, 0x86, 0x29, 0x24, 0xA3, 0x89,
  0x24, 0x8A, 0x18, 0x40, 0xFF, 0xFE, 0xB9, 0xEC, 0x61, 0x86, 0x18, 0x41,
  0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x10, 0xB9,
  0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x3C, 0x42, 0x41,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3E, 0xB8, 0xC6, 0x82, 0x82,
  0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x3D, 0x43, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01,
  0x01, 0x01, 0x01, 0x01, 0xBE, 0x21, 0x08, 0x42, 0x10, 0x84, 0x20, 0x7E,
  0x08, 0x20, 0x40, 0xC0, 0xC1, 0x04, 0x1F, 0x80, 0x21, 0x3E, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x43, 0x80, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x0D, 0xE8, 0x81, 0x81, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x18,
  0x18, 0x18, 0x82, 0x0C, 0x10, 0x91, 0x44, 0x8A, 0x24, 0x51, 0x22, 0x90,
  0xA2, 0x85, 0x14, 0x28, 0xA1, 0x82, 0x04, 0x10, 0x41, 0x42, 0x22, 0x24,
  0x18, 0x08, 0x18, 0x14, 0x22, 0x42, 0xC1, 0x81, 0x81, 0x42, 0x42, 0x42,
  0x24, 0x24, 0x24, 0x18, 0x18, 0x08, 0x10, 0x10, 0x10, 0x20, 0xC0, 0xFC,
  0x10, 0x82, 0x10, 0x82, 0x10, 0x42, 0x0F, 0xC0, 0x19, 0x08, 0x42, 0x10,
  0x88, 0x82, 0x08, 0x42, 0x10, 0x84, 0x18, 0xFF, 0xFF, 0xF0, 0xC1, 0x08,
  0x42, 0x10, 0x82, 0x19, 0x08, 0x42, 0x10, 0x84, 0xC0, 0xF1, 0x8F,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 14, 4, 2, -14 },
  { 3, 4, 5, 7, 1, -14 },
  { 6, 11, 14, 11, 0, -14 },
  { 26, 8, 16, 10, 1, -15 },
  { 42, 12, 14, 14, 1, -14 },
  { 63, 11, 15, 12, 1, -15 },
  { 84, 1, 5, 4, 1, -14 },
  { 85, 4, 17, 5, 1, -14 },
  { 94, 3, 17, 5, 1, -14 },
  { 101, 7, 7, 10, 1, -15 },
  { 108, 8, 10, 10, 1, -12 },
  { 118, 2, 5, 4, 1, -2 },
  { 120, 4, 1, 6, 1, -6 },
  { 121, 1, 1, 4, 2, -1 },
  { 122, 6, 14, 7, 0, -14 },
  { 133, 8, 15, 10, 1, -15 },
  { 148, 4, 14, 10, 2, -14 },
  { 155, 8, 14, 10, 1, -14 },
  { 169, 8, 14, 10, 1, -14 },
  { 183, 10, 14, 10, 0, -14 },
  { 201, 8, 14, 10, 1, -14 },
  { 215, 8, 14, 10, 1, -14 },
  { 229, 8, 14, 10, 1, -14 },
  { 243, 8, 14, 10, 1, -14 },
  { 257, 8, 14, 10, 1, -14 },
  { 271, 1, 11, 4, 2, -11 },
  { 273, 2, 14, 4, 1, -11 },
  { 277, 8, 9, 10, 1, -12 },
  { 286, 8, 4, 10, 1, -9 },
  { 290, 8, 9, 10, 1, -12 },
  { 299, 6, 14, 7, 1, -14 },
  { 310, 14, 16, 16, 1, -14 },
  { 338, 10, 14, 10, 0, -14 },
  { 356, 8, 14, 11, 2, -14 },
  { 370, 9, 14, 11, 1, -14 },
  { 386, 9, 14, 12, 2, -14 },
  { 402, 7, 14, 10, 2, -14 },
  { 415, 7, 14, 9, 2, -14 },
  { 428, 11, 15, 13, 1, -15 },
  { 449, 9, 14, 13, 2, -14 },
  { 465, 3, 14, 5, 1, -14 },
  { 471, 5, 18, 4, -2, -14 },
  { 483, 8, 14, 10, 2, -14 },
  { 497, 7, 14, 9, 2, -14 },
  { 510, 12, 14, 16, 2, -14 },
  { 531, 9, 14, 13, 2, -14 },
  { 547, 11, 15, 13, 1, -15 },
  { 568, 7, 14, 10, 2, -14 },
  { 581, 11, 18, 13, 1, -15 },
  { 606, 8, 14, 10, 2, -14 },
  { 620, 8, 14, 10, 1, -14 },
  { 634, 9, 14, 9, 0, -14 },
  { 650, 9, 14, 13, 2, -14 },
  { 666, 10, 14, 10, 0, -14 },
  { 684, 16, 14, 16, 0, -14 },
  { 712, 9, 14, 9, 0, -14 },
  { 728, 9, 14, 9, 0, -14 },
  { 744, 8, 14, 10, 1, -14 },
  { 758, 4, 17, 6, 2, -14 },
  { 767, 6, 14, 7, 0, -14 },
  { 778, 4, 17, 6, 1, -14 },
  { 787, 9, 8, 10, 1, -14 },
  { 796, 8, 1, 8, 0, 2 },
  { 797, 3, 3, 5, 1, -15 },
  { 799, 7, 11, 9, 1, -11 },
  { 809, 8, 15, 11, 2, -15 },
  { 824, 7, 11, 8, 1, -11 },
  { 834, 8, 15, 11, 1, -15 },
  { 849, 8, 11, 10, 1, -11 },
  { 860, 6, 15, 5, 0, -15 },
  { 872, 8, 16, 11, 1, -11 },
  { 888, 7, 15, 10, 2, -15 },
  { 902, 2, 15, 4, 1, -15 },
  { 906, 4, 20, 4, -1, -15 },
  { 916, 6, 15, 8, 2, -15 },
  { 928, 1, 15, 4, 2, -15 },
  { 930, 12, 11, 16, 2, -11 },
  { 947, 7, 11, 10, 2, -11 },
  { 957, 8, 11, 10, 1, -11 },
  { 968, 8, 16, 11, 2, -11 },
  { 984, 8, 16, 11, 1, -11 },
  { 1000, 5, 11, 7, 2, -11 },
  { 1007, 6, 11, 8, 1, -11 },
  { 1016, 5, 13, 6, 0, -13 },
  { 1025, 7, 11, 10, 2, -11 },
  { 1035, 8, 11, 8, 0, -11 },
  { 1046, 13, 11, 13, 0, -11 },
  { 1064, 8, 11, 9, 0, -11 },
  { 1075, 8, 16, 8, 0, -11 },
  { 1091, 6, 11, 8, 1, -11 },
  { 1100, 5, 17, 7, 1, -14 },
  { 1111, 1, 20, 10, 4, -15 },
  { 1114, 5, 17, 7, 1, -14 },
  { 1125, 8, 2, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight20pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT20PT7B_H_
