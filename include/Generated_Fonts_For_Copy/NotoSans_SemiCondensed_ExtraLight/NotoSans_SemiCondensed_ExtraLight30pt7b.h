#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT30PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight30pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x03, 0xC0, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x40, 0x02, 0x08, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x41, 0x00, 0x82,
  0x1F, 0xFF, 0x84, 0x10, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x41, 0x00,
  0x82, 0x1F, 0xFF, 0x84, 0x10, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x41,
  0x01, 0x84, 0x02, 0x08, 0x00, 0x04, 0x00, 0x80, 0x7E, 0x32, 0x6C, 0x41,
  0x08, 0x21, 0x04, 0x20, 0x84, 0x18, 0x81, 0x90, 0x0E, 0x00, 0x70, 0x0B,
  0x01, 0x10, 0x21, 0x04, 0x20, 0x84, 0x10, 0x82, 0x38, 0x4D, 0xFF, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x18, 0x00, 0x13, 0x01, 0x08, 0x40, 0xC2, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x84, 0x08, 0x21, 0x02, 0x08, 0x80, 0x82, 0x20,
  0x20, 0x93, 0xC8, 0x24, 0x8A, 0x12, 0x41, 0x4C, 0x90, 0x4C, 0x44, 0x10,
  0x11, 0x04, 0x08, 0x41, 0x02, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x30,
  0x41, 0x08, 0x08, 0x86, 0x03, 0xE0, 0x07, 0x00, 0x08, 0xC0, 0x10, 0x40,
  0x10, 0x20, 0x10, 0x20, 0x10, 0x20, 0x10, 0x60, 0x10, 0x40, 0x08, 0x80,
  0x07, 0x00, 0x06, 0x00, 0x1B, 0x00, 0x31, 0x03, 0x60, 0x82, 0x40, 0x42,
  0x40, 0x22, 0xC0, 0x34, 0x40, 0x1C, 0x40, 0x08, 0x40, 0x14, 0x30, 0x62,
  0x1F, 0xC1, 0xFE, 0x0C, 0x61, 0x08, 0x21, 0x84, 0x10, 0x41, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0x41, 0x04, 0x18, 0x20, 0x81, 0x04, 0x08, 0x30, 0xC1,
  0x82, 0x0C, 0x10, 0x60, 0x82, 0x08, 0x20, 0xC3, 0x0C, 0x30, 0xC2, 0x08,
  0x20, 0x86, 0x10, 0x42, 0x08, 0x43, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x0C, 0x4E, 0x7E, 0x03, 0x00, 0xD0, 0x13, 0x04, 0x21, 0x82, 0x00, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x1F, 0xFF,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x2D, 0xA4,
  0xA0, 0xFE, 0xF0, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x20, 0x20, 0x10, 0x18,
  0x08, 0x04, 0x06, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x30,
  0x10, 0x08, 0x00, 0x0E, 0x03, 0x98, 0x60, 0xC4, 0x04, 0xC0, 0x28, 0x02,
  0x80, 0x28, 0x02, 0x80, 0x28, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x28, 0x02, 0x80, 0x2C, 0x02, 0x40, 0x64, 0x04, 0x20, 0x81, 0xF0,
  0x0C, 0x56, 0x71, 0x84, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x0F, 0x03, 0x9C, 0x40, 0x60, 0x02, 0x00, 0x20,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0F,
  0xFF, 0x0F, 0x03, 0x9C, 0xC0, 0x60, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x0C, 0x1F, 0x80, 0x3C, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0xC0, 0x67, 0xF8, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x78, 0x01, 0x60, 0x09, 0x80, 0x66, 0x01, 0x18,
  0x08, 0x60, 0x21, 0x81, 0x06, 0x08, 0x18, 0x20, 0x61, 0x01, 0x8C, 0x06,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x7F, 0xC4, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xFF, 0x06, 0x1C, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x48, 0x0C, 0x7F, 0x00, 0x01, 0xC0, 0xC4,
  0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x09, 0xF8,
  0xA0, 0x4C, 0x02, 0x80, 0x28, 0x03, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x40, 0x24, 0x06, 0x20, 0x41, 0xF8, 0xFF, 0xF8, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x18, 0x40, 0x4C, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x24, 0x04, 0x60, 0xC1, 0x18, 0x0E, 0x01, 0xB0, 0x60,
  0xCC, 0x06, 0x80, 0x28, 0x03, 0x80, 0x38, 0x03, 0x80, 0x2C, 0x02, 0x60,
  0x43, 0xF8, 0x07, 0x01, 0x8C, 0x20, 0x64, 0x02, 0x40, 0x34, 0x01, 0xC0,
  0x1C, 0x01, 0x40, 0x14, 0x01, 0x40, 0x36, 0x03, 0x38, 0xD0, 0xF1, 0x00,
  0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x01, 0x83, 0xF0, 0xF0,
  0x00, 0x00, 0x0F, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x5A, 0x4B, 0x40, 0x00,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x38, 0x73, 0x80, 0x40, 0x10,
  0x08, 0x04, 0x02, 0x03, 0x01, 0x01, 0x81, 0x81, 0x81, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x00, 0x00, 0x00, 0x03, 0x01, 0x80, 0x03, 0xFE, 0x00, 0xC0,
  0x30, 0x18, 0x00, 0x83, 0x00, 0x04, 0x20, 0x00, 0x64, 0x00, 0x02, 0x40,
  0xFC, 0x28, 0x10, 0x41, 0x82, 0x04, 0x18, 0x60, 0x41, 0x84, 0x04, 0x18,
  0x40, 0x41, 0x84, 0x0C, 0x18, 0x40, 0xC1, 0x84, 0x0C, 0x28, 0x21, 0x42,
  0x83, 0x36, 0x48, 0x0C, 0x38, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x3F, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x02, 0x80, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40, 0x04, 0x20, 0x04, 0x20,
  0x08, 0x20, 0x08, 0x10, 0x08, 0x10, 0x10, 0x10, 0x1F, 0xF8, 0x10, 0x08,
  0x20, 0x08, 0x20, 0x0C, 0x20, 0x04, 0x40, 0x04, 0x40, 0x06, 0xC0, 0x02,
  0x80, 0x03, 0xFF, 0xC8, 0x06, 0x80, 0x28, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x28, 0x02, 0x80, 0x4F, 0xF0, 0x81, 0xC8, 0x02, 0x80, 0x38, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x28, 0x0C, 0xFF, 0x00, 0x01, 0xE0,
  0x38, 0xF1, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x08, 0x1F,
  0xE0, 0xFF, 0x82, 0x01, 0x88, 0x03, 0x20, 0x04, 0x80, 0x0A, 0x00, 0x28,
  0x00, 0xA0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xA0, 0x02, 0x80, 0x1A, 0x00, 0x48, 0x06, 0x20, 0x70,
  0xFF, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x3F, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFE, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x00, 0xF0, 0x0E, 0x3C,
  0x60, 0x09, 0x80, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x07, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x40, 0x02, 0x80, 0x04, 0x80, 0x09, 0x80, 0x11, 0xC0, 0x20,
  0xFF, 0x80, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0xFC, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x43, 0x0B,
  0xE0, 0x80, 0x38, 0x04, 0x80, 0xC8, 0x18, 0x83, 0x08, 0x20, 0x84, 0x08,
  0x80, 0x98, 0x0B, 0x80, 0xE8, 0x0C, 0x40, 0x86, 0x08, 0x20, 0x81, 0x08,
  0x18, 0x80, 0x88, 0x04, 0x80, 0x68, 0x02, 0x80, 0x30, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xC0,
  0xC0, 0x00, 0xF0, 0x00, 0x5E, 0x00, 0x16, 0x80, 0x05, 0xA0, 0x02, 0x6C,
  0x00, 0x99, 0x00, 0x66, 0x40, 0x11, 0x88, 0x04, 0x62, 0x02, 0x18, 0xC0,
  0x86, 0x10, 0x21, 0x84, 0x10, 0x61, 0x84, 0x18, 0x23, 0x06, 0x08, 0x81,
  0x81, 0x20, 0x60, 0x58, 0x18, 0x14, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40,
  0xC0, 0x0E, 0x00, 0x78, 0x03, 0x40, 0x19, 0x00, 0xC8, 0x06, 0x20, 0x31,
  0x81, 0x84, 0x0C, 0x30, 0x60, 0x83, 0x02, 0x18, 0x18, 0xC0, 0x46, 0x03,
  0x30, 0x09, 0x80, 0x2C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x80, 0x03,
  0xC0, 0x0E, 0x38, 0x10, 0x0C, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x40, 0x02, 0x60,
  0x06, 0x30, 0x04, 0x18, 0x18, 0x0F, 0xF0, 0xFF, 0x90, 0x1A, 0x01, 0x40,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0A, 0x06, 0x7F, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00,
  0x03, 0xC0, 0x0E, 0x38, 0x10, 0x0C, 0x20, 0x06, 0x40, 0x02, 0x40, 0x02,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x03, 0x40, 0x02,
  0x60, 0x06, 0x30, 0x04, 0x18, 0x18, 0x0F, 0xF0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0xFF, 0x88, 0x0C, 0x80, 0x68, 0x02,
  0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x0C, 0xFF, 0x0F, 0xE0,
  0x82, 0x08, 0x10, 0x81, 0x08, 0x08, 0x80, 0xC8, 0x04, 0x80, 0x68, 0x02,
  0x80, 0x30, 0x07, 0x81, 0xCF, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xC0, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x80, 0x67, 0xF8, 0xFF,
  0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x50, 0x04, 0xC0, 0x61, 0xFC, 0x00, 0xC0, 0x02, 0x80,
  0x09, 0x00, 0x12, 0x00, 0x22, 0x00, 0x84, 0x01, 0x08, 0x02, 0x08, 0x08,
  0x10, 0x10, 0x20, 0x20, 0x20, 0xC0, 0x41, 0x00, 0x82, 0x01, 0x8C, 0x01,
  0x10, 0x02, 0x20, 0x06, 0xC0, 0x05, 0x00, 0x0A, 0x00, 0x1C, 0x00, 0x10,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x50, 0x1E, 0x02,
  0x40, 0x48, 0x09, 0x01, 0x20, 0x26, 0x04, 0x81, 0x88, 0x33, 0x04, 0x20,
  0x84, 0x10, 0x82, 0x10, 0x43, 0x08, 0x43, 0x04, 0x61, 0x88, 0x11, 0x02,
  0x20, 0x44, 0x08, 0x81, 0x90, 0x26, 0x02, 0xC0, 0xD0, 0x0A, 0x01, 0x40,
  0x28, 0x05, 0x00, 0xA0, 0x14, 0x01, 0x80, 0x60, 0x04, 0x00, 0x80, 0x60,
  0x08, 0x80, 0x43, 0x03, 0x04, 0x08, 0x18, 0x60, 0x21, 0x00, 0xCC, 0x01,
  0x20, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xE0, 0x04, 0x80, 0x33, 0x00,
  0x84, 0x04, 0x18, 0x10, 0x20, 0x80, 0x46, 0x01, 0x10, 0x02, 0xC0, 0x0C,
  0xC0, 0x0A, 0x00, 0xD8, 0x04, 0x40, 0x63, 0x02, 0x08, 0x30, 0x41, 0x01,
  0x08, 0x08, 0x80, 0x24, 0x01, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x7F,
  0xF0, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0F, 0xFF, 0x80, 0xFE, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x83, 0xF0, 0xC0, 0x10, 0x02, 0x00, 0x80, 0x20,
  0x04, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0xFC, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x07, 0xF0, 0x02, 0x00, 0x18, 0x01, 0x40, 0x09, 0x00,
  0x88, 0x04, 0x20, 0x41, 0x02, 0x04, 0x20, 0x21, 0x01, 0x90, 0x04, 0x80,
  0x38, 0x00, 0x80, 0xFF, 0xF0, 0xC3, 0x08, 0x20, 0x80, 0x1F, 0x84, 0x18,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x08, 0x7F, 0x30, 0x28, 0x07, 0x00,
  0xE0, 0x3C, 0x06, 0x81, 0x50, 0x29, 0xF9, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xF8, 0xD0, 0x6E, 0x02, 0xC0, 0x3C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x03, 0xE0, 0x2B, 0x06, 0x9F, 0x80, 0x1F, 0xCC, 0x16, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0x7F, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x31, 0xF3, 0x20, 0xB4, 0x07, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x40, 0x76, 0x09, 0x3F,
  0x10, 0x1F, 0x04, 0x11, 0x01, 0x60, 0x28, 0x03, 0x00, 0x60, 0x0F, 0xFF,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x08, 0xFE, 0x07,
  0x84, 0x06, 0x02, 0x01, 0x00, 0x80, 0x41, 0xFC, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x1F, 0x24, 0x1D, 0x01, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x80, 0xD8, 0x29, 0xF9, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x07, 0x81, 0x9F, 0xE0, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x7C, 0xD0, 0x5C, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x08, 0x70, 0x05, 0x55, 0x55, 0x55, 0x50, 0x18,
  0xC0, 0x00, 0x00, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x2F, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x06, 0xC0, 0x98, 0x23, 0x08, 0x63, 0x0C, 0xC1,
  0x90, 0x36, 0x07, 0x20, 0xC6, 0x18, 0x43, 0x04, 0x60, 0x8C, 0x09, 0x81,
  0xB0, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x9F, 0x0F, 0x96, 0x12,
  0x0A, 0x81, 0x81, 0xE0, 0x30, 0x1C, 0x04, 0x03, 0x80, 0x80, 0x70, 0x10,
  0x0E, 0x02, 0x01, 0xC0, 0x40, 0x38, 0x08, 0x07, 0x01, 0x00, 0xE0, 0x20,
  0x1C, 0x04, 0x03, 0x80, 0x80, 0x70, 0x10, 0x0E, 0x02, 0x01, 0x8F, 0x92,
  0x0A, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x1F, 0x82, 0x0C, 0x40,
  0x6C, 0x02, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x03, 0xC0, 0x24, 0x06, 0x20, 0xC1, 0xF8, 0x8F, 0x89, 0x06, 0xA0,
  0x2C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x3E, 0x02, 0xF0, 0x6C, 0xF8, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x1F, 0x24, 0x15, 0x01, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x02, 0x80, 0xD8, 0x29, 0xF9, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x8F, 0x90, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3F, 0x98, 0x14, 0x03, 0x00,
  0x40, 0x10, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x40,
  0x18, 0x09, 0xFC, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x10, 0x10, 0x1F, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x1C, 0x06, 0x80, 0xD8, 0x29, 0xF9, 0x80, 0x34, 0x02,
  0x40, 0x24, 0x02, 0x20, 0x42, 0x04, 0x20, 0x43, 0x08, 0x10, 0x81, 0x08,
  0x19, 0x00, 0x90, 0x09, 0x00, 0xE0, 0x06, 0x00, 0x60, 0xC0, 0x40, 0x28,
  0x0C, 0x0D, 0x01, 0x81, 0x20, 0x50, 0x22, 0x0B, 0x04, 0x41, 0x21, 0x88,
  0x44, 0x21, 0x08, 0x84, 0x11, 0x08, 0x82, 0x61, 0x20, 0x48, 0x24, 0x0D,
  0x06, 0x80, 0xA0, 0x50, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x10, 0x80,
  0x68, 0x09, 0x82, 0x10, 0x41, 0x10, 0x36, 0x02, 0x80, 0x20, 0x0E, 0x01,
  0x40, 0x44, 0x18, 0x82, 0x08, 0xC1, 0x90, 0x14, 0x01, 0xC0, 0x14, 0x03,
  0x40, 0x26, 0x02, 0x20, 0x62, 0x04, 0x30, 0x41, 0x0C, 0x10, 0x81, 0x88,
  0x09, 0x00, 0x90, 0x09, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x01, 0x80, 0xF0, 0x00, 0x7F, 0xC0, 0x20, 0x18,
  0x04, 0x03, 0x00, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x0C, 0x03, 0xFF, 0x07, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x30, 0xC0, 0x30, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x18, 0x08, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x18,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x04, 0x03, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18, 0x30, 0xC0,
  0x3C, 0x0E, 0x18, 0xE0, 0x38,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 21, 7, 2, -21 },
  { 7, 6, 7, 10, 2, -21 },
  { 13, 15, 21, 17, 1, -21 },
  { 53, 11, 25, 15, 2, -23 },
  { 88, 18, 22, 22, 2, -22 },
  { 138, 16, 22, 18, 1, -22 },
  { 182, 1, 7, 5, 2, -21 },
  { 183, 6, 26, 8, 1, -21 },
  { 203, 6, 26, 8, 1, -21 },
  { 223, 11, 11, 14, 2, -23 },
  { 239, 13, 14, 15, 1, -18 },
  { 262, 3, 7, 6, 1, -3 },
  { 265, 7, 1, 9, 1, -9 },
  { 266, 2, 2, 6, 2, -2 },
  { 267, 9, 21, 10, 1, -21 },
  { 291, 12, 22, 15, 2, -22 },
  { 324, 6, 21, 15, 3, -21 },
  { 340, 12, 22, 15, 1, -22 },
  { 373, 12, 22, 15, 1, -22 },
  { 406, 14, 22, 15, 1, -22 },
  { 445, 12, 21, 15, 2, -21 },
  { 477, 12, 22, 15, 2, -22 },
  { 510, 13, 21, 15, 1, -21 },
  { 545, 12, 22, 15, 2, -22 },
  { 578, 12, 22, 15, 1, -22 },
  { 611, 2, 16, 6, 2, -16 },
  { 615, 3, 20, 6, 1, -16 },
  { 623, 13, 13, 15, 1, -17 },
  { 645, 13, 7, 15, 1, -14 },
  { 657, 13, 13, 15, 1, -17 },
  { 679, 9, 22, 11, 1, -22 },
  { 704, 20, 24, 23, 2, -21 },
  { 764, 16, 21, 16, 0, -21 },
  { 806, 12, 21, 17, 3, -21 },
  { 838, 14, 22, 16, 2, -22 },
  { 877, 14, 21, 19, 3, -21 },
  { 914, 10, 21, 15, 3, -21 },
  { 941, 10, 21, 13, 3, -21 },
  { 968, 15, 22, 20, 2, -22 },
  { 1010, 13, 21, 19, 3, -21 },
  { 1045, 6, 21, 8, 1, -21 },
  { 1061, 6, 26, 7, -2, -21 },
  { 1081, 12, 21, 15, 3, -21 },
  { 1113, 10, 21, 14, 3, -21 },
  { 1140, 18, 21, 23, 3, -21 },
  { 1188, 13, 21, 19, 3, -21 },
  { 1223, 16, 22, 20, 2, -22 },
  { 1267, 11, 21, 15, 3, -21 },
  { 1296, 16, 27, 20, 2, -22 },
  { 1350, 12, 21, 16, 3, -21 },
  { 1382, 12, 22, 15, 1, -22 },
  { 1415, 13, 21, 14, 0, -21 },
  { 1450, 13, 21, 19, 3, -21 },
  { 1485, 15, 21, 15, 0, -21 },
  { 1525, 22, 21, 24, 1, -21 },
  { 1583, 14, 21, 14, 0, -21 },
  { 1620, 13, 21, 13, 0, -21 },
  { 1655, 13, 21, 15, 1, -21 },
  { 1690, 6, 26, 9, 3, -21 },
  { 1710, 10, 21, 10, 0, -21 },
  { 1737, 6, 26, 9, 1, -21 },
  { 1757, 13, 13, 15, 1, -22 },
  { 1779, 12, 1, 12, 0, 3 },
  { 1781, 5, 5, 7, 1, -23 },
  { 1785, 11, 16, 14, 1, -16 },
  { 1807, 12, 23, 16, 2, -23 },
  { 1842, 10, 16, 13, 2, -16 },
  { 1862, 12, 23, 16, 2, -23 },
  { 1897, 11, 16, 15, 2, -16 },
  { 1919, 9, 23, 8, 0, -23 },
  { 1945, 11, 23, 16, 2, -16 },
  { 1977, 11, 23, 16, 2, -23 },
  { 2009, 2, 22, 6, 2, -22 },
  { 2015, 5, 29, 6, -1, -22 },
  { 2034, 11, 23, 13, 2, -23 },
  { 2066, 2, 23, 6, 2, -23 },
  { 2072, 19, 16, 23, 2, -16 },
  { 2110, 11, 16, 16, 2, -16 },
  { 2132, 12, 16, 16, 2, -16 },
  { 2156, 12, 23, 16, 2, -16 },
  { 2191, 11, 23, 16, 2, -16 },
  { 2223, 8, 16, 10, 2, -16 },
  { 2239, 10, 16, 12, 1, -16 },
  { 2259, 8, 20, 9, 0, -20 },
  { 2279, 11, 16, 16, 2, -16 },
  { 2301, 12, 16, 12, 0, -16 },
  { 2325, 19, 16, 19, 0, -16 },
  { 2363, 11, 16, 13, 1, -16 },
  { 2385, 12, 23, 12, 0, -16 },
  { 2420, 10, 16, 12, 1, -16 },
  { 2440, 8, 26, 10, 1, -21 },
  { 2466, 1, 30, 14, 7, -23 },
  { 2470, 8, 26, 10, 1, -21 },
  { 2496, 13, 3, 15, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight30pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT30PT7B_H_
