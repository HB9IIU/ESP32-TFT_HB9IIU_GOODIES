#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT33PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight33pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xA0, 0x0F, 0xC7, 0x8F, 0x1E, 0x2C, 0x58,
  0xB1, 0x42, 0x84, 0x03, 0x04, 0x01, 0x02, 0x00, 0x81, 0x00, 0x41, 0x80,
  0x20, 0x80, 0x10, 0x40, 0x18, 0x20, 0x08, 0x10, 0x7F, 0xFF, 0x82, 0x0C,
  0x01, 0x04, 0x00, 0x82, 0x00, 0xC1, 0x00, 0x40, 0x80, 0x20, 0x41, 0xFF,
  0xFE, 0xFF, 0xFF, 0x04, 0x10, 0x06, 0x08, 0x02, 0x04, 0x01, 0x02, 0x00,
  0x83, 0x00, 0x41, 0x00, 0x20, 0x80, 0x04, 0x00, 0x40, 0x1F, 0xC7, 0x47,
  0x44, 0x08, 0x40, 0x84, 0x08, 0x40, 0x84, 0x08, 0x40, 0x44, 0x03, 0x40,
  0x1C, 0x00, 0x78, 0x04, 0xC0, 0x42, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x43, 0x84, 0x6F, 0xF8, 0x04, 0x00, 0x40, 0x04, 0x00, 0x3C,
  0x01, 0x06, 0x60, 0x30, 0x42, 0x02, 0x08, 0x30, 0x60, 0x81, 0x04, 0x08,
  0x10, 0x40, 0x81, 0x08, 0x08, 0x10, 0x80, 0x81, 0x10, 0x08, 0x11, 0x00,
  0x81, 0x23, 0xC8, 0x32, 0x42, 0x42, 0x4C, 0x36, 0x64, 0x81, 0x38, 0x88,
  0x10, 0x08, 0x81, 0x01, 0x88, 0x10, 0x10, 0x81, 0x03, 0x08, 0x10, 0x20,
  0x81, 0x06, 0x08, 0x10, 0x40, 0x43, 0x0C, 0x04, 0x20, 0x80, 0x3C, 0x07,
  0x80, 0x0C, 0x60, 0x0C, 0x18, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x80, 0x60, 0xC0, 0x10, 0xC0, 0x04, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xB0, 0x03, 0x08, 0x09, 0x02, 0x05, 0x01, 0x82, 0x80, 0x62, 0x40,
  0x19, 0x20, 0x07, 0x90, 0x01, 0x88, 0x00, 0xC6, 0x00, 0xB1, 0x81, 0x8C,
  0x7F, 0x83, 0xFF, 0xFE, 0x80, 0x06, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x10,
  0x60, 0x81, 0x02, 0x04, 0x08, 0x30, 0x60, 0x40, 0x81, 0x02, 0x04, 0x0C,
  0x08, 0x10, 0x30, 0x20, 0x60, 0x40, 0x60, 0xC1, 0x02, 0x0C, 0x10, 0x60,
  0x82, 0x0C, 0x30, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x0C, 0x20,
  0x86, 0x10, 0x42, 0x18, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xC4,
  0x37, 0xDC, 0x06, 0x00, 0xE0, 0x09, 0x01, 0x08, 0x30, 0xC2, 0x04, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x3F,
  0xFF, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x24, 0xB6, 0x96, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x20, 0x18,
  0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x06, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08,
  0x02, 0x00, 0x0F, 0x80, 0xC6, 0x08, 0x18, 0xC0, 0x64, 0x01, 0x20, 0x0B,
  0x00, 0x50, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x04, 0x80, 0x24, 0x03,
  0x10, 0x10, 0xC1, 0x03, 0xF0, 0x02, 0x1C, 0x69, 0x96, 0x30, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x1F, 0x03, 0xCE, 0x30, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x03, 0x00, 0x1F, 0xFF, 0x0F, 0x80, 0xE3, 0x84, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x06,
  0x03, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x6C, 0x03, 0x1F, 0xF0, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x80, 0x0B, 0x00, 0x26, 0x00, 0xCC,
  0x01, 0x18, 0x04, 0x30, 0x18, 0x60, 0x20, 0xC0, 0xC1, 0x81, 0x03, 0x04,
  0x06, 0x18, 0x0C, 0x20, 0x18, 0x80, 0x31, 0xFF, 0xFC, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x3F, 0xF3, 0xFF, 0x98,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x1F, 0xE0, 0x80, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x13, 0x03, 0x8F, 0xF0, 0x03,
  0xF0, 0x70, 0x86, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x04, 0x18, 0x27, 0xF1, 0x60, 0x6E, 0x01, 0x60, 0x0E, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x70, 0x02, 0x80, 0x34, 0x01, 0x10, 0x18, 0xC1,
  0x81, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x0F, 0x81, 0xC7, 0x18, 0x0C, 0x80, 0x2C,
  0x01, 0x60, 0x0B, 0x00, 0x48, 0x02, 0x60, 0x21, 0x83, 0x07, 0x60, 0x0E,
  0x01, 0x98, 0x18, 0x31, 0x00, 0xD8, 0x02, 0x80, 0x1C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0xA0, 0x09, 0x81, 0x83, 0xF8, 0x0F, 0x01, 0xC6, 0x18,
  0x19, 0x80, 0x48, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x80, 0x74, 0x03, 0x98, 0x6C, 0x7C, 0x60, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xE0, 0xB8,
  0x00, 0x00, 0x00, 0xF0, 0x23, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x22,
  0x26, 0x64, 0x4C, 0x00, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x00, 0x3E, 0x38, 0xE0, 0x08, 0x03, 0x00,
  0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x80, 0x40, 0x10, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x10, 0x00, 0x07, 0xFC, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x18, 0x10,
  0x00, 0x30, 0xC0, 0x00, 0x66, 0x00, 0x00, 0x90, 0x0F, 0xC2, 0x40, 0xC2,
  0x0F, 0x06, 0x08, 0x18, 0x10, 0x20, 0x60, 0x80, 0x81, 0x82, 0x02, 0x06,
  0x08, 0x08, 0x18, 0x20, 0x20, 0x60, 0x80, 0x81, 0x82, 0x02, 0x0E, 0x08,
  0x18, 0x28, 0x10, 0xD1, 0xB0, 0x7E, 0x7C, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x50, 0x00, 0x28, 0x00,
  0x16, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x60, 0x04, 0x10, 0x02, 0x08,
  0x01, 0x06, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x60, 0x7F, 0xF0, 0x20,
  0x08, 0x10, 0x06, 0x18, 0x01, 0x08, 0x00, 0x84, 0x00, 0x66, 0x00, 0x12,
  0x00, 0x0B, 0x00, 0x07, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x88, 0x03, 0x20,
  0x06, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x1A, 0x00, 0x48,
  0x06, 0x3F, 0xE0, 0x80, 0xE2, 0x00, 0x68, 0x00, 0xA0, 0x02, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x06, 0x3F, 0xF0,
  0x01, 0xF8, 0x0E, 0x1C, 0x70, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x83, 0xFE, 0xFC, 0x01, 0xFF,
  0xC2, 0x00, 0xC4, 0x00, 0xC8, 0x00, 0xD0, 0x00, 0xA0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x14, 0x00, 0x68, 0x00,
  0x90, 0x06, 0x20, 0x38, 0x7F, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0xF8, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0F, 0xFF, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x01, 0xFC, 0x03, 0xC3, 0xC3, 0x00, 0x22, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x07, 0xFC, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xA0, 0x00, 0x50, 0x00, 0x2C, 0x00, 0x13, 0x00, 0x08, 0xC0, 0x04, 0x38,
  0x06, 0x07, 0xFE, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0xFB, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x9F, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x38, 0xDF, 0x00, 0x80, 0x0A, 0x00, 0x68, 0x03, 0x20,
  0x18, 0x80, 0xC2, 0x02, 0x08, 0x10, 0x20, 0xC0, 0x86, 0x02, 0x30, 0x09,
  0x80, 0x27, 0x00, 0xA4, 0x03, 0x18, 0x08, 0x30, 0x20, 0x40, 0x81, 0x82,
  0x03, 0x08, 0x04, 0x20, 0x18, 0x80, 0x22, 0x00, 0x48, 0x01, 0xA0, 0x03,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x07, 0xFF, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xE0, 0x00, 0x5A, 0x00, 0x05, 0xA0, 0x00, 0xD9, 0x00, 0x09,
  0x90, 0x00, 0x99, 0x80, 0x19, 0x88, 0x01, 0x18, 0x80, 0x11, 0x8C, 0x02,
  0x18, 0x40, 0x21, 0x84, 0x06, 0x18, 0x60, 0x41, 0x82, 0x04, 0x18, 0x20,
  0xC1, 0x81, 0x08, 0x18, 0x10, 0x81, 0x81, 0x98, 0x18, 0x09, 0x01, 0x80,
  0x90, 0x18, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x0D, 0x00, 0x1B, 0x00, 0x32, 0x00, 0x66, 0x00, 0xC6, 0x01,
  0x84, 0x03, 0x0C, 0x06, 0x08, 0x0C, 0x18, 0x18, 0x10, 0x30, 0x10, 0x60,
  0x30, 0xC0, 0x21, 0x80, 0x63, 0x00, 0x46, 0x00, 0x4C, 0x00, 0xD8, 0x00,
  0xB0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x03, 0xF0, 0x03, 0x87, 0x01, 0x80,
  0x60, 0xC0, 0x0C, 0x20, 0x01, 0x90, 0x00, 0x24, 0x00, 0x0B, 0x00, 0x03,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xD0, 0x00, 0x34, 0x00,
  0x09, 0x80, 0x06, 0x20, 0x01, 0x04, 0x00, 0xC0, 0xC0, 0xC0, 0x1F, 0xE0,
  0xF8, 0x0F, 0xFC, 0x80, 0x68, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x38, 0x02, 0x80, 0xCF, 0xF8, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x03, 0xF0, 0x03, 0x87, 0x01, 0x80, 0x60, 0xC0, 0x0C, 0x20, 0x01, 0x90,
  0x00, 0x24, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xD0, 0x00, 0x34, 0x00, 0x09, 0x80, 0x06, 0x20, 0x01, 0x04,
  0x00, 0xC0, 0xC0, 0xE0, 0x1F, 0xE0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0xFC, 0x03, 0xFF, 0x08,
  0x06, 0x20, 0x0C, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x12,
  0x00, 0x48, 0x03, 0x20, 0x18, 0xFF, 0x83, 0xFC, 0x08, 0x10, 0x20, 0x60,
  0x80, 0x82, 0x01, 0x08, 0x06, 0x20, 0x08, 0x80, 0x32, 0x00, 0x48, 0x01,
  0xA0, 0x03, 0x0F, 0xC1, 0xC3, 0x98, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x60, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x1A, 0x03, 0x9F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x34, 0x00, 0x4C, 0x01, 0x8C, 0x06, 0x0F, 0xF0, 0x80,
  0x01, 0xE0, 0x00, 0x90, 0x00, 0x48, 0x00, 0x66, 0x00, 0x21, 0x00, 0x10,
  0x80, 0x18, 0x60, 0x08, 0x10, 0x04, 0x08, 0x06, 0x06, 0x02, 0x01, 0x01,
  0x00, 0x81, 0x80, 0x40, 0x80, 0x10, 0x40, 0x08, 0x60, 0x04, 0x20, 0x03,
  0x10, 0x00, 0x98, 0x00, 0x48, 0x00, 0x34, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x80, 0x08, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x58,
  0x03, 0x80, 0x24, 0x01, 0x40, 0x32, 0x01, 0x20, 0x19, 0x00, 0x90, 0x08,
  0xC0, 0x4C, 0x04, 0x20, 0x22, 0x06, 0x10, 0x31, 0x03, 0x08, 0x10, 0x81,
  0x06, 0x08, 0x60, 0x81, 0x04, 0x10, 0xC0, 0x86, 0x08, 0x60, 0x42, 0x04,
  0x20, 0x31, 0x03, 0x10, 0x08, 0x80, 0x98, 0x04, 0xC0, 0x48, 0x02, 0x40,
  0x24, 0x01, 0xA0, 0x1A, 0x00, 0x50, 0x07, 0x00, 0x38, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x40, 0x06, 0xC0, 0x08, 0x80, 0x31, 0x80,
  0x41, 0x01, 0x01, 0x02, 0x03, 0x08, 0x02, 0x30, 0x06, 0x40, 0x05, 0x80,
  0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x50, 0x01, 0x90, 0x02, 0x30, 0x0C,
  0x20, 0x10, 0x60, 0x60, 0x40, 0x80, 0xC2, 0x00, 0x8C, 0x01, 0x90, 0x01,
  0x60, 0x03, 0x80, 0x07, 0x80, 0x09, 0x00, 0x33, 0x00, 0x42, 0x00, 0x86,
  0x02, 0x04, 0x04, 0x0C, 0x18, 0x08, 0x20, 0x18, 0xC0, 0x11, 0x00, 0x36,
  0x00, 0x28, 0x00, 0x70, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x7F,
  0xFD, 0xFF, 0xF0, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0xFC, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00,
  0x80, 0x10, 0x04, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06,
  0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x60, 0x08, 0x03, 0xFF, 0xFC, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0x01,
  0x00, 0x03, 0x00, 0x0A, 0x00, 0x36, 0x00, 0x44, 0x01, 0x8C, 0x02, 0x08,
  0x0C, 0x18, 0x10, 0x10, 0x60, 0x30, 0x80, 0x23, 0x00, 0x64, 0x00, 0x58,
  0x00, 0xC0, 0xFF, 0xF8, 0xC0, 0x83, 0x06, 0x0C, 0x07, 0x83, 0x8E, 0x20,
  0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x07, 0xF1, 0x81, 0x60,
  0x14, 0x01, 0x40, 0x3C, 0x03, 0x40, 0x34, 0x05, 0x60, 0xD3, 0xF9, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x11, 0xF0,
  0x98, 0xC5, 0x01, 0x30, 0x0D, 0x80, 0x28, 0x01, 0x40, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x28, 0x01, 0x60, 0x1B, 0x00,
  0x94, 0x0C, 0x9F, 0x80, 0x07, 0xC3, 0x9C, 0xC0, 0x30, 0x04, 0x01, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x30, 0x23, 0xFC, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0xE1, 0x19, 0xC9, 0x01, 0x50, 0x0B, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x3C, 0x01, 0xA0, 0x0D, 0x80, 0xA6, 0x0D, 0x1F, 0x88, 0x0F, 0x01,
  0xDC, 0x20, 0x64, 0x02, 0x40, 0x3C, 0x01, 0x80, 0x18, 0x01, 0xFF, 0xF8,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x11,
  0xFE, 0x07, 0xC3, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0xFF,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x00, 0x0F, 0x01, 0xC6,
  0x48, 0x0A, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xE0, 0x0D, 0x00, 0x6C, 0x05, 0x30,
  0x48, 0xFC, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06,
  0x70, 0xE0, 0xFC, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x70, 0x99, 0xCA, 0x06, 0xC0, 0x2C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x74, 0x01, 0x55, 0x55, 0x55, 0x55,
  0x08, 0xC2, 0x00, 0x00, 0x01, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x8E, 0x5C, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0xD0, 0x32, 0x04, 0x41,
  0x08, 0x41, 0x18, 0x26, 0x04, 0xC0, 0xAC, 0x18, 0x82, 0x18, 0x41, 0x88,
  0x11, 0x03, 0x20, 0x24, 0x02, 0x80, 0x60, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0x07, 0x8B, 0x18, 0xCE, 0xA0, 0xD0, 0x2C, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x0F, 0x09, 0x9C, 0xA0,
  0x6C, 0x02, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x07,
  0x80, 0xC7, 0x08, 0x0C, 0x80, 0x2C, 0x01, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x0D, 0x00, 0x4C,
  0x06, 0x30, 0x60, 0xFE, 0x00, 0x07, 0x04, 0xC6, 0x28, 0x09, 0x80, 0x6C,
  0x01, 0x40, 0x0A, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xE0, 0x0B, 0x00, 0xDC, 0x04, 0xB0, 0x64, 0xFE, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x00,
  0x0F, 0x01, 0xCE, 0x48, 0x0A, 0x80, 0x5C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00,
  0x6C, 0x05, 0x30, 0x48, 0xFC, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x0F, 0x9B, 0xA0, 0xC0, 0xC0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x0F, 0x87, 0x1D, 0x80, 0x20, 0x04, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x03, 0x00, 0x30, 0x02, 0x00, 0x40, 0x08, 0x03, 0xC0,
  0xCF, 0xF0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x07, 0xFC, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x80, 0x7C, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xF0, 0x1A,
  0x05, 0x3F, 0x20, 0xC0, 0x1A, 0x00, 0x90, 0x04, 0xC0, 0x62, 0x02, 0x10,
  0x10, 0xC1, 0x82, 0x08, 0x10, 0x40, 0xC6, 0x02, 0x20, 0x11, 0x00, 0xD8,
  0x02, 0x80, 0x14, 0x00, 0xA0, 0x02, 0x00, 0xC0, 0x30, 0x1A, 0x01, 0x80,
  0x98, 0x14, 0x04, 0xC0, 0xB0, 0x22, 0x04, 0x82, 0x10, 0x64, 0x10, 0xC2,
  0x20, 0x82, 0x11, 0x84, 0x10, 0x84, 0x40, 0x88, 0x22, 0x06, 0x41, 0x10,
  0x12, 0x04, 0x80, 0xB0, 0x28, 0x05, 0x01, 0x40, 0x38, 0x0E, 0x00, 0xC0,
  0x30, 0x04, 0x01, 0x00, 0xC0, 0x36, 0x06, 0x20, 0x43, 0x0C, 0x18, 0x80,
  0x90, 0x0F, 0x00, 0x60, 0x06, 0x00, 0xF0, 0x09, 0x01, 0x88, 0x30, 0xC2,
  0x04, 0x60, 0x64, 0x02, 0x80, 0x10, 0xC0, 0x0A, 0x00, 0xD8, 0x04, 0x40,
  0x22, 0x03, 0x18, 0x10, 0x40, 0x82, 0x0C, 0x18, 0x40, 0x42, 0x02, 0x20,
  0x11, 0x00, 0x48, 0x02, 0x80, 0x14, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x13, 0x00, 0xF0, 0x00, 0x7F,
  0xE0, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xFF, 0xE0, 0x00,
  0x83, 0xC3, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x80, 0x83, 0x80, 0xE0, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xC0, 0x78, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0x40, 0x30, 0x0E, 0x07, 0x04, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x0F, 0x00, 0x7C, 0x0C,
  0x38, 0xE0, 0x3C,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 24, 7, 3, -24 },
  { 7, 7, 9, 11, 2, -24 },
  { 15, 17, 24, 19, 1, -24 },
  { 66, 12, 27, 17, 2, -25 },
  { 107, 20, 24, 24, 2, -24 },
  { 167, 17, 24, 20, 2, -24 },
  { 218, 2, 9, 6, 2, -24 },
  { 221, 7, 29, 9, 1, -24 },
  { 247, 6, 29, 9, 1, -24 },
  { 269, 12, 12, 16, 2, -25 },
  { 287, 14, 15, 17, 1, -19 },
  { 314, 3, 8, 6, 1, -4 },
  { 317, 8, 2, 10, 1, -10 },
  { 319, 2, 2, 7, 3, -2 },
  { 320, 10, 24, 11, 1, -24 },
  { 350, 13, 24, 17, 2, -24 },
  { 389, 7, 24, 17, 3, -24 },
  { 410, 13, 24, 17, 2, -24 },
  { 449, 14, 24, 17, 1, -24 },
  { 491, 15, 24, 17, 1, -24 },
  { 536, 13, 24, 17, 2, -24 },
  { 575, 13, 24, 17, 2, -24 },
  { 614, 13, 24, 17, 2, -24 },
  { 653, 13, 24, 17, 2, -24 },
  { 692, 13, 24, 17, 2, -24 },
  { 731, 2, 18, 7, 3, -18 },
  { 736, 4, 22, 7, 1, -18 },
  { 747, 14, 14, 17, 1, -19 },
  { 772, 13, 8, 17, 2, -16 },
  { 785, 14, 14, 17, 1, -19 },
  { 810, 10, 24, 12, 1, -24 },
  { 840, 22, 27, 26, 2, -24 },
  { 915, 17, 24, 17, 0, -24 },
  { 966, 14, 24, 18, 3, -24 },
  { 1008, 15, 24, 18, 2, -24 },
  { 1053, 15, 24, 20, 3, -24 },
  { 1098, 11, 24, 16, 3, -24 },
  { 1131, 11, 24, 15, 3, -24 },
  { 1164, 17, 24, 21, 2, -24 },
  { 1215, 15, 24, 21, 3, -24 },
  { 1260, 5, 24, 9, 2, -24 },
  { 1275, 7, 30, 7, -3, -24 },
  { 1302, 14, 24, 17, 3, -24 },
  { 1344, 11, 24, 15, 3, -24 },
  { 1377, 20, 24, 26, 3, -24 },
  { 1437, 15, 24, 21, 3, -24 },
  { 1482, 18, 24, 22, 2, -24 },
  { 1536, 12, 24, 17, 3, -24 },
  { 1572, 18, 30, 22, 2, -24 },
  { 1640, 14, 24, 17, 3, -24 },
  { 1682, 13, 24, 16, 2, -24 },
  { 1721, 15, 24, 15, 0, -24 },
  { 1766, 15, 24, 21, 3, -24 },
  { 1811, 17, 24, 17, 0, -24 },
  { 1862, 25, 24, 26, 1, -24 },
  { 1937, 15, 24, 15, 0, -24 },
  { 1982, 15, 24, 15, 0, -24 },
  { 2027, 14, 24, 16, 1, -24 },
  { 2069, 6, 29, 10, 3, -24 },
  { 2091, 10, 24, 11, 1, -24 },
  { 2121, 7, 29, 10, 1, -24 },
  { 2147, 15, 14, 17, 1, -24 },
  { 2174, 13, 1, 13, 0, 3 },
  { 2176, 6, 5, 8, 1, -25 },
  { 2180, 12, 18, 15, 1, -18 },
  { 2207, 13, 25, 18, 3, -25 },
  { 2248, 11, 18, 14, 2, -18 },
  { 2273, 13, 25, 18, 2, -25 },
  { 2314, 12, 18, 16, 2, -18 },
  { 2341, 10, 25, 9, 0, -25 },
  { 2373, 13, 26, 18, 2, -18 },
  { 2416, 12, 25, 17, 3, -25 },
  { 2454, 2, 24, 7, 2, -24 },
  { 2460, 5, 32, 7, -1, -24 },
  { 2480, 11, 25, 14, 3, -25 },
  { 2515, 1, 25, 7, 3, -25 },
  { 2519, 20, 18, 26, 3, -18 },
  { 2564, 12, 18, 17, 3, -18 },
  { 2591, 13, 18, 17, 2, -18 },
  { 2621, 13, 26, 18, 3, -18 },
  { 2664, 13, 26, 18, 2, -18 },
  { 2707, 8, 18, 11, 3, -18 },
  { 2725, 11, 18, 14, 1, -18 },
  { 2750, 9, 22, 10, 0, -22 },
  { 2775, 11, 17, 17, 3, -17 },
  { 2799, 13, 17, 13, 0, -17 },
  { 2827, 21, 17, 21, 0, -17 },
  { 2872, 12, 17, 14, 1, -17 },
  { 2898, 13, 25, 13, 0, -17 },
  { 2939, 11, 17, 13, 1, -17 },
  { 2963, 9, 29, 11, 1, -24 },
  { 2996, 1, 33, 16, 7, -25 },
  { 3001, 9, 29, 11, 1, -24 },
  { 3034, 13, 3, 17, 2, -13 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight33pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT33PT7B_H_
