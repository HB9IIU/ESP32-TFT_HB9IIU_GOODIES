#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT27PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x55, 0x60, 0x3C, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x04,
  0x20, 0x10, 0x80, 0x42, 0x02, 0x08, 0x08, 0x20, 0x21, 0x07, 0xFF, 0xC2,
  0x10, 0x08, 0x40, 0x41, 0x01, 0x04, 0x04, 0x20, 0xFF, 0xF8, 0x42, 0x01,
  0x08, 0x08, 0x20, 0x20, 0x80, 0x84, 0x02, 0x10, 0x00, 0x04, 0x00, 0x80,
  0x7C, 0x12, 0x64, 0x40, 0x88, 0x21, 0x06, 0x20, 0x44, 0x0C, 0x80, 0x70,
  0x03, 0x00, 0x58, 0x08, 0x81, 0x08, 0x21, 0x04, 0x20, 0x8C, 0x11, 0x7F,
  0xC0, 0x40, 0x08, 0x01, 0x00, 0x10, 0x00, 0x16, 0x06, 0x10, 0x82, 0x08,
  0x41, 0x04, 0x21, 0x04, 0x10, 0x82, 0x08, 0x81, 0x04, 0x40, 0x42, 0x46,
  0x21, 0x2C, 0x90, 0xA4, 0x25, 0x92, 0x11, 0x12, 0x08, 0x09, 0x04, 0x08,
  0x82, 0x04, 0x41, 0x04, 0x20, 0x82, 0x08, 0x42, 0x04, 0x41, 0x01, 0xE0,
  0x02, 0x00, 0x33, 0x00, 0x42, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x04,
  0x20, 0x08, 0xC0, 0x0B, 0x00, 0x18, 0x00, 0x58, 0x01, 0x18, 0x24, 0x10,
  0x48, 0x11, 0x20, 0x12, 0x40, 0x1C, 0xC0, 0x30, 0x80, 0x71, 0x81, 0x20,
  0xFC, 0x30, 0xFE, 0x18, 0x88, 0x44, 0x21, 0x08, 0x84, 0x21, 0x08, 0x42,
  0x08, 0x42, 0x10, 0x42, 0x08, 0x20, 0xC2, 0x08, 0x41, 0x08, 0x41, 0x08,
  0x42, 0x10, 0x84, 0x23, 0x10, 0x84, 0x42, 0x23, 0x00, 0x04, 0x01, 0x00,
  0x40, 0x10, 0xE4, 0xC7, 0xC0, 0xA0, 0x28, 0x11, 0x08, 0x20, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xF0, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x69, 0x25, 0x00, 0xFC, 0xF0, 0x01,
  0x80, 0x80, 0x40, 0x40, 0x20, 0x30, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02,
  0x01, 0x01, 0x80, 0x80, 0x40, 0x40, 0x20, 0x30, 0x00, 0x04, 0x03, 0x70,
  0x83, 0x10, 0x24, 0x02, 0x80, 0x50, 0x0A, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x44, 0x08, 0xC2, 0x0F,
  0x80, 0x0C, 0x52, 0x71, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x40, 0x04, 0x07, 0x71, 0x03, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03,
  0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x7F, 0xF0, 0x04, 0x0F, 0x73, 0x03,
  0x00, 0x20, 0x04, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x80, 0xE0, 0x7E, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0A, 0x03, 0x3F, 0x80,
  0x00, 0x80, 0x18, 0x02, 0x80, 0x28, 0x04, 0x80, 0xC8, 0x08, 0x81, 0x08,
  0x10, 0x82, 0x08, 0x40, 0x84, 0x08, 0x80, 0x8F, 0xFF, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x7F, 0x90, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x60, 0xE7, 0x00, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0xA0, 0x6F, 0xE0, 0x01, 0x07, 0x23, 0x01, 0x80, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x9E, 0x28, 0x6C, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x50, 0x16, 0x08, 0xFC, 0xFF, 0xE0, 0x04, 0x01, 0x80, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x00, 0x04, 0x03, 0x30,
  0x81, 0x20, 0x34, 0x02, 0x80, 0x50, 0x11, 0x02, 0x11, 0x81, 0xC0, 0x6C,
  0x10, 0x64, 0x06, 0x80, 0x70, 0x0C, 0x01, 0x40, 0x28, 0x05, 0x81, 0x0F,
  0xC0, 0x04, 0x07, 0x71, 0x83, 0x20, 0x24, 0x05, 0x00, 0x60, 0x0C, 0x01,
  0xC0, 0x28, 0x0D, 0x01, 0x98, 0xD0, 0xC2, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x40, 0x10, 0x04, 0x3F, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x6C, 0x00, 0x00,
  0x00, 0x34, 0x92, 0x80, 0x00, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x00, 0x10, 0xEE, 0x02, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02,
  0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x00, 0x00, 0x00, 0x30, 0x30, 0x03,
  0xFC, 0x00, 0x80, 0x40, 0x60, 0x06, 0x08, 0x00, 0x42, 0x00, 0x04, 0xC0,
  0xF0, 0x90, 0x62, 0x12, 0x10, 0x41, 0x42, 0x08, 0x30, 0x41, 0x06, 0x10,
  0x20, 0xC2, 0x04, 0x18, 0x40, 0x84, 0x84, 0x30, 0x90, 0x85, 0x12, 0x0F,
  0x3C, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x28, 0x01, 0x20, 0x04,
  0x80, 0x13, 0x00, 0x84, 0x02, 0x10, 0x08, 0x60, 0x40, 0x81, 0x02, 0x07,
  0xF8, 0x20, 0x10, 0x80, 0x42, 0x01, 0x10, 0x02, 0x40, 0x0B, 0x00, 0x28,
  0x00, 0x40, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14,
  0x04, 0xFF, 0x10, 0xF2, 0x03, 0x40, 0x28, 0x07, 0x00, 0x60, 0x1C, 0x02,
  0x80, 0x50, 0x33, 0xF8, 0x00, 0x01, 0x00, 0xE7, 0x30, 0x02, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x00, 0xFF, 0xFF,
  0x08, 0x08, 0x80, 0x48, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x28, 0x06, 0x80,
  0x48, 0x18, 0xFE, 0x00, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0xFF, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x3F, 0xE0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x7F, 0xA0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x00,
  0x00, 0x80, 0x39, 0xE1, 0x00, 0x88, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x1F, 0xE0, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x70, 0x01, 0x40, 0x04, 0x80, 0x11, 0x80, 0x43, 0xFE, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xFF,
  0xF8, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x3E, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x0C, 0x29, 0xB8, 0x80, 0xD0,
  0x12, 0x04, 0x41, 0x08, 0x41, 0x18, 0x26, 0x04, 0x80, 0xB0, 0x1B, 0x02,
  0x20, 0x42, 0x08, 0x41, 0x04, 0x20, 0x44, 0x08, 0x80, 0x90, 0x1A, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0xE0, 0x80,
  0x03, 0xC0, 0x05, 0xC0, 0x05, 0xC0, 0x05, 0xA0, 0x09, 0xA0, 0x09, 0xB0,
  0x09, 0x90, 0x11, 0x90, 0x11, 0x88, 0x31, 0x88, 0x21, 0x88, 0x21, 0x84,
  0x41, 0x84, 0x41, 0x84, 0x41, 0x82, 0x81, 0x82, 0x81, 0x83, 0x81, 0x81,
  0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1A, 0x01, 0xA0, 0x19, 0x01, 0x98, 0x18,
  0x81, 0x84, 0x18, 0x41, 0x82, 0x18, 0x21, 0x81, 0x18, 0x19, 0x80, 0x98,
  0x05, 0x80, 0x58, 0x03, 0x80, 0x30, 0x01, 0x00, 0x39, 0xC0, 0xC0, 0x42,
  0x00, 0x44, 0x00, 0x90, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x60, 0x02,
  0x40, 0x08, 0xC0, 0x30, 0xC0, 0xC0, 0x7E, 0x00, 0xFE, 0x20, 0x68, 0x0A,
  0x02, 0x80, 0x60, 0x18, 0x0E, 0x02, 0x80, 0xA0, 0xCF, 0xC2, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x01, 0x00, 0x39, 0xC0,
  0xC0, 0x42, 0x00, 0x44, 0x00, 0x90, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80,
  0x05, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x50, 0x00, 0xA0, 0x01,
  0x60, 0x02, 0x40, 0x08, 0xC0, 0x30, 0xC0, 0xC0, 0x7E, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0xFF, 0x10, 0x32, 0x02, 0x40,
  0x68, 0x05, 0x00, 0xA0, 0x24, 0x04, 0x81, 0x9F, 0xC2, 0x10, 0x42, 0x08,
  0x21, 0x06, 0x20, 0x44, 0x0C, 0x80, 0x90, 0x1A, 0x01, 0x80, 0x06, 0x07,
  0xBD, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x03, 0x00,
  0x1C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0A, 0x03,
  0x7F, 0x80, 0xFF, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x28, 0x02, 0x40, 0x11, 0x01,
  0x07, 0xF0, 0x80, 0x0D, 0x00, 0x24, 0x00, 0x90, 0x04, 0x20, 0x10, 0x80,
  0x42, 0x02, 0x0C, 0x08, 0x10, 0x20, 0x41, 0x01, 0x84, 0x02, 0x10, 0x08,
  0x80, 0x32, 0x00, 0x48, 0x01, 0x40, 0x05, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x40, 0x18, 0x06, 0x01, 0x80, 0x60, 0x2C, 0x0A, 0x02, 0x40, 0xA0,
  0x24, 0x09, 0x02, 0x40, 0x90, 0x46, 0x11, 0x04, 0x21, 0x10, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x83, 0x20, 0x88, 0x12, 0x0C, 0x81, 0x20, 0x48, 0x12,
  0x05, 0x01, 0xC0, 0x50, 0x0C, 0x05, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00,
  0x40, 0x32, 0x02, 0x20, 0x61, 0x04, 0x10, 0x80, 0x88, 0x09, 0x00, 0x50,
  0x06, 0x00, 0x60, 0x05, 0x00, 0x90, 0x08, 0x81, 0x08, 0x10, 0x42, 0x04,
  0x60, 0x24, 0x03, 0xC0, 0x10, 0xC0, 0x14, 0x02, 0x40, 0x22, 0x04, 0x20,
  0x41, 0x08, 0x10, 0x80, 0x98, 0x09, 0x00, 0x70, 0x06, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0xFF, 0xE0,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x03, 0xFF,
  0x80, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0xC0, 0x20, 0x18, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08,
  0x04, 0x01, 0x00, 0x80, 0x60, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xE0, 0x06, 0x00, 0x60, 0x09,
  0x00, 0x90, 0x10, 0x81, 0x08, 0x20, 0x42, 0x04, 0x40, 0x24, 0x02, 0x80,
  0x10, 0xFF, 0xE0, 0x82, 0x08, 0x20, 0x80, 0x0C, 0x1C, 0xC0, 0x08, 0x02,
  0x00, 0xC0, 0x10, 0x04, 0x7F, 0x60, 0x50, 0x38, 0x0E, 0x03, 0x80, 0xD0,
  0x53, 0xE4, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x21, 0x04,
  0xDC, 0xA0, 0xD8, 0x0B, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x38, 0x0B, 0x01, 0x50, 0x49, 0xF0, 0x03, 0x07, 0x32, 0x01, 0x80,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0xF8, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0x08,
  0xCD, 0x20, 0x68, 0x0D, 0x00, 0xA0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0x40, 0x28, 0x05, 0x01, 0x90, 0x51, 0xF2, 0x04, 0x03, 0x30, 0x83, 0x20,
  0x24, 0x04, 0x80, 0x70, 0x0F, 0xFF, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x47, 0xF0, 0x07, 0x09, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFE,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x04, 0x03, 0x34, 0x81, 0xA0, 0x34, 0x02, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x05, 0x00, 0xA0, 0x14, 0x06, 0x41, 0x47, 0xC8, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x27, 0xB8, 0x08, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x42, 0x6E, 0xA0, 0xB0, 0x1C, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0xB0,
  0x0A, 0xAA, 0xAA, 0xAA, 0x10, 0xC0, 0x00, 0x00, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x15, 0x90, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x03, 0x02, 0x83, 0x43, 0x21, 0x11, 0x09, 0x05,
  0x43, 0xA1, 0x88, 0x86, 0x41, 0x20, 0x50, 0x28, 0x08, 0xFF, 0xFF, 0xF8,
  0x0C, 0x04, 0x59, 0x99, 0xA8, 0x70, 0x58, 0x18, 0x18, 0x08, 0x0C, 0x04,
  0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30,
  0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x02, 0x06, 0x26, 0xEA, 0x0B,
  0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x02, 0x01, 0x98, 0x20, 0x44, 0x02, 0x40, 0x24, 0x02,
  0xC0, 0x2C, 0x03, 0xC0, 0x34, 0x02, 0x40, 0x24, 0x02, 0x60, 0x62, 0x04,
  0x1F, 0x80, 0x06, 0x13, 0x72, 0x83, 0x60, 0x2C, 0x07, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x2C, 0x05, 0x41, 0x27, 0xC4, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x06, 0x03, 0x74, 0x81, 0xA0,
  0x34, 0x02, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x05, 0x00, 0xA0, 0x14,
  0x06, 0x41, 0x47, 0xC8, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x05, 0x3E, 0x86, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x00, 0x08, 0x39, 0xD0, 0x10, 0x08, 0x02, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x20, 0x10, 0x0C, 0x0B, 0xF8, 0x20, 0x40, 0x81, 0x0F, 0xE4,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x10, 0x3C, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0F, 0x03, 0x41, 0x4F, 0x90, 0x80, 0x68, 0x09, 0x01, 0x20, 0x42, 0x08,
  0x41, 0x08, 0x40, 0x88, 0x11, 0x02, 0x40, 0x28, 0x05, 0x00, 0xC0, 0x08,
  0x00, 0xC0, 0xC0, 0xA0, 0x60, 0xD0, 0x50, 0x48, 0x28, 0x22, 0x12, 0x11,
  0x09, 0x18, 0x88, 0x88, 0x44, 0x64, 0x12, 0x12, 0x0A, 0x09, 0x05, 0x05,
  0x02, 0x81, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0xC0, 0xD0, 0x62, 0x10, 0x88,
  0x12, 0x07, 0x00, 0xC0, 0x30, 0x16, 0x0C, 0x82, 0x11, 0x04, 0xC0, 0xA0,
  0x30, 0xC0, 0x68, 0x09, 0x01, 0x30, 0x62, 0x08, 0x41, 0x0C, 0x40, 0x88,
  0x11, 0x02, 0x40, 0x28, 0x05, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x40, 0x58, 0x04, 0x00, 0x7F, 0x80, 0x80, 0x80, 0x40, 0x40,
  0x60, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x0C, 0x07, 0xFC, 0x0E, 0x30,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x86, 0x02, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x03, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0,
  0x20, 0x40, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x10, 0x20, 0x30, 0x81, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x02, 0x38, 0x00, 0x38, 0x1C, 0x63, 0x81,
  0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 19, 6, 2, -19 },
  { 6, 5, 7, 9, 2, -19 },
  { 11, 14, 19, 15, 1, -19 },
  { 45, 11, 23, 14, 1, -21 },
  { 77, 17, 20, 20, 1, -20 },
  { 120, 15, 20, 16, 1, -20 },
  { 158, 1, 7, 5, 2, -19 },
  { 159, 5, 23, 7, 1, -19 },
  { 174, 5, 23, 7, 1, -19 },
  { 189, 10, 10, 13, 1, -21 },
  { 202, 12, 13, 14, 1, -16 },
  { 222, 3, 6, 5, 1, -3 },
  { 225, 6, 1, 8, 1, -8 },
  { 226, 2, 2, 6, 2, -2 },
  { 227, 9, 19, 9, 0, -19 },
  { 249, 11, 20, 14, 1, -20 },
  { 277, 6, 19, 14, 2, -19 },
  { 292, 11, 20, 14, 1, -20 },
  { 320, 11, 20, 14, 1, -20 },
  { 348, 12, 19, 14, 1, -19 },
  { 377, 10, 19, 14, 2, -19 },
  { 401, 10, 20, 14, 2, -20 },
  { 426, 11, 19, 14, 1, -19 },
  { 453, 11, 20, 14, 1, -20 },
  { 481, 11, 20, 14, 1, -20 },
  { 509, 2, 14, 6, 2, -14 },
  { 513, 3, 17, 6, 1, -14 },
  { 520, 12, 12, 14, 1, -16 },
  { 538, 12, 7, 14, 1, -13 },
  { 549, 12, 12, 14, 1, -16 },
  { 567, 8, 20, 10, 1, -20 },
  { 587, 19, 22, 21, 1, -19 },
  { 640, 14, 19, 14, 0, -19 },
  { 674, 11, 19, 15, 3, -19 },
  { 701, 12, 20, 15, 2, -20 },
  { 731, 12, 19, 17, 3, -19 },
  { 760, 9, 19, 13, 3, -19 },
  { 782, 9, 19, 12, 3, -19 },
  { 804, 14, 20, 18, 2, -20 },
  { 839, 12, 19, 17, 3, -19 },
  { 868, 5, 19, 7, 1, -19 },
  { 880, 6, 24, 6, -2, -19 },
  { 898, 11, 19, 14, 3, -19 },
  { 925, 9, 19, 12, 3, -19 },
  { 947, 16, 19, 21, 3, -19 },
  { 985, 12, 19, 17, 3, -19 },
  { 1014, 15, 20, 18, 2, -20 },
  { 1052, 10, 19, 14, 3, -19 },
  { 1076, 15, 25, 18, 2, -20 },
  { 1123, 11, 19, 14, 3, -19 },
  { 1150, 11, 20, 13, 1, -20 },
  { 1178, 12, 19, 12, 0, -19 },
  { 1207, 13, 19, 17, 2, -19 },
  { 1238, 14, 19, 14, 0, -19 },
  { 1272, 20, 19, 22, 1, -19 },
  { 1320, 12, 19, 12, 0, -19 },
  { 1349, 12, 19, 12, 0, -19 },
  { 1378, 11, 19, 13, 1, -19 },
  { 1405, 6, 23, 8, 2, -19 },
  { 1423, 9, 19, 9, 0, -19 },
  { 1445, 5, 23, 8, 1, -19 },
  { 1460, 12, 11, 14, 1, -19 },
  { 1477, 11, 1, 11, 0, 2 },
  { 1479, 5, 5, 7, 1, -21 },
  { 1483, 10, 15, 13, 1, -15 },
  { 1502, 11, 21, 14, 2, -21 },
  { 1531, 10, 15, 11, 1, -15 },
  { 1550, 11, 21, 14, 1, -21 },
  { 1579, 11, 15, 13, 1, -15 },
  { 1600, 8, 21, 7, 0, -21 },
  { 1621, 11, 22, 14, 1, -15 },
  { 1652, 10, 21, 14, 2, -21 },
  { 1679, 2, 20, 6, 2, -20 },
  { 1684, 5, 27, 6, -1, -20 },
  { 1701, 9, 21, 11, 2, -21 },
  { 1725, 1, 21, 5, 2, -21 },
  { 1728, 17, 15, 21, 2, -15 },
  { 1760, 10, 15, 14, 2, -15 },
  { 1779, 12, 15, 14, 1, -15 },
  { 1802, 11, 21, 14, 2, -15 },
  { 1831, 11, 21, 14, 1, -15 },
  { 1860, 7, 15, 9, 2, -15 },
  { 1874, 9, 15, 11, 1, -15 },
  { 1891, 7, 18, 8, 0, -18 },
  { 1907, 10, 14, 14, 2, -14 },
  { 1925, 11, 14, 11, 0, -14 },
  { 1945, 17, 14, 17, 0, -14 },
  { 1975, 10, 14, 12, 1, -14 },
  { 1993, 11, 21, 11, 0, -14 },
  { 2022, 9, 14, 11, 1, -14 },
  { 2038, 7, 23, 9, 1, -19 },
  { 2059, 1, 28, 13, 6, -21 },
  { 2063, 7, 23, 9, 1, -19 },
  { 2084, 12, 3, 14, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight27pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT27PT7B_H_
