#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT51PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight51pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x80,
  0x00, 0x5F, 0xF0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01,
  0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x02, 0x00, 0x80, 0x00,
  0xC0, 0x10, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xF0, 0x0C,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x80, 0x30, 0x00, 0x10, 0x04, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x40, 0x18, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x40, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x20, 0x0C, 0x00, 0x04, 0x01, 0x00, 0x01,
  0x80, 0x20, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30,
  0x00, 0x18, 0x06, 0x00, 0x02, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0x3C, 0x8F, 0x8C, 0x10,
  0x23, 0x02, 0x00, 0xC0, 0x40, 0x18, 0x08, 0x03, 0x01, 0x00, 0x60, 0x20,
  0x0C, 0x04, 0x01, 0x80, 0x80, 0x30, 0x10, 0x07, 0x02, 0x00, 0x70, 0x40,
  0x07, 0x08, 0x00, 0x79, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x13, 0xC0, 0x02, 0x1C, 0x00, 0x41, 0xC0, 0x08, 0x1C, 0x01, 0x01,
  0x80, 0x20, 0x30, 0x04, 0x06, 0x00, 0x80, 0xC0, 0x10, 0x18, 0x02, 0x03,
  0x00, 0x40, 0x60, 0x08, 0x1A, 0x01, 0x07, 0x78, 0x23, 0xCF, 0xFF, 0xE0,
  0x1F, 0xE0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0x00, 0xC3, 0x80, 0x0C, 0x03,
  0x03, 0x00, 0x18, 0x04, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x01, 0x80,
  0x20, 0x30, 0x03, 0x00, 0x40, 0xC0, 0x04, 0x00, 0x81, 0x80, 0x08, 0x01,
  0x06, 0x00, 0x18, 0x02, 0x0C, 0x00, 0x30, 0x0C, 0x10, 0x00, 0x60, 0x18,
  0x61, 0xF8, 0xC0, 0x30, 0x87, 0x39, 0x80, 0x63, 0x18, 0x19, 0x80, 0x86,
  0x30, 0x33, 0x03, 0x18, 0xC0, 0x23, 0x0C, 0x31, 0x80, 0x67, 0xF8, 0xC3,
  0x00, 0xC3, 0xC1, 0x84, 0x01, 0x80, 0x06, 0x08, 0x03, 0x00, 0x0C, 0x30,
  0x06, 0x00, 0x30, 0x60, 0x0C, 0x00, 0x60, 0xC0, 0x18, 0x01, 0x81, 0x80,
  0x30, 0x03, 0x01, 0x00, 0x60, 0x0C, 0x02, 0x00, 0xC0, 0x18, 0x06, 0x01,
  0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x04, 0x01, 0x00, 0x10, 0x18,
  0x06, 0x00, 0x30, 0x30, 0x08, 0x00, 0x31, 0xC0, 0x30, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x18,
  0x1C, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x30, 0x03, 0x00,
  0x06, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00,
  0x30, 0x00, 0x60, 0x06, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x18, 0x00, 0x01,
  0x83, 0x80, 0x18, 0x60, 0x38, 0x03, 0x18, 0x03, 0x00, 0x67, 0x00, 0x30,
  0x0C, 0xC0, 0x03, 0x03, 0x18, 0x00, 0x30, 0x63, 0x00, 0x07, 0x0C, 0x60,
  0x00, 0x73, 0x0C, 0x00, 0x06, 0xE1, 0x80, 0x00, 0x78, 0x30, 0x00, 0x06,
  0x06, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x7E, 0x0E, 0x00, 0x1C, 0xE0, 0xE0,
  0x0F, 0x0C, 0x0F, 0x0F, 0x80, 0xC0, 0xFF, 0xC0, 0x0E, 0x00, 0x80, 0x00,
  0x00, 0xFF, 0xFA, 0xAA, 0x80, 0x01, 0xC0, 0xC0, 0x30, 0x18, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x38, 0x07,
  0xE0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06,
  0x03, 0x03, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x30, 0x18, 0x18,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x20, 0x30, 0x17, 0x86, 0x0E, 0x7C, 0xCF, 0xA0,
  0xFF, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x33, 0x00, 0x06, 0x30, 0x01,
  0x86, 0x00, 0x60, 0x60, 0x1C, 0x06, 0x03, 0x00, 0xE0, 0x20, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x19, 0xCE, 0x63, 0x18, 0xCC, 0x63,
  0x11, 0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0x5F, 0xF0, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0E, 0x07, 0x01,
  0xC0, 0x38, 0x38, 0x01, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x36,
  0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x0C,
  0x30, 0x00, 0xC1, 0x80, 0x18, 0x0C, 0x03, 0x00, 0x79, 0xE0, 0x03, 0xFC,
  0x00, 0x01, 0xC0, 0xF0, 0x7C, 0x3B, 0x38, 0xDC, 0x3E, 0x0F, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x03, 0xF0,
  0x01, 0xFF, 0xC0, 0x78, 0x0F, 0x0E, 0x00, 0x38, 0x40, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xF8,
  0x0F, 0x00, 0xE1, 0xE0, 0x03, 0x84, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x30, 0x00, 0x71, 0xF8, 0x1F, 0x03, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x60, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0x60, 0x01, 0x80, 0x60, 0x03,
  0x00, 0x60, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x0C,
  0x00, 0x60, 0x18, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x60,
  0x00, 0x60, 0xE0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x3F, 0xFF, 0xC3, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x67, 0xF8, 0x07, 0xFF, 0xE0, 0x30, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0xCC, 0x00, 0x38, 0xFC, 0x3E, 0x03, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0xFC, 0x03, 0xC0, 0x20, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x3F, 0xE0, 0xC7, 0x87, 0x8C, 0xC0, 0x1C, 0xD8, 0x00, 0xEF, 0x00,
  0x06, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x36,
  0x00, 0x03, 0x60, 0x00, 0x33, 0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x0C,
  0x0C, 0x01, 0xC0, 0x70, 0x78, 0x03, 0xFE, 0x00, 0x02, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x1C, 0x07, 0x83,
  0x80, 0x1C, 0x30, 0x00, 0xC6, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00,
  0xC3, 0x80, 0x1C, 0x1C, 0x03, 0x80, 0xF0, 0xE0, 0x03, 0xBC, 0x00, 0x0F,
  0x00, 0x03, 0xFC, 0x00, 0xF0, 0xE0, 0x1C, 0x03, 0x83, 0x80, 0x1C, 0x70,
  0x00, 0xC6, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x60, 0x00, 0x67, 0x00, 0x0E, 0x38, 0x01, 0xC1, 0xE0, 0xF8, 0x07, 0xFE,
  0x00, 0x06, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0x81, 0xE0, 0x30,
  0x03, 0x83, 0x80, 0x0C, 0x18, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x06,
  0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0D, 0x80, 0x00, 0x24, 0x00,
  0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0xEC, 0x00, 0x07, 0x60, 0x00, 0x3B,
  0x80, 0x03, 0xCC, 0x00, 0x16, 0x70, 0x01, 0xB1, 0xC0, 0x39, 0x87, 0xFF,
  0x0C, 0x0F, 0xF0, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x60,
  0x78, 0x03, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xA0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0xFF, 0x80, 0x39, 0xCE, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0xE7, 0x31, 0x8C, 0xC6,
  0x31, 0x98, 0xC4, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFF,
  0xF8, 0x70, 0x1C, 0x40, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x00, 0x63, 0x00, 0x1F, 0xE0, 0x19, 0x80, 0x1F,
  0xFC, 0x02, 0x60, 0x0E, 0x03, 0x00, 0xD8, 0x06, 0x00, 0xC0, 0x3C, 0x01,
  0x80, 0x30, 0x0F, 0x00, 0xC0, 0x0C, 0x03, 0xC0, 0x30, 0x03, 0x00, 0xF0,
  0x18, 0x00, 0xC0, 0x3C, 0x06, 0x00, 0x30, 0x0F, 0x01, 0x80, 0x0C, 0x03,
  0xC0, 0x60, 0x03, 0x00, 0xF0, 0x18, 0x00, 0xC0, 0x3C, 0x06, 0x00, 0x70,
  0x0F, 0x01, 0x80, 0x1C, 0x03, 0xC0, 0x60, 0x07, 0x00, 0xF0, 0x0C, 0x01,
  0xC0, 0x6C, 0x03, 0x00, 0xF0, 0x1B, 0x00, 0xE0, 0x64, 0x0C, 0x40, 0x1E,
  0x71, 0xCE, 0x18, 0x03, 0xF8, 0x3F, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x20, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x13, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x18, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x30, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80,
  0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x18, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x30, 0x00, 0x30,
  0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00,
  0x0C, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x06, 0x01, 0xFC, 0x30, 0x00, 0x71, 0x80,
  0x01, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x3B, 0x00, 0x00, 0xD8, 0x00, 0x06,
  0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0xCC, 0x00,
  0x06, 0x60, 0x00, 0x63, 0x00, 0x07, 0x18, 0x00, 0xE0, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x30, 0x00, 0xF1, 0x80, 0x01, 0xCC, 0x00, 0x06, 0x60, 0x00,
  0x1B, 0x00, 0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0xD8, 0x00, 0x0C, 0xC0, 0x00, 0xE6, 0x00, 0x1E, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFC, 0x07, 0x80, 0x38, 0x1C,
  0x00, 0x10, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x08, 0x0F, 0xC3, 0xF0, 0x07, 0xFF,
  0xC0, 0x00, 0x40, 0x00, 0xFF, 0xFC, 0x00, 0xC0, 0x7F, 0x00, 0xC0, 0x03,
  0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0xE0, 0xC0, 0x01, 0xC0, 0xC0, 0x07, 0x80, 0xFF, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xB0, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3F,
  0xFF, 0xD8, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xC0, 0x1F,
  0x01, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x0F, 0x00, 0x03,
  0x80, 0x7F, 0x1F, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x30, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x3E, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0xC0, 0x18, 0x06, 0x7F, 0x8F, 0xE0, 0xC0, 0x00, 0x76,
  0x00, 0x07, 0x30, 0x00, 0x71, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x60, 0x03,
  0x03, 0x00, 0x38, 0x18, 0x03, 0x80, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x30,
  0x18, 0x01, 0x81, 0x80, 0x0C, 0x1C, 0x00, 0x61, 0xC0, 0x03, 0x1C, 0x00,
  0x18, 0xE0, 0x00, 0xCF, 0x00, 0x06, 0xDC, 0x00, 0x3C, 0x70, 0x01, 0xC1,
  0x80, 0x0E, 0x0E, 0x00, 0x60, 0x30, 0x03, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0x60, 0x30, 0x03, 0x81, 0x80, 0x0C, 0x0C, 0x00,
  0x30, 0x60, 0x01, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xE6,
  0x00, 0x03, 0x30, 0x00, 0x1D, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x6F, 0x60, 0x00, 0x01, 0xBD,
  0x80, 0x00, 0x06, 0xF3, 0x00, 0x00, 0x33, 0xCC, 0x00, 0x00, 0xCF, 0x30,
  0x00, 0x03, 0x3C, 0x60, 0x00, 0x18, 0xF1, 0x80, 0x00, 0x63, 0xC6, 0x00,
  0x01, 0x0F, 0x0C, 0x00, 0x0C, 0x3C, 0x30, 0x00, 0x30, 0xF0, 0xE0, 0x01,
  0x83, 0xC1, 0x80, 0x06, 0x0F, 0x06, 0x00, 0x18, 0x3C, 0x0C, 0x00, 0xC0,
  0xF0, 0x30, 0x03, 0x03, 0xC0, 0xC0, 0x0C, 0x0F, 0x01, 0x80, 0x60, 0x3C,
  0x06, 0x01, 0x80, 0xF0, 0x18, 0x0C, 0x03, 0xC0, 0x30, 0x30, 0x0F, 0x00,
  0xC0, 0xC0, 0x3C, 0x03, 0x86, 0x00, 0xF0, 0x06, 0x18, 0x03, 0xC0, 0x18,
  0x60, 0x0F, 0x00, 0x33, 0x00, 0x3C, 0x00, 0xCC, 0x00, 0xF0, 0x03, 0x30,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7B, 0x00, 0x00, 0xF3, 0x00, 0x01,
  0xE6, 0x00, 0x03, 0xC6, 0x00, 0x07, 0x8E, 0x00, 0x0F, 0x0C, 0x00, 0x1E,
  0x1C, 0x00, 0x3C, 0x18, 0x00, 0x78, 0x18, 0x00, 0xF0, 0x38, 0x01, 0xE0,
  0x30, 0x03, 0xC0, 0x70, 0x07, 0x80, 0x60, 0x0F, 0x00, 0x60, 0x1E, 0x00,
  0xC0, 0x3C, 0x00, 0xC0, 0x78, 0x01, 0xC0, 0xF0, 0x01, 0x81, 0xE0, 0x01,
  0x83, 0xC0, 0x03, 0x07, 0x80, 0x03, 0x0F, 0x00, 0x07, 0x1E, 0x00, 0x06,
  0x3C, 0x00, 0x0E, 0x78, 0x00, 0x0C, 0xF0, 0x00, 0x0D, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x30,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x0E, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x20,
  0x00, 0xFF, 0xF8, 0x18, 0x1F, 0xC3, 0x00, 0x1E, 0x60, 0x00, 0xCC, 0x00,
  0x1D, 0x80, 0x01, 0xB0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xB0, 0x00,
  0x36, 0x00, 0x0E, 0xC0, 0x01, 0x98, 0x00, 0xE3, 0x00, 0x78, 0x7F, 0xFC,
  0x0F, 0xFC, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xC0,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x18,
  0x18, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFC, 0x06, 0x07,
  0xF8, 0x30, 0x01, 0xE1, 0x80, 0x03, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x63,
  0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00,
  0x19, 0x80, 0x00, 0xCC, 0x00, 0x0E, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18,
  0x00, 0x30, 0xC0, 0x03, 0x06, 0x00, 0x70, 0x3F, 0xFF, 0x01, 0xFF, 0xE0,
  0x0C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x80, 0xC0,
  0x0C, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x30,
  0x60, 0x00, 0xC3, 0x00, 0x07, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xE6, 0x00,
  0x03, 0x30, 0x00, 0x1D, 0x80, 0x00, 0x70, 0x01, 0xFC, 0x01, 0xFF, 0xF8,
  0x78, 0x07, 0x9C, 0x00, 0x27, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x3A, 0x00, 0x0E, 0x7F, 0x1F, 0x87, 0xFF, 0xC0, 0x01,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x1C, 0x0E, 0x00, 0x78, 0x07, 0xC3, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x08,
  0x00, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x03, 0x80, 0x06, 0x00, 0x60,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00,
  0x30, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x38,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30,
  0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x19, 0x80, 0x00, 0xE0, 0x00,
  0x33, 0x00, 0x03, 0xC0, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0xCE, 0x00,
  0x0D, 0x80, 0x03, 0x0C, 0x00, 0x1B, 0x00, 0x06, 0x18, 0x00, 0x66, 0x00,
  0x0C, 0x30, 0x00, 0xC6, 0x00, 0x18, 0x70, 0x01, 0x8C, 0x00, 0x60, 0x60,
  0x03, 0x18, 0x00, 0xC0, 0xC0, 0x0C, 0x30, 0x01, 0x81, 0x80, 0x18, 0x30,
  0x03, 0x03, 0x80, 0x30, 0x60, 0x0C, 0x03, 0x00, 0x60, 0xC0, 0x18, 0x06,
  0x01, 0x81, 0x80, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x1C, 0x06, 0x03,
  0x01, 0x80, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x30, 0x30, 0x0C, 0x06, 0x00,
  0x60, 0x60, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x30, 0x00, 0xC1, 0x80,
  0x30, 0x60, 0x01, 0x86, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x61, 0x80,
  0x06, 0x18, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x0C, 0xC0,
  0x03, 0x18, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x33, 0x00, 0x06, 0xC0,
  0x00, 0x36, 0x00, 0x0D, 0x80, 0x00, 0x68, 0x00, 0x1B, 0x00, 0x00, 0xF0,
  0x00, 0x16, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x38,
  0x60, 0x00, 0x60, 0xE0, 0x01, 0xC0, 0xC0, 0x03, 0x01, 0xC0, 0x0C, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x03, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x1B,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x60, 0x00, 0x06, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0xC1, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x03, 0x80, 0x1C, 0x03, 0x00,
  0x30, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x0C,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x19, 0x80, 0x00, 0x37, 0x00,
  0x00, 0x30, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x71, 0x80,
  0x00, 0xC3, 0x00, 0x03, 0x83, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x06, 0x00,
  0x30, 0x0C, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x18, 0x0C,
  0x00, 0x30, 0x18, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xE3, 0x80,
  0x00, 0xC6, 0x00, 0x01, 0x9C, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0xFF, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1A, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x10, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x03,
  0x03, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x00,
  0xC0, 0x30, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0x30,
  0xC0, 0x00, 0xC6, 0x00, 0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xFF,
  0xFF, 0xF8, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x03, 0x07,
  0xFC, 0x07, 0xC7, 0xC1, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x0F, 0x01, 0xFF, 0xC3, 0xF0, 0x31, 0xC0, 0x0C, 0xC0, 0x03, 0x60,
  0x00, 0xD8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x76, 0x00, 0x3D, 0x80, 0x0B, 0x70, 0x06, 0xCF, 0x07, 0x31, 0xFF, 0x0C,
  0x06, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0xC3, 0xFE, 0x0C, 0x78,
  0x78, 0xCC, 0x01, 0xCD, 0x80, 0x0C, 0xF0, 0x00, 0x6E, 0x00, 0x06, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x6E, 0x00, 0x06, 0xF0, 0x00, 0xED, 0x80, 0x0C, 0xCC, 0x03, 0x8C, 0xF0,
  0xF0, 0xC3, 0xFE, 0x00, 0x02, 0x00, 0x03, 0xFF, 0x83, 0xE3, 0xC3, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x87,
  0xC3, 0xC0, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x03, 0xFC, 0x30, 0xF0, 0xF3, 0x1C, 0x03, 0xB3, 0x80, 0x0B, 0x30, 0x00,
  0xF6, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0xF3, 0x00, 0x0B,
  0x18, 0x03, 0x30, 0xF0, 0xF3, 0x07, 0xFC, 0x30, 0x06, 0x00, 0x03, 0xFC,
  0x01, 0xE1, 0xE0, 0x70, 0x0C, 0x1C, 0x00, 0xC3, 0x00, 0x0C, 0xC0, 0x01,
  0x98, 0x00, 0x33, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x41, 0xF0, 0xF8,
  0x0F, 0xFE, 0x00, 0x10, 0x00, 0x00, 0xFC, 0x07, 0xFC, 0x1C, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x07, 0xFC, 0x30, 0xF0, 0xF3,
  0x1C, 0x01, 0xB3, 0x80, 0x0B, 0x30, 0x00, 0xF6, 0x00, 0x07, 0x60, 0x00,
  0x7E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x60, 0x00, 0x76,
  0x00, 0x07, 0x70, 0x00, 0xF3, 0x00, 0x1B, 0x18, 0x03, 0x30, 0xF0, 0xE3,
  0x07, 0xFC, 0x30, 0x04, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x60, 0x03, 0x87, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x3F, 0xE1, 0x8E, 0x1E, 0x33, 0x00, 0xE6, 0xC0, 0x0E, 0xF0,
  0x00, 0xDC, 0x00, 0x1B, 0x80, 0x03, 0x70, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x18, 0xDF, 0xE0, 0x00, 0x03, 0x6D, 0xB6,
  0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x03, 0x01, 0xC0, 0xE0,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x19, 0xFC, 0xFC, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x33, 0x00, 0x39,
  0x80, 0x18, 0xC0, 0x18, 0x60, 0x18, 0x30, 0x18, 0x18, 0x1C, 0x0C, 0x0C,
  0x06, 0x0C, 0x03, 0x0C, 0x01, 0x8E, 0x00, 0xCF, 0x80, 0x66, 0xC0, 0x36,
  0x30, 0x1E, 0x18, 0x0E, 0x06, 0x06, 0x03, 0x83, 0x00, 0xC1, 0x80, 0x30,
  0xC0, 0x18, 0x60, 0x06, 0x30, 0x03, 0x98, 0x00, 0xCC, 0x00, 0x36, 0x00,
  0x1F, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xC3, 0xFC, 0x0F, 0xF0, 0xCF, 0x1E, 0x1C, 0x3C, 0xD8, 0x06, 0x30,
  0x0C, 0xD0, 0x03, 0x60, 0x06, 0xF0, 0x03, 0x40, 0x06, 0xE0, 0x01, 0xC0,
  0x03, 0xE0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC3, 0xFE, 0x18, 0xE1, 0xE3, 0x30, 0x0E, 0x6C, 0x00, 0xEF, 0x00,
  0x0D, 0xC0, 0x01, 0xB8, 0x00, 0x37, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x03, 0xFE, 0x00, 0x78, 0x7C, 0x07,
  0x00, 0x70, 0x70, 0x01, 0x83, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x00,
  0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x66, 0x00,
  0x03, 0x30, 0x00, 0x30, 0xC0, 0x01, 0x87, 0x00, 0x18, 0x1C, 0x01, 0x80,
  0x7C, 0x78, 0x00, 0xFF, 0x80, 0x00, 0x40, 0x00, 0xC3, 0xFE, 0x0C, 0x78,
  0x78, 0xCC, 0x01, 0xCD, 0x80, 0x0C, 0xD0, 0x00, 0x6F, 0x00, 0x06, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x6F, 0x00, 0x06, 0xF0, 0x00, 0xED, 0x80, 0x0C, 0xCC, 0x03, 0x8C, 0x78,
  0xF0, 0xC3, 0xFE, 0x0C, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x30, 0xF0, 0xF3, 0x1C, 0x03, 0xB3, 0x80, 0x1B, 0x30, 0x00, 0xF6, 0x00,
  0x07, 0x60, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xE0, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0xF3, 0x00, 0x1B, 0x18, 0x03,
  0x31, 0xF0, 0xE3, 0x07, 0xFC, 0x30, 0x04, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0xC3, 0xFE, 0x3D, 0xB3, 0x01, 0xB0, 0x0D, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x0F, 0xFE, 0x0F, 0x0F,
  0x8C, 0x00, 0x4C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0xC0,
  0x06, 0x7C, 0x1E, 0x0F, 0xFE, 0x00, 0x30, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x1F, 0xFE, 0xFF, 0xF0, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x0F, 0x18, 0x3F, 0xC0, 0x30, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x15, 0x80, 0x0D, 0x70,
  0x06, 0x4F, 0x8F, 0x10, 0xFF, 0x84, 0x02, 0x00, 0xC0, 0x00, 0x36, 0x00,
  0x03, 0x60, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0C, 0x30,
  0x00, 0xC1, 0x80, 0x0C, 0x18, 0x01, 0x81, 0x80, 0x18, 0x0C, 0x01, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x06, 0x06, 0x00, 0x60, 0x60,
  0x03, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x10, 0xC0, 0x01, 0x98,
  0x00, 0x19, 0x80, 0x00, 0x98, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x13, 0x00, 0x16, 0x00, 0x66, 0x00, 0x6C, 0x00, 0xCC,
  0x00, 0xD8, 0x01, 0x98, 0x01, 0x90, 0x02, 0x18, 0x06, 0x30, 0x0C, 0x30,
  0x0C, 0x60, 0x18, 0x60, 0x18, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x40, 0xC0,
  0xC1, 0x81, 0x81, 0x81, 0x83, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x0C,
  0x06, 0x08, 0x06, 0x18, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x60, 0x18, 0x60,
  0x18, 0xC0, 0x11, 0x80, 0x31, 0x00, 0x33, 0x00, 0x66, 0x00, 0x66, 0x00,
  0xCC, 0x00, 0xD8, 0x00, 0xD8, 0x00, 0xB0, 0x01, 0xA0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x67, 0x00, 0x0C, 0x30, 0x01, 0xC1, 0x80, 0x18, 0x1C,
  0x03, 0x00, 0xC0, 0x30, 0x06, 0x06, 0x00, 0x60, 0xE0, 0x03, 0x0C, 0x00,
  0x39, 0x80, 0x01, 0x98, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x1B, 0x80, 0x01, 0x98, 0x00, 0x30, 0xC0, 0x07, 0x0C,
  0x00, 0x60, 0x60, 0x0C, 0x07, 0x01, 0xC0, 0x30, 0x18, 0x01, 0x83, 0x00,
  0x1C, 0x30, 0x00, 0xC6, 0x00, 0x06, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x36,
  0x00, 0x03, 0x60, 0x00, 0x33, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06,
  0x18, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC0, 0xC0, 0x18, 0x0C, 0x01,
  0x80, 0xC0, 0x18, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x02, 0x00, 0x30,
  0x60, 0x03, 0x06, 0x00, 0x30, 0x40, 0x01, 0x0C, 0x00, 0x18, 0xC0, 0x01,
  0x88, 0x00, 0x09, 0x80, 0x00, 0xD8, 0x00, 0x0D, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x0D, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x07, 0x80, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x1C, 0x03, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xE0,
  0x01, 0xF0, 0x07, 0xC0, 0x30, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x38,
  0x0F, 0xC0, 0x3C, 0x00, 0x3F, 0xC0, 0x05, 0xC7, 0xC0, 0x3C, 0x03, 0xE3,
  0xA0, 0x03, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 36, 11, 4, -36 },
  { 15, 9, 13, 17, 4, -36 },
  { 30, 27, 36, 29, 1, -36 },
  { 152, 19, 42, 26, 3, -39 },
  { 252, 31, 38, 37, 3, -37 },
  { 400, 27, 38, 30, 3, -37 },
  { 529, 2, 13, 9, 4, -36 },
  { 533, 10, 44, 14, 2, -36 },
  { 588, 9, 44, 14, 2, -36 },
  { 638, 19, 19, 24, 3, -39 },
  { 684, 22, 24, 26, 2, -30 },
  { 750, 5, 13, 10, 2, -6 },
  { 759, 12, 2, 15, 2, -15 },
  { 762, 3, 4, 11, 4, -4 },
  { 764, 15, 36, 17, 1, -36 },
  { 832, 20, 37, 26, 3, -37 },
  { 925, 10, 36, 26, 5, -36 },
  { 970, 20, 37, 26, 3, -37 },
  { 1063, 21, 38, 26, 2, -37 },
  { 1163, 24, 37, 26, 1, -37 },
  { 1274, 20, 37, 26, 3, -36 },
  { 1367, 20, 38, 26, 3, -37 },
  { 1462, 20, 36, 26, 3, -36 },
  { 1552, 20, 38, 26, 3, -37 },
  { 1647, 21, 38, 26, 2, -37 },
  { 1747, 3, 27, 11, 4, -27 },
  { 1758, 5, 34, 11, 2, -27 },
  { 1780, 22, 23, 26, 2, -30 },
  { 1844, 22, 12, 26, 2, -24 },
  { 1877, 22, 23, 26, 2, -30 },
  { 1941, 16, 37, 19, 1, -37 },
  { 2015, 34, 41, 40, 3, -36 },
  { 2190, 26, 36, 26, 0, -36 },
  { 2307, 21, 36, 28, 5, -36 },
  { 2402, 23, 38, 28, 3, -37 },
  { 2512, 24, 36, 32, 5, -36 },
  { 2620, 17, 36, 25, 5, -36 },
  { 2697, 17, 36, 23, 5, -36 },
  { 2774, 27, 38, 33, 3, -37 },
  { 2903, 23, 36, 32, 5, -36 },
  { 3007, 8, 36, 14, 3, -36 },
  { 3043, 11, 45, 11, -4, -36 },
  { 3105, 21, 36, 26, 5, -36 },
  { 3200, 17, 36, 23, 5, -36 },
  { 3277, 30, 36, 40, 5, -36 },
  { 3412, 23, 36, 33, 5, -36 },
  { 3516, 28, 38, 34, 3, -37 },
  { 3649, 19, 36, 26, 5, -36 },
  { 3735, 28, 46, 34, 3, -37 },
  { 3896, 21, 36, 27, 5, -36 },
  { 3991, 19, 38, 25, 3, -37 },
  { 4082, 23, 36, 23, 0, -36 },
  { 4186, 24, 37, 32, 4, -36 },
  { 4297, 26, 36, 26, 0, -36 },
  { 4414, 39, 36, 41, 1, -36 },
  { 4590, 23, 36, 23, 0, -36 },
  { 4694, 23, 36, 23, 0, -36 },
  { 4798, 21, 36, 25, 2, -36 },
  { 4893, 10, 44, 16, 4, -36 },
  { 4948, 15, 36, 17, 1, -36 },
  { 5016, 11, 44, 16, 1, -36 },
  { 5077, 22, 21, 26, 2, -37 },
  { 5135, 21, 1, 21, 0, 5 },
  { 5138, 9, 8, 13, 2, -39 },
  { 5147, 18, 28, 24, 2, -27 },
  { 5210, 20, 40, 27, 4, -39 },
  { 5310, 17, 28, 21, 3, -27 },
  { 5370, 20, 40, 27, 3, -39 },
  { 5470, 19, 28, 25, 3, -27 },
  { 5537, 15, 39, 13, 1, -39 },
  { 5611, 20, 39, 27, 3, -27 },
  { 5709, 19, 39, 27, 4, -39 },
  { 5802, 3, 37, 10, 4, -37 },
  { 5816, 9, 49, 10, -2, -37 },
  { 5872, 17, 39, 22, 4, -39 },
  { 5955, 2, 39, 10, 4, -39 },
  { 5965, 32, 27, 40, 4, -27 },
  { 6073, 19, 27, 27, 4, -27 },
  { 6138, 21, 28, 26, 3, -27 },
  { 6212, 20, 39, 27, 4, -27 },
  { 6310, 20, 39, 27, 3, -27 },
  { 6408, 13, 27, 17, 4, -27 },
  { 6452, 17, 28, 21, 2, -27 },
  { 6512, 13, 35, 15, 1, -34 },
  { 6569, 18, 28, 27, 4, -27 },
  { 6632, 20, 27, 20, 0, -27 },
  { 6700, 31, 27, 33, 1, -27 },
  { 6805, 20, 27, 22, 1, -27 },
  { 6873, 20, 39, 21, 0, -27 },
  { 6971, 16, 27, 20, 2, -27 },
  { 7025, 14, 44, 18, 2, -36 },
  { 7102, 2, 52, 25, 11, -39 },
  { 7115, 14, 44, 18, 2, -36 },
  { 7192, 22, 4, 26, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight51pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT51PT7B_H_
