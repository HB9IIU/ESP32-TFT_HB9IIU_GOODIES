#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT28PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight28pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x55, 0x55, 0x54, 0x0F, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x04,
  0x10, 0x10, 0x40, 0x42, 0x01, 0x08, 0x04, 0x20, 0x20, 0x87, 0xFF, 0xC2,
  0x08, 0x08, 0x40, 0x21, 0x00, 0x84, 0x04, 0x10, 0x10, 0x43, 0xFF, 0xE1,
  0x08, 0x04, 0x20, 0x10, 0x80, 0x82, 0x02, 0x08, 0x08, 0x20, 0x04, 0x00,
  0xC0, 0xF7, 0x32, 0x04, 0x41, 0x88, 0x31, 0x02, 0x20, 0x44, 0x06, 0x80,
  0x30, 0x03, 0x80, 0x4C, 0x08, 0xC1, 0x08, 0x21, 0x04, 0x20, 0x86, 0x11,
  0x3F, 0xC0, 0x40, 0x08, 0x01, 0x00, 0x3C, 0x04, 0x10, 0x81, 0x04, 0x20,
  0x81, 0x08, 0x20, 0x42, 0x10, 0x20, 0x84, 0x08, 0x22, 0x01, 0x08, 0x80,
  0x42, 0x4F, 0x10, 0x92, 0x24, 0x29, 0x08, 0xF2, 0x41, 0x01, 0x10, 0x40,
  0x44, 0x10, 0x31, 0x04, 0x08, 0x41, 0x02, 0x10, 0x41, 0x04, 0x20, 0x40,
  0x88, 0x20, 0x3C, 0x0F, 0x80, 0x21, 0x80, 0xC1, 0x01, 0x02, 0x02, 0x04,
  0x02, 0x08, 0x04, 0x20, 0x04, 0xC0, 0x0E, 0x00, 0x18, 0x00, 0x48, 0x01,
  0x08, 0x34, 0x08, 0x48, 0x18, 0xB0, 0x1A, 0x60, 0x14, 0x40, 0x10, 0x80,
  0x50, 0x81, 0x10, 0xFC, 0x30, 0xFE, 0x08, 0x84, 0x42, 0x21, 0x08, 0x46,
  0x21, 0x08, 0x42, 0x18, 0x42, 0x10, 0xC2, 0x18, 0x41, 0xC2, 0x08, 0x41,
  0x08, 0x41, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0xC4, 0x23, 0x11, 0x98,
  0x04, 0x00, 0x80, 0x10, 0x62, 0x33, 0xF8, 0x08, 0x02, 0x80, 0x88, 0x11,
  0x84, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xFF,
  0xF0, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x6D, 0x25,
  0x20, 0xFC, 0xF0, 0x00, 0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x18, 0x08,
  0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x10,
  0x18, 0x00, 0x3F, 0x0C, 0x31, 0x02, 0x60, 0x28, 0x05, 0x00, 0xA0, 0x14,
  0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xA0, 0x14, 0x02,
  0xC0, 0x48, 0x11, 0x86, 0x0F, 0x80, 0x08, 0xDB, 0x98, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x3F, 0x8C, 0x18, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x20, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x7F, 0xF0, 0x3F,
  0x98, 0x18, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x01, 0x83,
  0xC0, 0x06, 0x00, 0x30, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0E,
  0x03, 0x3F, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x50, 0x04, 0x80, 0x24, 0x02,
  0x20, 0x31, 0x01, 0x08, 0x10, 0x41, 0x82, 0x08, 0x10, 0x80, 0x84, 0x04,
  0x40, 0x23, 0xFF, 0xE0, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x7F, 0x88, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0xFF,
  0x10, 0x30, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x1A, 0x06, 0x7F, 0x80, 0x0F, 0xC2, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x9F, 0x9C, 0x1B, 0x01, 0x40, 0x38, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0xC0, 0x48, 0x09, 0x82, 0x0F, 0x80, 0xFF, 0xF0, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x1F, 0x82, 0x04, 0x60, 0x24, 0x02, 0x40, 0x24, 0x02, 0x20,
  0x63, 0x0C, 0x19, 0x80, 0x60, 0x19, 0x82, 0x04, 0x40, 0x24, 0x03, 0xC0,
  0x1C, 0x01, 0x40, 0x34, 0x02, 0x20, 0x41, 0xF8, 0x1F, 0x82, 0x0C, 0x40,
  0x44, 0x02, 0x40, 0x2C, 0x02, 0x80, 0x2C, 0x02, 0x40, 0x34, 0x06, 0x20,
  0x61, 0xFA, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x01,
  0x87, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x6C, 0x00, 0x00, 0x00, 0x06, 0x92,
  0x52, 0x00, 0x00, 0x30, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x0C,
  0x00, 0xFE, 0x83, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x06, 0x0C, 0x18,
  0x10, 0x10, 0x20, 0x20, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0xFC, 0x00,
  0x70, 0x30, 0x0C, 0x01, 0x81, 0x00, 0x0C, 0x30, 0x00, 0x42, 0x00, 0x02,
  0x40, 0xFC, 0x24, 0x10, 0x42, 0x42, 0x04, 0x24, 0x20, 0x42, 0x42, 0x04,
  0x38, 0x20, 0x42, 0x82, 0x0C, 0x24, 0x20, 0xC2, 0x42, 0x0C, 0x24, 0x31,
  0x44, 0x40, 0xE3, 0x86, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x71, 0xC0, 0x01, 0xF0, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x28,
  0x00, 0xA0, 0x04, 0x80, 0x11, 0x00, 0x44, 0x02, 0x10, 0x08, 0x20, 0x20,
  0x81, 0x02, 0x04, 0x04, 0x1F, 0xF0, 0x80, 0x42, 0x00, 0x88, 0x02, 0x40,
  0x09, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xFF, 0x10, 0x1A, 0x01, 0x40, 0x38,
  0x07, 0x00, 0xE0, 0x14, 0x02, 0x80, 0x9F, 0xE2, 0x03, 0x40, 0x28, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0A, 0x03, 0x7F, 0x80, 0x0F, 0xF1,
  0x81, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x18, 0x10, 0xFF, 0xFE, 0x04, 0x0C, 0x20, 0x19, 0x00, 0x48, 0x01,
  0x40, 0x0A, 0x00, 0x50, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0A, 0x00, 0x50, 0x06, 0x80, 0x24, 0x02, 0x20, 0x61, 0xFC,
  0x00, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F,
  0xE0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x1F, 0xF0,
  0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3F,
  0xF0, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x00, 0x07,
  0xF8, 0x60, 0x13, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x0F, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x50, 0x01, 0x40, 0x04, 0x80, 0x11, 0x80, 0x43, 0xFE, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F,
  0xFF, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x09, 0xF0, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x86, 0xF0,
  0x80, 0x70, 0x1A, 0x06, 0x40, 0x88, 0x21, 0x08, 0x23, 0x04, 0xC0, 0xB0,
  0x16, 0x03, 0x20, 0x46, 0x08, 0x41, 0x04, 0x20, 0xC4, 0x08, 0x80, 0x90,
  0x1A, 0x01, 0x40, 0x10, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x1F, 0xF0, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xA0,
  0x05, 0xA0, 0x05, 0xB0, 0x09, 0x90, 0x09, 0x90, 0x09, 0x88, 0x11, 0x88,
  0x11, 0x88, 0x31, 0x84, 0x21, 0x84, 0x21, 0x86, 0x41, 0x82, 0x41, 0x82,
  0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x80, 0x1C, 0x01, 0xC0, 0x1A,
  0x01, 0xA0, 0x19, 0x01, 0x98, 0x18, 0x81, 0x8C, 0x18, 0x41, 0x82, 0x18,
  0x21, 0x81, 0x18, 0x19, 0x80, 0x98, 0x05, 0x80, 0x58, 0x03, 0x80, 0x38,
  0x01, 0x0F, 0xE0, 0x60, 0x20, 0x80, 0x22, 0x00, 0x24, 0x00, 0x50, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xA0, 0x02, 0x40, 0x04, 0x40, 0x10, 0x40,
  0x40, 0x7F, 0x00, 0xFE, 0x20, 0x68, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x28, 0xF3, 0xC0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x0F, 0xE0, 0x20, 0x20, 0x80, 0x22, 0x00, 0x24,
  0x00, 0x50, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xA0, 0x02, 0x40, 0x04,
  0x40, 0x10, 0x40, 0x40, 0x7F, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0xFE, 0x10, 0x32, 0x03, 0x40, 0x28, 0x05, 0x00, 0xA0,
  0x14, 0x02, 0x80, 0x90, 0x33, 0xF8, 0x42, 0x08, 0x21, 0x04, 0x20, 0x44,
  0x0C, 0x80, 0x90, 0x1A, 0x01, 0x40, 0x30, 0x1F, 0xC4, 0x05, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0E, 0x03, 0x7F, 0xC0, 0xFF,
  0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x28, 0x01, 0x40, 0x0B,
  0x00, 0x8C, 0x0C, 0x3F, 0x80, 0x80, 0x07, 0x00, 0x34, 0x00, 0x90, 0x02,
  0x60, 0x18, 0x80, 0x42, 0x01, 0x0C, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x02, 0x10, 0x08, 0x40, 0x21, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x05,
  0x80, 0xA0, 0x24, 0x05, 0x01, 0x20, 0x48, 0x19, 0x02, 0x40, 0x8C, 0x11,
  0x04, 0x20, 0x88, 0x21, 0x08, 0x43, 0x08, 0x42, 0x10, 0x62, 0x08, 0x81,
  0x10, 0x44, 0x09, 0x02, 0x40, 0x48, 0x12, 0x03, 0x40, 0x50, 0x0A, 0x02,
  0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x13, 0x01,
  0x88, 0x08, 0x20, 0xC1, 0x04, 0x04, 0x40, 0x22, 0x00, 0xA0, 0x05, 0x00,
  0x10, 0x01, 0xC0, 0x0A, 0x00, 0x88, 0x04, 0x40, 0x41, 0x02, 0x08, 0x20,
  0x23, 0x01, 0x10, 0x05, 0x80, 0x30, 0x80, 0x1A, 0x00, 0x90, 0x08, 0x40,
  0x42, 0x06, 0x08, 0x20, 0x43, 0x03, 0x10, 0x09, 0x80, 0x68, 0x01, 0x40,
  0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0xFF, 0xE0, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0F, 0xFF, 0xFE, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x3F, 0xC0, 0x20, 0x10, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20,
  0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x30, 0x08, 0x04, 0x01, 0x00, 0x80,
  0x40, 0x10, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x3F, 0x02, 0x00, 0x60, 0x05, 0x00, 0x90, 0x08,
  0x81, 0x08, 0x30, 0x42, 0x04, 0x60, 0x24, 0x02, 0xC0, 0x10, 0xFF, 0xE0,
  0xC1, 0x0C, 0x30, 0x5F, 0x08, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x1C,
  0x79, 0x60, 0x50, 0x18, 0x06, 0x03, 0xC0, 0xD0, 0x53, 0xE4, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x27, 0xE5, 0x86, 0xA0, 0x58, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0x50, 0x69, 0xF8, 0x1F, 0x90, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x04, 0x03, 0x00, 0xFE, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x0F, 0x13, 0x0D, 0x20, 0x54, 0x03, 0x40,
  0x34, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x14, 0x03, 0x40, 0x34, 0x03, 0x60,
  0x52, 0x05, 0x1F, 0x90, 0x1F, 0x18, 0x64, 0x0A, 0x01, 0x80, 0x60, 0x18,
  0x07, 0xFF, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x18, 0x13, 0xF8, 0x0F,
  0x88, 0x04, 0x02, 0x01, 0x00, 0x83, 0xF8, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x0F,
  0x93, 0x05, 0x20, 0x54, 0x03, 0x40, 0x34, 0x03, 0xC0, 0x1C, 0x01, 0xC0,
  0x34, 0x03, 0x40, 0x34, 0x03, 0x60, 0x52, 0x05, 0x1F, 0x90, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x06, 0x70, 0xC1, 0xF0, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x09, 0xF2, 0xC3, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0xF0,
  0x2A, 0xAA, 0xAA, 0xAA, 0x18, 0xC0, 0x00, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x15, 0xB8, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x0A, 0x04, 0x82, 0x21, 0x88, 0x42, 0x20,
  0x98, 0x2A, 0x0C, 0x43, 0x10, 0x82, 0x20, 0xC8, 0x12, 0x02, 0x80, 0xC0,
  0xFF, 0xFF, 0xF8, 0x9F, 0x1F, 0x28, 0x68, 0x6C, 0x0C, 0x0B, 0x03, 0x03,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x04, 0x9F, 0x2C, 0x3A, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x0F, 0x83, 0x04, 0x20,
  0x24, 0x02, 0x40, 0x14, 0x01, 0xC0, 0x1C, 0x01, 0x40, 0x14, 0x01, 0x40,
  0x14, 0x02, 0x20, 0x23, 0x04, 0x1F, 0x80, 0x8F, 0x96, 0x1A, 0x81, 0x60,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C,
  0x05, 0x41, 0xA7, 0xE4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x00, 0x0F, 0x93, 0x0D, 0x20, 0x54, 0x03, 0x40, 0x34, 0x03, 0xC0,
  0x3C, 0x01, 0xC0, 0x34, 0x03, 0x40, 0x34, 0x03, 0x60, 0x52, 0x07, 0x1F,
  0xB0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x9F,
  0x62, 0x86, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x00, 0x3F, 0x30, 0x50, 0x10, 0x0C, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0x20, 0x10, 0x0C, 0x0F, 0xFC, 0x20, 0x40, 0x87, 0xF2, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x18, 0x10, 0x3C, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0xC0, 0xD0, 0x53, 0xE4, 0x80, 0x38, 0x0D, 0x01, 0x20, 0x26, 0x0C,
  0x41, 0x08, 0x21, 0x8C, 0x11, 0x02, 0x20, 0x64, 0x05, 0x00, 0xA0, 0x14,
  0x01, 0x00, 0xC0, 0xC0, 0xD0, 0x30, 0x24, 0x0C, 0x09, 0x02, 0x82, 0x61,
  0x21, 0x88, 0x48, 0x42, 0x12, 0x10, 0x8C, 0x44, 0x12, 0x13, 0x04, 0x84,
  0x81, 0x20, 0xA0, 0x50, 0x28, 0x0C, 0x0E, 0x03, 0x03, 0x00, 0xC0, 0x40,
  0x80, 0x50, 0x26, 0x18, 0x84, 0x12, 0x04, 0x80, 0xC0, 0x30, 0x0C, 0x04,
  0x83, 0x30, 0x84, 0x40, 0x90, 0x28, 0x04, 0x80, 0x28, 0x05, 0x01, 0x20,
  0x22, 0x04, 0x41, 0x08, 0x20, 0x84, 0x11, 0x02, 0x20, 0x24, 0x05, 0x00,
  0xA0, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x01,
  0xC0, 0x00, 0x7F, 0x80, 0xC0, 0x40, 0x40, 0x20, 0x20, 0x30, 0x10, 0x18,
  0x08, 0x08, 0x04, 0x04, 0x06, 0x03, 0xFE, 0x07, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x60, 0xE0, 0x30, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x18, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0,
  0x30, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x07,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0xF0, 0x7C,
  0x18, 0x3F,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 20, 6, 2, -20 },
  { 6, 5, 7, 9, 2, -20 },
  { 11, 14, 20, 16, 1, -20 },
  { 46, 11, 23, 14, 1, -21 },
  { 78, 18, 20, 20, 1, -20 },
  { 123, 15, 20, 17, 1, -20 },
  { 161, 1, 7, 5, 2, -20 },
  { 162, 5, 24, 7, 1, -20 },
  { 177, 5, 24, 7, 1, -20 },
  { 192, 11, 10, 13, 1, -21 },
  { 206, 12, 13, 14, 1, -16 },
  { 226, 3, 7, 5, 1, -3 },
  { 229, 6, 1, 8, 1, -8 },
  { 230, 2, 2, 6, 2, -2 },
  { 231, 9, 20, 9, 0, -20 },
  { 254, 11, 20, 14, 2, -20 },
  { 282, 5, 20, 14, 3, -20 },
  { 295, 11, 20, 14, 1, -20 },
  { 323, 11, 20, 14, 1, -20 },
  { 351, 13, 20, 14, 1, -20 },
  { 384, 11, 20, 14, 2, -20 },
  { 412, 11, 20, 14, 2, -20 },
  { 440, 12, 20, 14, 1, -20 },
  { 470, 12, 20, 14, 1, -20 },
  { 500, 12, 20, 14, 1, -20 },
  { 530, 2, 15, 6, 2, -15 },
  { 534, 3, 19, 6, 1, -15 },
  { 542, 12, 12, 14, 1, -16 },
  { 560, 12, 7, 14, 1, -13 },
  { 571, 12, 12, 14, 1, -16 },
  { 589, 8, 20, 10, 1, -20 },
  { 609, 20, 23, 22, 1, -20 },
  { 667, 14, 20, 14, 0, -20 },
  { 702, 11, 20, 16, 3, -20 },
  { 730, 12, 20, 15, 2, -20 },
  { 760, 13, 20, 17, 3, -20 },
  { 793, 9, 20, 14, 3, -20 },
  { 816, 9, 20, 12, 3, -20 },
  { 839, 14, 20, 18, 2, -20 },
  { 874, 12, 20, 18, 3, -20 },
  { 904, 5, 20, 8, 1, -20 },
  { 917, 6, 25, 6, -2, -20 },
  { 936, 11, 20, 14, 3, -20 },
  { 964, 9, 20, 13, 3, -20 },
  { 987, 16, 20, 22, 3, -20 },
  { 1027, 12, 20, 18, 3, -20 },
  { 1057, 15, 20, 19, 2, -20 },
  { 1095, 10, 20, 14, 3, -20 },
  { 1120, 15, 25, 19, 2, -20 },
  { 1167, 11, 20, 15, 3, -20 },
  { 1195, 11, 20, 14, 1, -20 },
  { 1223, 13, 20, 13, 0, -20 },
  { 1256, 13, 20, 18, 2, -20 },
  { 1289, 14, 20, 14, 0, -20 },
  { 1324, 21, 20, 22, 1, -20 },
  { 1377, 13, 20, 13, 0, -20 },
  { 1410, 13, 20, 13, 0, -20 },
  { 1443, 12, 20, 14, 1, -20 },
  { 1473, 6, 24, 9, 2, -20 },
  { 1491, 9, 20, 9, 0, -20 },
  { 1514, 5, 24, 9, 1, -20 },
  { 1529, 12, 11, 14, 1, -20 },
  { 1546, 11, 1, 11, 0, 2 },
  { 1548, 5, 4, 7, 1, -21 },
  { 1551, 10, 15, 13, 1, -15 },
  { 1570, 11, 21, 15, 2, -21 },
  { 1599, 9, 15, 12, 2, -15 },
  { 1616, 12, 21, 15, 1, -21 },
  { 1648, 10, 15, 14, 2, -15 },
  { 1667, 9, 21, 7, 0, -21 },
  { 1691, 12, 22, 15, 1, -15 },
  { 1724, 10, 21, 15, 2, -21 },
  { 1751, 2, 20, 6, 2, -20 },
  { 1756, 5, 27, 6, -1, -20 },
  { 1773, 10, 21, 12, 2, -21 },
  { 1800, 1, 21, 6, 2, -21 },
  { 1803, 18, 15, 22, 2, -15 },
  { 1837, 10, 15, 15, 2, -15 },
  { 1856, 12, 15, 15, 1, -15 },
  { 1879, 11, 22, 15, 2, -15 },
  { 1910, 12, 22, 15, 1, -15 },
  { 1943, 7, 15, 10, 2, -15 },
  { 1957, 9, 15, 11, 1, -15 },
  { 1974, 7, 18, 8, 0, -18 },
  { 1990, 10, 15, 15, 2, -15 },
  { 2009, 11, 15, 11, 0, -15 },
  { 2030, 18, 15, 18, 0, -15 },
  { 2064, 10, 15, 12, 1, -15 },
  { 2083, 11, 22, 11, 0, -15 },
  { 2114, 9, 15, 11, 1, -15 },
  { 2131, 8, 24, 10, 1, -20 },
  { 2155, 1, 28, 14, 6, -21 },
  { 2159, 8, 24, 10, 1, -20 },
  { 2183, 12, 2, 14, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight28pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT28PT7B_H_
