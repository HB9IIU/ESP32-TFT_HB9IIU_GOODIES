#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT66PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight66pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x6F, 0xFF,
  0xF2, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0xFC, 0xC7, 0xF0, 0x78, 0x30,
  0x1C, 0x3C, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x01, 0xC0,
  0x30, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x03,
  0x80, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x07, 0x00, 0xC0,
  0x01, 0xC0, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x00, 0xF0,
  0xC0, 0x00, 0x1F, 0x30, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0C, 0xF8, 0x00, 0x03, 0x0F,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x03,
  0x00, 0x60, 0x00, 0xC0, 0x1C, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x01, 0xC0,
  0x03, 0x00, 0x70, 0x00, 0xC0, 0x1C, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x01,
  0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x38, 0x00, 0x30, 0x1C, 0x40, 0x0C,
  0x0E, 0x1F, 0x03, 0x0F, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xC0, 0x03, 0x8F, 0x00, 0x00, 0xC0, 0x03, 0x81,
  0xC0, 0x00, 0x60, 0x03, 0x80, 0x60, 0x00, 0x70, 0x01, 0x80, 0x38, 0x00,
  0x30, 0x00, 0xC0, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x1C, 0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x18, 0x00,
  0xE0, 0x0E, 0x00, 0x0C, 0x00, 0x70, 0x06, 0x00, 0x06, 0x00, 0x18, 0x07,
  0x00, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x80, 0x06, 0x03, 0x80, 0x01,
  0xC0, 0x03, 0x01, 0x80, 0x00, 0x60, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x00,
  0xC0, 0xC0, 0x00, 0x18, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x00, 0x70, 0x60,
  0x3E, 0x06, 0x00, 0x38, 0x30, 0x7F, 0x83, 0x00, 0x18, 0x30, 0x70, 0xE1,
  0xC0, 0x0C, 0x18, 0x70, 0x38, 0x60, 0x0E, 0x1C, 0x30, 0x0E, 0x30, 0x07,
  0x0C, 0x38, 0x03, 0x1C, 0x03, 0x0E, 0x18, 0x01, 0x87, 0x03, 0x86, 0x1C,
  0x00, 0xE1, 0xE7, 0x87, 0x0E, 0x00, 0x70, 0x7F, 0x83, 0x06, 0x00, 0x18,
  0x0F, 0x03, 0x83, 0x00, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x06, 0x00, 0x01,
  0xC0, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x00, 0xE0, 0x30,
  0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x30,
  0x00, 0x30, 0x06, 0x00, 0x18, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x03, 0x80, 0x06, 0x00, 0x18, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0xC0,
  0x03, 0x00, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x01, 0x80, 0x60, 0x01, 0x80,
  0x00, 0xE0, 0x70, 0x01, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x70, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x18, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x00, 0x3C, 0x0E, 0x00, 0x07, 0x0F, 0x00, 0xE0, 0x00, 0xE1, 0xC0, 0x0E,
  0x00, 0x18, 0x70, 0x00, 0xE0, 0x03, 0x1C, 0x00, 0x1E, 0x00, 0xE3, 0x80,
  0x01, 0xC0, 0x18, 0x60, 0x00, 0x1C, 0x03, 0x1C, 0x00, 0x01, 0xC0, 0xE3,
  0x80, 0x00, 0x1C, 0x18, 0x70, 0x00, 0x01, 0xC7, 0x0E, 0x00, 0x00, 0x1C,
  0xC1, 0xC0, 0x00, 0x03, 0xB8, 0x38, 0x00, 0x00, 0x3E, 0x03, 0x00, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0xE0,
  0x00, 0x07, 0x38, 0x1E, 0x00, 0x03, 0xC7, 0x01, 0xE0, 0x00, 0xF0, 0x70,
  0x1F, 0x00, 0x7C, 0x07, 0x01, 0xFF, 0xFE, 0x00, 0x70, 0x0F, 0xFF, 0x00,
  0x07, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70,
  0x03, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0xF0, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x0C, 0x03, 0x7E, 0x06, 0x0F, 0xCF, 0xE3, 0x3F, 0x80, 0x7F, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x70, 0x30, 0x00, 0x70, 0x1C,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x04, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x71, 0xCE, 0x38, 0xE3, 0x8C, 0x71, 0xC6, 0x18, 0xE3,
  0x0C, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x6F, 0xFF, 0xF6, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x07,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x07,
  0x0C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0E, 0x60, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06, 0xE0,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x1C,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x01, 0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0x9C, 0x3C, 0x71, 0xE1, 0xCF,
  0x07, 0x70, 0x1F, 0x80, 0x74, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xE0, 0x78,
  0x00, 0x1C, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0xF0, 0xF8,
  0x00, 0x1E, 0x18, 0x00, 0x03, 0xC4, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x1E,
  0x3E, 0x00, 0x1F, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x00, 0xFA,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x38,
  0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0xE0,
  0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x03, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x38, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xDF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE3, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0xF8,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0xFF, 0x00, 0xE1, 0xFF, 0xF0, 0x38, 0xF8, 0x3F, 0x0E, 0x70, 0x01,
  0xE3, 0x38, 0x00, 0x3C, 0xDC, 0x00, 0x07, 0x36, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x0E,
  0x01, 0xE0, 0x0F, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x38, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x1C, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x01, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x06, 0x1E, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0xF0, 0x1F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x0E,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x38, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x37, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1E,
  0x38, 0x00, 0x06, 0xC3, 0x80, 0x01, 0x98, 0x38, 0x00, 0xE3, 0x03, 0xE0,
  0xF8, 0x60, 0x3F, 0xFE, 0x0C, 0x00, 0xFE, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x40,
  0x07, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x6F, 0xFF, 0xF6, 0x1E, 0x3C, 0x78, 0xF0, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1, 0xC7, 0x0E, 0x1C,
  0x38, 0x61, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xC1, 0x86, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0E, 0x00, 0x7C, 0x80, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x7F, 0xFC, 0x00, 0xC7, 0x00, 0x07,
  0xE7, 0xE0, 0x06, 0x38, 0x00, 0x70, 0x03, 0x00, 0x39, 0x80, 0x07, 0x00,
  0x18, 0x01, 0xCC, 0x00, 0x70, 0x01, 0xC0, 0x06, 0xE0, 0x07, 0x00, 0x0E,
  0x00, 0x37, 0x00, 0x38, 0x00, 0x70, 0x01, 0xB0, 0x01, 0x80, 0x03, 0x80,
  0x0D, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x6C, 0x00, 0xC0, 0x00, 0xE0, 0x03,
  0x60, 0x06, 0x00, 0x07, 0x00, 0x1B, 0x00, 0x30, 0x00, 0x38, 0x00, 0xD8,
  0x01, 0x80, 0x01, 0x80, 0x07, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x3E, 0x00,
  0x60, 0x00, 0x60, 0x01, 0xB0, 0x03, 0x00, 0x03, 0x00, 0x0D, 0x80, 0x18,
  0x00, 0x18, 0x00, 0xEC, 0x00, 0xC0, 0x01, 0xC0, 0x06, 0x60, 0x06, 0x00,
  0x0E, 0x00, 0x33, 0x00, 0x38, 0x00, 0x58, 0x03, 0x98, 0x00, 0xC0, 0x06,
  0xC0, 0x18, 0xE0, 0x07, 0x00, 0x76, 0x01, 0xC7, 0x00, 0x1C, 0x07, 0x38,
  0x1C, 0x18, 0x00, 0xF8, 0xF0, 0xF3, 0xC0, 0xC0, 0x01, 0xFF, 0x03, 0xFC,
  0x07, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1C, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0x80,
  0x07, 0xF0, 0x70, 0x00, 0x0F, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07,
  0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0C, 0xE0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0x00, 0x3F,
  0xE0, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x1F, 0xC1,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x08, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x04, 0x03, 0xF0, 0x00, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x0F, 0xF0, 0x07, 0x00,
  0x01, 0xF8, 0x0E, 0x00, 0x00, 0xF8, 0x1C, 0x00, 0x00, 0x78, 0x38, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x01,
  0xF0, 0x0E, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x30, 0x78, 0x00, 0x00,
  0x0C, 0x0F, 0x00, 0x00, 0x03, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0x1F, 0x80,
  0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x3C, 0xFF, 0xE3, 0xFF, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0xF0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x07, 0x80, 0x07, 0x00, 0xE0,
  0x00, 0xE0, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xC7, 0xC0, 0x00, 0x39, 0xDC, 0x00,
  0x07, 0x73, 0x80, 0x00, 0xFC, 0x38, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xC0,
  0x70, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xF0, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00,
  0x1C, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xD8,
  0x00, 0x00, 0x00, 0x3F, 0xDC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x37, 0xEC, 0x00, 0x00, 0x00, 0x77, 0xEE, 0x00, 0x00, 0x00, 0x67,
  0xEE, 0x00, 0x00, 0x00, 0x67, 0xE6, 0x00, 0x00, 0x00, 0xE7, 0xE7, 0x00,
  0x00, 0x00, 0xC7, 0xE3, 0x00, 0x00, 0x00, 0xC7, 0xE3, 0x80, 0x00, 0x01,
  0xC7, 0xE3, 0x80, 0x00, 0x01, 0x87, 0xE1, 0x80, 0x00, 0x03, 0x87, 0xE1,
  0xC0, 0x00, 0x03, 0x87, 0xE1, 0xC0, 0x00, 0x03, 0x07, 0xE0, 0xC0, 0x00,
  0x07, 0x07, 0xE0, 0xE0, 0x00, 0x06, 0x07, 0xE0, 0x60, 0x00, 0x06, 0x07,
  0xE0, 0x70, 0x00, 0x0E, 0x07, 0xE0, 0x70, 0x00, 0x0C, 0x07, 0xE0, 0x30,
  0x00, 0x1C, 0x07, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0xE0, 0x38, 0x00, 0x18,
  0x07, 0xE0, 0x18, 0x00, 0x38, 0x07, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0xE0,
  0x1C, 0x00, 0x30, 0x07, 0xE0, 0x0C, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00,
  0x60, 0x07, 0xE0, 0x06, 0x00, 0x60, 0x07, 0xE0, 0x07, 0x00, 0xE0, 0x07,
  0xE0, 0x07, 0x00, 0xC0, 0x07, 0xE0, 0x03, 0x01, 0xC0, 0x07, 0xE0, 0x03,
  0x81, 0xC0, 0x07, 0xE0, 0x03, 0x81, 0x80, 0x07, 0xE0, 0x01, 0x83, 0x80,
  0x07, 0xE0, 0x01, 0xC3, 0x00, 0x07, 0xE0, 0x01, 0xC3, 0x00, 0x07, 0xE0,
  0x00, 0xC7, 0x00, 0x07, 0xE0, 0x00, 0xE6, 0x00, 0x07, 0xE0, 0x00, 0x6E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0x3E, 0xE0, 0x00, 0x00, 0xFB, 0x80, 0x00, 0x03, 0xE7, 0x00, 0x00,
  0x0F, 0x9C, 0x00, 0x00, 0x3E, 0x38, 0x00, 0x00, 0xF8, 0x70, 0x00, 0x03,
  0xE1, 0xC0, 0x00, 0x0F, 0x83, 0x80, 0x00, 0x3E, 0x0E, 0x00, 0x00, 0xF8,
  0x1C, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x3E, 0x01,
  0xC0, 0x00, 0xF8, 0x07, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x0F, 0x80, 0x18,
  0x00, 0x3E, 0x00, 0x70, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0x80,
  0x0F, 0x80, 0x07, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0x38, 0x03,
  0xE0, 0x00, 0x70, 0x0F, 0x80, 0x01, 0xC0, 0x3E, 0x00, 0x03, 0x80, 0xF8,
  0x00, 0x0E, 0x03, 0xE0, 0x00, 0x1C, 0x0F, 0x80, 0x00, 0x30, 0x3E, 0x00,
  0x00, 0xE0, 0xF8, 0x00, 0x01, 0xC3, 0xE0, 0x00, 0x07, 0x0F, 0x80, 0x00,
  0x0E, 0x3E, 0x00, 0x00, 0x38, 0xF8, 0x00, 0x00, 0x73, 0xE0, 0x00, 0x00,
  0xEF, 0x80, 0x00, 0x03, 0xBE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x38,
  0x01, 0xFE, 0x1C, 0x00, 0x0F, 0x8E, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x73, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0xF0, 0xE0, 0x07, 0xF0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x03, 0x80, 0x1F, 0xE0, 0x70, 0x00, 0x3E, 0x0E,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x1C, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38,
  0x38, 0x00, 0x1E, 0x07, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0xE0, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x38, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x3E,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x87, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x80, 0x00, 0x1E, 0x3E, 0x00, 0x1F, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70,
  0x01, 0x80, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x38,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x38, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x67, 0x00, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x60,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x61,
  0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x03, 0x80, 0x03,
  0x83, 0x00, 0x03, 0x80, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x0E, 0x00,
  0x0C, 0x0E, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x18, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x01, 0x80, 0x70, 0x01, 0x80, 0x06, 0x00, 0x30, 0x06, 0x00, 0x70,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x03, 0x80, 0x30, 0x03, 0x80, 0x30, 0x00, 0x30, 0x06, 0x00, 0x30,
  0x0E, 0x00, 0x07, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0xE0, 0x38, 0x00, 0x1C, 0x06, 0x00, 0x1C, 0x06, 0x00, 0x01, 0x80, 0xC0,
  0x01, 0x81, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x30, 0x38, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x18, 0x00, 0x07, 0x18, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0,
  0x00, 0x01, 0xDC, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x03,
  0x80, 0x00, 0xE0, 0x0C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x60, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x1C, 0x30, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x18, 0x06, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xE0,
  0x07, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0x87, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x33, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x0C,
  0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xF0, 0x07, 0x81, 0x80, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x0F, 0xFE, 0x03,
  0xFF, 0xFC, 0x1F, 0xC0, 0x38, 0x78, 0x00, 0x73, 0xC0, 0x00, 0xE7, 0x00,
  0x01, 0xDC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xB8, 0x00, 0x33, 0x70, 0x00, 0xE6, 0x78, 0x03, 0x8C,
  0x7F, 0xFE, 0x18, 0x7F, 0xF0, 0x30, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x03, 0x80, 0x07,
  0x03, 0xFF, 0x00, 0xE1, 0xFF, 0xF8, 0x1C, 0x70, 0x07, 0x83, 0x9C, 0x00,
  0x38, 0x77, 0x00, 0x03, 0x8E, 0xC0, 0x00, 0x71, 0xF0, 0x00, 0x07, 0x3E,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x0C, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0D, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x0E, 0x7C, 0x00,
  0x01, 0xCF, 0x80, 0x00, 0x71, 0xD8, 0x00, 0x1C, 0x3B, 0x80, 0x07, 0x87,
  0x3C, 0x03, 0xE0, 0xE3, 0xFF, 0xF8, 0x18, 0x1F, 0xFC, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x06, 0x80, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC1, 0xF0,
  0x06, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x70,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x1E, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x07,
  0xFF, 0x07, 0x01, 0xFF, 0xF8, 0xE0, 0xF8, 0x07, 0x9C, 0x1C, 0x00, 0x33,
  0x87, 0x00, 0x03, 0x71, 0xC0, 0x00, 0x3E, 0x38, 0x00, 0x07, 0xCE, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x0F, 0x30, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70,
  0x00, 0x01, 0xE6, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x01,
  0xF1, 0xC0, 0x00, 0x3E, 0x38, 0x00, 0x0D, 0xC3, 0xC0, 0x03, 0x18, 0x3C,
  0x01, 0xE3, 0x03, 0xFF, 0xF0, 0x60, 0x1F, 0xFC, 0x0C, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x06, 0x38, 0x00, 0x03, 0x98, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x02, 0x03, 0xC0, 0x07, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x1F, 0xFC, 0x03, 0x80, 0x80, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xF0, 0xFF,
  0xFE, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0xFC, 0x0C, 0x07, 0xFF, 0xE3, 0x83, 0xE0, 0x1E, 0x70, 0xF0, 0x00,
  0xEE, 0x1C, 0x00, 0x0D, 0xC7, 0x00, 0x00, 0xF8, 0xC0, 0x00, 0x1F, 0x38,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x07, 0x98, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1E, 0x70, 0x00,
  0x07, 0xC7, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x37, 0x0F, 0x00, 0x0C, 0xE0,
  0xF0, 0x07, 0x1C, 0x0F, 0xFF, 0xC3, 0x80, 0x7F, 0xF0, 0x70, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE1, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x1E, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0xFF, 0xE0, 0xE1, 0xFF, 0xF8, 0xE3, 0x80, 0x3C, 0xE6, 0x00,
  0x1C, 0xEC, 0x00, 0x0E, 0xF8, 0x00, 0x06, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x6F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0xC0,
  0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x39, 0x9E, 0x3F,
  0xC7, 0xE0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x1E,
  0xE0, 0x00, 0x39, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x87, 0x00, 0x0E, 0x0E,
  0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x70, 0x07, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0xF8, 0x00, 0x71, 0xB0, 0x00, 0xE6, 0x70,
  0x01, 0xDC, 0x70, 0x03, 0xF0, 0xE0, 0x07, 0xC0, 0xE0, 0x0F, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x03, 0x81,
  0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x1C,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x08, 0x00,
  0x03, 0x80, 0x60, 0x7F, 0xC0, 0x0F, 0xFC, 0x30, 0xFF, 0xF8, 0x1F, 0xFF,
  0x1C, 0xF0, 0x1E, 0x1E, 0x03, 0xCE, 0xE0, 0x07, 0x1C, 0x00, 0xF7, 0x60,
  0x01, 0xDC, 0x00, 0x3B, 0xE0, 0x00, 0x6C, 0x00, 0x0F, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x30,
  0x00, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xF0, 0x00, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x60,
  0x00, 0x0F, 0x80, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x30, 0x00, 0x07,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00,
  0x06, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0xC0, 0x7F, 0xE0, 0xC1, 0xFF, 0xF8, 0xE3,
  0x80, 0x3C, 0xE7, 0x00, 0x1C, 0xEC, 0x00, 0x0E, 0xF8, 0x00, 0x06, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78, 0x1C,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x1C, 0x1C,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x18, 0x0F, 0xFC, 0x03, 0x87, 0xFF, 0xE0, 0x71, 0xE0,
  0x1E, 0x0E, 0x70, 0x00, 0xE1, 0xDC, 0x00, 0x0E, 0x3B, 0x00, 0x01, 0xC7,
  0xC0, 0x00, 0x1C, 0xF8, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x07, 0x78, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x37, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xCF, 0x80,
  0x00, 0x39, 0xF0, 0x00, 0x07, 0x3B, 0x00, 0x01, 0xC7, 0x70, 0x00, 0x70,
  0xE7, 0x00, 0x1E, 0x1C, 0x70, 0x07, 0x83, 0x87, 0xFF, 0xE0, 0x70, 0x7F,
  0xF0, 0x0E, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFC, 0x1C,
  0x07, 0xFF, 0xE3, 0x83, 0xE0, 0x1E, 0x70, 0xF0, 0x00, 0xCE, 0x1C, 0x00,
  0x0D, 0xC7, 0x00, 0x00, 0xF8, 0xC0, 0x00, 0x1F, 0x38, 0x00, 0x01, 0xE6,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07,
  0x98, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3E, 0x70, 0x00, 0x07, 0xC7, 0x00,
  0x01, 0xB8, 0xE0, 0x00, 0x37, 0x0F, 0x00, 0x1C, 0xE0, 0xF0, 0x07, 0x1C,
  0x0F, 0xFF, 0xC3, 0x80, 0xFF, 0xF0, 0x70, 0x01, 0xE0, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x08,
  0x70, 0x7F, 0xF8, 0x7F, 0xDC, 0x70, 0x1E, 0x70, 0x07, 0x60, 0x03, 0xB0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFE, 0x78,
  0x00, 0xE3, 0x80, 0x01, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x80, 0x00, 0xF7, 0x80, 0x0F, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFE, 0x00, 0x3E, 0x00, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x38, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x60, 0x00, 0x0B,
  0x70, 0x00, 0x1B, 0x70, 0x00, 0x33, 0x38, 0x00, 0x73, 0x1E, 0x01, 0xE3,
  0x0F, 0xFF, 0xC3, 0x07, 0xFF, 0x03, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x0E, 0x30, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x1C,
  0x00, 0x06, 0x07, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x30,
  0x0E, 0x00, 0x1C, 0x01, 0x80, 0x07, 0x00, 0x60, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x06,
  0x01, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x70, 0x38, 0x00, 0x0C, 0x0E, 0x00,
  0x03, 0x03, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x06, 0x18,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0x60, 0x00, 0x3E, 0x00, 0x07, 0x70,
  0x00, 0x36, 0x00, 0x06, 0x70, 0x00, 0x36, 0x00, 0x06, 0x30, 0x00, 0x77,
  0x00, 0x0E, 0x30, 0x00, 0x67, 0x00, 0x0E, 0x38, 0x00, 0x63, 0x00, 0x0C,
  0x38, 0x00, 0x63, 0x00, 0x0C, 0x18, 0x00, 0xE3, 0x80, 0x1C, 0x18, 0x00,
  0xC1, 0x80, 0x1C, 0x1C, 0x00, 0xC1, 0x80, 0x18, 0x1C, 0x01, 0xC1, 0xC0,
  0x18, 0x0C, 0x01, 0xC1, 0xC0, 0x38, 0x0C, 0x01, 0x80, 0xC0, 0x38, 0x0E,
  0x01, 0x80, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x06, 0x03, 0x00,
  0xE0, 0x70, 0x07, 0x03, 0x00, 0x60, 0x70, 0x07, 0x07, 0x00, 0x70, 0x60,
  0x07, 0x07, 0x00, 0x70, 0x60, 0x03, 0x06, 0x00, 0x30, 0xE0, 0x03, 0x8E,
  0x00, 0x30, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xC0, 0x01, 0x8C, 0x00, 0x38,
  0xC0, 0x01, 0x8C, 0x00, 0x19, 0xC0, 0x01, 0xDC, 0x00, 0x19, 0xC0, 0x01,
  0xDC, 0x00, 0x1D, 0x80, 0x00, 0xD8, 0x00, 0x0D, 0x80, 0x00, 0xD8, 0x00,
  0x0D, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x03, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x38, 0x0E,
  0x00, 0x0C, 0x03, 0x80, 0x07, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0xE0,
  0x03, 0x80, 0x70, 0x00, 0x70, 0x18, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x0E, 0x1C,
  0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x1C, 0x00, 0x38,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x01,
  0xC0, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x03, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x06, 0x00, 0x0C, 0x01, 0xC0,
  0x07, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x38, 0x00,
  0xE0, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x60,
  0x00, 0x30, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x18, 0x70, 0x00, 0x07, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0xC7, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xC0, 0x07, 0xF0, 0x03, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x17, 0xFF, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x00, 0x7F, 0x7E, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 48, 15, 5, -47 },
  { 25, 12, 17, 22, 5, -47 },
  { 51, 34, 47, 37, 2, -47 },
  { 251, 26, 54, 34, 3, -50 },
  { 427, 41, 49, 48, 3, -48 },
  { 679, 35, 49, 39, 3, -48 },
  { 894, 2, 17, 12, 5, -47 },
  { 899, 12, 57, 18, 3, -47 },
  { 985, 13, 57, 18, 2, -47 },
  { 1078, 25, 24, 32, 3, -50 },
  { 1153, 28, 31, 34, 3, -39 },
  { 1262, 6, 16, 13, 3, -7 },
  { 1274, 16, 2, 20, 2, -19 },
  { 1278, 4, 6, 14, 5, -5 },
  { 1281, 20, 47, 22, 1, -47 },
  { 1399, 26, 49, 34, 4, -48 },
  { 1559, 14, 47, 34, 6, -47 },
  { 1642, 26, 48, 34, 3, -48 },
  { 1798, 26, 49, 34, 3, -48 },
  { 1958, 32, 47, 34, 1, -47 },
  { 2146, 26, 48, 34, 4, -47 },
  { 2302, 26, 49, 34, 4, -48 },
  { 2462, 27, 47, 34, 3, -47 },
  { 2621, 27, 49, 34, 3, -48 },
  { 2787, 27, 49, 34, 3, -48 },
  { 2953, 4, 36, 14, 5, -35 },
  { 2971, 7, 44, 14, 2, -35 },
  { 3010, 28, 29, 34, 3, -38 },
  { 3112, 28, 16, 34, 3, -31 },
  { 3168, 28, 29, 34, 3, -38 },
  { 3270, 20, 49, 24, 2, -48 },
  { 3393, 45, 53, 52, 3, -47 },
  { 3692, 34, 47, 34, 0, -47 },
  { 3892, 27, 47, 37, 6, -47 },
  { 4051, 30, 49, 36, 4, -48 },
  { 4235, 31, 47, 41, 6, -47 },
  { 4418, 23, 47, 32, 6, -47 },
  { 4554, 23, 47, 29, 6, -47 },
  { 4690, 34, 49, 43, 4, -48 },
  { 4899, 30, 47, 42, 6, -47 },
  { 5076, 12, 47, 18, 3, -47 },
  { 5147, 14, 59, 15, -5, -47 },
  { 5251, 27, 47, 33, 6, -47 },
  { 5410, 22, 47, 30, 6, -47 },
  { 5540, 40, 47, 52, 6, -47 },
  { 5775, 30, 47, 42, 6, -47 },
  { 5952, 36, 49, 44, 4, -48 },
  { 6173, 25, 47, 34, 6, -47 },
  { 6320, 36, 59, 44, 4, -48 },
  { 6586, 27, 47, 35, 6, -47 },
  { 6745, 26, 49, 32, 3, -48 },
  { 6905, 30, 47, 30, 0, -47 },
  { 7082, 30, 48, 42, 6, -47 },
  { 7262, 33, 47, 33, 0, -47 },
  { 7456, 51, 47, 53, 1, -47 },
  { 7756, 30, 47, 30, 0, -47 },
  { 7933, 30, 47, 30, 0, -47 },
  { 8110, 28, 47, 32, 2, -47 },
  { 8275, 13, 57, 21, 6, -47 },
  { 8368, 20, 47, 22, 1, -47 },
  { 8486, 13, 57, 21, 2, -47 },
  { 8579, 29, 27, 34, 2, -47 },
  { 8677, 27, 2, 27, 0, 6 },
  { 8684, 11, 10, 16, 3, -50 },
  { 8698, 23, 37, 31, 3, -36 },
  { 8805, 27, 51, 35, 5, -50 },
  { 8978, 22, 37, 28, 4, -36 },
  { 9080, 27, 51, 35, 3, -50 },
  { 9253, 25, 37, 32, 4, -36 },
  { 9369, 19, 50, 17, 1, -50 },
  { 9488, 27, 52, 35, 3, -36 },
  { 9664, 24, 50, 34, 5, -50 },
  { 9814, 4, 48, 14, 5, -48 },
  { 9838, 11, 64, 14, -2, -48 },
  { 9926, 23, 50, 28, 5, -50 },
  { 10070, 3, 50, 13, 5, -50 },
  { 10089, 41, 36, 51, 5, -36 },
  { 10274, 24, 36, 34, 5, -36 },
  { 10382, 28, 37, 34, 3, -36 },
  { 10512, 27, 51, 35, 5, -36 },
  { 10685, 27, 51, 35, 3, -36 },
  { 10858, 17, 36, 23, 5, -36 },
  { 10935, 21, 37, 27, 3, -36 },
  { 11033, 16, 44, 19, 1, -43 },
  { 11121, 24, 36, 34, 5, -35 },
  { 11229, 26, 35, 26, 0, -35 },
  { 11343, 40, 35, 42, 1, -35 },
  { 11518, 26, 35, 28, 1, -35 },
  { 11632, 26, 51, 27, 0, -35 },
  { 11798, 21, 35, 26, 2, -35 },
  { 11890, 18, 57, 23, 2, -47 },
  { 12019, 2, 66, 32, 15, -50 },
  { 12036, 18, 57, 23, 3, -47 },
  { 12165, 28, 6, 34, 3, -26 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight66pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT66PT7B_H_
