#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHT18PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHT18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLight.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLight18pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xA0, 0xC0, 0x99, 0x99, 0x90, 0x09, 0x02, 0x41, 0x10,
  0x44, 0x7F, 0xC4, 0x41, 0x20, 0x48, 0xFF, 0x88, 0x82, 0x20, 0x88, 0x24,
  0x00, 0x10, 0x71, 0x54, 0x89, 0x12, 0x14, 0x1C, 0x14, 0x24, 0x48, 0x99,
  0x4F, 0x04, 0x00, 0x70, 0x92, 0x22, 0x24, 0x45, 0x08, 0xA1, 0x15, 0xA5,
  0x4B, 0xA9, 0x0A, 0x21, 0x44, 0x48, 0x88, 0x92, 0x1C, 0x38, 0x22, 0x11,
  0x08, 0x82, 0x41, 0xC0, 0xC0, 0x91, 0x84, 0xC1, 0xA0, 0xD0, 0x67, 0xC8,
  0xF8, 0x29, 0x49, 0x24, 0x92, 0x48, 0x91, 0x91, 0x22, 0x49, 0x24, 0x94,
  0xA4, 0x10, 0x22, 0x4B, 0xE3, 0x05, 0x11, 0x00, 0x10, 0x20, 0x40, 0x8F,
  0xE2, 0x04, 0x08, 0x10, 0xF0, 0xF0, 0xC0, 0x04, 0x20, 0x82, 0x10, 0x41,
  0x08, 0x21, 0x04, 0x10, 0x80, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0A, 0x23, 0x80, 0x2E, 0x92, 0x49, 0x24, 0x92, 0x79, 0x08,
  0x08, 0x10, 0x20, 0x81, 0x04, 0x10, 0x41, 0x02, 0x0F, 0xE0, 0x79, 0x08,
  0x08, 0x10, 0x20, 0x8E, 0x02, 0x02, 0x04, 0x08, 0x1F, 0xC0, 0x02, 0x03,
  0x02, 0x81, 0x41, 0x20, 0x90, 0x88, 0x84, 0x42, 0x7F, 0xC0, 0x80, 0x40,
  0x20, 0x7C, 0x81, 0x04, 0x08, 0x1F, 0x01, 0x01, 0x02, 0x04, 0x08, 0x1F,
  0xC0, 0x1C, 0x41, 0x04, 0x08, 0x17, 0xB0, 0xC1, 0x83, 0x06, 0x0A, 0x13,
  0xC0, 0xFE, 0x04, 0x08, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20, 0x81, 0x02,
  0x00, 0x3C, 0x86, 0x0C, 0x14, 0x45, 0x0E, 0x22, 0x83, 0x06, 0x0C, 0x17,
  0xC0, 0x79, 0x0A, 0x0C, 0x18, 0x30, 0x61, 0xBD, 0x02, 0x04, 0x10, 0x2F,
  0x80, 0xB0, 0x00, 0x30, 0xB0, 0x00, 0xAA, 0x06, 0x31, 0x84, 0x06, 0x03,
  0x01, 0x81, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0xC0, 0x60, 0x30, 0x10, 0xC6,
  0x10, 0x40, 0xF8, 0x10, 0x41, 0x04, 0x21, 0x08, 0x20, 0x80, 0x00, 0x20,
  0x0F, 0x83, 0x04, 0x40, 0x24, 0x01, 0x87, 0x98, 0x89, 0x90, 0x99, 0x09,
  0x91, 0x19, 0x11, 0x8E, 0xE8, 0x00, 0x40, 0x03, 0x08, 0x0F, 0x00, 0x08,
  0x06, 0x05, 0x02, 0x81, 0x21, 0x10, 0x88, 0x7E, 0x41, 0x20, 0x90, 0x30,
  0x18, 0x08, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0xBF, 0x41, 0x83, 0x06, 0x0C,
  0x1F, 0xC0, 0x1F, 0x20, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x40, 0x60, 0x1F, 0xF8, 0x84, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x82, 0x86, 0xF8, 0xFE, 0x08, 0x20, 0x82, 0x0F, 0xE0, 0x82, 0x08,
  0x20, 0xFC, 0xFE, 0x08, 0x20, 0x82, 0x0F, 0xE0, 0x82, 0x08, 0x20, 0x80,
  0x1F, 0x90, 0x10, 0x10, 0x08, 0x04, 0x02, 0x1D, 0x01, 0x80, 0xC0, 0x50,
  0x24, 0x11, 0xF8, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0xE9, 0x24, 0x92, 0x49, 0x2E, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x4F, 0x83, 0x0A, 0x24, 0x8A, 0x14, 0x38, 0x48, 0x91, 0x12,
  0x14, 0x28, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0xFC, 0x80, 0x60, 0x1C, 0x0F, 0x03, 0xC0, 0xE8, 0x5A, 0x16, 0x45, 0x92,
  0x64, 0x98, 0xC6, 0x31, 0x84, 0x40, 0x81, 0x81, 0xC1, 0xC1, 0xA1, 0x91,
  0x91, 0x89, 0x89, 0x85, 0x83, 0x83, 0x81, 0x1F, 0x18, 0x24, 0x0A, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x09, 0x02, 0x3F, 0x00,
  0xFA, 0x18, 0x61, 0x86, 0x18, 0xFC, 0x82, 0x08, 0x20, 0x80, 0x1F, 0x18,
  0x24, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x09,
  0x02, 0x3F, 0x00, 0x80, 0x10, 0x06, 0xF9, 0x0A, 0x14, 0x18, 0x50, 0xA2,
  0x78, 0x89, 0x12, 0x14, 0x28, 0x20, 0x7F, 0x02, 0x04, 0x08, 0x08, 0x0E,
  0x02, 0x02, 0x04, 0x08, 0x1F, 0xC0, 0xFF, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x7C, 0x80, 0xC0, 0x50, 0x48,
  0x24, 0x11, 0x10, 0x88, 0x44, 0x14, 0x0A, 0x05, 0x02, 0x80, 0x80, 0x81,
  0x05, 0x04, 0x14, 0x30, 0x50, 0xA2, 0x42, 0x88, 0x92, 0x22, 0x48, 0x89,
  0x14, 0x24, 0x50, 0x61, 0x41, 0x85, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x42,
  0x22, 0x24, 0x14, 0x18, 0x08, 0x18, 0x24, 0x24, 0x42, 0x41, 0x81, 0x81,
  0x81, 0x42, 0x42, 0x24, 0x24, 0x18, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08,
  0xFE, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x20, 0x81, 0x04, 0x0F, 0xE0,
  0xF2, 0x49, 0x24, 0x92, 0x49, 0x27, 0x81, 0x04, 0x10, 0x20, 0x82, 0x04,
  0x10, 0x20, 0x82, 0x04, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x4F, 0x10, 0x18,
  0x28, 0x44, 0x44, 0x82, 0x83, 0xFE, 0x89, 0x80, 0x7A, 0x10, 0x41, 0x1D,
  0x98, 0x61, 0x85, 0xF0, 0x80, 0x80, 0x80, 0x80, 0x9C, 0xE2, 0xC2, 0x81,
  0x81, 0x81, 0x81, 0x82, 0xC2, 0xBC, 0x3D, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x40, 0xF0, 0x02, 0x04, 0x08, 0x13, 0xA8, 0xE0, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x2F, 0xC0, 0x38, 0x8A, 0x0C, 0x1F, 0xF0, 0x20, 0x40, 0x40, 0x78,
  0x1C, 0x82, 0x08, 0xF0, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x80, 0x3A,
  0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0xFC, 0x08, 0x10, 0x3F, 0x80,
  0x81, 0x02, 0x04, 0x09, 0xDC, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x40, 0x9F, 0xF8, 0x20, 0x12, 0x49, 0x24, 0x92, 0x49, 0xE0, 0x81, 0x02,
  0x04, 0x08, 0x50, 0xA2, 0x48, 0xA1, 0xA2, 0x24, 0x48, 0x50, 0xC0, 0xFF,
  0xFC, 0xB8, 0xCC, 0x72, 0x82, 0x18, 0x21, 0x82, 0x18, 0x21, 0x82, 0x18,
  0x21, 0x82, 0x18, 0x21, 0x9D, 0xC7, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x04, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x42, 0x78, 0x9C, 0xA2,
  0xC2, 0x81, 0x81, 0x81, 0x81, 0x82, 0xC2, 0xBC, 0x80, 0x80, 0x80, 0x80,
  0x3A, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0xFC, 0x08, 0x10, 0x20,
  0x40, 0xBE, 0x31, 0x08, 0x42, 0x10, 0x84, 0x00, 0x7A, 0x08, 0x20, 0x40,
  0xC0, 0x81, 0x07, 0xE0, 0x42, 0x3E, 0x84, 0x21, 0x08, 0x42, 0x10, 0x70,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x46, 0xF4, 0x83, 0x05, 0x0A,
  0x24, 0x44, 0x8A, 0x14, 0x10, 0x20, 0x84, 0x30, 0xC5, 0x18, 0xA5, 0x14,
  0x94, 0x92, 0x8A, 0x51, 0x8A, 0x30, 0x82, 0x10, 0x82, 0x84, 0x91, 0x41,
  0x83, 0x0A, 0x12, 0x45, 0x84, 0x83, 0x05, 0x0A, 0x24, 0x44, 0x8A, 0x14,
  0x10, 0x20, 0x40, 0x82, 0x1C, 0x00, 0xF8, 0x42, 0x22, 0x11, 0x08, 0x87,
  0xC0, 0x19, 0x10, 0x84, 0x21, 0x08, 0xC2, 0x10, 0x84, 0x20, 0x83, 0xFF,
  0xFF, 0xC0, 0xC1, 0x08, 0x42, 0x10, 0x85, 0x31, 0x08, 0x42, 0x10, 0x98,
  0xFE,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLight18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 13, 4, 1, -13 },
  { 5, 4, 5, 6, 1, -13 },
  { 8, 10, 13, 10, 0, -13 },
  { 25, 7, 15, 9, 1, -14 },
  { 39, 11, 13, 13, 1, -13 },
  { 57, 9, 13, 11, 1, -13 },
  { 72, 1, 5, 3, 1, -13 },
  { 73, 3, 16, 5, 1, -13 },
  { 79, 3, 16, 5, 1, -13 },
  { 85, 7, 7, 9, 1, -14 },
  { 92, 7, 9, 9, 1, -11 },
  { 100, 1, 4, 4, 1, -2 },
  { 101, 4, 1, 5, 1, -5 },
  { 102, 2, 1, 4, 1, -1 },
  { 103, 6, 13, 6, 0, -13 },
  { 113, 7, 13, 9, 1, -13 },
  { 125, 3, 13, 9, 2, -13 },
  { 130, 7, 13, 9, 1, -13 },
  { 142, 7, 13, 9, 1, -13 },
  { 154, 9, 13, 9, 0, -13 },
  { 169, 7, 13, 9, 1, -13 },
  { 181, 7, 13, 9, 1, -13 },
  { 193, 7, 13, 9, 1, -13 },
  { 205, 7, 13, 9, 1, -13 },
  { 217, 7, 13, 9, 1, -13 },
  { 229, 2, 10, 4, 1, -10 },
  { 232, 2, 12, 4, 1, -10 },
  { 235, 7, 8, 9, 1, -10 },
  { 242, 7, 5, 9, 1, -9 },
  { 247, 7, 8, 9, 1, -10 },
  { 254, 6, 13, 7, 0, -13 },
  { 264, 12, 15, 14, 1, -13 },
  { 287, 9, 13, 9, 0, -13 },
  { 302, 7, 13, 10, 2, -13 },
  { 314, 8, 13, 10, 1, -13 },
  { 327, 8, 13, 11, 2, -13 },
  { 340, 6, 13, 9, 2, -13 },
  { 350, 6, 13, 8, 2, -13 },
  { 360, 9, 13, 12, 1, -13 },
  { 375, 8, 13, 11, 2, -13 },
  { 388, 3, 13, 5, 1, -13 },
  { 393, 3, 16, 4, -1, -13 },
  { 399, 7, 13, 9, 2, -13 },
  { 411, 6, 13, 8, 2, -13 },
  { 421, 10, 13, 14, 2, -13 },
  { 438, 8, 13, 12, 2, -13 },
  { 451, 10, 13, 12, 1, -13 },
  { 468, 6, 13, 9, 2, -13 },
  { 478, 10, 16, 12, 1, -13 },
  { 498, 7, 13, 9, 2, -13 },
  { 510, 7, 13, 9, 1, -13 },
  { 522, 8, 13, 8, 0, -13 },
  { 535, 8, 13, 11, 2, -13 },
  { 548, 9, 13, 9, 0, -13 },
  { 563, 14, 13, 14, 0, -13 },
  { 586, 8, 13, 8, 0, -13 },
  { 599, 8, 13, 8, 0, -13 },
  { 612, 7, 13, 9, 1, -13 },
  { 624, 3, 16, 6, 2, -13 },
  { 630, 6, 13, 6, 0, -13 },
  { 640, 3, 16, 6, 1, -13 },
  { 646, 8, 7, 9, 1, -13 },
  { 653, 7, 1, 7, 0, 1 },
  { 654, 3, 3, 4, 1, -14 },
  { 656, 6, 10, 8, 1, -10 },
  { 664, 8, 14, 10, 1, -14 },
  { 678, 6, 10, 8, 1, -10 },
  { 686, 7, 14, 10, 1, -14 },
  { 699, 7, 10, 9, 1, -10 },
  { 708, 6, 14, 5, 0, -14 },
  { 719, 7, 14, 10, 1, -10 },
  { 732, 7, 14, 9, 1, -14 },
  { 745, 1, 13, 4, 1, -13 },
  { 747, 3, 17, 4, -1, -13 },
  { 754, 7, 14, 8, 1, -14 },
  { 767, 1, 14, 4, 1, -14 },
  { 769, 12, 10, 14, 1, -10 },
  { 784, 7, 10, 9, 1, -10 },
  { 793, 7, 10, 9, 1, -10 },
  { 802, 8, 14, 10, 1, -10 },
  { 816, 7, 14, 10, 1, -10 },
  { 829, 5, 10, 6, 1, -10 },
  { 836, 6, 10, 7, 1, -10 },
  { 844, 5, 12, 5, 0, -12 },
  { 852, 7, 10, 9, 1, -10 },
  { 861, 7, 10, 7, 0, -10 },
  { 870, 11, 10, 12, 0, -10 },
  { 884, 7, 10, 8, 0, -10 },
  { 893, 7, 14, 7, 0, -10 },
  { 906, 5, 10, 7, 1, -10 },
  { 913, 5, 16, 6, 1, -13 },
  { 923, 1, 18, 9, 4, -14 },
  { 926, 5, 16, 6, 1, -13 },
  { 936, 7, 1, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLight18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLight18pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLight18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHT18PT7B_H_
