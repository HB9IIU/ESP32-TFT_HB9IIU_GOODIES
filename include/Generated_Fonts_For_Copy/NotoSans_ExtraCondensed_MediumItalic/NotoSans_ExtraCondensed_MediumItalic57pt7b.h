#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC57PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0x20, 0x00, 0x3F, 0x1F, 0x9F, 0x0F,
  0x8F, 0x87, 0xCF, 0xC3, 0xE7, 0xC3, 0xF3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8,
  0x7C, 0x78, 0x3C, 0x7C, 0x1E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x07, 0x87,
  0x83, 0xC3, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x70, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x1E, 0x10, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x00, 0xF0,
  0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0xC3, 0xC0, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0,
  0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x03, 0xF3, 0x1C, 0x03, 0xE3, 0x04, 0x07, 0xC7, 0x00, 0x07,
  0xC7, 0x00, 0x07, 0xC6, 0x00, 0x07, 0xC6, 0x00, 0x07, 0xC6, 0x00, 0x07,
  0xCE, 0x00, 0x07, 0xEC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3B, 0xF0, 0x00, 0x33, 0xF0, 0x00,
  0x31, 0xF0, 0x00, 0x31, 0xF0, 0x00, 0x71, 0xF0, 0x00, 0x71, 0xF0, 0x00,
  0x61, 0xF0, 0x40, 0x63, 0xE0, 0x60, 0x67, 0xE0, 0xFC, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0xF0, 0x01,
  0xE0, 0x1F, 0xF0, 0x07, 0x80, 0x7F, 0xE0, 0x1F, 0x01, 0xE3, 0xC0, 0x3C,
  0x03, 0xC3, 0xC0, 0xF8, 0x0F, 0x07, 0x81, 0xE0, 0x1E, 0x1F, 0x07, 0xC0,
  0x7C, 0x3C, 0x0F, 0x00, 0xF0, 0x78, 0x3E, 0x01, 0xE0, 0xF0, 0x78, 0x03,
  0xC1, 0xE1, 0xE0, 0x0F, 0x83, 0xC3, 0xC0, 0x1E, 0x07, 0x8F, 0x00, 0x3C,
  0x1E, 0x1E, 0x00, 0x78, 0x3C, 0x78, 0x00, 0xF0, 0x78, 0xF0, 0xF9, 0xE1,
  0xF3, 0xC3, 0xFB, 0xC3, 0xC7, 0x8F, 0xFF, 0x87, 0x9E, 0x3F, 0xFF, 0x1E,
  0x3C, 0xF9, 0xFF, 0xFC, 0xF1, 0xE3, 0xFF, 0xF3, 0xE7, 0x87, 0xBF, 0xC7,
  0x8F, 0x0F, 0x3F, 0x1F, 0x3E, 0x1E, 0x00, 0x3C, 0x78, 0x3C, 0x00, 0xF8,
  0xF0, 0x78, 0x01, 0xE1, 0xE0, 0xF0, 0x07, 0xC7, 0x81, 0xE0, 0x0F, 0x0F,
  0x03, 0xC0, 0x3C, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x1E, 0x01, 0xE0, 0x78,
  0x3C, 0x03, 0xC0, 0xF0, 0xF8, 0x0F, 0x01, 0xE1, 0xE0, 0x1E, 0x03, 0xC3,
  0xC0, 0x78, 0x07, 0x8F, 0x00, 0xF0, 0x0F, 0x3E, 0x03, 0xC0, 0x1F, 0xF8,
  0x07, 0x80, 0x1F, 0xE0, 0x1E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xCF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x7C, 0x3F, 0xF8, 0x3E,
  0x3F, 0x7E, 0x3F, 0x1F, 0x1F, 0x1F, 0x1F, 0x0F, 0x8F, 0x9F, 0x87, 0xEF,
  0x8F, 0x81, 0xF7, 0xC7, 0xC0, 0xFF, 0xC7, 0xC0, 0x7F, 0xE3, 0xE0, 0x1F,
  0xE1, 0xF0, 0x0F, 0xF0, 0xF8, 0x07, 0xF0, 0x7C, 0x03, 0xF8, 0x3E, 0x01,
  0xFC, 0x1F, 0x81, 0xFE, 0x0F, 0xE3, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF,
  0xF3, 0xE0, 0x7F, 0xF1, 0xF8, 0x1F, 0xE0, 0xFC, 0x01, 0x80, 0x00, 0x00,
  0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8,
  0xF8, 0xF0, 0xF0, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x41, 0xE0, 0x1E, 0x3C, 0x03, 0xF7, 0x8E, 0x7F, 0xFF, 0xDF, 0xFF,
  0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF,
  0x01, 0xF9, 0xE0, 0x7E, 0x3E, 0x07, 0x87, 0xC0, 0x70, 0x7C, 0x04, 0x0E,
  0x00, 0x01, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0,
  0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0,
  0xF0, 0x3E, 0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3E, 0xFD, 0xFB, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x07, 0xC0, 0xF8, 0x1F,
  0x07, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x0F,
  0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F, 0x3F, 0x00,
  0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x7E, 0x01, 0xF9,
  0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0,
  0x0F, 0xCF, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F,
  0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x7E, 0x0F,
  0x81, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFF, 0x1F,
  0xFE, 0x7F, 0xFD, 0xF9, 0xF3, 0xE3, 0xE3, 0x87, 0xC2, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xC1, 0xFC, 0x01, 0xC0,
  0x7E, 0x00, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xE0, 0x3F, 0x00, 0x80, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xC0, 0x0F, 0xE0,
  0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xBE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0x7C, 0x00, 0x0E, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0xFC,
  0x00, 0x3C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF8,
  0x01, 0xE1, 0xF8, 0x03, 0xE1, 0xF0, 0x03, 0xC1, 0xF0, 0x07, 0x81, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x1E, 0x03, 0xE0,
  0x3C, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xBF, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x80, 0x0F, 0xC0, 0x80, 0x1F, 0xC0, 0xF0, 0x7F, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xCE, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x0F, 0x00, 0x1F, 0x3F, 0xC0, 0x3F, 0x7F, 0xE0, 0x3E, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xC3, 0xF0, 0x7F, 0x03, 0xF0, 0x7F, 0x01, 0xF0,
  0x7E, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0x7C, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xE0,
  0xFC, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0,
  0x7C, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x3F,
  0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0xFC, 0x03, 0xF1, 0xF8,
  0x01, 0xF3, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xEF, 0xC0, 0x1F, 0xCF, 0xC0,
  0x3F, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x7C, 0x01, 0xF0,
  0xFC, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0xFC, 0x07, 0xE0,
  0xFE, 0x0F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7E, 0x0F, 0x80,
  0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0,
  0x1F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07,
  0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x07, 0xFF, 0x7C, 0x07, 0xFC, 0xF8, 0x07, 0xE3, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x08, 0x1F, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x03, 0xF0,
  0x7F, 0x07, 0xF0, 0x7E, 0x03, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC0, 0x78, 0x02, 0x00, 0x00, 0x1C, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFD, 0xFC, 0x0C, 0x0F, 0xC2, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0x3F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x01, 0xF0,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x0F, 0xE0, 0xF0, 0x78,
  0x1F, 0xF8, 0x78, 0x78, 0x1F, 0xFC, 0x3C, 0x3C, 0x1F, 0x9E, 0x1E, 0x1C,
  0x0F, 0x0F, 0x0F, 0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x0F, 0x07, 0x83, 0xCF,
  0x07, 0x83, 0xC1, 0xC7, 0x83, 0xC1, 0xE0, 0xE3, 0xC3, 0xC1, 0xE0, 0xF1,
  0xC1, 0xE0, 0xF0, 0x79, 0xE0, 0xF0, 0x78, 0x3C, 0xF0, 0xF0, 0x3C, 0x1C,
  0x78, 0x78, 0x3C, 0x1E, 0x3C, 0x3C, 0x1E, 0x0F, 0x1C, 0x1E, 0x0F, 0x07,
  0x0E, 0x0F, 0x0F, 0x87, 0x8F, 0x07, 0x87, 0xC3, 0x87, 0x83, 0xC7, 0xE3,
  0xC3, 0xC1, 0xE3, 0x73, 0xC1, 0xE0, 0xFF, 0xBF, 0xE0, 0xF0, 0x3F, 0x9F,
  0xE0, 0x78, 0x1F, 0x87, 0xE0, 0x3C, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x08, 0x00, 0x0F, 0x80,
  0x18, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xEF, 0x00, 0x03, 0xEF, 0x00, 0x03,
  0xDF, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xDF, 0x00, 0x0F, 0x9F, 0x00, 0x0F,
  0x9F, 0x00, 0x1F, 0x9F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xFC,
  0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xE0,
  0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x1F, 0x80,
  0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3F, 0x00,
  0x1F, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x07, 0xC0, 0x3F,
  0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0,
  0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x01, 0xF0, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xF8, 0x1F,
  0x80, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x01, 0xF0,
  0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x03,
  0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x7E,
  0x07, 0xE0, 0x3F, 0x81, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xE0, 0x30, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x10, 0x07, 0xF8, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xF0, 0xFF, 0x00, 0x7E, 0x07, 0xF0,
  0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0xC0,
  0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x00,
  0xF8, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x81, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x07, 0xE0,
  0x3E, 0x01, 0xFC, 0x07, 0xC0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x0F,
  0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x1C, 0x01, 0xFC,
  0x00, 0x40, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x7E,
  0x03, 0xFF, 0x87, 0xC0, 0x3F, 0xF0, 0xFC, 0x03, 0xFF, 0x0F, 0xC0, 0x3F,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F,
  0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x7C, 0x0F, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0xC0,
  0x7E, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x3F, 0xC3, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0,
  0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF8, 0x07,
  0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7C, 0x01, 0xF0,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x3E, 0x00, 0x7E,
  0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x80,
  0x1F, 0x80, 0x7E, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x07,
  0xC0, 0x1F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF8, 0x07,
  0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x3E, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0xFC,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x01,
  0xF0, 0x7E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x9F, 0x80,
  0x00, 0xFC, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFD, 0xF0, 0x00, 0x1F, 0xCF, 0x80,
  0x00, 0xFC, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01,
  0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3F, 0x00, 0x3E, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xBC,
  0x00, 0x7F, 0xE0, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x3E, 0xF0, 0x03, 0xFF,
  0x80, 0x7D, 0xE0, 0x0F, 0xBE, 0x00, 0xFB, 0xC0, 0x1F, 0x7C, 0x03, 0xE7,
  0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x00, 0xFB, 0xF0, 0x0F, 0x9E, 0x01, 0xE7,
  0xC0, 0x1F, 0x3C, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x0F, 0x1F, 0x00, 0xF8,
  0xF8, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x7C, 0xFC, 0x03, 0xE3, 0xE1, 0xF1,
  0xF0, 0x07, 0xC7, 0xC3, 0xE3, 0xE0, 0x1F, 0x8F, 0x8F, 0x87, 0xC0, 0x3E,
  0x1F, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x3C, 0x3F, 0x00, 0xF8, 0x7C, 0xF8,
  0x7C, 0x01, 0xF0, 0xF9, 0xE0, 0xF8, 0x07, 0xC1, 0xF7, 0xC1, 0xF0, 0x0F,
  0x83, 0xEF, 0x87, 0xE0, 0x1F, 0x07, 0xFE, 0x0F, 0x80, 0x3E, 0x0F, 0xFC,
  0x1F, 0x00, 0x7C, 0x1F, 0xF0, 0x3E, 0x01, 0xF0, 0x3F, 0xE0, 0x7C, 0x03,
  0xE0, 0x3F, 0x81, 0xF8, 0x07, 0xC0, 0x7F, 0x03, 0xE0, 0x0F, 0x80, 0xFC,
  0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x3E, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0xFE, 0x00,
  0x7E, 0x01, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x00,
  0x7C, 0x01, 0xFF, 0x00, 0x7C, 0x01, 0xEF, 0x00, 0xFC, 0x03, 0xEF, 0x00,
  0xF8, 0x03, 0xEF, 0x80, 0xF8, 0x03, 0xEF, 0x80, 0xF8, 0x03, 0xEF, 0x80,
  0xF8, 0x03, 0xEF, 0x81, 0xF8, 0x07, 0xC7, 0x81, 0xF0, 0x07, 0xC7, 0x81,
  0xF0, 0x07, 0xC7, 0xC1, 0xF0, 0x07, 0xC7, 0xC1, 0xF0, 0x0F, 0xC7, 0xC3,
  0xE0, 0x0F, 0x87, 0xC3, 0xE0, 0x0F, 0x83, 0xC3, 0xE0, 0x0F, 0x83, 0xC3,
  0xE0, 0x0F, 0x83, 0xE3, 0xE0, 0x1F, 0x83, 0xE7, 0xC0, 0x1F, 0x03, 0xE7,
  0xC0, 0x1F, 0x03, 0xE7, 0xC0, 0x1F, 0x01, 0xE7, 0xC0, 0x1F, 0x01, 0xE7,
  0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x3E, 0x01, 0xFF, 0x80, 0x3E, 0x01, 0xFF,
  0x80, 0x3E, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0xFF,
  0x00, 0x7C, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0xFF,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0x07, 0xF0, 0x3F, 0x00, 0xFC,
  0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0xFC, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF3, 0xF0,
  0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xF7,
  0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0x9F, 0x00, 0x03,
  0xE7, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00,
  0x07, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0xBF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xC3,
  0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F,
  0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x3F, 0x03,
  0xE0, 0x1F, 0x81, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x7F, 0xC0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0x07, 0xF0, 0x3F,
  0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x01, 0xF0,
  0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x01,
  0xF3, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xCF, 0x80,
  0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF,
  0x00, 0x03, 0xE7, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F,
  0xBF, 0x00, 0x07, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0,
  0x7F, 0xBF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE0, 0xFE, 0x03,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7C,
  0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x3F,
  0x81, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0xFC,
  0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x83,
  0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xE0, 0x70, 0x0F, 0xE0, 0x08, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x30, 0x01, 0xF8, 0x1E,
  0x03, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x40,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00,
  0x7E, 0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x07,
  0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x07,
  0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0xFC,
  0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x7C, 0x00, 0xFC,
  0x0F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81,
  0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x0F,
  0xFB, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8,
  0x03, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8,
  0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0xF8,
  0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0xF8,
  0x7E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF9, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xFB,
  0xE0, 0x00, 0xFB, 0xE0, 0x00, 0xFB, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF0,
  0x03, 0xF3, 0xE0, 0x07, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0xC0, 0x0F, 0x8F,
  0x80, 0x3F, 0x80, 0x3F, 0x1F, 0x00, 0x7F, 0x00, 0x7C, 0x3E, 0x00, 0xFE,
  0x01, 0xF8, 0x7C, 0x03, 0xFC, 0x03, 0xE0, 0xF8, 0x07, 0xF8, 0x07, 0xC1,
  0xF0, 0x1F, 0xF0, 0x1F, 0x83, 0xE0, 0x3D, 0xE0, 0x3E, 0x07, 0xC0, 0x7F,
  0xC0, 0xFC, 0x0F, 0x81, 0xFF, 0x81, 0xF0, 0x1F, 0x03, 0xDF, 0x03, 0xE0,
  0x3E, 0x07, 0xBE, 0x0F, 0xC0, 0x7C, 0x1F, 0x7C, 0x1F, 0x00, 0xF8, 0x3C,
  0xF8, 0x3E, 0x01, 0xF0, 0xF9, 0xF0, 0xF8, 0x07, 0xE1, 0xE3, 0xE1, 0xF0,
  0x0F, 0xC3, 0xC7, 0x87, 0xE0, 0x1F, 0x8F, 0x8F, 0x0F, 0x80, 0x3E, 0x1E,
  0x1E, 0x1F, 0x00, 0x7C, 0x7C, 0x3C, 0x7E, 0x00, 0xF8, 0xF8, 0x78, 0xF8,
  0x01, 0xF1, 0xE0, 0xF3, 0xF0, 0x03, 0xE7, 0xC1, 0xE7, 0xC0, 0x07, 0xCF,
  0x03, 0xCF, 0x80, 0x0F, 0xBE, 0x07, 0xBF, 0x00, 0x1F, 0x7C, 0x0F, 0x7C,
  0x00, 0x3E, 0xF0, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7C, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xE0,
  0x7E, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x3E, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0xFC, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0,
  0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x7D, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0x9F, 0x80, 0x7E, 0x7E,
  0x01, 0xF1, 0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x81, 0xF8, 0x3E, 0x07,
  0xC0, 0xF8, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00,
  0xF8, 0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x00, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0x78, 0x1E, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7D,
  0xF0, 0x00, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F,
  0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0x7C,
  0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xEF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFC, 0x3F, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x1E, 0x07, 0x80,
  0x00, 0x7F, 0x1F, 0x00, 0xFF, 0x9F, 0x01, 0xFF, 0x9E, 0x03, 0xFF, 0xFE,
  0x07, 0xFB, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xFC,
  0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8,
  0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xFC, 0x03, 0xF0,
  0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0,
  0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0x7E, 0x3F, 0xC0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xF7, 0xC0, 0x3F, 0xE7, 0xC0, 0x1F, 0xC7, 0x80, 0x02, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x3F, 0x00, 0x7C, 0xFF, 0x00, 0xFB, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFC,
  0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x03,
  0xE1, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC3,
  0xE0, 0x0F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0xF8, 0x7C,
  0x03, 0xF0, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0x87, 0xE0, 0x3F, 0x0F, 0xE0,
  0xFC, 0x1F, 0xE3, 0xF8, 0x3D, 0xFF, 0xE0, 0xFB, 0xFF, 0x81, 0xF3, 0xFE,
  0x03, 0xC3, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xF9, 0xC0, 0x7E, 0x04, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x40,
  0x7F, 0x0C, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0xEF,
  0x80, 0x1F, 0xFB, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFB, 0xFE, 0x01, 0xF8,
  0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x3E, 0x00, 0xF8,
  0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x01,
  0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xFC,
  0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x07, 0xE3, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xF7, 0xC0, 0x0F, 0xF9, 0xF0, 0x01, 0xFC, 0x78, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7E, 0x1F, 0x03, 0xE0, 0x7C, 0x3E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F,
  0x00, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xC3, 0xE0, 0xFE,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x04, 0x1F, 0x80,
  0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xC4, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xC7, 0xC0, 0x0F, 0xF9, 0xF0, 0x07, 0xFE, 0x78, 0x03,
  0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x7E, 0x0F, 0xE0, 0x3F, 0x03, 0xF0,
  0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x81, 0xF8,
  0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x01,
  0xF0, 0x07, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC1,
  0xFC, 0x01, 0xF8, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFD, 0xF0, 0x03,
  0xFE, 0xFC, 0x00, 0x7F, 0x3E, 0x00, 0x02, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x08, 0x01, 0xF8, 0x03, 0x80, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x7C, 0xFF, 0x00, 0xFB, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x03, 0xF0, 0x7C, 0x07, 0xE1, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0xF8, 0x07,
  0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x07, 0xC0, 0x7C, 0x1F, 0x80, 0xF8,
  0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0xFC,
  0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0x00, 0x78, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x03, 0xE0,
  0xFC, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xC7,
  0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0xCF, 0x80, 0x0F, 0x9F, 0x80, 0x0F, 0xBF,
  0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x9F, 0x00, 0x3F, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x0F,
  0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x03, 0xE3, 0xF0, 0x3F, 0x00, 0xF3, 0xFE, 0x3F, 0xE0, 0x3D,
  0xFF, 0xDF, 0xFC, 0x0F, 0x7F, 0xFF, 0xFF, 0x07, 0xFC, 0xFF, 0xDF, 0xC1,
  0xFC, 0x1F, 0xC1, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x1F, 0x81, 0xF8, 0x1F,
  0x07, 0xC0, 0x7C, 0x07, 0xC3, 0xF0, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC0,
  0x7C, 0x3E, 0x03, 0xF0, 0x3F, 0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x3E,
  0x03, 0xE1, 0xF8, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE0, 0x3E, 0x1F, 0x01,
  0xF0, 0x1F, 0x87, 0xC0, 0x7C, 0x07, 0xC3, 0xF0, 0x1F, 0x01, 0xF0, 0xF8,
  0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x0F, 0xC3,
  0xE0, 0x3E, 0x03, 0xE1, 0xF8, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE0, 0x3E,
  0x1F, 0x01, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x01,
  0xF0, 0xFC, 0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0x0F, 0xC0, 0x03, 0xC3, 0xF0, 0x07, 0x8F, 0xF0, 0x0F, 0x3F, 0xF0, 0x1E,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0,
  0x3F, 0x07, 0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0x80, 0x7C,
  0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0x83,
  0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x3F, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x0F, 0xC0,
  0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xF3, 0xF8, 0x1F, 0x07,
  0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xF3,
  0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xC0,
  0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x01, 0xF9, 0xF0, 0x07, 0xE7, 0xC0, 0x1F,
  0x3F, 0x00, 0x7C, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0x8F, 0xC0, 0x7E, 0x3F,
  0x01, 0xF8, 0x7C, 0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xE3, 0xF8, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x20, 0x00,
  0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x3F, 0xC0, 0x07, 0x9F, 0xF8, 0x01, 0xEF,
  0xFF, 0x00, 0x7F, 0x8F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xE0, 0x7C, 0x03,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0x7C,
  0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3E, 0x00,
  0xFC, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E,
  0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0xC0,
  0x7C, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x3F,
  0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0x7F, 0xF0, 0x07, 0xCF,
  0xF8, 0x01, 0xF1, 0xFC, 0x00, 0x7C, 0x10, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x1F, 0x00, 0xFF, 0x9E, 0x01, 0xFF, 0x9E, 0x03, 0xFF, 0xFE, 0x07,
  0xF3, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xFC, 0x1F,
  0x80, 0xFC, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC,
  0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0x7E, 0x3F, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xF7, 0xC0, 0x3F, 0xEF, 0xC0, 0x1F, 0xCF, 0x80, 0x02, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xC3, 0xE0, 0x78, 0xFC, 0x0F, 0x3F, 0x81, 0xEF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xF8, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x7E, 0x1E, 0x03, 0xE0, 0x10, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x06, 0x01, 0xF8,
  0x3C, 0x3F, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF,
  0xC0, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xFF, 0x1F, 0xFE, 0x7F, 0xFC, 0xFF,
  0xF9, 0xFF, 0xE0, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xF8, 0x01, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C,
  0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F, 0x83,
  0xE0, 0x1F, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x87, 0xE0, 0x3E, 0x0F, 0x80,
  0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF8, 0x0F,
  0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF0,
  0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xF8, 0xFF, 0x03,
  0xFF, 0xBC, 0x07, 0xFF, 0x78, 0x0F, 0xFC, 0xF0, 0x0F, 0xF1, 0xE0, 0x03,
  0x00, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xEF, 0x80, 0x7E,
  0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0x87, 0x80, 0xF8, 0x78, 0x1F,
  0x87, 0x81, 0xF0, 0x78, 0x1F, 0x07, 0x83, 0xE0, 0x78, 0x3E, 0x07, 0x87,
  0xC0, 0x78, 0x7C, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0x79,
  0xF0, 0x07, 0x9F, 0x00, 0x7B, 0xE0, 0x07, 0xBE, 0x00, 0x7B, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x1F,
  0x7C, 0x07, 0xE0, 0x3E, 0x7C, 0x0F, 0xE0, 0x3E, 0x7C, 0x0F, 0xE0, 0x3E,
  0x78, 0x0F, 0xE0, 0x7C, 0xF8, 0x1F, 0xE0, 0x7C, 0xF8, 0x1F, 0xE0, 0xF8,
  0xF8, 0x1F, 0xE0, 0xF8, 0xF8, 0x3D, 0xE0, 0xF8, 0xF8, 0x3D, 0xE1, 0xF0,
  0xF8, 0x7D, 0xE1, 0xF0, 0xF8, 0x7B, 0xE3, 0xE0, 0xF8, 0x7B, 0xE3, 0xE0,
  0xF8, 0xF3, 0xE3, 0xE0, 0xF8, 0xF3, 0xE7, 0xC0, 0xF9, 0xF3, 0xE7, 0xC0,
  0xF9, 0xE3, 0xE7, 0x80, 0xF9, 0xE3, 0xEF, 0x80, 0xFB, 0xE3, 0xCF, 0x80,
  0xFB, 0xC3, 0xDF, 0x00, 0xFB, 0xC3, 0xDF, 0x00, 0xFF, 0x83, 0xDE, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x0F, 0x81, 0xF8, 0x03, 0xE0,
  0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x01,
  0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xF9, 0xF0, 0x00,
  0x3E, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xE1, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x80,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xE0, 0x07,
  0xC0, 0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F,
  0x80, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7D, 0xF0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x40, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x38, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x04, 0xFF, 0x80, 0x17, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xF8, 0x01, 0xFF, 0x20, 0x00, 0x70,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 15, 42, 14, 0, -41 },
  { 80, 17, 15, 20, 6, -41 },
  { 112, 27, 41, 25, 0, -41 },
  { 251, 24, 46, 23, 0, -43 },
  { 389, 31, 42, 36, 3, -41 },
  { 552, 25, 42, 26, 0, -41 },
  { 684, 8, 15, 12, 6, -41 },
  { 699, 18, 50, 15, 1, -41 },
  { 812, 18, 50, 15, -4, -41 },
  { 925, 19, 21, 21, 5, -44 },
  { 975, 22, 27, 25, 2, -34 },
  { 1050, 11, 15, 12, -3, -7 },
  { 1071, 13, 5, 15, 1, -18 },
  { 1080, 7, 8, 12, 0, -7 },
  { 1087, 27, 41, 20, -3, -41 },
  { 1226, 22, 42, 23, 1, -41 },
  { 1342, 15, 41, 23, 6, -41 },
  { 1419, 25, 41, 23, -2, -41 },
  { 1548, 24, 42, 23, -1, -41 },
  { 1674, 24, 41, 23, -1, -41 },
  { 1797, 24, 42, 23, 0, -41 },
  { 1923, 24, 42, 23, 1, -41 },
  { 2049, 24, 41, 23, 2, -41 },
  { 2172, 24, 42, 23, 0, -41 },
  { 2298, 23, 42, 23, 0, -41 },
  { 2419, 12, 32, 12, 0, -31 },
  { 2467, 15, 39, 12, -3, -31 },
  { 2541, 22, 26, 25, 2, -33 },
  { 2613, 22, 16, 25, 2, -28 },
  { 2657, 22, 26, 25, 2, -33 },
  { 2729, 19, 42, 17, 1, -41 },
  { 2829, 33, 46, 34, 1, -41 },
  { 3019, 24, 41, 24, -4, -41 },
  { 3142, 26, 41, 25, 0, -41 },
  { 3276, 25, 42, 23, 2, -41 },
  { 3408, 27, 41, 27, 0, -41 },
  { 3547, 24, 41, 21, 0, -41 },
  { 3670, 24, 41, 20, 0, -41 },
  { 3793, 28, 42, 29, 2, -41 },
  { 3940, 30, 41, 28, 0, -41 },
  { 4094, 23, 41, 16, -3, -41 },
  { 4212, 23, 52, 12, -9, -41 },
  { 4362, 29, 41, 24, 0, -41 },
  { 4511, 16, 41, 20, 0, -41 },
  { 4593, 39, 41, 38, 0, -41 },
  { 4793, 32, 41, 30, 0, -41 },
  { 4957, 26, 42, 29, 2, -41 },
  { 5094, 25, 41, 24, 0, -41 },
  { 5223, 26, 51, 29, 2, -41 },
  { 5389, 25, 41, 25, 0, -41 },
  { 5518, 25, 42, 22, -1, -41 },
  { 5650, 21, 41, 20, 4, -41 },
  { 5758, 27, 42, 28, 2, -41 },
  { 5900, 24, 41, 24, 5, -41 },
  { 6023, 39, 41, 38, 4, -41 },
  { 6223, 29, 41, 22, -3, -41 },
  { 6372, 22, 41, 21, 4, -41 },
  { 6485, 26, 41, 20, -2, -41 },
  { 6619, 22, 50, 16, -2, -41 },
  { 6757, 10, 41, 20, 6, -41 },
  { 6809, 22, 50, 16, -4, -41 },
  { 6947, 23, 23, 23, 0, -41 },
  { 7014, 18, 3, 18, -5, 5 },
  { 7021, 9, 9, 15, 8, -44 },
  { 7032, 24, 32, 25, 1, -31 },
  { 7128, 23, 44, 24, 0, -43 },
  { 7255, 20, 32, 19, 1, -31 },
  { 7335, 26, 44, 25, 1, -43 },
  { 7478, 21, 32, 22, 1, -31 },
  { 7562, 28, 58, 14, -7, -44 },
  { 7765, 26, 45, 25, -1, -31 },
  { 7912, 23, 43, 24, 0, -43 },
  { 8036, 14, 42, 12, 0, -42 },
  { 8110, 21, 56, 12, -7, -42 },
  { 8257, 24, 43, 22, 0, -43 },
  { 8386, 14, 43, 11, 0, -43 },
  { 8462, 34, 31, 36, 0, -31 },
  { 8594, 23, 31, 24, 0, -31 },
  { 8684, 22, 32, 24, 1, -31 },
  { 8772, 26, 44, 24, -3, -31 },
  { 8915, 24, 45, 25, 1, -31 },
  { 9050, 19, 31, 17, 0, -31 },
  { 9124, 21, 32, 19, -1, -31 },
  { 9208, 15, 39, 14, 1, -38 },
  { 9282, 23, 32, 24, 1, -31 },
  { 9374, 20, 31, 20, 3, -31 },
  { 9452, 32, 31, 32, 3, -31 },
  { 9576, 26, 31, 21, -3, -31 },
  { 9677, 28, 45, 20, -5, -31 },
  { 9835, 21, 31, 17, -2, -31 },
  { 9917, 22, 50, 19, 1, -41 },
  { 10055, 5, 57, 21, 8, -44 },
  { 10091, 21, 50, 19, -3, -41 },
  { 10223, 22, 8, 25, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC57PT7B_H_
