#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC16PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x22, 0x26, 0x44, 0x0C, 0xC0, 0xDB, 0xBA, 0x1A, 0x24, 0x53,
  0xF2, 0x45, 0x3F, 0x7E, 0x50, 0xA2, 0x40, 0x08, 0x3C, 0xF3, 0x47, 0x06,
  0x06, 0x0E, 0x2D, 0x53, 0xE1, 0x02, 0x00, 0x21, 0x39, 0x34, 0x92, 0x8B,
  0x45, 0x5B, 0xBA, 0xA9, 0x35, 0x92, 0x99, 0x48, 0xC0, 0x08, 0x38, 0x91,
  0x22, 0x87, 0x1C, 0xAF, 0xDD, 0x1B, 0x77, 0xE0, 0xEA, 0x18, 0x88, 0x46,
  0x21, 0x18, 0xC6, 0x31, 0x84, 0x20, 0x10, 0x86, 0x31, 0x8C, 0x62, 0x10,
  0x8C, 0x46, 0x22, 0x00, 0x11, 0x4F, 0xCC, 0x58, 0x20, 0x82, 0x3F, 0x20,
  0x82, 0x00, 0x2D, 0x60, 0xF0, 0xF0, 0x03, 0x06, 0x04, 0x0C, 0x08, 0x18,
  0x10, 0x20, 0x20, 0x40, 0xC0, 0x08, 0x72, 0x59, 0x65, 0x14, 0x73, 0xCF,
  0x2D, 0x9C, 0x3F, 0xA2, 0x66, 0x44, 0x4C, 0xC0, 0x0C, 0x3C, 0x48, 0x10,
  0x20, 0xC3, 0x04, 0x10, 0x41, 0x87, 0xE0, 0x18, 0x78, 0x18, 0x20, 0x47,
  0x0E, 0x04, 0x0C, 0x12, 0x67, 0x80, 0x06, 0x18, 0x30, 0xA3, 0xC5, 0x92,
  0x24, 0xFD, 0xF8, 0x40, 0x80, 0x3E, 0x40, 0x83, 0x07, 0x81, 0x83, 0x06,
  0x09, 0x33, 0xC0, 0x06, 0x3C, 0xC1, 0x06, 0x0B, 0x9B, 0x26, 0xCD, 0x99,
  0x63, 0x80, 0x7E, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x18, 0x20, 0xC3, 0x00,
  0x08, 0x78, 0x9B, 0x32, 0x47, 0x0E, 0x24, 0xCD, 0x1B, 0x23, 0x80, 0x08,
  0xF6, 0x59, 0x45, 0x37, 0xCF, 0x08, 0x61, 0x38, 0x2C, 0x00, 0x06, 0xC0,
  0x11, 0x00, 0x00, 0x02, 0x64, 0xC0, 0x0C, 0xEE, 0x30, 0x70, 0x70, 0x40,
  0xFC, 0x00, 0x3F, 0xFC, 0x83, 0x83, 0x83, 0x33, 0x08, 0x00, 0x11, 0xE0,
  0xC2, 0x18, 0x42, 0x18, 0x40, 0x04, 0x30, 0x02, 0x03, 0x61, 0x08, 0x82,
  0x6E, 0xD6, 0xA5, 0x29, 0x5A, 0x94, 0xA6, 0xCC, 0x01, 0x00, 0x7C, 0x00,
  0x0E, 0x1C, 0x38, 0xF1, 0x66, 0xCF, 0xBF, 0x66, 0x8F, 0x18, 0x3E, 0x44,
  0x89, 0x37, 0xCF, 0x91, 0x22, 0x4D, 0x9B, 0xE0, 0x08, 0x7D, 0x82, 0x0C,
  0x18, 0x20, 0x40, 0x81, 0x03, 0x27, 0x80, 0x3E, 0x6C, 0x89, 0x16, 0x2C,
  0x51, 0xA3, 0x4D, 0xB3, 0xC0, 0x3E, 0x60, 0x81, 0x07, 0xCF, 0x10, 0x20,
  0x41, 0x93, 0xC0, 0x3E, 0x60, 0x81, 0x06, 0x0F, 0x10, 0x20, 0x41, 0x83,
  0x00, 0x0C, 0x7D, 0x82, 0x0C, 0x18, 0x67, 0x42, 0x8D, 0x1B, 0x33, 0xC0,
  0x31, 0x33, 0x23, 0x23, 0x7E, 0x7E, 0x46, 0x46, 0x44, 0xC4, 0xCC, 0x3E,
  0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x20, 0x43, 0xC0, 0x0C, 0x30, 0x82,
  0x18, 0x61, 0x04, 0x10, 0xC3, 0x08, 0x63, 0x00, 0x33, 0x26, 0x2C, 0x28,
  0x78, 0x78, 0x78, 0x58, 0x48, 0xC8, 0xCC, 0x31, 0x88, 0x46, 0x31, 0x08,
  0x46, 0x7C, 0x30, 0xE7, 0x1C, 0xE7, 0x1C, 0xA7, 0x9C, 0xF5, 0x96, 0xB2,
  0xF4, 0x5C, 0x99, 0xB3, 0x26, 0x00, 0x31, 0x98, 0x8E, 0x47, 0x26, 0xB3,
  0x59, 0x28, 0x94, 0x4E, 0x67, 0x31, 0x80, 0x08, 0x79, 0x9A, 0x3C, 0x78,
  0xE1, 0xC2, 0x8D, 0x1B, 0x67, 0x80, 0x3E, 0x6C, 0x89, 0x36, 0x6F, 0x9C,
  0x20, 0x41, 0x83, 0x00, 0x08, 0x79, 0x9A, 0x3C, 0x78, 0xE1, 0xC2, 0x8D,
  0x1B, 0x67, 0x83, 0x06, 0x06, 0x00, 0x3E, 0x4C, 0x99, 0x36, 0x4F, 0x96,
  0x2C, 0x49, 0x93, 0x30, 0x08, 0x7D, 0x83, 0x06, 0x06, 0x0E, 0x0C, 0x08,
  0x12, 0x67, 0x80, 0xFC, 0xC2, 0x08, 0x61, 0x86, 0x10, 0x43, 0x0C, 0x00,
  0x62, 0x8D, 0x1A, 0x2C, 0x59, 0xA3, 0x46, 0x89, 0x33, 0xC0, 0xC7, 0x8B,
  0x36, 0x4D, 0x9B, 0x34, 0x78, 0xE1, 0xC3, 0x00, 0xC4, 0x79, 0x8B, 0x33,
  0x6E, 0x4D, 0x49, 0xAB, 0x3D, 0x47, 0x38, 0xE6, 0x18, 0xC3, 0x18, 0x00,
  0x13, 0x12, 0x1E, 0x1C, 0x1C, 0x18, 0x18, 0x3C, 0x2C, 0x4C, 0xCC, 0xCD,
  0x25, 0x94, 0x71, 0x86, 0x10, 0x41, 0x0C, 0x00, 0x1F, 0x06, 0x04, 0x0C,
  0x08, 0x18, 0x30, 0x30, 0x60, 0x44, 0xF8, 0x0E, 0x38, 0x40, 0x81, 0x06,
  0x0C, 0x10, 0x20, 0x41, 0x83, 0x04, 0x0E, 0x3C, 0x00, 0xAA, 0xFD, 0x54,
  0x1C, 0x70, 0xC2, 0x08, 0x21, 0x86, 0x10, 0x41, 0x0C, 0x23, 0x8E, 0x00,
  0x18, 0x30, 0xF1, 0x24, 0x58, 0xC0, 0xF8, 0xCC, 0x1A, 0x7D, 0x9A, 0x24,
  0x59, 0xB3, 0x6C, 0x68, 0x30, 0x60, 0x81, 0x63, 0xCC, 0xD9, 0xA2, 0x45,
  0x9B, 0x25, 0xC0, 0x1C, 0xE6, 0x10, 0x43, 0x0C, 0x32, 0x70, 0x03, 0x02,
  0x02, 0x1E, 0x3E, 0x64, 0x44, 0x44, 0xCC, 0xCC, 0xD8, 0x68, 0x18, 0xF6,
  0x53, 0x7B, 0x0C, 0x32, 0x78, 0x07, 0x0C, 0x0C, 0x0E, 0x1C, 0x18, 0x18,
  0x18, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0xE0, 0xC0, 0x1A, 0x7D, 0x9A,
  0x24, 0x59, 0xB3, 0x6C, 0x68, 0x10, 0x65, 0x8E, 0x00, 0x30, 0xC2, 0x0B,
  0x3D, 0x96, 0x53, 0x4F, 0x3C, 0xB2, 0x33, 0x02, 0x26, 0x64, 0x4C, 0xCC,
  0x0C, 0x30, 0x02, 0x08, 0x61, 0x84, 0x10, 0x43, 0x0C, 0x20, 0x8E, 0x30,
  0x30, 0x60, 0x81, 0x32, 0xCD, 0x1C, 0x38, 0x70, 0xB3, 0x66, 0x40, 0x33,
  0x22, 0x26, 0x64, 0x44, 0xCC, 0x2D, 0x8F, 0xF6, 0x4D, 0x92, 0x4C, 0x93,
  0x2C, 0x9B, 0x26, 0xD9, 0x00, 0x2C, 0xF6, 0x59, 0x4D, 0x3C, 0xF2, 0xC8,
  0x18, 0xF6, 0x51, 0x47, 0x3C, 0xD6, 0x70, 0x16, 0x1A, 0x33, 0x33, 0x22,
  0x22, 0x26, 0x64, 0x7C, 0x40, 0x40, 0xC0, 0xC0, 0x1A, 0x7D, 0x92, 0x24,
  0x59, 0xB3, 0x6C, 0x68, 0x10, 0x60, 0xC1, 0x00, 0x29, 0xD8, 0xC4, 0x23,
  0x18, 0xC0, 0x3B, 0x50, 0xC3, 0x18, 0x52, 0xF0, 0x11, 0x0E, 0xE6, 0x31,
  0x08, 0x46, 0x18, 0x26, 0x4D, 0x93, 0x24, 0xC9, 0xB2, 0x6C, 0x68, 0x8E,
  0x29, 0xA4, 0xB2, 0x8E, 0x30, 0xC0, 0x89, 0xCC, 0xA6, 0x57, 0x6A, 0xA5,
  0x73, 0x31, 0x98, 0xCC, 0x00, 0x32, 0x6C, 0x50, 0xC1, 0x87, 0x0A, 0x34,
  0xCC, 0x23, 0x22, 0x26, 0x24, 0x2C, 0x28, 0x28, 0x30, 0x30, 0x30, 0x20,
  0xE0, 0xC0, 0x3C, 0xF0, 0x86, 0x10, 0xC2, 0x10, 0xF8, 0x0C, 0x61, 0x04,
  0x30, 0xCC, 0x18, 0x21, 0x86, 0x18, 0x70, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0x18, 0x20, 0x86, 0x18, 0x60, 0xC6, 0x30, 0xC2, 0x08, 0xE2, 0x00, 0xC7,
  0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 4, 4, 6, 2, -11 },
  { 9, 7, 11, 7, 0, -11 },
  { 19, 7, 13, 6, 0, -12 },
  { 31, 9, 12, 10, 1, -12 },
  { 45, 7, 12, 7, 0, -12 },
  { 56, 2, 4, 3, 2, -11 },
  { 57, 5, 14, 4, 0, -11 },
  { 66, 5, 15, 4, -1, -12 },
  { 76, 6, 5, 6, 1, -12 },
  { 80, 6, 7, 7, 1, -9 },
  { 86, 3, 4, 3, -1, -2 },
  { 88, 4, 1, 4, 0, -5 },
  { 89, 2, 2, 3, 0, -2 },
  { 90, 8, 11, 6, -1, -11 },
  { 101, 6, 12, 6, 0, -12 },
  { 110, 4, 11, 6, 2, -11 },
  { 116, 7, 12, 6, -1, -12 },
  { 127, 7, 12, 6, 0, -12 },
  { 138, 7, 12, 6, 0, -12 },
  { 149, 7, 11, 6, 0, -11 },
  { 159, 7, 12, 6, 0, -12 },
  { 170, 7, 11, 6, 0, -11 },
  { 180, 7, 12, 6, 0, -12 },
  { 191, 6, 12, 6, 0, -12 },
  { 200, 3, 9, 3, 0, -9 },
  { 204, 4, 11, 3, -1, -9 },
  { 210, 6, 7, 7, 1, -9 },
  { 216, 6, 5, 7, 1, -8 },
  { 220, 6, 7, 7, 1, -9 },
  { 226, 6, 12, 5, 0, -12 },
  { 235, 10, 13, 10, 0, -12 },
  { 252, 7, 11, 7, -1, -11 },
  { 262, 7, 11, 7, 0, -11 },
  { 272, 7, 12, 6, 1, -12 },
  { 283, 7, 11, 8, 0, -11 },
  { 293, 7, 11, 6, 0, -11 },
  { 303, 7, 11, 6, 0, -11 },
  { 313, 7, 12, 8, 1, -12 },
  { 324, 8, 11, 8, 0, -11 },
  { 335, 7, 11, 4, -1, -11 },
  { 345, 6, 14, 3, -2, -11 },
  { 356, 8, 11, 7, 0, -11 },
  { 367, 5, 11, 6, 0, -11 },
  { 374, 11, 11, 11, 0, -11 },
  { 390, 9, 11, 8, 0, -11 },
  { 403, 7, 12, 8, 1, -12 },
  { 414, 7, 11, 7, 0, -11 },
  { 424, 7, 15, 8, 1, -12 },
  { 438, 7, 11, 7, 0, -11 },
  { 448, 7, 12, 6, 0, -12 },
  { 459, 6, 11, 6, 1, -11 },
  { 468, 7, 11, 8, 1, -11 },
  { 478, 7, 11, 7, 1, -11 },
  { 488, 11, 11, 11, 1, -11 },
  { 504, 8, 11, 6, -1, -11 },
  { 515, 6, 11, 6, 1, -11 },
  { 524, 8, 11, 6, -1, -11 },
  { 535, 7, 15, 5, -1, -12 },
  { 549, 2, 11, 6, 2, -11 },
  { 552, 6, 15, 5, -1, -12 },
  { 564, 7, 6, 7, 0, -11 },
  { 570, 5, 1, 5, -1, 1 },
  { 571, 3, 2, 4, 2, -12 },
  { 572, 7, 9, 7, 0, -9 },
  { 580, 7, 12, 7, 0, -12 },
  { 591, 6, 9, 5, 0, -9 },
  { 598, 8, 12, 7, 0, -12 },
  { 610, 6, 9, 6, 0, -9 },
  { 617, 8, 16, 4, -2, -12 },
  { 633, 7, 13, 7, 0, -9 },
  { 645, 6, 12, 7, 0, -12 },
  { 654, 4, 12, 3, 0, -12 },
  { 660, 6, 16, 3, -2, -12 },
  { 672, 7, 12, 6, 0, -12 },
  { 683, 4, 12, 3, 0, -12 },
  { 689, 10, 9, 10, 0, -9 },
  { 701, 6, 9, 7, 0, -9 },
  { 708, 6, 9, 7, 0, -9 },
  { 715, 8, 13, 7, -1, -9 },
  { 728, 7, 13, 7, 0, -9 },
  { 740, 5, 9, 5, 0, -9 },
  { 746, 5, 9, 5, 0, -9 },
  { 752, 5, 11, 4, 0, -11 },
  { 759, 7, 9, 7, 0, -9 },
  { 767, 6, 9, 6, 1, -9 },
  { 774, 9, 9, 9, 1, -9 },
  { 785, 7, 9, 6, -1, -9 },
  { 793, 8, 13, 6, -1, -9 },
  { 806, 6, 9, 5, -1, -9 },
  { 813, 6, 14, 5, 0, -11 },
  { 824, 2, 16, 6, 2, -12 },
  { 828, 6, 14, 5, -1, -11 },
  { 839, 6, 2, 7, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC16PT7B_H_
