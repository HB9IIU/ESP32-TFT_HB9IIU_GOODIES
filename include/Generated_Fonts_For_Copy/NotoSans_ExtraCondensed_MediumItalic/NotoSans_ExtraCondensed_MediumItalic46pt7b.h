#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC46PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x7C, 0x07, 0xC0, 0xFC, 0x0F,
  0x80, 0x78, 0x00, 0x7C, 0x7B, 0xE3, 0xDE, 0x3E, 0xF1, 0xE7, 0x8F, 0x38,
  0x7B, 0xC3, 0xDE, 0x1C, 0xF1, 0xE7, 0x0F, 0x38, 0x79, 0xC3, 0x80, 0x00,
  0x3C, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x0F,
  0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x81, 0xE3, 0xC0,
  0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x87, 0x00, 0x38, 0x70, 0x01, 0xC3,
  0x80, 0x0E, 0x1C, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x03,
  0x87, 0x80, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x0F, 0x1E, 0x00, 0x70, 0xE0,
  0x03, 0x87, 0x00, 0x3C, 0x78, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0x98, 0xC1,
  0xE3, 0x00, 0x3C, 0x60, 0x07, 0x98, 0x00, 0xF3, 0x00, 0x1E, 0x60, 0x03,
  0xEC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x01, 0xBE, 0x00, 0x33, 0xC0, 0x06, 0x78, 0x00,
  0xCF, 0x00, 0x11, 0xE0, 0x06, 0x3C, 0x20, 0xCF, 0x8F, 0x1B, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xE0, 0x0E,
  0x03, 0xF8, 0x07, 0x80, 0xFF, 0x01, 0xC0, 0x71, 0xC0, 0xF0, 0x3C, 0x70,
  0x38, 0x0E, 0x1C, 0x1C, 0x03, 0x87, 0x07, 0x01, 0xE1, 0xC3, 0x80, 0x70,
  0x70, 0xE0, 0x1C, 0x3C, 0x70, 0x07, 0x0F, 0x3C, 0x01, 0xC3, 0x8E, 0x00,
  0xF0, 0xE7, 0x80, 0x3C, 0x79, 0xC3, 0xCE, 0x1C, 0xF3, 0xFB, 0x87, 0x39,
  0xFE, 0xF3, 0x9E, 0x73, 0xDF, 0xE7, 0x3C, 0x77, 0xF3, 0xCE, 0x1C, 0xF8,
  0xE7, 0x87, 0x00, 0x79, 0xC3, 0xC0, 0x1C, 0x70, 0xF0, 0x0F, 0x1C, 0x38,
  0x03, 0x8F, 0x0E, 0x01, 0xE3, 0x83, 0x80, 0x70, 0xE1, 0xE0, 0x38, 0x38,
  0x70, 0x0E, 0x0E, 0x1C, 0x07, 0x03, 0x8F, 0x03, 0xC0, 0xE3, 0x80, 0xE0,
  0x3F, 0xE0, 0x78, 0x07, 0xF0, 0x1C, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1E, 0x7C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C,
  0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xCF,
  0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0x1E, 0xF8, 0xF3, 0xE7, 0x9F, 0x3C,
  0x79, 0xE7, 0x87, 0xDE, 0x78, 0x3F, 0xCF, 0x03, 0xFC, 0xF0, 0x3F, 0x8F,
  0x01, 0xF8, 0xF0, 0x1F, 0x0F, 0x03, 0xF0, 0xF0, 0x7F, 0x0F, 0xDF, 0xF8,
  0xFF, 0xFF, 0x87, 0xFE, 0x7C, 0x3F, 0x87, 0xC0, 0x7D, 0xF7, 0x9E, 0x79,
  0xEF, 0x3C, 0xF3, 0xCE, 0x38, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x02, 0x0E, 0x07, 0x1C, 0x0F, 0xF8,
  0xFF, 0xFF, 0x9F, 0xFF, 0x07, 0xFE, 0x1F, 0x80, 0x7F, 0x81, 0xF7, 0x07,
  0xCF, 0x07, 0x1E, 0x06, 0x1E, 0x08, 0x30, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x1F, 0x1F, 0x1E, 0x3E, 0x3C,
  0x3C, 0x78, 0x78, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x39, 0xF7,
  0xFF, 0xF9, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x7C, 0x78, 0x3C, 0x3C, 0x3C,
  0x1E, 0x1E, 0x0F, 0x1F, 0x07, 0x8F, 0x03, 0xCF, 0x81, 0xE7, 0xC0, 0xF3,
  0xC0, 0x79, 0xE0, 0x3D, 0xF0, 0x1E, 0xF0, 0x1F, 0x78, 0x0F, 0xBC, 0x07,
  0x9E, 0x03, 0xDF, 0x01, 0xEF, 0x81, 0xF7, 0x80, 0xF3, 0xC0, 0x79, 0xE0,
  0x7C, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x1F, 0x1E, 0x0F, 0x0F, 0x0F, 0x07,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x00, 0xF0, 0x1F,
  0x03, 0xF0, 0x7E, 0x1F, 0xE3, 0xFE, 0x7D, 0xEF, 0xBE, 0xF3, 0xC6, 0x3C,
  0x43, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x00, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1E, 0x1F,
  0x00, 0x40, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x01, 0x81, 0xF0, 0x10, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x80, 0x3E, 0x0F, 0x9F, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1D, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0xC0,
  0x07, 0x3C, 0x00, 0x73, 0xC0, 0x0E, 0x78, 0x01, 0xE7, 0x80, 0x1C, 0x78,
  0x03, 0x87, 0x80, 0x78, 0xF8, 0x07, 0x0F, 0x00, 0xF0, 0xF0, 0x0E, 0x0F,
  0x01, 0xC0, 0xF0, 0x3C, 0x1F, 0x03, 0x81, 0xE0, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x0E, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x08, 0x07, 0xC1, 0xE7, 0xF8, 0x3F,
  0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC7, 0x80, 0x7B, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0x7E, 0x1F, 0x0F,
  0x83, 0xE1, 0xF0, 0x3C, 0x3C, 0x07, 0x8F, 0x80, 0xF1, 0xF0, 0x1E, 0x3E,
  0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF8, 0x7C,
  0x1E, 0x07, 0x87, 0xC0, 0xFB, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1F,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xF3, 0xF0, 0x78,
  0x3E, 0x0F, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0,
  0x7C, 0x3E, 0x0F, 0x03, 0xC3, 0xC0, 0x7C, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0x80, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x7C, 0xF8, 0x1F, 0x1F,
  0x07, 0xC1, 0xF0, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x8F, 0x81, 0xE1, 0xF8, 0xFC,
  0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0xE0, 0x3F, 0xF8, 0x1F, 0xFF, 0x07, 0xC7, 0xC3, 0xE0, 0xF0, 0xF0, 0x3C,
  0x3C, 0x0F, 0x1F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E,
  0x03, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0x78, 0x3F, 0x1F, 0x1F, 0xC7, 0xFF,
  0xE1, 0xFF, 0x78, 0x3F, 0x9E, 0x07, 0xCF, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x31, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x78, 0x3F, 0x0F, 0x83, 0xE0, 0xF0, 0x00, 0x00, 0xE0, 0x1F, 0x01, 0xF0,
  0x3F, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01,
  0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0x7F, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0x70, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x1C,
  0x00, 0x08, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF1,
  0x83, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0xF0, 0x03, 0x80, 0x70,
  0x00, 0xF0, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC3,
  0x81, 0xFC, 0x70, 0xE0, 0xFF, 0x1C, 0x70, 0x7B, 0xC7, 0x1C, 0x38, 0xF1,
  0xCE, 0x1E, 0x38, 0x73, 0x87, 0x0E, 0x1C, 0xE3, 0xC3, 0x87, 0x70, 0xE1,
  0xE1, 0xDC, 0x38, 0x70, 0xE7, 0x1E, 0x1C, 0x39, 0xC7, 0x07, 0x0E, 0xF1,
  0xC3, 0xC3, 0xB8, 0x70, 0xE1, 0xCE, 0x1C, 0x38, 0x73, 0x87, 0x1E, 0x38,
  0xE1, 0xCF, 0x9E, 0x38, 0x7F, 0x7F, 0x0E, 0x0F, 0x9F, 0x83, 0x81, 0xC1,
  0x80, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x80, 0x0F, 0x80, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xEE, 0x00, 0x1E,
  0xE0, 0x01, 0xEE, 0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x7D, 0xE0, 0x07,
  0x9E, 0x00, 0x79, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x1F, 0x1E, 0x01,
  0xE1, 0xE0, 0x1E, 0x1E, 0x03, 0xC1, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xF8, 0x1E, 0x0F, 0x01, 0xE1, 0xF0, 0x1E,
  0x1E, 0x01, 0xE3, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x1E, 0x7C, 0x01,
  0xE7, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0x7C, 0x0F, 0x03,
  0xE0, 0xF8, 0x1F, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x1F,
  0x03, 0xE0, 0xF8, 0x3E, 0x07, 0x83, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0x83, 0xE0, 0x3C, 0x0F, 0x81, 0xE0,
  0x3C, 0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x07, 0xC1,
  0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF0, 0x1F, 0x07, 0x81, 0xF0, 0x3F, 0xFF,
  0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x40, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x08, 0x07, 0xF7, 0x80,
  0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3C, 0x3F, 0x01, 0xE0, 0x7C,
  0x0F, 0x03, 0xE0, 0xF8, 0x0F, 0x07, 0xC0, 0x78, 0x3C, 0x03, 0xC1, 0xE0,
  0x1E, 0x1F, 0x00, 0xF0, 0xF8, 0x07, 0x87, 0xC0, 0x3C, 0x3C, 0x01, 0xE1,
  0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0x80, 0x3C, 0x3C, 0x03,
  0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0x80, 0x7C, 0x3C,
  0x07, 0xC1, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0x87, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xF0, 0x38, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x07, 0xFC, 0xF8, 0x1F, 0xE3,
  0xE0, 0x7F, 0x8F, 0x81, 0xFE, 0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xE3, 0xC0,
  0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F,
  0x0F, 0x80, 0x78, 0x3E, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xFE, 0xFE, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0xE0, 0x0F, 0x01,
  0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1E, 0x03, 0xC0, 0x1E, 0x03,
  0xC0, 0x3E, 0x03, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3C, 0x07,
  0x80, 0x3C, 0x07, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x78, 0x0F,
  0x80, 0x78, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x01, 0xF0, 0x3E,
  0x01, 0xF0, 0x3E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x03, 0xE0, 0x3C,
  0x03, 0xE0, 0x7C, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x78,
  0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x01,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x1F, 0x07,
  0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0xF8, 0x03, 0xE3, 0xE0,
  0x07, 0x87, 0xC0, 0x0F, 0x1F, 0x00, 0x1E, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0xFB, 0xE0, 0x01, 0xEF, 0x80, 0x03, 0xDE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xE3,
  0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x1F, 0x00, 0x3C, 0x3E,
  0x00, 0x78, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xF0,
  0x0F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x0F, 0x80,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF8,
  0x03, 0xFC, 0x07, 0xF8, 0x03, 0xBC, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xF8,
  0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x38,
  0x1E, 0xF8, 0x0F, 0x38, 0x1E, 0xF8, 0x0F, 0x38, 0x3C, 0xF0, 0x1F, 0x38,
  0x3C, 0xF0, 0x1E, 0x38, 0x38, 0xF0, 0x1E, 0x38, 0x79, 0xF0, 0x1E, 0x38,
  0x71, 0xE0, 0x1E, 0x3C, 0xF1, 0xE0, 0x3E, 0x3C, 0xF1, 0xE0, 0x3C, 0x3D,
  0xE1, 0xE0, 0x3C, 0x3D, 0xE3, 0xE0, 0x3C, 0x3F, 0xC3, 0xC0, 0x3C, 0x3F,
  0xC3, 0xC0, 0x78, 0x3F, 0x83, 0xC0, 0x78, 0x3F, 0x83, 0xC0, 0x78, 0x3F,
  0x07, 0xC0, 0x78, 0x3F, 0x07, 0x80, 0xF8, 0x3E, 0x07, 0x80, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0x80, 0xF8, 0x03,
  0xC0, 0xFC, 0x01, 0xE0, 0x7E, 0x00, 0xF0, 0x3F, 0x80, 0xF8, 0x1F, 0xC0,
  0x78, 0x0F, 0xE0, 0x3C, 0x0F, 0xF0, 0x1E, 0x07, 0xB8, 0x0F, 0x03, 0xDC,
  0x0F, 0x01, 0xEF, 0x07, 0x81, 0xF7, 0x83, 0xC0, 0xF3, 0xC1, 0xE0, 0x79,
  0xE1, 0xF0, 0x3C, 0x70, 0xF0, 0x1E, 0x38, 0x78, 0x1F, 0x1E, 0x3C, 0x0F,
  0x0F, 0x1E, 0x07, 0x87, 0x9F, 0x03, 0xC3, 0xCF, 0x01, 0xE1, 0xE7, 0x81,
  0xF0, 0x73, 0xC0, 0xF0, 0x3D, 0xE0, 0x78, 0x1F, 0xE0, 0x3C, 0x0F, 0xF0,
  0x1E, 0x07, 0xF8, 0x1E, 0x03, 0xFC, 0x0F, 0x00, 0xFE, 0x07, 0x80, 0x7E,
  0x03, 0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x81, 0xE0, 0x0F, 0xC0, 0xF0, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE3, 0xE0, 0x1F, 0x1E,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x78, 0x01, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0x7D, 0xE0, 0x03, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0xC0,
  0x0F, 0xBE, 0x00, 0x7D, 0xE0, 0x03, 0xEF, 0x00, 0x1E, 0x78, 0x01, 0xF3,
  0xC0, 0x0F, 0x9E, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x3C, 0x03,
  0xE1, 0xF0, 0x3E, 0x0F, 0x83, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x03, 0xC3, 0xF0, 0x3C, 0x1F, 0x03, 0xC0, 0xF0, 0x7C,
  0x0F, 0x07, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0xF0, 0x7C, 0x1F, 0x3F, 0xC1,
  0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE3, 0xE0,
  0x1F, 0x1E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x78, 0x01, 0xF7,
  0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xE0, 0x03, 0xFF, 0x00, 0x1E, 0xF8, 0x00,
  0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xE0, 0x03, 0xEF, 0x00, 0x1E, 0x78,
  0x01, 0xF3, 0xC0, 0x0F, 0x9E, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3C,
  0x3C, 0x03, 0xE1, 0xF0, 0x3E, 0x0F, 0x83, 0xF0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xC3, 0xF0, 0x3C, 0x1F, 0x03, 0xC1, 0xF0, 0x7C, 0x0F,
  0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xE0, 0xF0, 0x3E, 0x0F, 0x07, 0xC0, 0xF0, 0xFC, 0x1F, 0xFF, 0x81, 0xFF,
  0xF0, 0x1F, 0xFC, 0x01, 0xE7, 0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3E,
  0x3C, 0x03, 0xC3, 0xE0, 0x3C, 0x3E, 0x03, 0xC3, 0xE0, 0x7C, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF0,
  0xF0, 0x0F, 0x80, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0x06, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC1, 0x00, 0x3E, 0x0E, 0x03, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xE0, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x7C, 0x3E, 0x01, 0xE0, 0xF8,
  0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xC1, 0xF0, 0x0F,
  0x07, 0xC0, 0x3C, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1E, 0x0F,
  0x80, 0x78, 0x3E, 0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x1F, 0x00,
  0xF0, 0x7C, 0x03, 0xC1, 0xE0, 0x1F, 0x07, 0x80, 0x7C, 0x1E, 0x01, 0xE0,
  0xF8, 0x07, 0x83, 0xE0, 0x1E, 0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xE0, 0xF0,
  0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x01, 0xF0, 0x3C, 0x07, 0x80, 0xF8, 0x3E,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0x78, 0x03, 0xEF, 0x00, 0x79,
  0xE0, 0x1F, 0x3C, 0x03, 0xE7, 0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xC3,
  0xC0, 0xF8, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x07,
  0x87, 0xC0, 0xF0, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F,
  0x3E, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0xF0,
  0x07, 0x80, 0x7D, 0xE0, 0x1F, 0x00, 0xF3, 0xC0, 0x3E, 0x01, 0xE7, 0x80,
  0x7C, 0x07, 0xCF, 0x01, 0xF8, 0x0F, 0x1E, 0x03, 0xF0, 0x1E, 0x3C, 0x0F,
  0xE0, 0x7C, 0x78, 0x1F, 0xC0, 0xF0, 0xF0, 0x3F, 0x83, 0xE1, 0xE0, 0xFF,
  0x07, 0x83, 0xC1, 0xDE, 0x0F, 0x07, 0x87, 0xBC, 0x3E, 0x0F, 0x0F, 0x78,
  0x78, 0x1E, 0x1C, 0xF1, 0xF0, 0x3C, 0x79, 0xE3, 0xC0, 0x78, 0xF3, 0xC7,
  0x80, 0xF1, 0xC7, 0x9F, 0x01, 0xE7, 0x8F, 0x3C, 0x03, 0xCE, 0x1C, 0x78,
  0x0F, 0xBC, 0x39, 0xE0, 0x1F, 0x78, 0x73, 0xC0, 0x3C, 0xE0, 0xEF, 0x80,
  0x7B, 0xC1, 0xDE, 0x00, 0xF7, 0x03, 0xBC, 0x01, 0xFE, 0x07, 0xF0, 0x03,
  0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x3C, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF8,
  0x00, 0x78, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xEF, 0x00,
  0x03, 0xCF, 0x00, 0x07, 0xCF, 0x00, 0x07, 0x8F, 0x80, 0x0F, 0x8F, 0x80,
  0x1F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x3C, 0x07, 0x80,
  0x7C, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x03,
  0xDF, 0x03, 0xEF, 0x81, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0xF0, 0x78,
  0x78, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xDE, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0F, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0xC0,
  0x0F, 0x78, 0x03, 0xCF, 0x00, 0x78, 0xE0, 0x1E, 0x1E, 0x07, 0x83, 0xC0,
  0xF0, 0x78, 0x3C, 0x07, 0x07, 0x80, 0xF1, 0xE0, 0x1E, 0x78, 0x03, 0xDF,
  0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0xF9, 0xF1, 0xE3, 0xE3,
  0xC3, 0x87, 0x80, 0x01, 0xF1, 0xE0, 0x7F, 0x3C, 0x1F, 0xF7, 0x87, 0xFF,
  0xE1, 0xF8, 0xFC, 0x3E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x3C, 0x07,
  0x8F, 0x80, 0xF1, 0xF0, 0x1E, 0x3C, 0x07, 0xC7, 0x80, 0xF1, 0xF0, 0x1E,
  0x3E, 0x03, 0xC7, 0xC0, 0xF8, 0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xC0, 0xF8,
  0x7C, 0x1F, 0x0F, 0x87, 0xE1, 0xF9, 0xFC, 0x1F, 0xFF, 0x03, 0xFD, 0xE0,
  0x3F, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x7E, 0x03, 0xDF, 0xE0, 0x7F, 0xFC, 0x1F, 0xEF,
  0x83, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x81, 0xE1, 0xE0, 0x3C, 0x7C, 0x0F,
  0x8F, 0x01, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x8F, 0x80, 0xF1, 0xE0, 0x1E,
  0x3C, 0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0xC0, 0xF0,
  0xF8, 0x3E, 0x1F, 0x07, 0x83, 0xF1, 0xF0, 0xF7, 0xFC, 0x1E, 0xFF, 0x03,
  0x8F, 0xC0, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x10, 0x7C, 0xE0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x7C, 0x78, 0x07, 0xF3,
  0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xE0, 0x7C, 0x3F, 0x03, 0xE0, 0xF8, 0x3E,
  0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0xF8, 0x0F, 0x07, 0xC0, 0x78,
  0x3C, 0x07, 0xC1, 0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0xF8, 0x0F, 0x07, 0xC0,
  0x78, 0x3C, 0x07, 0xC1, 0xE0, 0x3C, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x03,
  0xE1, 0xF8, 0x1F, 0x1F, 0x80, 0x7F, 0xDC, 0x03, 0xFD, 0xE0, 0x0F, 0xCF,
  0x00, 0x00, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0x8F, 0x1F, 0x0F, 0x1E,
  0x07, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x1E, 0x78, 0x7E, 0x7F,
  0xFC, 0xFF, 0xF0, 0xFF, 0x80, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x18, 0x7F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x80, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x78, 0x07, 0xFB, 0xC0, 0x7F, 0xDE,
  0x07, 0xFF, 0xE0, 0x3C, 0x3F, 0x03, 0xE0, 0xF8, 0x1E, 0x07, 0xC1, 0xF0,
  0x3C, 0x0F, 0x01, 0xE0, 0xF8, 0x0F, 0x07, 0xC0, 0x78, 0x3C, 0x07, 0xC1,
  0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0xF8, 0x0F, 0x07, 0xC0, 0xF8, 0x3C, 0x07,
  0xC1, 0xE0, 0x3C, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE1, 0xF8, 0x1F,
  0x9F, 0xC0, 0x7F, 0xFC, 0x03, 0xFD, 0xE0, 0x0F, 0xCF, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x18, 0x0F, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x79, 0xF8, 0x1E, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFC,
  0x3C, 0x3E, 0x0F, 0x0F, 0x83, 0xC3, 0xC0, 0xF1, 0xF0, 0x3C, 0x78, 0x1F,
  0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF8, 0x1E, 0x3C, 0x0F, 0x8F,
  0x03, 0xC3, 0xC0, 0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0xC7, 0x81,
  0xE1, 0xE0, 0x78, 0xF8, 0x1E, 0x3C, 0x0F, 0x8F, 0x03, 0xC0, 0x01, 0xE0,
  0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x81,
  0xF0, 0x78, 0x3E, 0x07, 0x87, 0xC0, 0xF8, 0x78, 0x0F, 0x0F, 0x00, 0xF1,
  0xF0, 0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x01, 0xEF, 0x80, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0x78, 0x03,
  0xE7, 0x80, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0x78, 0x7C, 0x07, 0x87, 0xC0,
  0x78, 0x3C, 0x07, 0x83, 0xC0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E,
  0x00, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x9F, 0x07, 0xC0, 0x73, 0xF9,
  0xFE, 0x07, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF1, 0xF0,
  0xF8, 0x3E, 0x1F, 0x0F, 0x03, 0xC1, 0xF0, 0xF0, 0x3C, 0x1F, 0x1F, 0x07,
  0xC1, 0xE1, 0xE0, 0x78, 0x1E, 0x1E, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0x1E,
  0x1E, 0x07, 0x83, 0xC3, 0xE0, 0xF0, 0x3C, 0x3C, 0x0F, 0x03, 0xC3, 0xC0,
  0xF0, 0x3C, 0x3C, 0x0F, 0x07, 0xC7, 0xC1, 0xF0, 0x78, 0x78, 0x1E, 0x07,
  0x87, 0x81, 0xE0, 0x78, 0x78, 0x1E, 0x07, 0x87, 0x81, 0xE0, 0xF8, 0xF8,
  0x3E, 0x0F, 0x0F, 0x03, 0xC0, 0xF0, 0xF0, 0x3C, 0x0F, 0x00, 0x07, 0x1F,
  0x01, 0xCF, 0xE0, 0x77, 0xFC, 0x3F, 0xFF, 0x0F, 0xC3, 0xC3, 0xE0, 0xF0,
  0xF8, 0x3C, 0x3C, 0x0F, 0x1F, 0x03, 0xC7, 0x81, 0xF1, 0xE0, 0x78, 0x78,
  0x1E, 0x1E, 0x07, 0x8F, 0x81, 0xE3, 0xC0, 0xF8, 0xF0, 0x3C, 0x3C, 0x0F,
  0x1F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x7C, 0x78, 0x1E, 0x1E, 0x07, 0x8F,
  0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0xC1, 0xFB, 0xE1, 0xF0, 0xF8, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F,
  0x3C, 0x07, 0xBE, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x1F, 0x78, 0x0F, 0x3C, 0x07, 0x9E,
  0x07, 0xCF, 0x87, 0xC3, 0xE7, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xC0,
  0x00, 0x01, 0xE7, 0xE0, 0x0E, 0x7F, 0x80, 0x77, 0xFC, 0x07, 0xF3, 0xE0,
  0x3F, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC0,
  0xF8, 0x3C, 0x07, 0xC1, 0xE0, 0x3E, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x07,
  0x80, 0x78, 0x3C, 0x07, 0xC1, 0xE0, 0x3E, 0x0F, 0x01, 0xE0, 0x78, 0x1F,
  0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x78, 0x0F, 0xCF, 0xC0, 0xF7,
  0xFC, 0x07, 0xBF, 0xC0, 0x3C, 0xFC, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xF9, 0xE0, 0x7F, 0xBC, 0x1F, 0xF7, 0x07, 0xEF, 0xE0, 0xF0, 0xFC,
  0x3E, 0x0F, 0x87, 0x81, 0xF1, 0xE0, 0x3C, 0x3C, 0x07, 0x8F, 0x80, 0xF1,
  0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0x80, 0xF1, 0xF0, 0x1E, 0x3E, 0x03, 0xC7,
  0xC0, 0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xC0, 0xF8, 0x78, 0x1F, 0x0F,
  0x87, 0xE1, 0xF9, 0xF8, 0x1F, 0xFF, 0x03, 0xFD, 0xE0, 0x3F, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x07, 0x1F, 0x07, 0x3E, 0x07, 0x7E, 0x0F, 0xFE, 0x0F, 0xE2,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x9E,
  0x1E, 0x04, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x81, 0xF0, 0xE7, 0xF0,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x80, 0xFF, 0x3F, 0xF3, 0xFF, 0x7F, 0xE1, 0xF0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF9, 0x0F, 0xF0,
  0x7F, 0x07, 0xF0, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x7C, 0x0F,
  0x1E, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x3C, 0x07, 0x8F,
  0x03, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x7C, 0x0F, 0x1E, 0x07, 0xC7, 0x81,
  0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x3E, 0x0F, 0x8F, 0x03, 0xE3, 0xC1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x7F, 0x0F, 0xFF, 0xC1, 0xFE, 0xF0, 0x3F, 0x38, 0x00,
  0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78,
  0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF1, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0,
  0xF3, 0xC0, 0xF3, 0xC0, 0xF7, 0x80, 0xF7, 0x80, 0xF7, 0x80, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x1F, 0x03, 0xDE, 0x07, 0xC0, 0xF7, 0x83, 0xF0, 0x79,
  0xE0, 0xFC, 0x1E, 0x78, 0x3F, 0x0F, 0x1E, 0x1F, 0xC3, 0xC7, 0x87, 0xF0,
  0xF1, 0xE3, 0xFC, 0x78, 0x78, 0xEF, 0x1E, 0x1E, 0x3B, 0xCF, 0x07, 0x9E,
  0xE3, 0xC1, 0xE7, 0x38, 0xF0, 0x7B, 0xCE, 0x78, 0x1E, 0xE3, 0x9E, 0x07,
  0x38, 0xE7, 0x01, 0xDE, 0x3B, 0xC0, 0x77, 0x0E, 0xF0, 0x1D, 0xC3, 0xB8,
  0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x03,
  0xF0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0xF0, 0x3C, 0x1F, 0x03, 0xC1, 0xE0, 0x3C, 0x3C, 0x03, 0xC7,
  0xC0, 0x3E, 0x78, 0x01, 0xEF, 0x80, 0x1E, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xBC, 0x00, 0xFB, 0xC0, 0x0F, 0x3C, 0x01,
  0xF3, 0xC0, 0x1E, 0x3E, 0x03, 0xC3, 0xE0, 0x7C, 0x1E, 0x07, 0x81, 0xE0,
  0xF8, 0x1E, 0x00, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0x78, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x0F,
  0x1E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF7,
  0x80, 0x01, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0x80, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x03, 0xFC, 0x03, 0xF0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x03, 0xF8, 0x07,
  0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x7F, 0xFF,
  0xFF, 0x9F, 0xFF, 0x80, 0xFF, 0xA0, 0x0F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 12, 33, 11, 0, -33 },
  { 51, 13, 12, 16, 5, -33 },
  { 71, 21, 33, 20, 0, -33 },
  { 158, 19, 38, 18, 0, -35 },
  { 249, 26, 33, 29, 2, -33 },
  { 357, 20, 33, 21, 0, -33 },
  { 440, 6, 12, 9, 5, -33 },
  { 449, 14, 40, 12, 1, -33 },
  { 519, 14, 40, 12, -3, -33 },
  { 589, 15, 16, 17, 4, -35 },
  { 619, 17, 22, 20, 2, -27 },
  { 666, 8, 11, 10, -2, -5 },
  { 677, 10, 4, 12, 1, -14 },
  { 682, 6, 6, 10, 0, -6 },
  { 687, 22, 33, 16, -2, -33 },
  { 778, 17, 33, 18, 1, -33 },
  { 849, 12, 33, 19, 5, -33 },
  { 899, 21, 33, 18, -2, -33 },
  { 986, 20, 33, 18, -1, -33 },
  { 1069, 20, 33, 19, -1, -33 },
  { 1152, 19, 33, 18, 0, -33 },
  { 1231, 19, 33, 18, 1, -33 },
  { 1310, 20, 33, 18, 1, -33 },
  { 1393, 19, 33, 18, 0, -33 },
  { 1472, 18, 33, 18, 0, -33 },
  { 1547, 10, 25, 10, 0, -25 },
  { 1579, 12, 31, 10, -2, -25 },
  { 1626, 17, 21, 20, 2, -27 },
  { 1671, 17, 13, 20, 2, -23 },
  { 1699, 17, 21, 20, 2, -27 },
  { 1744, 15, 33, 14, 1, -33 },
  { 1806, 26, 37, 28, 1, -33 },
  { 1927, 20, 33, 19, -3, -33 },
  { 2010, 21, 33, 20, 0, -33 },
  { 2097, 20, 33, 18, 2, -33 },
  { 2180, 21, 33, 22, 0, -33 },
  { 2267, 19, 33, 17, 0, -33 },
  { 2346, 19, 33, 16, 0, -33 },
  { 2425, 22, 33, 23, 2, -33 },
  { 2516, 24, 33, 23, 0, -33 },
  { 2615, 18, 33, 13, -2, -33 },
  { 2690, 18, 42, 10, -7, -33 },
  { 2785, 23, 33, 19, 0, -33 },
  { 2880, 13, 33, 16, 0, -33 },
  { 2934, 32, 33, 30, 0, -33 },
  { 3066, 25, 33, 24, 0, -33 },
  { 3170, 21, 33, 23, 2, -33 },
  { 3257, 20, 33, 19, 0, -33 },
  { 3340, 21, 41, 23, 2, -33 },
  { 3448, 20, 33, 20, 0, -33 },
  { 3531, 21, 33, 18, -1, -33 },
  { 3618, 17, 33, 17, 3, -33 },
  { 3689, 22, 33, 22, 2, -33 },
  { 3780, 19, 33, 19, 4, -33 },
  { 3859, 31, 33, 31, 3, -33 },
  { 3987, 24, 33, 18, -3, -33 },
  { 4086, 17, 33, 17, 4, -33 },
  { 4157, 21, 33, 16, -2, -33 },
  { 4244, 17, 40, 13, -1, -33 },
  { 4329, 8, 33, 16, 5, -33 },
  { 4362, 17, 40, 13, -3, -33 },
  { 4447, 19, 18, 19, 0, -33 },
  { 4490, 15, 3, 14, -4, 4 },
  { 4496, 7, 7, 12, 7, -35 },
  { 4503, 19, 25, 20, 1, -25 },
  { 4563, 19, 35, 20, 0, -35 },
  { 4647, 16, 25, 15, 1, -25 },
  { 4697, 21, 35, 20, 1, -35 },
  { 4789, 16, 25, 18, 1, -25 },
  { 4839, 23, 46, 11, -6, -35 },
  { 4972, 21, 36, 20, -1, -25 },
  { 5067, 18, 35, 20, 0, -35 },
  { 5146, 11, 34, 9, 0, -34 },
  { 5193, 17, 45, 9, -6, -34 },
  { 5289, 20, 35, 17, 0, -35 },
  { 5377, 12, 35, 9, 0, -35 },
  { 5430, 28, 25, 29, 0, -25 },
  { 5518, 18, 25, 20, 0, -25 },
  { 5575, 17, 25, 19, 1, -25 },
  { 5629, 21, 36, 20, -2, -25 },
  { 5724, 19, 36, 20, 1, -25 },
  { 5810, 16, 25, 13, 0, -25 },
  { 5860, 16, 25, 15, 0, -25 },
  { 5910, 12, 30, 12, 1, -30 },
  { 5955, 18, 25, 20, 1, -25 },
  { 6012, 16, 25, 16, 3, -25 },
  { 6062, 26, 25, 26, 2, -25 },
  { 6144, 20, 25, 17, -2, -25 },
  { 6207, 23, 36, 16, -4, -25 },
  { 6311, 17, 25, 14, -2, -25 },
  { 6365, 17, 40, 15, 1, -33 },
  { 6450, 4, 46, 17, 6, -35 },
  { 6473, 17, 40, 15, -3, -33 },
  { 6558, 18, 6, 20, 2, -19 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC46PT7B_H_
