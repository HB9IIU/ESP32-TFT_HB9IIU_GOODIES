#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC54PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x3F, 0x1F,
  0x3F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3E, 0x3C, 0x3E, 0x3C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x78, 0x78,
  0xF0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0,
  0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x78,
  0x00, 0x78, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x0E,
  0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x0F, 0x00, 0x0F, 0x07, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x70, 0x00,
  0x78, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xCC, 0x70, 0x1F, 0x18, 0x20,
  0x3E, 0x30, 0x00, 0x78, 0xE0, 0x00, 0xF1, 0x80, 0x01, 0xE3, 0x00, 0x03,
  0xE6, 0x00, 0x07, 0xCC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x6F, 0xC0, 0x00, 0xCF, 0x80, 0x03, 0x1F,
  0x00, 0x06, 0x3E, 0x00, 0x0C, 0x7C, 0x00, 0x18, 0xF8, 0x40, 0x71, 0xF0,
  0x40, 0xC7, 0xC1, 0xF1, 0x9F, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0xE0, 0x01, 0xE0, 0x1F, 0xC0, 0x0F, 0x00, 0xFF, 0x80, 0x3C, 0x07, 0xDE,
  0x01, 0xE0, 0x1E, 0x38, 0x07, 0x80, 0xF0, 0xF0, 0x3C, 0x03, 0xC3, 0xC0,
  0xF0, 0x1E, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x1C, 0x01, 0xE0, 0xE0, 0xF0,
  0x07, 0x07, 0x87, 0x80, 0x3C, 0x1E, 0x1E, 0x00, 0xF0, 0x78, 0xF0, 0x03,
  0xC1, 0xE3, 0xC0, 0x0F, 0x07, 0x1E, 0x00, 0x3C, 0x3C, 0x78, 0x30, 0xE0,
  0xF3, 0xC3, 0xF3, 0x83, 0x8F, 0x1F, 0xEE, 0x1E, 0x78, 0xFF, 0xBC, 0xF1,
  0xE7, 0x9E, 0xFF, 0xCF, 0x1C, 0x3F, 0xFE, 0x3C, 0xF0, 0xF7, 0xF1, 0xE3,
  0x83, 0xCF, 0x87, 0x9E, 0x0F, 0x00, 0x3C, 0x78, 0x38, 0x00, 0xF1, 0xE1,
  0xE0, 0x07, 0x8F, 0x07, 0x80, 0x3E, 0x3C, 0x1E, 0x00, 0xF0, 0xF0, 0x78,
  0x07, 0x83, 0xC1, 0xE0, 0x1E, 0x0F, 0x0F, 0x00, 0xF0, 0x3C, 0x3C, 0x03,
  0xC0, 0xE0, 0xF0, 0x1E, 0x03, 0x87, 0x80, 0x78, 0x0F, 0x1E, 0x03, 0xC0,
  0x3C, 0xF0, 0x0F, 0x00, 0xFF, 0x80, 0x78, 0x01, 0xFE, 0x03, 0xE0, 0x07,
  0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01,
  0xE1, 0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xF3, 0xE0, 0x01, 0xF3, 0xC0, 0x01,
  0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0x0F, 0xFE, 0x1F, 0x1F,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3F, 0x3C, 0x7C, 0x1F, 0x7C, 0x7C,
  0x1F, 0x7C, 0xF8, 0x1F, 0xF8, 0xF8, 0x0F, 0xF8, 0xF8, 0x0F, 0xF0, 0xF8,
  0x0F, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xE0, 0xF8, 0x1F, 0xE0, 0xFC,
  0x3F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFD, 0xF0, 0x3F, 0xF1, 0xF8, 0x1F,
  0xE1, 0xF8, 0x02, 0x00, 0x00, 0x1F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C,
  0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x06, 0x1E, 0x03, 0xCF, 0x01, 0xFF, 0x8F, 0xFF, 0xFF,
  0x7F, 0xFF, 0x83, 0xFF, 0xC1, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFB,
  0xC1, 0xF9, 0xF0, 0xF8, 0xF8, 0x38, 0x3E, 0x04, 0x1E, 0x00, 0x04, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0xF8,
  0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0,
  0x3C, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C,
  0x7D, 0xFB, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x01, 0xF8, 0xF8, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0,
  0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F,
  0x80, 0x78, 0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F,
  0x8F, 0x80, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0,
  0x0F, 0x8F, 0x80, 0x7C, 0x78, 0x07, 0xE7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1,
  0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x03,
  0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x1F, 0x1F, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7C,
  0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x8F, 0xFE,
  0x7E, 0xF3, 0xE7, 0xCF, 0x1F, 0x18, 0x7C, 0x41, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xF0,
  0x3F, 0x00, 0x60, 0x3F, 0x00, 0x40, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0x9F, 0xE0, 0x18, 0x0F, 0xC0, 0x20, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC1, 0x00, 0x1F, 0x83, 0x80, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0x78, 0x00, 0x1F, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xE7, 0xC0, 0x03, 0xCF,
  0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x7C, 0x00, 0x78, 0xF8, 0x00, 0xE1, 0xF0,
  0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x1C, 0x1F, 0x00, 0x78, 0x3E, 0x01,
  0xE0, 0x7C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78,
  0x0F, 0x81, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x82, 0x00,
  0xFE, 0x0E, 0x07, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0x18, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0xC0, 0x07,
  0xCF, 0xE0, 0x3E, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xE1,
  0xF8, 0x7F, 0x03, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xF8,
  0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xF0, 0xFC, 0x0F, 0x81,
  0xF0, 0x7E, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0,
  0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3E,
  0x1F, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xF8, 0xFC, 0x0F,
  0xC1, 0xF0, 0x7E, 0x07, 0xC1, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3E, 0x00,
  0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8,
  0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8,
  0x0F, 0x83, 0xE0, 0x7E, 0x0F, 0x81, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3E,
  0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0xFC, 0x7C, 0x03,
  0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xE1,
  0xF0, 0x3F, 0x87, 0xE1, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xDF, 0x01, 0xFE, 0x7C, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x08, 0x1F, 0xC0, 0x3F, 0xFF,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x80, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x03, 0xE0, 0x7E, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00,
  0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x1F, 0x83,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0x3F, 0x80, 0x03, 0xE0, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0x80, 0x3E, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0xC0, 0x78, 0x3C,
  0x0F, 0xF8, 0x70, 0xF0, 0x3F, 0xF0, 0xE1, 0xE0, 0xFF, 0xE1, 0xC7, 0x83,
  0xC3, 0x83, 0x8F, 0x0F, 0x0F, 0x0F, 0x1C, 0x1E, 0x1E, 0x1E, 0x78, 0x78,
  0x3C, 0x3C, 0xF0, 0xF0, 0x70, 0x79, 0xC1, 0xC1, 0xE0, 0xE7, 0x87, 0x83,
  0xC1, 0xCF, 0x0F, 0x07, 0x87, 0x9E, 0x1E, 0x0E, 0x0F, 0x38, 0x38, 0x3C,
  0x1C, 0x70, 0xF0, 0x78, 0x38, 0xE1, 0xE0, 0xF0, 0xF3, 0xC3, 0xC3, 0xE1,
  0xC7, 0x87, 0x87, 0x87, 0x8F, 0x0F, 0x1F, 0x0E, 0x1E, 0x1F, 0x77, 0x78,
  0x3C, 0x1F, 0xCF, 0xF0, 0x78, 0x3F, 0x9F, 0xC0, 0xF0, 0x1C, 0x1E, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x04, 0x00, 0x0F,
  0x80, 0x70, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7B, 0xC0, 0x01,
  0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0xCF,
  0x00, 0x1E, 0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xE3, 0xC0, 0x1F, 0x0F, 0x00,
  0x7C, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x1F, 0x01, 0xF0,
  0x7C, 0x07, 0xC1, 0xF0, 0x3F, 0x07, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E,
  0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x3F, 0x00, 0x7C, 0xF8, 0x01,
  0xF7, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x80, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xF0, 0x3F, 0x01, 0xF0, 0x3F,
  0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F,
  0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x3F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7E,
  0x07, 0xC0, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0x83, 0xF0, 0x1F, 0x01, 0xF8,
  0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF8,
  0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0x7C, 0x3F, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x01, 0xF8, 0x08, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x01, 0x00, 0x7F, 0x07, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0x87, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1,
  0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x7E, 0x00, 0xFC,
  0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x0F, 0xC0, 0xF8, 0x07,
  0xE0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x0F, 0xF0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xE0, 0x3F, 0x80, 0x10, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x3F, 0xE1, 0xF0, 0x1F, 0xF8, 0xFC, 0x07, 0xFE, 0x3F, 0x01, 0xFF, 0x8F,
  0xC0, 0x7F, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00,
  0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x1F,
  0x80, 0x7C, 0x07, 0xF8, 0x3F, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x3F,
  0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1F,
  0x00, 0x3E, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07,
  0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x07,
  0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00,
  0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xF8,
  0x07, 0xC0, 0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x04, 0x7E,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x7E, 0x00,
  0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x0F,
  0x8F, 0x80, 0x01, 0xF3, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xDF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF7, 0xC0, 0x00, 0xFC, 0xF8, 0x00,
  0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x07,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F,
  0x80, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xBC, 0x00, 0xF7,
  0xC0, 0x3D, 0xE0, 0x0F, 0xBC, 0x03, 0xEF, 0x00, 0x7B, 0xE0, 0x1F, 0x7C,
  0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3C, 0xF8, 0x07, 0xDF, 0x03, 0xE7, 0xC0,
  0x7C, 0xF8, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0xF3, 0xE0, 0x1F, 0x3E, 0x0F,
  0x9F, 0x00, 0xF9, 0xF0, 0x78, 0xF8, 0x07, 0x8F, 0x87, 0xC7, 0xC0, 0x7C,
  0x7C, 0x3C, 0x7C, 0x03, 0xE3, 0xE3, 0xE3, 0xE0, 0x1F, 0x0F, 0x1E, 0x1F,
  0x00, 0xF8, 0x79, 0xF0, 0xF8, 0x07, 0x83, 0xCF, 0x07, 0xC0, 0x7C, 0x1E,
  0x78, 0x7C, 0x03, 0xE0, 0xF7, 0xC3, 0xE0, 0x1F, 0x07, 0xBC, 0x1F, 0x00,
  0xF8, 0x3F, 0xE0, 0xF8, 0x07, 0x81, 0xFE, 0x0F, 0x80, 0x7C, 0x0F, 0xF0,
  0x7C, 0x03, 0xE0, 0x7F, 0x03, 0xE0, 0x1F, 0x03, 0xF8, 0x1F, 0x00, 0xF8,
  0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x03, 0xF0,
  0x01, 0xF0, 0x0F, 0xC0, 0x07, 0x80, 0x7F, 0x00, 0x3E, 0x01, 0xFE, 0x00,
  0xF8, 0x07, 0xF8, 0x03, 0xE0, 0x1F, 0xE0, 0x0F, 0x80, 0x7F, 0x80, 0x7C,
  0x03, 0xFE, 0x01, 0xF0, 0x0F, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x1F, 0x00,
  0xF7, 0xC0, 0x7C, 0x03, 0xCF, 0x03, 0xE0, 0x1F, 0x3C, 0x0F, 0x80, 0x7C,
  0xF0, 0x3E, 0x01, 0xF3, 0xC0, 0xF8, 0x07, 0x8F, 0x83, 0xC0, 0x3E, 0x3E,
  0x1F, 0x00, 0xF8, 0x78, 0x7C, 0x03, 0xE1, 0xE1, 0xF0, 0x0F, 0x87, 0x87,
  0xC0, 0x3C, 0x1E, 0x1E, 0x01, 0xF0, 0x7C, 0xF8, 0x07, 0xC1, 0xF3, 0xE0,
  0x1F, 0x03, 0xCF, 0x80, 0x7C, 0x0F, 0x3E, 0x01, 0xE0, 0x3C, 0xF0, 0x0F,
  0x80, 0xF7, 0xC0, 0x3E, 0x03, 0xFF, 0x00, 0xF8, 0x0F, 0xFC, 0x03, 0xE0,
  0x1F, 0xE0, 0x0F, 0x00, 0x7F, 0x80, 0x7C, 0x01, 0xFE, 0x01, 0xF0, 0x07,
  0xF8, 0x07, 0xC0, 0x1F, 0xE0, 0x1F, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0xFC,
  0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x1F, 0x87, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x01, 0xF1, 0xF0,
  0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x7E,
  0x00, 0x1F, 0xBF, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7,
  0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x8F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1, 0xF8, 0x07,
  0xE0, 0xFC, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0xFE, 0x01, 0xF0, 0x3F, 0x01,
  0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03,
  0xE0, 0x1F, 0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3E, 0x07,
  0xC0, 0x3E, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xFC, 0x0F,
  0x87, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x01,
  0xF1, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0x7C, 0x00,
  0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80,
  0x03, 0xE7, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xF9, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x8F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1,
  0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x1F, 0xC7, 0xF0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0xFE, 0x01,
  0xF0, 0x3E, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x3F, 0x03,
  0xE0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x3E, 0x07,
  0xC0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F,
  0x83, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x1F,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E,
  0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0xF8,
  0x03, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x1C, 0x03, 0xF0, 0x04, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x80, 0x0F, 0xC0, 0xE0, 0x1F, 0xC0, 0xFC, 0x7F, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x7E,
  0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0,
  0x7C, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07,
  0xC0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x0F,
  0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xF8,
  0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x01,
  0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8,
  0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xE1, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x04,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xBE, 0x00,
  0x3E, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xF0, 0xF8,
  0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E,
  0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03,
  0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xC0, 0x03, 0xDF, 0x00,
  0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0x80, 0x1F, 0x7C,
  0x00, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x80, 0x3E, 0x7C, 0x01, 0xF8, 0x03,
  0xE7, 0xC0, 0x3F, 0x80, 0x7C, 0x78, 0x03, 0xF8, 0x07, 0xC7, 0x80, 0x3F,
  0x80, 0xFC, 0x78, 0x07, 0xF8, 0x0F, 0x8F, 0x80, 0x7F, 0x00, 0xF8, 0xF8,
  0x0F, 0xF0, 0x1F, 0x0F, 0x80, 0xFF, 0x01, 0xF0, 0xF8, 0x0F, 0xF0, 0x1F,
  0x0F, 0x81, 0xEF, 0x03, 0xE0, 0xF8, 0x1E, 0xF0, 0x3E, 0x0F, 0x83, 0xEF,
  0x07, 0xC0, 0xF8, 0x3C, 0xF0, 0x7C, 0x0F, 0x83, 0xCF, 0x07, 0xC0, 0xF8,
  0x7C, 0xF0, 0xF8, 0x0F, 0x87, 0x8F, 0x0F, 0x80, 0xF8, 0xF8, 0xF1, 0xF8,
  0x0F, 0x8F, 0x0F, 0x1F, 0x00, 0xF8, 0xF0, 0xF1, 0xF0, 0x0F, 0x9F, 0x0F,
  0x3E, 0x00, 0xF9, 0xE0, 0xF3, 0xE0, 0x0F, 0x9E, 0x0F, 0x3E, 0x00, 0xFB,
  0xC0, 0xF7, 0xC0, 0x0F, 0xBC, 0x0F, 0x7C, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x0F,
  0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x7C,
  0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x7C,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3F, 0x3E, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8,
  0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x03, 0xF0,
  0x03, 0xE0, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7C, 0xF8,
  0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x81, 0xF0,
  0x3C, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x7C, 0x03, 0xE3,
  0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xF0, 0x7C, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xCF, 0x80,
  0x1F, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xE1, 0xF0, 0x1F, 0x07, 0xC0, 0x78,
  0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x07,
  0x8F, 0x80, 0x1E, 0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xF8, 0xFC, 0xFC, 0x7C, 0x3E, 0x3E, 0x1E, 0x1F, 0x0F,
  0x00, 0x18, 0x00, 0x03, 0xF8, 0xF0, 0x1F, 0xF3, 0xC0, 0xFF, 0xDF, 0x07,
  0xFF, 0xFC, 0x3F, 0x8F, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x01,
  0xF8, 0x7C, 0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF1,
  0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x78, 0x7C, 0x03, 0xE1, 0xF0,
  0x0F, 0x8F, 0xC0, 0x3E, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x1F,
  0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xFC, 0x1F, 0xC1, 0xF0, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFB, 0xE0, 0x3F, 0xCF, 0x80, 0x7E, 0x3C, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x20, 0x03,
  0xE7, 0xF0, 0x0F, 0xBF, 0xE0, 0x7D, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xF0,
  0xFC, 0x1F, 0x81, 0xF0, 0x7C, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C,
  0x03, 0xF1, 0xF0, 0x0F, 0x87, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07,
  0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xF1, 0xF8, 0x0F, 0x87,
  0xE0, 0x7E, 0x1F, 0x81, 0xF0, 0x7F, 0x0F, 0xC1, 0xFF, 0xFE, 0x0F, 0xBF,
  0xF0, 0x3C, 0xFF, 0x80, 0xF1, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xC1,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x04, 0x0F, 0xC3, 0x01,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x02,
  0x07, 0xC0, 0x0F, 0xE7, 0xC0, 0x0F, 0xFB, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xE3, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x03,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x78,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x0F,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03,
  0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF8, 0x03, 0xFF, 0xBC, 0x01, 0xFF,
  0x9E, 0x00, 0x7F, 0xDF, 0x00, 0x1F, 0x8F, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0x7E,
  0x0F, 0x83, 0xC3, 0xE0, 0x78, 0xF8, 0x0F, 0x1F, 0x01, 0xE7, 0xC0, 0x7C,
  0xF8, 0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3,
  0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x41, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xF8, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x88, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x3F, 0x8F, 0x00, 0x7F, 0xCF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xF8, 0xFF, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0x7E, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80,
  0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01,
  0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x3F, 0x07,
  0xF0, 0x3F, 0x0F, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFB, 0xE0, 0x0F, 0xFB,
  0xE0, 0x07, 0xE7, 0xC0, 0x01, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x80, 0x3F, 0x00, 0xF9, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x30, 0x03, 0xE7, 0xF0, 0x0F, 0xFF, 0xE0, 0x7D, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83,
  0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0,
  0x3E, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C,
  0x1E, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E,
  0x03, 0xE1, 0xF0, 0x0F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07,
  0xC1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x80,
  0x00, 0x78, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0xF0,
  0x3E, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F,
  0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xEF, 0x80,
  0x07, 0xBE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFB, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F,
  0x0F, 0x80, 0x3C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x10, 0x01, 0xE7, 0xF8, 0x7F,
  0x00, 0xF7, 0xFC, 0xFF, 0xC0, 0xFF, 0xFF, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF8,
  0x1F, 0x0F, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E,
  0x07, 0xC1, 0xF0, 0x1E, 0x03, 0xE0, 0xF0, 0x1F, 0x01, 0xF0, 0xF8, 0x0F,
  0x80, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x1F, 0x03,
  0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x1F, 0x07, 0xC0,
  0x7C, 0x0F, 0x83, 0xE0, 0x3C, 0x07, 0xC1, 0xF0, 0x3E, 0x03, 0xE1, 0xF0,
  0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x3E,
  0x03, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x1E, 0x0F,
  0x80, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x1E,
  0x3F, 0x80, 0xF7, 0xFE, 0x0F, 0xBF, 0xF0, 0x7B, 0xFF, 0x83, 0xF8, 0x7C,
  0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xE0,
  0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0x7C, 0x07, 0xC3,
  0xE0, 0x3E, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x7C, 0x07,
  0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x7C,
  0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0x7C, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0xFC, 0x3F, 0x0F, 0x81, 0xF1, 0xF8, 0x1F, 0x1F,
  0x01, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7,
  0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xC0, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x0F,
  0xCF, 0x80, 0xF8, 0x7C, 0x1F, 0x87, 0xC3, 0xF0, 0x7F, 0xFE, 0x03, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x3C, 0x7F, 0x00, 0x1E, 0x7F, 0xC0, 0x0F, 0x7F, 0xE0, 0x0F, 0xFF,
  0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x01, 0xF8,
  0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1E,
  0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x1F, 0x01, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xEF, 0xFC,
  0x01, 0xF7, 0xFC, 0x00, 0xF9, 0xFC, 0x00, 0x7C, 0x30, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x03, 0xF8, 0xF0, 0x1F, 0xF3, 0xC0, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x1F, 0x0F, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x7E, 0x1F, 0x01,
  0xF8, 0x7C, 0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF1,
  0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x78, 0x7C, 0x03, 0xE1, 0xF0,
  0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x1F,
  0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFB, 0xE0, 0x3F, 0xCF, 0x80, 0x7E, 0x7C, 0x00, 0x41,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0xF3, 0xF0, 0x3D, 0xFC, 0x1F, 0x7E, 0x07, 0xFF, 0x81, 0xEF,
  0xE0, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xE0,
  0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xE0, 0x61, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x80, 0x7C, 0x30, 0x3F, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0,
  0x3F, 0xF8, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x03, 0xFF, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF,
  0xC3, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x04, 0x00, 0x07, 0xC0,
  0x7C, 0x1E, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8,
  0x3E, 0x03, 0xE0, 0xF0, 0x0F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C,
  0x07, 0xC1, 0xF0, 0x1F, 0x07, 0x80, 0x78, 0x3E, 0x03, 0xE0, 0xF8, 0x0F,
  0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07,
  0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x81,
  0xF8, 0x3E, 0x07, 0xE0, 0xFC, 0x3F, 0x83, 0xFF, 0xFC, 0x07, 0xFE, 0xF0,
  0x1F, 0xF3, 0xC0, 0x3F, 0x8F, 0x00, 0x18, 0x00, 0x00, 0xF8, 0x03, 0xFF,
  0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1E, 0x3E,
  0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x7C,
  0x3E, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x3E, 0x3C, 0x03, 0xCF, 0x80, 0x79,
  0xF0, 0x0F, 0x7C, 0x01, 0xEF, 0x80, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x7F, 0xE0, 0x3F,
  0x01, 0xEF, 0x81, 0xFC, 0x0F, 0xBE, 0x07, 0xF0, 0x3E, 0xF8, 0x1F, 0xC1,
  0xF3, 0xE0, 0xFF, 0x07, 0xCF, 0x83, 0xFC, 0x1E, 0x3E, 0x0E, 0xF0, 0xF8,
  0xF8, 0x7B, 0xC3, 0xE3, 0xE1, 0xEF, 0x0F, 0x0F, 0x8F, 0x3C, 0x7C, 0x3E,
  0x3C, 0xF1, 0xE0, 0xF8, 0xF7, 0xCF, 0x83, 0xE7, 0x9E, 0x3E, 0x0F, 0x9E,
  0x78, 0xF0, 0x3E, 0xF1, 0xE7, 0xC0, 0xFB, 0xC7, 0x9E, 0x03, 0xEF, 0x1E,
  0x78, 0x0F, 0x78, 0x7B, 0xE0, 0x3D, 0xE1, 0xEF, 0x00, 0xF7, 0x87, 0xFC,
  0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x00,
  0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0xF8,
  0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07,
  0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF3, 0xE0, 0x00, 0x7B, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x07,
  0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x01, 0xE0, 0x1F,
  0x00, 0x3C, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x00, 0xF0, 0x1F, 0x00, 0x1E,
  0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0xC0,
  0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF1,
  0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x79, 0xF0, 0x00,
  0x0F, 0x3C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x9F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x02,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x60, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x0E,
  0x00, 0x09, 0xFE, 0x00, 0x5F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFA, 0x00, 0x7F, 0x90, 0x00, 0x20,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 14, 39, 13, 0, -39 },
  { 70, 16, 14, 19, 5, -39 },
  { 98, 25, 39, 24, 0, -39 },
  { 220, 23, 44, 22, 0, -41 },
  { 347, 30, 40, 34, 3, -39 },
  { 497, 24, 40, 25, 0, -39 },
  { 617, 8, 14, 11, 5, -39 },
  { 631, 17, 48, 14, 1, -39 },
  { 733, 17, 48, 14, -4, -39 },
  { 835, 17, 19, 20, 5, -41 },
  { 876, 21, 26, 24, 2, -32 },
  { 945, 11, 13, 11, -3, -6 },
  { 963, 12, 5, 14, 1, -17 },
  { 971, 7, 7, 11, 0, -7 },
  { 978, 26, 39, 19, -3, -39 },
  { 1105, 21, 40, 22, 1, -39 },
  { 1210, 14, 39, 22, 6, -39 },
  { 1279, 24, 39, 22, -2, -39 },
  { 1396, 23, 40, 22, -1, -39 },
  { 1511, 23, 39, 22, -1, -39 },
  { 1624, 22, 40, 22, 0, -39 },
  { 1734, 22, 40, 22, 1, -39 },
  { 1844, 22, 39, 22, 2, -39 },
  { 1952, 22, 40, 22, 0, -39 },
  { 2062, 22, 40, 22, 0, -39 },
  { 2172, 11, 29, 12, 0, -29 },
  { 2212, 15, 36, 12, -3, -29 },
  { 2280, 21, 24, 24, 2, -31 },
  { 2343, 21, 16, 24, 2, -27 },
  { 2385, 21, 24, 24, 2, -31 },
  { 2448, 18, 39, 16, 1, -39 },
  { 2536, 31, 43, 33, 1, -39 },
  { 2703, 22, 39, 23, -3, -39 },
  { 2811, 24, 39, 24, 0, -39 },
  { 2928, 24, 40, 22, 2, -39 },
  { 3048, 25, 39, 26, 0, -39 },
  { 3170, 23, 39, 20, 0, -39 },
  { 3283, 23, 39, 19, 0, -39 },
  { 3396, 26, 40, 27, 2, -39 },
  { 3526, 28, 39, 27, 0, -39 },
  { 3663, 22, 39, 15, -3, -39 },
  { 3771, 21, 50, 12, -8, -39 },
  { 3903, 27, 39, 23, 0, -39 },
  { 4035, 15, 39, 19, 0, -39 },
  { 4109, 37, 39, 36, 0, -39 },
  { 4290, 30, 39, 28, 0, -39 },
  { 4437, 25, 40, 28, 2, -39 },
  { 4562, 24, 39, 23, 0, -39 },
  { 4679, 25, 48, 28, 2, -39 },
  { 4829, 24, 39, 23, 0, -39 },
  { 4946, 24, 40, 21, -1, -39 },
  { 5066, 20, 39, 19, 4, -39 },
  { 5164, 26, 40, 26, 2, -39 },
  { 5294, 22, 39, 23, 5, -39 },
  { 5402, 36, 39, 36, 4, -39 },
  { 5578, 28, 39, 21, -3, -39 },
  { 5715, 21, 39, 20, 4, -39 },
  { 5818, 24, 39, 19, -2, -39 },
  { 5935, 21, 48, 15, -2, -39 },
  { 6061, 10, 39, 19, 5, -39 },
  { 6110, 21, 48, 15, -4, -39 },
  { 6236, 22, 22, 22, 0, -39 },
  { 6297, 18, 3, 17, -5, 5 },
  { 6304, 8, 8, 14, 8, -41 },
  { 6312, 22, 31, 23, 1, -30 },
  { 6398, 22, 42, 23, 0, -41 },
  { 6514, 19, 31, 18, 1, -30 },
  { 6588, 25, 42, 23, 1, -41 },
  { 6720, 19, 31, 21, 1, -30 },
  { 6794, 26, 54, 13, -7, -41 },
  { 6970, 24, 43, 23, -1, -30 },
  { 7099, 22, 41, 23, 0, -41 },
  { 7212, 13, 40, 11, 0, -40 },
  { 7277, 20, 53, 11, -7, -40 },
  { 7410, 23, 41, 21, 0, -41 },
  { 7528, 14, 41, 11, 0, -41 },
  { 7600, 33, 30, 34, 0, -30 },
  { 7724, 21, 30, 23, 0, -30 },
  { 7803, 20, 31, 23, 1, -30 },
  { 7881, 25, 43, 23, -3, -30 },
  { 8016, 22, 43, 23, 1, -30 },
  { 8135, 18, 30, 16, 0, -30 },
  { 8203, 18, 31, 18, 0, -30 },
  { 8273, 14, 37, 14, 1, -36 },
  { 8338, 22, 30, 23, 1, -29 },
  { 8421, 19, 29, 19, 3, -29 },
  { 8490, 30, 29, 30, 3, -29 },
  { 8599, 25, 29, 20, -3, -29 },
  { 8690, 27, 42, 19, -5, -29 },
  { 8832, 20, 29, 16, -2, -29 },
  { 8905, 20, 48, 18, 1, -39 },
  { 9025, 5, 54, 20, 7, -41 },
  { 9059, 20, 48, 18, -3, -39 },
  { 9179, 21, 8, 24, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC54PT7B_H_
