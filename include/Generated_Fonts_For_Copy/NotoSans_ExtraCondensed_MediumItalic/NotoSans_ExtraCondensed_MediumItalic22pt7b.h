#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC22PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x86, 0x18, 0xC3, 0x0C, 0x30, 0x86, 0x00, 0x01, 0x8E,
  0x30, 0x66, 0xD9, 0xB2, 0x6C, 0xD9, 0x00, 0x06, 0xC1, 0x30, 0xC8, 0x36,
  0x09, 0x8F, 0xF5, 0x90, 0x4C, 0x32, 0x0C, 0x8F, 0xF8, 0x90, 0x64, 0x13,
  0x04, 0xC3, 0x20, 0x02, 0x01, 0x03, 0xE3, 0xF3, 0x49, 0xA0, 0xD0, 0x78,
  0x1C, 0x07, 0x03, 0xC1, 0x60, 0xB4, 0xB3, 0xF8, 0xF8, 0x10, 0x10, 0x00,
  0x18, 0x63, 0xC4, 0x6C, 0xC4, 0xC8, 0xCD, 0x8C, 0x90, 0xCB, 0x2D, 0xAF,
  0xF6, 0x96, 0x59, 0x0D, 0x90, 0x93, 0x19, 0x31, 0x12, 0x31, 0x66, 0x1C,
  0x07, 0x03, 0xC1, 0x90, 0x64, 0x1B, 0x06, 0xC1, 0xE0, 0x70, 0x3C, 0xDB,
  0x6C, 0xDB, 0x1C, 0xC7, 0x31, 0xCF, 0xF1, 0xEE, 0x6D, 0xAD, 0x80, 0x06,
  0x18, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30,
  0x60, 0x40, 0xC1, 0x80, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x60, 0xC1, 0x86, 0x0C, 0x30, 0x63, 0x80, 0x18, 0x33, 0x67,
  0xF3, 0xED, 0x3B, 0x24, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x33, 0x66, 0x4C, 0x7F, 0xC0, 0x7F, 0x00, 0x00, 0xC0, 0x30,
  0x18, 0x06, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0x06, 0x03, 0x00, 0x07, 0x07, 0x86, 0x66, 0x33, 0x19, 0x8D,
  0x86, 0xC7, 0x63, 0x31, 0x98, 0xD8, 0xEC, 0x63, 0x31, 0xF0, 0xF0, 0x0C,
  0x73, 0xDB, 0xD8, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x07,
  0x87, 0xF0, 0x8C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x1C, 0x07, 0xF3, 0xFC, 0x0F, 0x1F, 0xC4, 0x60, 0x30,
  0x18, 0x18, 0x1C, 0x38, 0x3E, 0x03, 0x01, 0xC0, 0xE0, 0x60, 0x33, 0xF1,
  0xF0, 0x01, 0x81, 0xC1, 0xE0, 0xE0, 0xF0, 0x58, 0x4C, 0x64, 0x26, 0x33,
  0x31, 0x9F, 0xEF, 0xF0, 0x60, 0x30, 0x18, 0x1F, 0x8F, 0xC6, 0x02, 0x03,
  0x01, 0x80, 0xF0, 0xFC, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x64, 0x33, 0xF1,
  0xF0, 0x07, 0x1F, 0x38, 0x30, 0x60, 0x60, 0xDC, 0xFE, 0xE6, 0xC6, 0xC6,
  0xC6, 0xC6, 0xCC, 0xFC, 0x78, 0x7F, 0xBF, 0xC0, 0xC0, 0x60, 0x60, 0x30,
  0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x81, 0x80, 0x0F,
  0x0F, 0xCC, 0x66, 0x33, 0x19, 0x98, 0x7C, 0x38, 0x3E, 0x33, 0x38, 0xD8,
  0x6C, 0x36, 0x33, 0xF8, 0xF8, 0x0E, 0x0F, 0x8E, 0x66, 0x33, 0x1B, 0x0D,
  0x8E, 0xC6, 0x7F, 0x1D, 0x80, 0xC0, 0xC0, 0x60, 0x63, 0xF1, 0xE0, 0x11,
  0xCC, 0x00, 0x00, 0x00, 0x02, 0x39, 0x80, 0x0C, 0x71, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xC3, 0x18, 0x63, 0x0C, 0x00, 0x01, 0x03, 0x0F, 0x3C, 0xF0,
  0xE0, 0x78, 0x1E, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0xC0, 0x70, 0x1C, 0x07, 0x07, 0x1E, 0x78, 0xE0, 0x80, 0x1E, 0x3E, 0x27,
  0x03, 0x06, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x20, 0x40, 0x00, 0x60, 0xE0,
  0xE0, 0x03, 0xC0, 0xEE, 0x18, 0x33, 0x03, 0x23, 0x16, 0x79, 0x4D, 0x9C,
  0x9B, 0x99, 0x39, 0x32, 0x93, 0x29, 0x36, 0x9D, 0xC8, 0x80, 0x80, 0x0C,
  0x00, 0x7E, 0x03, 0xC0, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0xD8, 0x6C, 0x36,
  0x33, 0x19, 0x9F, 0xCF, 0xEE, 0x36, 0x1B, 0x0F, 0x07, 0x83, 0x1F, 0x07,
  0xE1, 0x9C, 0x63, 0x30, 0xCC, 0x73, 0x18, 0xFC, 0x3F, 0x18, 0xC6, 0x19,
  0x8E, 0x63, 0x18, 0xCF, 0xE3, 0xF0, 0x07, 0x8F, 0xCE, 0x26, 0x07, 0x03,
  0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xF0, 0xF8,
  0x1F, 0x07, 0xE1, 0x9C, 0x63, 0x38, 0xCC, 0x33, 0x0C, 0xC3, 0x30, 0xD8,
  0x76, 0x19, 0x86, 0x63, 0x19, 0xCF, 0xE3, 0xE0, 0x1F, 0x8F, 0xC6, 0x03,
  0x03, 0x81, 0x80, 0xC0, 0x7E, 0x3E, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0xF1, 0xF8, 0x1F, 0x8F, 0xC6, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x7C, 0x3E,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0x07, 0xC3, 0xFC, 0xE1,
  0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC7, 0x98, 0x33, 0x06, 0x61,
  0xCC, 0x31, 0xC6, 0x1F, 0xC3, 0xF8, 0x18, 0x71, 0x86, 0x18, 0x61, 0x86,
  0x38, 0xE3, 0x0C, 0x30, 0xC3, 0xFC, 0x3F, 0xC6, 0x1C, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x18, 0xC3, 0x0C, 0x30, 0x1F, 0x8F, 0x83, 0x81, 0x80, 0xC0,
  0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC1, 0xF8,
  0x03, 0x03, 0x03, 0x03, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0xF0, 0xF0, 0x18, 0x63, 0x18, 0x67,
  0x0C, 0xC3, 0x30, 0x6E, 0x0D, 0x81, 0xE0, 0x3C, 0x0F, 0xC1, 0x98, 0x33,
  0x06, 0x60, 0xCC, 0x31, 0xC6, 0x18, 0x18, 0x61, 0x86, 0x38, 0xC3, 0x0C,
  0x31, 0x86, 0x18, 0x61, 0x8F, 0xFF, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x78,
  0xE0, 0xE3, 0xC3, 0xC6, 0x87, 0x8D, 0x1B, 0x1A, 0x36, 0x34, 0xD8, 0xC9,
  0xB1, 0x92, 0x63, 0x3C, 0xC6, 0x73, 0x08, 0xE6, 0x31, 0xCC, 0x63, 0x18,
  0x1C, 0x31, 0xC3, 0x1C, 0x31, 0xC2, 0x34, 0x63, 0x66, 0x36, 0x63, 0x66,
  0x36, 0xC6, 0x6C, 0x62, 0xC6, 0x3C, 0x63, 0xC4, 0x38, 0xC3, 0x8C, 0x38,
  0x07, 0x07, 0xE3, 0x9C, 0xC3, 0x60, 0xD8, 0x3E, 0x0F, 0x03, 0xC1, 0xF0,
  0x6C, 0x1B, 0x0E, 0xC3, 0x31, 0xCF, 0xE1, 0xF0, 0x1F, 0x07, 0xE1, 0x9C,
  0x63, 0x38, 0xCC, 0x73, 0x18, 0xCE, 0x3F, 0x1F, 0x86, 0x01, 0x80, 0x60,
  0x18, 0x0C, 0x03, 0x00, 0x07, 0x07, 0xE3, 0x9C, 0xC3, 0x60, 0xD8, 0x3E,
  0x0F, 0x03, 0xC1, 0xF0, 0x6C, 0x1B, 0x0E, 0xC3, 0x31, 0xCF, 0xE1, 0xF0,
  0x1C, 0x03, 0x00, 0xC0, 0x38, 0x1E, 0x07, 0xE1, 0x98, 0x67, 0x31, 0xCC,
  0x63, 0x18, 0xCE, 0x3F, 0x1F, 0x86, 0x61, 0x98, 0x66, 0x19, 0x8C, 0x73,
  0x0C, 0x0F, 0x0F, 0xCE, 0x26, 0x03, 0x01, 0x80, 0xE0, 0x38, 0x1E, 0x07,
  0x01, 0x80, 0xC0, 0x64, 0x33, 0xF1, 0xF0, 0x7F, 0xBF, 0x86, 0x03, 0x01,
  0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x81,
  0xC0, 0x30, 0xCC, 0x33, 0x0C, 0xC3, 0x61, 0x98, 0x66, 0x19, 0x86, 0xE3,
  0xB0, 0xCC, 0x33, 0x0C, 0xC7, 0x31, 0x8F, 0xE1, 0xF0, 0xC1, 0xE1, 0xF0,
  0xD8, 0x6C, 0x66, 0x33, 0x31, 0x98, 0xCC, 0x6C, 0x36, 0x1E, 0x0F, 0x07,
  0x03, 0x81, 0xC0, 0xC3, 0x0F, 0x0C, 0x3C, 0x70, 0xF1, 0xC6, 0xC7, 0x1B,
  0x3C, 0xCC, 0xF3, 0x36, 0xCC, 0xDB, 0x63, 0x4D, 0x8F, 0x3C, 0x3C, 0xF0,
  0xA3, 0xC3, 0x8E, 0x0E, 0x38, 0x30, 0xC0, 0x18, 0x61, 0x98, 0x33, 0x06,
  0xC0, 0xD8, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x1B, 0x03,
  0x70, 0xC6, 0x18, 0xC6, 0x18, 0xC3, 0xC7, 0xC6, 0xCC, 0xCC, 0xD8, 0x58,
  0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0x1F, 0xC7, 0xF0,
  0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0x0F, 0xE3, 0xF8, 0x0F, 0x87, 0x83, 0x01, 0x80, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x1E, 0x1F, 0x00, 0xCC, 0xC4, 0x66, 0x66, 0x66, 0x62, 0x33, 0x33,
  0x07, 0x87, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x1E, 0x1F, 0x00, 0x06,
  0x03, 0x03, 0x83, 0x61, 0xB1, 0x98, 0xCC, 0xC3, 0xC1, 0x80, 0xFE, 0xE6,
  0x63, 0x0E, 0xC7, 0xE3, 0x18, 0xC6, 0x61, 0x98, 0xC6, 0x31, 0x8C, 0xE3,
  0x19, 0xC7, 0xA1, 0xF8, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xB8, 0xFE,
  0x63, 0x31, 0x98, 0xD8, 0x6C, 0x36, 0x33, 0x1B, 0x9D, 0xFC, 0xDC, 0x00,
  0x1E, 0x79, 0x87, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xE7, 0xC0, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x1F, 0x07, 0xE1, 0x8C, 0x31, 0x8C,
  0x31, 0x8C, 0x31, 0x86, 0x31, 0xC6, 0x19, 0xC3, 0xD0, 0x7E, 0x00, 0x0F,
  0x1F, 0x33, 0x73, 0x63, 0x7E, 0x78, 0x60, 0xC0, 0x60, 0x76, 0x3E, 0x00,
  0xE0, 0x38, 0x0C, 0x01, 0x80, 0x30, 0x0F, 0x03, 0xE0, 0x30, 0x06, 0x00,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x61, 0xF8, 0x63, 0x0C, 0x63,
  0x0C, 0x63, 0x0C, 0x61, 0x8C, 0x71, 0x86, 0x70, 0xFC, 0x1F, 0x80, 0x30,
  0x06, 0x01, 0x87, 0x70, 0xFC, 0x00, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81,
  0xB8, 0xFE, 0x63, 0x31, 0x99, 0x98, 0xCC, 0x66, 0x33, 0x1B, 0x19, 0x8C,
  0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0xC6, 0x33, 0x18, 0xC6, 0x63, 0x18,
  0x03, 0x03, 0x00, 0x00, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0xF0, 0xE0, 0x1C, 0x0C, 0x06,
  0x03, 0x01, 0x81, 0x8C, 0xCC, 0x6E, 0x36, 0x16, 0x1F, 0x0F, 0x86, 0xC3,
  0x63, 0x19, 0x8C, 0xC6, 0x00, 0x1C, 0x61, 0x86, 0x18, 0xC3, 0x0C, 0x30,
  0xC6, 0x18, 0x61, 0x8E, 0x30, 0xC0, 0x37, 0x39, 0xFF, 0xCC, 0x66, 0x63,
  0x33, 0x31, 0xB1, 0x8D, 0x8C, 0x6C, 0x66, 0x66, 0x36, 0x31, 0xB1, 0x8D,
  0x8C, 0xC0, 0x37, 0x1F, 0xCC, 0x66, 0x33, 0x33, 0x19, 0x8C, 0xC6, 0x63,
  0x63, 0x31, 0x98, 0xC0, 0x1C, 0x3E, 0x67, 0xE3, 0xC3, 0xC3, 0xC6, 0xC6,
  0xC6, 0xCC, 0xFC, 0x78, 0x1B, 0x87, 0xF1, 0xCC, 0x63, 0x18, 0xCC, 0x33,
  0x0C, 0xC6, 0x31, 0x9C, 0xE7, 0xF1, 0xB8, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0xC0, 0x00, 0x0E, 0xC7, 0xE3, 0x18, 0xC6, 0x61, 0x98, 0xC6, 0x31, 0x8C,
  0xE3, 0x19, 0xC7, 0xE1, 0xF8, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x00,
  0x36, 0x7C, 0xE1, 0x83, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x00, 0x1F,
  0x3E, 0x60, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x0C, 0x0C, 0xFC, 0xF8, 0x11,
  0x8C, 0xFF, 0xB1, 0x8C, 0xC6, 0x31, 0x8C, 0x73, 0x80, 0x63, 0x63, 0x63,
  0x63, 0x46, 0xC6, 0xC6, 0xC6, 0xCE, 0xCC, 0xFC, 0xEC, 0xC3, 0xC6, 0xC6,
  0xCC, 0xCC, 0xCC, 0xD8, 0xD8, 0xF0, 0xF0, 0x60, 0x60, 0xC7, 0x3C, 0x63,
  0xCE, 0x3C, 0xE6, 0xCA, 0x6D, 0xAC, 0xD2, 0xCF, 0x2C, 0xF3, 0x8E, 0x38,
  0xE7, 0x0E, 0x70, 0x19, 0xC6, 0x61, 0xB0, 0x6C, 0x0E, 0x03, 0x01, 0xC0,
  0x70, 0x36, 0x0D, 0x86, 0x63, 0x18, 0x18, 0x63, 0x18, 0x63, 0x04, 0x60,
  0x98, 0x13, 0x02, 0xC0, 0x58, 0x0A, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x30, 0x06, 0x07, 0x80, 0xE0, 0x00, 0x1F, 0x1F, 0x06, 0x06, 0x0C, 0x0C,
  0x18, 0x30, 0x30, 0x60, 0x7C, 0xFC, 0x01, 0x83, 0x83, 0x81, 0x80, 0xC0,
  0x60, 0x70, 0x30, 0x18, 0x38, 0x3C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x60, 0x38, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x1E,
  0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x07, 0x0E, 0x18, 0x18, 0x18,
  0x30, 0x30, 0x30, 0x70, 0xE0, 0xF9, 0xFF, 0x86,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 16, 5, 0, -16 },
  { 13, 7, 6, 8, 2, -16 },
  { 19, 10, 16, 10, 0, -16 },
  { 39, 9, 18, 9, 0, -17 },
  { 60, 12, 16, 14, 1, -16 },
  { 84, 10, 16, 10, 0, -16 },
  { 104, 3, 6, 4, 2, -16 },
  { 107, 7, 19, 6, 0, -16 },
  { 124, 7, 19, 6, -2, -16 },
  { 141, 7, 8, 8, 2, -17 },
  { 148, 8, 10, 10, 1, -13 },
  { 158, 4, 6, 5, -1, -3 },
  { 161, 5, 2, 6, 0, -7 },
  { 163, 3, 3, 5, 0, -3 },
  { 165, 10, 16, 8, -1, -16 },
  { 185, 9, 16, 9, 0, -16 },
  { 203, 6, 16, 9, 2, -16 },
  { 215, 10, 16, 9, -1, -16 },
  { 235, 9, 16, 9, 0, -16 },
  { 253, 9, 16, 9, 0, -16 },
  { 271, 9, 16, 9, 0, -16 },
  { 289, 8, 16, 9, 1, -16 },
  { 305, 9, 16, 9, 1, -16 },
  { 323, 9, 16, 9, 0, -16 },
  { 341, 9, 16, 9, 0, -16 },
  { 359, 5, 12, 5, 0, -12 },
  { 367, 6, 15, 5, -1, -12 },
  { 379, 8, 10, 10, 1, -13 },
  { 389, 8, 6, 10, 1, -11 },
  { 395, 8, 10, 10, 1, -13 },
  { 405, 8, 16, 7, 0, -16 },
  { 421, 12, 18, 13, 1, -16 },
  { 448, 9, 16, 9, -1, -16 },
  { 466, 10, 16, 10, 0, -16 },
  { 486, 9, 16, 9, 1, -16 },
  { 504, 10, 16, 11, 0, -16 },
  { 524, 9, 16, 8, 0, -16 },
  { 542, 9, 16, 8, 0, -16 },
  { 560, 11, 16, 11, 1, -16 },
  { 582, 12, 16, 11, 0, -16 },
  { 606, 9, 16, 6, -1, -16 },
  { 624, 8, 20, 5, -3, -16 },
  { 644, 11, 16, 9, 0, -16 },
  { 666, 6, 16, 8, 0, -16 },
  { 678, 15, 16, 15, 0, -16 },
  { 708, 12, 16, 12, 0, -16 },
  { 732, 10, 16, 11, 1, -16 },
  { 752, 10, 16, 9, 0, -16 },
  { 772, 10, 20, 11, 1, -16 },
  { 797, 10, 16, 9, 0, -16 },
  { 817, 9, 16, 8, 0, -16 },
  { 835, 9, 16, 8, 1, -16 },
  { 853, 10, 16, 11, 1, -16 },
  { 873, 9, 16, 9, 2, -16 },
  { 891, 14, 16, 15, 2, -16 },
  { 919, 11, 16, 9, -1, -16 },
  { 941, 8, 16, 8, 2, -16 },
  { 957, 10, 16, 8, -1, -16 },
  { 977, 9, 20, 6, -1, -16 },
  { 1000, 4, 16, 8, 2, -16 },
  { 1008, 9, 20, 6, -2, -16 },
  { 1031, 9, 9, 9, 0, -16 },
  { 1042, 7, 1, 7, -2, 2 },
  { 1043, 4, 4, 6, 3, -17 },
  { 1045, 10, 12, 10, 0, -12 },
  { 1060, 9, 17, 9, 0, -17 },
  { 1080, 7, 12, 7, 1, -12 },
  { 1091, 11, 17, 10, 0, -17 },
  { 1115, 8, 12, 9, 0, -12 },
  { 1127, 11, 22, 5, -3, -17 },
  { 1158, 11, 17, 10, -1, -12 },
  { 1182, 9, 17, 9, 0, -17 },
  { 1202, 5, 16, 4, 0, -16 },
  { 1212, 8, 21, 4, -3, -16 },
  { 1233, 9, 17, 8, 0, -17 },
  { 1253, 6, 17, 4, 0, -17 },
  { 1266, 13, 12, 14, 0, -12 },
  { 1286, 9, 12, 9, 0, -12 },
  { 1300, 8, 12, 9, 1, -12 },
  { 1312, 10, 17, 9, -1, -12 },
  { 1334, 10, 17, 10, 0, -12 },
  { 1356, 7, 12, 6, 0, -12 },
  { 1367, 8, 12, 7, 0, -12 },
  { 1379, 5, 15, 6, 1, -15 },
  { 1389, 8, 12, 9, 1, -12 },
  { 1401, 8, 12, 8, 1, -12 },
  { 1413, 12, 12, 12, 1, -12 },
  { 1431, 10, 12, 8, -1, -12 },
  { 1446, 11, 17, 8, -2, -12 },
  { 1470, 8, 12, 7, -1, -12 },
  { 1482, 9, 19, 7, 0, -16 },
  { 1504, 2, 22, 8, 3, -17 },
  { 1510, 8, 19, 7, -1, -16 },
  { 1529, 8, 3, 10, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC22PT7B_H_
