#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC11PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0x24, 0x84, 0xF6, 0x80, 0x29, 0x5E, 0xA5, 0x7A, 0x94, 0x13,
  0xD8, 0xC3, 0x1A, 0xC8, 0x40, 0x4B, 0x4D, 0x3A, 0xB5, 0x55, 0xA6, 0x32,
  0x94, 0x46, 0xDA, 0x5E, 0x68, 0x32, 0x44, 0x88, 0x88, 0x84, 0x21, 0x11,
  0x22, 0x22, 0x48, 0xE7, 0xA2, 0x21, 0x3E, 0x42, 0x00, 0x78, 0xE0, 0x80,
  0x0C, 0x21, 0x04, 0x20, 0x84, 0x30, 0x35, 0x55, 0x99, 0xAE, 0x2E, 0xA4,
  0x96, 0x35, 0x11, 0x24, 0x8E, 0x70, 0xC4, 0xE3, 0x08, 0xDC, 0x18, 0x8C,
  0xA5, 0x78, 0x84, 0x3A, 0x10, 0xC1, 0x08, 0xDC, 0x39, 0x10, 0xED, 0x4A,
  0x4C, 0x78, 0x44, 0x22, 0x11, 0x18, 0x32, 0x54, 0xE6, 0x4A, 0x5C, 0x35,
  0x55, 0x71, 0x2E, 0x50, 0x20, 0x24, 0x02, 0xB0, 0x1B, 0x30, 0x60, 0x80,
  0xF8, 0x3E, 0xC1, 0x86, 0xC8, 0x00, 0x71, 0x12, 0x44, 0x08, 0x1C, 0x49,
  0x6B, 0x5A, 0xD6, 0xAA, 0x40, 0x70, 0x18, 0xC6, 0x52, 0xBD, 0x39, 0x32,
  0x52, 0xE5, 0x2A, 0x5C, 0x39, 0x10, 0x8C, 0x63, 0x0E, 0x32, 0x52, 0x94,
  0xAE, 0x5C, 0x3A, 0x10, 0xE4, 0x22, 0x1C, 0x3A, 0x10, 0x87, 0x22, 0x10,
  0x1C, 0x84, 0x10, 0xDB, 0x2C, 0x9C, 0x25, 0x24, 0x9E, 0x49, 0x29, 0x24,
  0x38, 0x88, 0x42, 0x10, 0x9C, 0x08, 0x84, 0x21, 0x08, 0x84, 0x26, 0x00,
  0x2D, 0x25, 0x18, 0x61, 0x89, 0x24, 0x29, 0x24, 0xA7, 0x23, 0x66, 0x66,
  0x6A, 0x6A, 0xAC, 0xB4, 0xB4, 0x25, 0x96, 0x5A, 0x59, 0x69, 0xA6, 0x3B,
  0x52, 0x9C, 0xC7, 0x4E, 0x32, 0x52, 0xB7, 0x22, 0x10, 0x3B, 0x52, 0x9C,
  0xC7, 0x4E, 0x20, 0x80, 0x32, 0x52, 0xA6, 0x32, 0x52, 0x3A, 0x10, 0xC2,
  0x08, 0xDC, 0xF4, 0x44, 0xC8, 0x88, 0x25, 0x24, 0x92, 0x4B, 0x49, 0x1C,
  0x9C, 0xAD, 0x4A, 0x63, 0x10, 0x93, 0x26, 0xD5, 0xAD, 0xDB, 0x36, 0x48,
  0x24, 0xA1, 0x84, 0x30, 0xC5, 0x36, 0x9A, 0xAC, 0xC8, 0x88, 0x78, 0x8C,
  0x44, 0x22, 0x1C, 0x34, 0x44, 0x44, 0x88, 0x8C, 0xAA, 0x55, 0x31, 0x11,
  0x12, 0x22, 0x2C, 0x23, 0x55, 0x90, 0xF0, 0x80, 0x7A, 0x95, 0x29, 0x78,
  0x22, 0x1C, 0xB5, 0x4A, 0x5C, 0x34, 0xC8, 0x86, 0x08, 0x5E, 0xA5, 0x4A,
  0x5E, 0x35, 0xBC, 0x86, 0x19, 0x0C, 0x42, 0x11, 0x08, 0x42, 0x20, 0x3A,
  0x95, 0x29, 0x78, 0x94, 0xC0, 0x24, 0x75, 0x55, 0x9B, 0x61, 0x24, 0xA4,
  0x30, 0x22, 0x22, 0x44, 0x44, 0x80, 0x22, 0x16, 0xA6, 0x32, 0x96, 0x29,
  0x24, 0xA4, 0x7E, 0xA5, 0x52, 0xA9, 0x54, 0x80, 0x75, 0x55, 0x9B, 0x35,
  0xD9, 0x96, 0x38, 0xB2, 0x8A, 0x49, 0xC4, 0x10, 0x80, 0x3A, 0x95, 0x29,
  0x78, 0x84, 0x20, 0x74, 0x44, 0x88, 0x74, 0x42, 0x2E, 0x6D, 0x25, 0x30,
  0x4A, 0x95, 0x29, 0x78, 0xB7, 0x6D, 0x00, 0xA6, 0xAE, 0xBC, 0xB2, 0xC0,
  0x29, 0x4C, 0x65, 0x68, 0x2C, 0xA3, 0x0C, 0x30, 0x82, 0x10, 0x80, 0x72,
  0x44, 0x8E, 0x12, 0x22, 0xC4, 0x44, 0x44, 0xFF, 0xE0, 0x31, 0x13, 0x13,
  0x22, 0x4C, 0x4D, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 3, 3, 4, 1, -8 },
  { 6, 5, 8, 5, 0, -8 },
  { 11, 5, 9, 4, 0, -8 },
  { 17, 6, 8, 7, 1, -8 },
  { 23, 5, 8, 5, 0, -8 },
  { 28, 2, 3, 2, 1, -8 },
  { 29, 4, 10, 3, 0, -8 },
  { 34, 4, 10, 3, -1, -8 },
  { 39, 4, 4, 4, 1, -8 },
  { 41, 5, 5, 5, 0, -6 },
  { 45, 3, 2, 2, -1, -1 },
  { 46, 3, 1, 3, 0, -3 },
  { 47, 1, 1, 2, 0, -1 },
  { 48, 6, 8, 4, -1, -8 },
  { 54, 4, 8, 4, 0, -8 },
  { 58, 3, 8, 4, 1, -8 },
  { 61, 4, 8, 4, 0, -8 },
  { 65, 5, 8, 4, 0, -8 },
  { 70, 5, 8, 4, 0, -8 },
  { 75, 5, 8, 4, 0, -8 },
  { 80, 5, 8, 4, 0, -8 },
  { 85, 5, 8, 4, 0, -8 },
  { 90, 5, 8, 4, 0, -8 },
  { 95, 4, 8, 4, 0, -8 },
  { 99, 2, 6, 2, 0, -6 },
  { 101, 3, 7, 2, -1, -6 },
  { 104, 5, 5, 5, 0, -6 },
  { 108, 5, 3, 5, 0, -5 },
  { 110, 5, 5, 5, 0, -6 },
  { 114, 4, 8, 3, 0, -8 },
  { 118, 7, 9, 7, 0, -8 },
  { 126, 5, 8, 5, -1, -8 },
  { 131, 5, 8, 5, 0, -8 },
  { 136, 5, 8, 4, 0, -8 },
  { 141, 5, 8, 5, 0, -8 },
  { 146, 5, 8, 4, 0, -8 },
  { 151, 5, 8, 4, 0, -8 },
  { 156, 6, 8, 6, 0, -8 },
  { 162, 6, 8, 5, 0, -8 },
  { 168, 5, 8, 3, -1, -8 },
  { 173, 5, 10, 2, -2, -8 },
  { 180, 6, 8, 5, 0, -8 },
  { 186, 3, 8, 4, 0, -8 },
  { 189, 8, 8, 7, 0, -8 },
  { 197, 6, 8, 6, 0, -8 },
  { 203, 5, 8, 6, 0, -8 },
  { 208, 5, 8, 5, 0, -8 },
  { 213, 5, 10, 6, 0, -8 },
  { 220, 5, 8, 5, 0, -8 },
  { 225, 5, 8, 4, 0, -8 },
  { 230, 4, 8, 4, 1, -8 },
  { 234, 6, 8, 5, 0, -8 },
  { 240, 5, 8, 5, 1, -8 },
  { 245, 7, 8, 7, 1, -8 },
  { 252, 6, 8, 4, -1, -8 },
  { 258, 4, 8, 4, 1, -8 },
  { 262, 5, 8, 4, 0, -8 },
  { 267, 4, 10, 3, 0, -8 },
  { 272, 2, 8, 4, 1, -8 },
  { 274, 4, 10, 3, -1, -8 },
  { 279, 4, 5, 5, 0, -8 },
  { 282, 4, 1, 3, -1, 1 },
  { 283, 1, 1, 3, 2, -8 },
  { 284, 5, 6, 5, 0, -6 },
  { 288, 5, 8, 5, 0, -8 },
  { 293, 4, 6, 4, 0, -6 },
  { 296, 5, 8, 5, 0, -8 },
  { 301, 4, 6, 4, 0, -6 },
  { 304, 5, 11, 3, -1, -8 },
  { 311, 5, 9, 5, 0, -6 },
  { 317, 4, 8, 5, 0, -8 },
  { 321, 3, 8, 2, 0, -8 },
  { 324, 4, 11, 2, -1, -8 },
  { 330, 5, 8, 4, 0, -8 },
  { 335, 3, 8, 2, 0, -8 },
  { 338, 7, 6, 7, 0, -6 },
  { 344, 4, 6, 5, 0, -6 },
  { 347, 4, 6, 5, 0, -6 },
  { 350, 6, 9, 5, -1, -6 },
  { 357, 5, 9, 5, 0, -6 },
  { 363, 4, 6, 3, 0, -6 },
  { 366, 4, 6, 4, 0, -6 },
  { 369, 3, 7, 3, 0, -7 },
  { 372, 5, 6, 5, 0, -6 },
  { 376, 3, 6, 4, 1, -6 },
  { 379, 6, 6, 6, 1, -6 },
  { 384, 5, 6, 4, -1, -6 },
  { 388, 6, 9, 4, -1, -6 },
  { 395, 4, 6, 3, 0, -6 },
  { 398, 4, 10, 4, 0, -8 },
  { 403, 1, 11, 4, 1, -8 },
  { 405, 4, 10, 4, -1, -8 },
  { 410, 5, 2, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC11PT7B_H_
