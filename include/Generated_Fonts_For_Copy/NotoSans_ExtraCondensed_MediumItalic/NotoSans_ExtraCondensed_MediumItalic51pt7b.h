#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC51PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x00, 0xF0, 0x00,
  0x3E, 0x3E, 0x7C, 0x7C, 0xF0, 0xFB, 0xE1, 0xE7, 0xC7, 0xCF, 0x8F, 0x9E,
  0x1E, 0x3C, 0x3C, 0x78, 0x79, 0xE0, 0xF3, 0xC1, 0xC7, 0x87, 0x8F, 0x0F,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x70, 0x70, 0x00, 0x70, 0xF0, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x11, 0xE1, 0xE0, 0x01, 0xE1, 0xC0, 0x01, 0xC1,
  0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x87,
  0x80, 0x07, 0x87, 0x80, 0x07, 0x07, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x0E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1C,
  0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x38,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x70, 0x70, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0x30, 0xC0, 0x78, 0xC0, 0x01, 0xE3, 0x00, 0x0F, 0x8C,
  0x00, 0x3E, 0x70, 0x00, 0xF9, 0x80, 0x01, 0xF6, 0x00, 0x07, 0xD8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x6F, 0xC0, 0x01, 0x9F,
  0x00, 0x06, 0x7C, 0x00, 0x19, 0xF0, 0x00, 0xC7, 0xC0, 0x03, 0x1F, 0x04,
  0x0C, 0x78, 0x18, 0x33, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x1E, 0x01, 0xFE, 0x01, 0xE0, 0x1F, 0xF0, 0x0F, 0x01,
  0xE3, 0xC0, 0xF0, 0x0F, 0x1E, 0x07, 0x00, 0x70, 0xF0, 0x78, 0x07, 0x87,
  0x83, 0x80, 0x3C, 0x3C, 0x3C, 0x01, 0xC1, 0xC1, 0xC0, 0x1E, 0x0E, 0x1E,
  0x00, 0xF0, 0xF0, 0xE0, 0x07, 0x87, 0x8F, 0x00, 0x38, 0x3C, 0x70, 0x01,
  0xC1, 0xC7, 0x80, 0x0E, 0x1E, 0x78, 0x7C, 0xF0, 0xF3, 0xCF, 0xF3, 0x87,
  0x3C, 0x7F, 0x9C, 0x79, 0xE7, 0x9E, 0xFF, 0x9E, 0x78, 0xF7, 0xF8, 0xF3,
  0xC7, 0x9F, 0x8F, 0x1C, 0x3C, 0x78, 0x79, 0xE1, 0xE0, 0x07, 0x8E, 0x0F,
  0x00, 0x3C, 0x70, 0x78, 0x03, 0xC7, 0x83, 0x80, 0x1C, 0x3C, 0x3C, 0x01,
  0xE1, 0xE1, 0xE0, 0x0E, 0x0E, 0x0F, 0x00, 0xF0, 0x70, 0x70, 0x07, 0x03,
  0x87, 0x80, 0x78, 0x1C, 0x3C, 0x03, 0x80, 0xE3, 0xC0, 0x3C, 0x07, 0x9E,
  0x03, 0xC0, 0x3F, 0xE0, 0x1E, 0x01, 0xFE, 0x01, 0xE0, 0x07, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x7C, 0x00,
  0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1F,
  0x1E, 0x00, 0x3E, 0x7C, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE1,
  0xF0, 0xFF, 0xC3, 0xC3, 0xEF, 0x8F, 0x8F, 0x8F, 0x1F, 0x1E, 0x1F, 0x3C,
  0x7C, 0x3E, 0xF8, 0xF0, 0x3D, 0xE3, 0xE0, 0x7F, 0xC7, 0xC0, 0xFF, 0x0F,
  0x80, 0xFE, 0x1E, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x0F, 0xE0, 0xF8,
  0x3F, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xEF, 0x83, 0xFF, 0x9F, 0x83, 0xFC,
  0x1F, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xE7, 0xCF, 0x9E, 0x3C,
  0x78, 0xF1, 0xC7, 0x8F, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x41, 0xC0, 0x71, 0xC0, 0xFD, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0x07,
  0xFF, 0x07, 0xC0, 0x0F, 0xE0, 0x3E, 0xF0, 0x7E, 0xF0, 0x7C, 0x78, 0x38,
  0x7C, 0x10, 0x78, 0x00, 0x20, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x7C,
  0x3C, 0x3E, 0x1E, 0x0E, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF,
  0xE0, 0x3C, 0xF9, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3E, 0x3E, 0x07, 0xC1, 0xE0, 0x7C, 0x1E, 0x0F,
  0x81, 0xF0, 0xF8, 0x1E, 0x1F, 0x01, 0xE1, 0xF0, 0x1E, 0x1F, 0x01, 0xE3,
  0xE0, 0x1E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0x80, 0x7C, 0x78, 0x07,
  0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x0F, 0x81,
  0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0xF8,
  0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0x20, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF8, 0x7F,
  0xE3, 0xFF, 0x9F, 0xBC, 0xF9, 0xF1, 0xC7, 0xC2, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xDF, 0xC0, 0x1C, 0x0F, 0x80, 0x30,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x7F, 0xFE, 0x01, 0xF1, 0xFC, 0x07, 0x03, 0xF0, 0x10, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x20, 0x07, 0xE0, 0xC0, 0x3F, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x0E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xDF, 0x00, 0x0E, 0x7C, 0x00, 0x79,
  0xE0, 0x01, 0xC7, 0x80, 0x0F, 0x3E, 0x00, 0x78, 0xF8, 0x01, 0xC3, 0xE0,
  0x0F, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xC1, 0xF0, 0x0F, 0x07, 0xC0, 0x78,
  0x1E, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x38, 0x0F, 0x81, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x88, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC2, 0x00, 0xFC, 0x18, 0x0F, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xE1, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0xF8,
  0x07, 0xDF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xE3, 0xF0, 0xFC,
  0x0F, 0x87, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x00, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x80,
  0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7C, 0x0F, 0x07, 0xE0, 0x7C, 0x3E, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0x80,
  0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xE0, 0x3F, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF0,
  0x0F, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0xC1, 0xE0, 0x3E, 0x0F, 0x01, 0xE0,
  0x7C, 0x1F, 0x03, 0xE1, 0xF0, 0x0F, 0x9F, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F,
  0x8F, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xC7, 0xC0, 0x3E,
  0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0x78, 0x03, 0xE3, 0xE0,
  0x1E, 0x1F, 0x01, 0xF0, 0xFC, 0x1F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x1F, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xF3, 0xF0, 0x7E, 0x1F, 0x07,
  0xC1, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x1F, 0x00, 0xF1,
  0xF0, 0x0F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F,
  0x1F, 0x03, 0xF1, 0xF0, 0x7F, 0x1F, 0x07, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xBE, 0x07, 0xF3, 0xC0, 0x3C, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x78, 0x1F, 0x83,
  0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x00, 0x00, 0x38,
  0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xE0,
  0xF3, 0xF0, 0x40, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x9F,
  0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xC0,
  0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xC1, 0xC0,
  0x7E, 0x0E, 0x1E, 0x07, 0xFC, 0x70, 0xE0, 0x7F, 0xC3, 0x8F, 0x07, 0x8E,
  0x1C, 0x70, 0x78, 0xF0, 0xE3, 0x87, 0x87, 0x87, 0x3C, 0x38, 0x38, 0x39,
  0xC3, 0xC1, 0xC1, 0xCE, 0x1E, 0x1E, 0x1E, 0xF0, 0xE0, 0xF0, 0xE7, 0x8F,
  0x07, 0x07, 0x38, 0x78, 0x78, 0x39, 0xC3, 0xC3, 0xC3, 0xCE, 0x1C, 0x1E,
  0x1C, 0xF0, 0xE0, 0xE0, 0xE7, 0x87, 0x0F, 0x0E, 0x3C, 0x38, 0x78, 0x71,
  0xE1, 0xE7, 0xC7, 0x0F, 0x0F, 0xF7, 0xF8, 0x78, 0x7F, 0x3F, 0x83, 0xC1,
  0xF0, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x02, 0x00,
  0x0F, 0x80, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xEF,
  0x00, 0x0F, 0x78, 0x00, 0xFB, 0xC0, 0x07, 0x9E, 0x00, 0x7C, 0xF0, 0x03,
  0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x78,
  0x07, 0xC3, 0xC0, 0x7C, 0x1E, 0x03, 0xE0, 0xF0, 0x1E, 0x07, 0x81, 0xF0,
  0x3C, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3,
  0xE0, 0x3E, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0xFC, 0x03,
  0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF8,
  0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0x80, 0x7C, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0xF8, 0x3F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0,
  0x0F, 0x83, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x0F,
  0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFE, 0xF8, 0x0F, 0xC0, 0x40, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x06, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xF0,
  0xFE, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xE0,
  0x3F, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x3E, 0x00,
  0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x3C, 0x03,
  0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x1F, 0xC0, 0x7C, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xF3, 0xF0,
  0x1F, 0xC0, 0x30, 0x1F, 0xC0, 0x08, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x03, 0xFE, 0x3F, 0x01, 0xFF, 0x1F, 0x01, 0xFF, 0x8F, 0x80,
  0xFF, 0x87, 0xC0, 0x7F, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x7F, 0x03, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x78, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F,
  0x80, 0x1E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x1F, 0x00,
  0x3C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x03,
  0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x02, 0x3F, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xE0,
  0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x03,
  0xE3, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3F, 0x00,
  0x07, 0xCF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3E, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xE7, 0x80, 0x01, 0xF1, 0xF0, 0x00,
  0x78, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x01, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7,
  0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x07, 0xBE, 0x03, 0xFF, 0x00, 0xF7, 0x80, 0x79, 0xE0, 0x3E, 0xF0, 0x0F,
  0x3C, 0x07, 0xBE, 0x03, 0xE7, 0x81, 0xF7, 0xC0, 0x7C, 0xF0, 0x3C, 0xF8,
  0x0F, 0x9E, 0x0F, 0x9E, 0x01, 0xE3, 0xC1, 0xE7, 0xC0, 0x3C, 0x78, 0x3C,
  0xF8, 0x0F, 0x8F, 0x0F, 0x1F, 0x01, 0xF1, 0xE1, 0xE3, 0xE0, 0x3E, 0x3C,
  0x78, 0x78, 0x07, 0x87, 0x8F, 0x1F, 0x00, 0xF0, 0xF3, 0xE3, 0xE0, 0x3E,
  0x1E, 0x78, 0x7C, 0x07, 0xC3, 0xDF, 0x0F, 0x00, 0xF8, 0x7B, 0xC1, 0xE0,
  0x1E, 0x0F, 0x78, 0x7C, 0x03, 0xC1, 0xFE, 0x0F, 0x80, 0xF8, 0x3F, 0xC1,
  0xF0, 0x1F, 0x07, 0xF0, 0x3C, 0x03, 0xC0, 0xFE, 0x07, 0x80, 0x78, 0x1F,
  0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C,
  0x0F, 0x80, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0xC0, 0x1F, 0x01,
  0xFC, 0x01, 0xF0, 0x1F, 0xC0, 0x1E, 0x01, 0xFC, 0x01, 0xE0, 0x3F, 0xC0,
  0x3E, 0x03, 0xFC, 0x03, 0xE0, 0x3F, 0xE0, 0x3E, 0x03, 0xFE, 0x03, 0xC0,
  0x3D, 0xE0, 0x7C, 0x07, 0xDE, 0x07, 0xC0, 0x7D, 0xE0, 0x7C, 0x07, 0x9E,
  0x07, 0x80, 0x79, 0xF0, 0x78, 0x0F, 0x9F, 0x0F, 0x80, 0xF8, 0xF0, 0xF8,
  0x0F, 0x8F, 0x0F, 0x80, 0xF0, 0xF0, 0xF0, 0x0F, 0x0F, 0x0F, 0x01, 0xF0,
  0xF9, 0xF0, 0x1F, 0x0F, 0x9F, 0x01, 0xF0, 0x79, 0xF0, 0x1E, 0x07, 0x9E,
  0x01, 0xE0, 0x79, 0xE0, 0x3E, 0x07, 0xBE, 0x03, 0xE0, 0x7B, 0xE0, 0x3E,
  0x07, 0xFC, 0x03, 0xC0, 0x3F, 0xC0, 0x3C, 0x03, 0xFC, 0x07, 0xC0, 0x3F,
  0xC0, 0x7C, 0x03, 0xFC, 0x07, 0x80, 0x3F, 0x80, 0x78, 0x03, 0xF8, 0x0F,
  0x80, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xDF,
  0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x3E,
  0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xE7,
  0xC0, 0x07, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8,
  0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00,
  0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01,
  0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C,
  0x3E, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0xFF, 0xFE, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x1F, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03,
  0xE0, 0x3E, 0x07, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0x83,
  0xF0, 0x1F, 0x0F, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xDF, 0xC0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x3F, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07,
  0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE,
  0x00, 0x1F, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0,
  0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x01,
  0xF8, 0x7E, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xE0, 0xFC, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01,
  0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xE0,
  0xF8, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x87, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xE0,
  0x07, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F,
  0x83, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x78, 0x0F, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7E, 0x03, 0x00, 0xF8, 0x02, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x20, 0x0F, 0xC0, 0xF8, 0x3F, 0x81, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0x78, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07,
  0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xFC, 0x3F, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x87,
  0x80, 0x3E, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1F, 0x07, 0x80,
  0xF8, 0x1E, 0x03, 0xE0, 0x78, 0x1F, 0x01, 0xE0, 0x7C, 0x07, 0x81, 0xE0,
  0x1E, 0x0F, 0x80, 0x78, 0x3E, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0xC0, 0x1E,
  0x3E, 0x00, 0x78, 0xF8, 0x01, 0xE3, 0xC0, 0x07, 0x9F, 0x00, 0x1E, 0x7C,
  0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xFE, 0x00, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0x00, 0xFB, 0xE0,
  0x0F, 0x80, 0x3E, 0xF8, 0x07, 0xE0, 0x1F, 0x3E, 0x01, 0xF8, 0x07, 0xCF,
  0x80, 0xFE, 0x01, 0xE3, 0xE0, 0x3F, 0x80, 0xF8, 0xF8, 0x0F, 0xE0, 0x3E,
  0x3E, 0x07, 0xF8, 0x1F, 0x0F, 0x81, 0xFE, 0x07, 0xC3, 0xE0, 0x77, 0x81,
  0xE0, 0xF8, 0x3D, 0xE0, 0xF8, 0x3E, 0x0F, 0x78, 0x3E, 0x0F, 0x87, 0x9E,
  0x1F, 0x03, 0xE1, 0xE7, 0x87, 0xC0, 0xF8, 0x79, 0xE1, 0xF0, 0x3E, 0x3C,
  0x78, 0xF8, 0x0F, 0x8F, 0x1E, 0x3E, 0x03, 0xC7, 0x87, 0x8F, 0x00, 0xF1,
  0xE1, 0xE7, 0xC0, 0x3C, 0x78, 0x79, 0xF0, 0x0F, 0x3C, 0x1E, 0xF8, 0x03,
  0xCF, 0x07, 0xBE, 0x00, 0xF7, 0xC1, 0xEF, 0x00, 0x3D, 0xE0, 0x77, 0xC0,
  0x0F, 0x78, 0x1D, 0xF0, 0x03, 0xFC, 0x0F, 0x78, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x0F,
  0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x3C,
  0x7C, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xBC, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F,
  0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0x80,
  0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0xC0,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xF7,
  0x80, 0x3E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0x87, 0xC0, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xC0, 0x3C, 0x7C,
  0x03, 0xC7, 0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x00, 0x3D, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x40, 0x7F,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F,
  0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x87, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xE0, 0xF0, 0x78, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x1E, 0xF8, 0x01, 0xF3, 0xC0, 0x0F, 0x1E, 0x00,
  0xF0, 0xF0, 0x0F, 0x87, 0xC0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x07,
  0x83, 0xC0, 0x3E, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0x9F, 0x00, 0x3D, 0xF0,
  0x01, 0xF0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xDF, 0xFF, 0xE0, 0xFC,
  0x7C, 0x7C, 0x3E, 0x1E, 0x1E, 0x0F, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0xF3,
  0xC0, 0xFF, 0xBE, 0x0F, 0xFF, 0xF0, 0xFE, 0x7F, 0x07, 0xC1, 0xF8, 0x7E,
  0x0F, 0xC3, 0xE0, 0x7E, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F,
  0x80, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x87, 0xE0, 0x7F, 0xEF,
  0x03, 0xFF, 0x78, 0x0F, 0xF3, 0xC0, 0x3F, 0x1E, 0x00, 0x40, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x8F, 0x80, 0x7C, 0xFE, 0x03, 0xEF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFE, 0x3F, 0x07, 0xE0, 0xF8, 0x7E, 0x07, 0xC3,
  0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0x80, 0x7C, 0x7C, 0x03,
  0xE3, 0xE0, 0x1E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x1E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x8F, 0xC0, 0xF8,
  0x7E, 0x07, 0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x79, 0xFF, 0x03, 0xC7, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFE, 0x30, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x30,
  0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x78, 0x78, 0x01,
  0xFE, 0xF8, 0x03, 0xFE, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xC7, 0xF0, 0x0F,
  0x83, 0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C,
  0x03, 0xC0, 0x7C, 0x03, 0xC0, 0x78, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8,
  0x07, 0xC0, 0xF8, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x1F, 0x80, 0xF8, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xEF, 0x00, 0x3F, 0xCF, 0x00, 0x1F, 0x8E, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF, 0x07, 0xC3, 0xC3, 0xE0,
  0xF1, 0xF0, 0x3C, 0x7C, 0x0F, 0x3E, 0x03, 0xCF, 0x81, 0xF3, 0xC0, 0xF9,
  0xF0, 0x7E, 0x7F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFE, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x10, 0x7F, 0x3C, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0x3F, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xE2, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x88, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x9F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x3C, 0x03, 0xFE, 0x78, 0x0F,
  0xFF, 0xF0, 0x3F, 0x9F, 0xC0, 0x7C, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xE0,
  0x7E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0xF8, 0x07,
  0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1E, 0x07, 0xC0, 0x3C, 0x0F, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0x83, 0xF8, 0x1F, 0x8F, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xDF, 0x00, 0x7F, 0x3C, 0x00, 0x10,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x02, 0x00, 0xF8, 0x06, 0x03, 0xF0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x7C, 0x07, 0xDF, 0xE0, 0x7F, 0xFF, 0x07, 0xBF, 0xF0, 0x7F,
  0x3F, 0x07, 0xE1, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xE1, 0xF0, 0x1E, 0x1F, 0x03, 0xE1,
  0xE0, 0x3E, 0x1E, 0x03, 0xE3, 0xE0, 0x3C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C,
  0x3C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0x87, 0xC0, 0xF8, 0x7C, 0x0F,
  0x87, 0x80, 0xF8, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0x1F, 0x00, 0x00,
  0x70, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x01, 0x03, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x1F,
  0x01, 0xE0, 0xF8, 0x07, 0x87, 0xC0, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03,
  0xE7, 0xC0, 0x0F, 0x3E, 0x00, 0x3D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xDF, 0x00,
  0x3F, 0x3C, 0x00, 0xF8, 0xF8, 0x03, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0x78, 0x07, 0x81, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0xF0, 0x0F, 0x3F, 0xC7, 0xF8, 0x1E, 0xFF, 0xDF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x7F, 0x3F, 0xE7, 0xE0, 0xFC, 0x3F, 0x07, 0xC3, 0xF0,
  0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0x3C, 0x1F, 0x03,
  0xE0, 0x78, 0x3C, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x03, 0xE1, 0xF0, 0x3E,
  0x07, 0xC3, 0xE0, 0x7C, 0x0F, 0x07, 0x80, 0xF0, 0x1E, 0x0F, 0x01, 0xE0,
  0x7C, 0x3E, 0x07, 0xC0, 0xF8, 0x7C, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x03,
  0xC1, 0xE0, 0x3C, 0x07, 0x87, 0xC0, 0x78, 0x1F, 0x0F, 0x81, 0xF0, 0x3E,
  0x1F, 0x03, 0xE0, 0x7C, 0x3C, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x01, 0xE1,
  0xF0, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x79, 0xFE, 0x07, 0xBF, 0xF0, 0x7B, 0xFF, 0x07, 0xF1,
  0xF0, 0x7E, 0x1F, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x1E, 0x1F, 0x01, 0xE1, 0xF0, 0x3E, 0x1E,
  0x03, 0xE1, 0xE0, 0x3E, 0x3E, 0x03, 0xC3, 0xE0, 0x3C, 0x3E, 0x07, 0xC3,
  0xC0, 0x7C, 0x7C, 0x07, 0x87, 0xC0, 0x78, 0x7C, 0x0F, 0x87, 0x80, 0xF8,
  0x78, 0x0F, 0x8F, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0x00, 0x7E,
  0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFC, 0x7C, 0x1F, 0x07,
  0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF0, 0x0F,
  0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDE, 0x00, 0xFB, 0xC0, 0x1E,
  0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0x80, 0xF9,
  0xF0, 0x3E, 0x3E, 0x07, 0xC3, 0xE1, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x71,
  0xFC, 0x00, 0xF3, 0xFE, 0x00, 0xF7, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0xFC,
  0x1F, 0x01, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xC0,
  0x1E, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0xC0,
  0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x1F, 0x7F, 0xC0, 0x1F, 0x3F, 0x00, 0x1E, 0x08, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xF3,
  0xC0, 0xFF, 0x9E, 0x0F, 0xFF, 0xF0, 0xFC, 0x7F, 0x07, 0xC1, 0xF8, 0x7C,
  0x0F, 0xC3, 0xE0, 0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0x1F, 0x0F,
  0x80, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7C, 0x1F, 0x87, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x1F, 0xF7, 0xC0, 0x7F, 0x3C, 0x00, 0x41, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x83, 0xCF, 0xC1, 0xEF, 0xE0, 0xF7,
  0xE0, 0x7F, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF,
  0xF1, 0xF8, 0x30, 0xF8, 0x08, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE2, 0x01, 0xF1, 0x01, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF8, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x47, 0xFE, 0x3F, 0xF8, 0xFF, 0xE0,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xF8,
  0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x7C,
  0x07, 0x83, 0xE0, 0x7C, 0x1E, 0x03, 0xE0, 0xF0, 0x1F, 0x0F, 0x80, 0xF0,
  0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1E, 0x03, 0xE1, 0xF0, 0x1E, 0x0F, 0x80,
  0xF0, 0x7C, 0x0F, 0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xE1, 0xF0, 0x1E, 0x0F,
  0x80, 0xF0, 0x7C, 0x0F, 0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xE1, 0xF0, 0x3E,
  0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x83, 0xE1, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x03, 0xFE, 0xF0, 0x0F, 0xE7, 0x80, 0x08, 0x00, 0x00, 0xF8, 0x07,
  0xFE, 0x03, 0xEF, 0x80, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0x8F,
  0x83, 0xE3, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x8F, 0x83, 0xE3,
  0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x1E, 0x03, 0xCF, 0x80, 0xF3, 0xC0,
  0x3D, 0xF0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1E, 0xF8, 0x3F, 0x83, 0xEF, 0x83, 0xF8,
  0x3E, 0xF8, 0x3F, 0x83, 0xCF, 0x87, 0xF8, 0x7C, 0xF0, 0x7F, 0x87, 0x8F,
  0x07, 0x78, 0x78, 0xF0, 0xF7, 0x0F, 0x8F, 0x0F, 0x70, 0xF0, 0xF1, 0xE7,
  0x1F, 0x0F, 0x1E, 0x71, 0xE0, 0xF1, 0xC7, 0x1E, 0x0F, 0x3C, 0xF3, 0xE0,
  0xF3, 0xCF, 0x3C, 0x0F, 0x78, 0xF3, 0xC0, 0xF7, 0x8F, 0x78, 0x0F, 0x78,
  0xF7, 0x80, 0xFF, 0x0F, 0x78, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC,
  0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x7E, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x0F, 0x80, 0x1E, 0x1E,
  0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0x78, 0x00, 0x7C, 0xF0, 0x00, 0xF1, 0xF0, 0x03, 0xE3,
  0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x0F, 0x00, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x0F,
  0x80, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0x80,
  0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x1F,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1E,
  0x7C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xC0, 0x00,
  0x1E, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x13, 0xF8, 0x01, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFE, 0x80, 0x3F, 0xC8, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 13, 36, 12, 0, -36 },
  { 60, 15, 13, 18, 5, -36 },
  { 85, 24, 36, 22, 0, -36 },
  { 193, 22, 42, 20, 0, -39 },
  { 309, 29, 38, 32, 2, -37 },
  { 447, 23, 38, 23, 0, -37 },
  { 557, 7, 13, 10, 5, -36 },
  { 569, 16, 45, 13, 1, -37 },
  { 659, 16, 45, 13, -4, -37 },
  { 749, 16, 18, 19, 5, -39 },
  { 785, 19, 24, 22, 2, -30 },
  { 842, 9, 13, 11, -2, -6 },
  { 857, 12, 5, 14, 1, -16 },
  { 865, 7, 6, 11, 0, -6 },
  { 871, 25, 37, 18, -3, -37 },
  { 987, 20, 38, 20, 1, -37 },
  { 1082, 14, 36, 21, 5, -36 },
  { 1145, 23, 37, 20, -2, -37 },
  { 1252, 22, 38, 20, -1, -37 },
  { 1357, 22, 37, 21, -1, -37 },
  { 1459, 21, 37, 20, 0, -36 },
  { 1557, 21, 38, 20, 1, -37 },
  { 1657, 22, 36, 20, 1, -36 },
  { 1756, 21, 38, 20, 0, -37 },
  { 1856, 20, 38, 20, 0, -37 },
  { 1951, 11, 28, 11, 0, -28 },
  { 1990, 14, 35, 11, -3, -28 },
  { 2052, 19, 23, 22, 2, -30 },
  { 2107, 19, 14, 22, 2, -25 },
  { 2141, 20, 23, 22, 2, -30 },
  { 2199, 17, 37, 15, 1, -37 },
  { 2278, 29, 41, 31, 1, -37 },
  { 2427, 21, 37, 22, -3, -37 },
  { 2525, 23, 36, 23, 0, -36 },
  { 2629, 22, 38, 20, 2, -37 },
  { 2734, 24, 36, 24, 0, -36 },
  { 2842, 21, 36, 19, 0, -36 },
  { 2937, 21, 36, 18, 0, -36 },
  { 3032, 25, 38, 26, 2, -37 },
  { 3151, 27, 36, 25, 0, -36 },
  { 3273, 21, 36, 14, -3, -36 },
  { 3368, 21, 46, 11, -8, -36 },
  { 3489, 26, 36, 22, 0, -36 },
  { 3606, 15, 36, 18, 0, -36 },
  { 3674, 35, 36, 34, 0, -36 },
  { 3832, 28, 36, 27, 0, -36 },
  { 3958, 23, 38, 26, 2, -37 },
  { 4068, 23, 36, 21, 0, -36 },
  { 4172, 23, 46, 26, 2, -37 },
  { 4305, 22, 36, 22, 0, -36 },
  { 4404, 23, 38, 20, -1, -37 },
  { 4514, 19, 36, 18, 3, -36 },
  { 4600, 24, 37, 25, 2, -36 },
  { 4711, 22, 36, 22, 4, -36 },
  { 4810, 34, 36, 34, 4, -36 },
  { 4963, 27, 36, 20, -3, -36 },
  { 5085, 20, 36, 19, 4, -36 },
  { 5175, 23, 36, 18, -2, -36 },
  { 5279, 20, 45, 14, -2, -37 },
  { 5392, 9, 37, 18, 5, -37 },
  { 5434, 19, 45, 14, -3, -37 },
  { 5541, 21, 20, 21, 0, -36 },
  { 5594, 17, 4, 16, -5, 4 },
  { 5603, 8, 8, 13, 7, -39 },
  { 5611, 21, 29, 22, 1, -28 },
  { 5688, 21, 40, 22, 0, -39 },
  { 5793, 17, 29, 17, 1, -28 },
  { 5855, 24, 40, 22, 1, -39 },
  { 5975, 18, 29, 20, 1, -28 },
  { 6041, 24, 51, 12, -6, -39 },
  { 6194, 23, 40, 22, -1, -28 },
  { 6309, 20, 39, 22, 0, -39 },
  { 6407, 12, 38, 10, 0, -38 },
  { 6464, 19, 50, 10, -7, -38 },
  { 6583, 22, 39, 19, 0, -39 },
  { 6691, 13, 39, 10, 0, -39 },
  { 6755, 31, 28, 32, 0, -28 },
  { 6864, 20, 28, 22, 0, -28 },
  { 6934, 19, 29, 21, 1, -28 },
  { 7003, 24, 40, 22, -3, -28 },
  { 7123, 21, 40, 22, 1, -28 },
  { 7228, 17, 28, 15, 0, -28 },
  { 7288, 17, 29, 17, 0, -28 },
  { 7350, 14, 35, 13, 1, -34 },
  { 7412, 21, 28, 22, 1, -27 },
  { 7486, 18, 27, 18, 3, -27 },
  { 7547, 28, 27, 29, 3, -27 },
  { 7642, 23, 27, 18, -2, -27 },
  { 7720, 26, 39, 18, -5, -27 },
  { 7847, 19, 27, 15, -2, -27 },
  { 7912, 19, 44, 17, 1, -36 },
  { 8017, 4, 51, 19, 7, -39 },
  { 8043, 19, 44, 17, -3, -36 },
  { 8148, 20, 8, 22, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC51PT7B_H_
