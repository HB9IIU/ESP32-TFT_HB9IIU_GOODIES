#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC67PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x10, 0x00, 0x00, 0x3F, 0x87, 0xF3, 0xF8, 0x7E, 0x3F, 0x07, 0xE3,
  0xF0, 0xFE, 0x3F, 0x0F, 0xE7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC,
  0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF0,
  0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x3E,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x80, 0x1E,
  0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xEE, 0x3C, 0x01,
  0xF8, 0xE0, 0xC0, 0x3F, 0x0E, 0x00, 0x03, 0xF0, 0xC0, 0x00, 0x3F, 0x0C,
  0x00, 0x03, 0xE1, 0xC0, 0x00, 0x3E, 0x1C, 0x00, 0x03, 0xF1, 0xC0, 0x00,
  0x3F, 0x18, 0x00, 0x03, 0xFB, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xEF, 0xE0, 0x00, 0x0E, 0x7E,
  0x00, 0x00, 0xC7, 0xE0, 0x00, 0x1C, 0x7E, 0x00, 0x01, 0xC3, 0xF0, 0x00,
  0x1C, 0x3E, 0x00, 0x01, 0xC3, 0xE0, 0x00, 0x18, 0x7E, 0x04, 0x03, 0x87,
  0xE0, 0x60, 0x38, 0xFE, 0x07, 0x83, 0x9F, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x7C, 0x03, 0xE0, 0x03, 0xC1, 0xF0, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x7C,
  0x00, 0x7C, 0x1F, 0x01, 0xE0, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x0F, 0x81,
  0xE0, 0x7C, 0x00, 0x3E, 0x07, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x0F, 0x80,
  0x07, 0xC0, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x0F,
  0x87, 0xC0, 0x01, 0xE0, 0x3C, 0x3E, 0x00, 0x07, 0x81, 0xF0, 0xF8, 0x00,
  0x3E, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x1F, 0x1F, 0x0F, 0xE3, 0xE0, 0xF8,
  0xF8, 0x7F, 0xCF, 0x83, 0xE3, 0xE3, 0xFF, 0xBE, 0x0F, 0x1F, 0x1F, 0xFE,
  0xF8, 0x7C, 0x7C, 0x7C, 0xF9, 0xF3, 0xE3, 0xE3, 0xE1, 0xE7, 0xFF, 0x8F,
  0x8F, 0x07, 0x9F, 0xFC, 0x7C, 0x7C, 0x1F, 0x3F, 0xE1, 0xE1, 0xE0, 0x7C,
  0x7F, 0x0F, 0x8F, 0x81, 0xE0, 0x60, 0x7C, 0x3E, 0x07, 0x80, 0x01, 0xF0,
  0xF0, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0xF8, 0x00, 0x3E, 0x1F, 0x03, 0xE0,
  0x01, 0xF0, 0x7C, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x3E, 0x00, 0x3E, 0x07,
  0x80, 0xF0, 0x00, 0xF8, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x1F, 0x00,
  0x1F, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x3E,
  0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x03, 0xE1, 0xF0, 0x03,
  0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x80, 0x1F, 0xFE, 0x00, 0x7C, 0x00, 0x7F,
  0xF0, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFE, 0x7F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x1F, 0xC1, 0xFB, 0xF0,
  0x7E, 0x0F, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF8, 0x7E, 0x3F,
  0x0F, 0xC1, 0xFC, 0xFC, 0x7E, 0x03, 0xF7, 0xE1, 0xF8, 0x0F, 0xDF, 0x87,
  0xE0, 0x3F, 0xFC, 0x3F, 0x00, 0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0x83, 0xF0,
  0x07, 0xFE, 0x0F, 0xC0, 0x1F, 0xF0, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x01,
  0xFE, 0x03, 0xF0, 0x07, 0xFC, 0x0F, 0xE0, 0x3F, 0xF0, 0x3F, 0x83, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xF1, 0xF8,
  0x0F, 0xFF, 0x87, 0xF0, 0x0F, 0xF8, 0x1F, 0xC0, 0x0F, 0x00, 0x00, 0x00,
  0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x0F, 0x87, 0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x81, 0xF0, 0x03, 0x87,
  0xC0, 0x1F, 0x9F, 0x02, 0x7F, 0xFC, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x1F, 0xDF, 0x00, 0xFE, 0x7E, 0x07, 0xF0, 0xF8, 0x0F, 0xC3,
  0xF0, 0x1E, 0x0F, 0xE0, 0x30, 0x1F, 0x00, 0x40, 0x70, 0x00, 0x01, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0,
  0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x07,
  0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x3E, 0x7E, 0xFF, 0xFF, 0xFE, 0xFE,
  0xFE, 0xFC, 0x20, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F,
  0x07, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x80,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x03,
  0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x07,
  0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x1F, 0x81,
  0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF,
  0x0F, 0xEF, 0xC7, 0xF3, 0xF3, 0xF9, 0xFC, 0x7C, 0x7E, 0x1E, 0x1F, 0x83,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFC, 0x3F, 0xE0, 0x07, 0x80, 0x7F, 0x00, 0x38, 0x03,
  0xF8, 0x00, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x7E, 0x0F, 0xF0, 0x07, 0x00, 0x7F, 0x00, 0x20, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x08, 0x00, 0x1F, 0xC0, 0xC0, 0x03, 0xFC, 0x0F, 0x00, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xBF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xDF, 0x80, 0x00, 0x3C, 0xFC, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x1E, 0x7E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xC0, 0xFC, 0x00, 0x3E, 0x07, 0xE0,
  0x03, 0xE0, 0x7E, 0x00, 0x1E, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x1F,
  0x00, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x80, 0x01, 0xFC, 0x06, 0x00, 0x1F, 0xE0, 0x3E,
  0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xF0,
  0x10, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x03, 0xF3, 0xFF, 0x80,
  0x7E, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xE1,
  0xFC, 0x0F, 0xF8, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x0F,
  0xF0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x07,
  0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7E,
  0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x03, 0xF8,
  0x1F, 0xC0, 0x3F, 0x8F, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80,
  0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0,
  0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF8,
  0x0F, 0xC0, 0x1F, 0x81, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC7, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xE0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x0F,
  0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xC7, 0xF0, 0x0F, 0xE0, 0x7E,
  0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF8,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00,
  0x3F, 0x87, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83,
  0xF0, 0x0F, 0xF0, 0x7E, 0x03, 0xFE, 0x0F, 0xE0, 0x7F, 0xC1, 0xFE, 0x3F,
  0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xEF, 0xC0, 0x7F, 0xF9, 0xF8, 0x07,
  0xFE, 0x7E, 0x00, 0x7F, 0x8F, 0xC0, 0x01, 0x81, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x40, 0x3F,
  0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x7C,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x1F,
  0x00, 0x10, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x7C, 0x3F, 0xC0, 0xC0, 0x7F, 0x04, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7C,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x7F, 0xC1, 0xF0,
  0x7C, 0x07, 0xFF, 0x87, 0xC3, 0xE0, 0x3F, 0xFE, 0x0F, 0x0F, 0x81, 0xFF,
  0xF8, 0x7C, 0x3C, 0x0F, 0x83, 0xC1, 0xF1, 0xF0, 0x3E, 0x1F, 0x07, 0xC7,
  0x81, 0xF0, 0x7C, 0x1F, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0xF8, 0x3E, 0x07,
  0x81, 0xE3, 0xC0, 0xF0, 0x3E, 0x07, 0x9F, 0x07, 0xC0, 0xF8, 0x1E, 0x7C,
  0x1F, 0x03, 0xE0, 0xF9, 0xE0, 0x78, 0x0F, 0x03, 0xE7, 0x83, 0xE0, 0x7C,
  0x0F, 0x1E, 0x0F, 0x81, 0xF0, 0x3C, 0xF8, 0x3E, 0x07, 0xC1, 0xF3, 0xE0,
  0xF0, 0x3E, 0x07, 0x8F, 0x03, 0xC0, 0xF8, 0x1E, 0x3C, 0x0F, 0x03, 0xE0,
  0xF8, 0xF0, 0x3C, 0x1F, 0x83, 0xC3, 0xC0, 0xF0, 0x7E, 0x1F, 0x0F, 0x03,
  0xC3, 0xF8, 0x78, 0x3C, 0x0F, 0x8F, 0xE3, 0xE0, 0xF0, 0x3F, 0xF7, 0xFF,
  0x03, 0xC0, 0xFF, 0xDF, 0xF8, 0x0F, 0x01, 0xFE, 0x3F, 0xC0, 0x3C, 0x03,
  0xF0, 0x7E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x80, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x00, 0x7F, 0xEF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xF0,
  0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x83, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F,
  0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xE0, 0x3F,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xF0, 0x03,
  0xF0, 0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF3, 0xF8, 0x00,
  0x3F, 0x3F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x3F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x01, 0xFC, 0x01, 0xFC, 0x07,
  0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x07,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0x80,
  0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03,
  0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8,
  0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x1F,
  0x00, 0x1F, 0xE0, 0x18, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x01, 0x00, 0x0F, 0xF8, 0x3C, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0x81, 0xFF, 0x00, 0x7F, 0x01,
  0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x03,
  0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F,
  0xC0, 0x7E, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xF0,
  0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xC0, 0x1F,
  0xE0, 0x1F, 0x80, 0x7F, 0x80, 0x3F, 0x01, 0xFF, 0x00, 0xFE, 0x0F, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xC1, 0xFC, 0x00, 0xFF, 0x80, 0x1C, 0x00, 0xFF, 0x00,
  0x04, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xF8, 0x7F, 0x00, 0x7F, 0xF8, 0x3F, 0x80, 0x3F, 0xFC, 0x1F,
  0xC0, 0x1F, 0xFE, 0x0F, 0xE0, 0x0F, 0xFF, 0x07, 0xE0, 0x0F, 0xFF, 0x03,
  0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x01, 0xF8,
  0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x0F,
  0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xFC, 0x07,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xE0, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xF0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x07,
  0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x07, 0xF0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x0F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x03, 0xBF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xF0,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xC0, 0x00, 0x0F, 0xF3,
  0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x0F,
  0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xFC, 0x01, 0xFB, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xEF, 0x80, 0x07,
  0xDF, 0x80, 0x1F, 0xBE, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xF8, 0x00, 0xFD,
  0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xEF, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0xBF,
  0x00, 0x3F, 0x3E, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xF0,
  0x03, 0xF3, 0xE0, 0x0F, 0x9F, 0xC0, 0x0F, 0xCF, 0x80, 0x7E, 0x7E, 0x00,
  0x7E, 0x3E, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0xF8, 0x0F, 0xC7, 0xE0, 0x07,
  0xE3, 0xF0, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC1, 0xF8, 0xFE, 0x00, 0xFC,
  0x3F, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xFC, 0x1F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC3, 0xE0, 0xFC, 0x00, 0xFC, 0x3F,
  0x1F, 0x87, 0xF0, 0x07, 0xE0, 0xFC, 0x7C, 0x1F, 0x80, 0x1F, 0x83, 0xF3,
  0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xCF, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0xFD, 0xF8, 0x3F, 0x00, 0x3F, 0x01, 0xF7, 0xC0,
  0xFC, 0x00, 0xFC, 0x07, 0xFF, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0xF8, 0x0F,
  0xC0, 0x0F, 0xC0, 0x7F, 0xE0, 0x7F, 0x00, 0x3F, 0x01, 0xFF, 0x01, 0xF8,
  0x01, 0xF8, 0x07, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0x1F, 0x80,
  0x1F, 0x80, 0x7F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x01, 0xFE,
  0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xE0,
  0x07, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0x01, 0xFF, 0x00,
  0x0F, 0xC0, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x01, 0xF8, 0x01, 0xF7, 0xC0, 0x0F,
  0xC0, 0x1F, 0xBE, 0x00, 0xFC, 0x00, 0xFD, 0xF8, 0x07, 0xE0, 0x07, 0xEF,
  0xC0, 0x3F, 0x00, 0x3F, 0x7E, 0x01, 0xF8, 0x01, 0xF1, 0xF0, 0x0F, 0xC0,
  0x1F, 0x8F, 0x80, 0xFC, 0x00, 0xFC, 0x7C, 0x07, 0xE0, 0x07, 0xE3, 0xF0,
  0x3F, 0x00, 0x3F, 0x1F, 0x81, 0xF8, 0x01, 0xF0, 0xFC, 0x1F, 0xC0, 0x1F,
  0x83, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x3F,
  0x00, 0x3F, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x3F, 0x1F, 0x80, 0x1F, 0x81,
  0xF8, 0xFC, 0x00, 0xFC, 0x07, 0xC7, 0xE0, 0x07, 0xE0, 0x3E, 0x3F, 0x00,
  0x3F, 0x01, 0xF1, 0xF8, 0x03, 0xF0, 0x0F, 0xDF, 0x80, 0x1F, 0x80, 0x7E,
  0xFC, 0x00, 0xFC, 0x03, 0xF7, 0xE0, 0x07, 0xE0, 0x0F, 0xBF, 0x00, 0x3F,
  0x00, 0x7D, 0xF8, 0x03, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x80, 0x1F, 0xFC,
  0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0x00,
  0x1F, 0xF0, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x07, 0xFC, 0x00,
  0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x0F,
  0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xF1, 0xFF, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFE, 0x7F,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0,
  0x01, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x1F,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xE0, 0x7F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x01, 0xFC,
  0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0x00,
  0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F,
  0x80, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7F, 0x01, 0xFE, 0x01, 0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF0,
  0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFC, 0x7F,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0xFC, 0xFE, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0xFE, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x01,
  0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0x00, 0x7F, 0x01, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x80,
  0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x01, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC1, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF8,
  0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E,
  0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x07,
  0xE0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x38, 0x01, 0xFE, 0x00, 0x20, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x03, 0x00, 0x07,
  0xF0, 0x0F, 0x00, 0x7F, 0xC0, 0x3F, 0xC7, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xE0,
  0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x0F, 0xE0,
  0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0,
  0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x1F, 0x80,
  0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x80, 0x07, 0xE0, 0x3F, 0x80,
  0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xCF,
  0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0,
  0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0,
  0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC,
  0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8,
  0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0xFD, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xE7, 0xE0, 0x01, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x8F, 0xC0, 0x0F,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0x07, 0xE0, 0x1F, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFF, 0xC0, 0x1F,
  0x83, 0xF8, 0x07, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x7D, 0xF0, 0x0F, 0xC0,
  0xFC, 0x03, 0xEF, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x7C, 0x07, 0xE0, 0x3F,
  0x01, 0xF3, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x9F, 0x03, 0xF8, 0x0F, 0xC0,
  0xFC, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xC7, 0xC1, 0xFC, 0x03, 0xF0, 0x7E,
  0x3E, 0x0F, 0xC0, 0x1F, 0x83, 0xE1, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x0F,
  0x87, 0xF0, 0x07, 0xE1, 0xF8, 0x7C, 0x3F, 0x00, 0x3F, 0x0F, 0x83, 0xE3,
  0xF8, 0x01, 0xF8, 0x7C, 0x1F, 0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0xF8, 0xFC,
  0x00, 0x7E, 0x3E, 0x07, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x3E, 0x7E, 0x00,
  0x1F, 0x9F, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xF8, 0x1F, 0xBF, 0x00, 0x07,
  0xEF, 0xC0, 0xFD, 0xF8, 0x00, 0x3F, 0x7C, 0x07, 0xDF, 0xC0, 0x01, 0xFF,
  0xE0, 0x3E, 0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xF7, 0xE0, 0x00, 0x7F, 0xF0,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0xC0,
  0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07,
  0xE7, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0,
  0x1F, 0x87, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x9F,
  0x80, 0x07, 0xE7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x07,
  0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xC0, 0xF8,
  0x01, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xF0,
  0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF1,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F,
  0x81, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF8, 0x7C, 0x03, 0xFF, 0x9F,
  0x80, 0xFF, 0xF3, 0xF0, 0x3F, 0xFF, 0x7C, 0x0F, 0xFF, 0xFF, 0x81, 0xFE,
  0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0,
  0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7E, 0x00,
  0x7E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x07,
  0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xE0, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFE,
  0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x0F, 0xF0, 0x3F, 0x01, 0xFE, 0x07, 0xF0,
  0x7F, 0xC0, 0xFF, 0xFD, 0xF0, 0x0F, 0xFF, 0xBE, 0x01, 0xFF, 0xE7, 0xC0,
  0x1F, 0xF8, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x0F, 0x00, 0x0F, 0xC7, 0xF8, 0x01, 0xF9, 0xFF, 0x80, 0x3F, 0x7F, 0xF8,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0xFE, 0x07, 0xF8,
  0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xE0,
  0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x0F,
  0xC0, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x3F, 0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0x83, 0xF8, 0x1F, 0xFF,
  0xFE, 0x03, 0xEF, 0xFF, 0x80, 0xFD, 0xFF, 0xF0, 0x1F, 0x1F, 0xFC, 0x03,
  0xE1, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x7F, 0x81, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x10, 0x3F, 0xC1, 0xC0, 0x7F,
  0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xE0, 0xFC, 0x00, 0x1F, 0xF1, 0xF8, 0x00, 0x7F, 0xF3, 0xF0, 0x01, 0xFF,
  0xF7, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0x83,
  0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF0,
  0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x07,
  0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8,
  0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0xC0, 0x0F, 0xE0,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x7C, 0x00, 0x3F, 0xFC,
  0xF8, 0x00, 0x3F, 0xF1, 0xF0, 0x00, 0x3F, 0xC3, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0x1F, 0xC1, 0xFC, 0x1F, 0x87, 0xF0,
  0x1F, 0x0F, 0xC0, 0x3E, 0x3F, 0x00, 0x7C, 0x7E, 0x01, 0xF9, 0xF8, 0x03,
  0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7F, 0x3F, 0x03, 0xFC,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x08, 0x7F, 0x00, 0x60, 0x7F, 0xC7,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xC4, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xDF, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x7C, 0x00, 0x3F, 0xF9, 0xF8, 0x00, 0xFF, 0xFB, 0xF0,
  0x03, 0xFF, 0xF7, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xE1, 0xFF, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7E,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xE0,
  0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x03,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x01, 0xF8, 0x0F, 0xF0, 0x03, 0xF0, 0x3F, 0xE0, 0x07, 0xF0, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0xFC, 0x00,
  0x1F, 0xF9, 0xF8, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x0E, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x10, 0x00, 0x7F, 0x00, 0x38, 0x01, 0xFE, 0x00, 0x7E, 0x0F,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x0F,
  0x00, 0x0F, 0xC7, 0xF8, 0x01, 0xF9, 0xFF, 0x80, 0x3F, 0x7F, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xE1, 0xFE, 0x07, 0xF8, 0x1F,
  0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xC0, 0xFE,
  0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC,
  0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81,
  0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F,
  0x80, 0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F,
  0x03, 0xF0, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x20, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F,
  0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF9, 0xFC, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFE, 0x7E, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x07,
  0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xE0,
  0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF8, 0x7F,
  0x81, 0xFE, 0x00, 0x7C, 0xFF, 0xE3, 0xFF, 0x80, 0x3E, 0xFF, 0xFB, 0xFF,
  0xE0, 0x1F, 0x7F, 0xFD, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xF8, 0x7F, 0xE1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x3F,
  0x00, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x1F, 0x81, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xFC,
  0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x01, 0xF8,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x1F, 0xE0, 0x07, 0xC7, 0xFE,
  0x00, 0xF9, 0xFF, 0xE0, 0x1F, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0x83, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81,
  0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F,
  0x80, 0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F,
  0x03, 0xF0, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xE0,
  0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0,
  0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00,
  0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03,
  0xF0, 0xFC, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x7F, 0x80, 0x03, 0xE3, 0xFF,
  0x00, 0x0F, 0x9F, 0xFE, 0x00, 0x3E, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0xFC,
  0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F,
  0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0,
  0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x1F,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xF9, 0xFF, 0xE0,
  0x07, 0xE7, 0xFF, 0x00, 0x1F, 0x8F, 0xF0, 0x00, 0x7E, 0x0E, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xFE, 0x1F, 0x00, 0x7F, 0xF3, 0xF0, 0x0F, 0xFF, 0xBF, 0x01, 0xFF,
  0xFB, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xF8, 0x3F, 0xE0, 0x7F, 0x01, 0xFE,
  0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC,
  0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x7F,
  0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x01,
  0xFC, 0x07, 0xE0, 0x3F, 0xC0, 0x7E, 0x03, 0xFC, 0x07, 0xF0, 0x7F, 0xC0,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFD, 0xF8, 0x01, 0xFF,
  0x9F, 0x80, 0x0F, 0xF3, 0xF8, 0x00, 0x38, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xE1, 0xF8, 0x07, 0xC7, 0xF0, 0x0F,
  0x9F, 0xE0, 0x1F, 0x7F, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFE, 0x7C, 0x07, 0xF0, 0x0C, 0x07, 0xF0,
  0x04, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xC0, 0x0F, 0xE0, 0xF0, 0x1F,
  0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x07, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xF2, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x83,
  0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F,
  0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x87, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0,
  0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0xC3, 0xF0, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x83, 0xF0,
  0x1F, 0xE0, 0xFC, 0x07, 0xF0, 0x3F, 0x03, 0xFC, 0x0F, 0xE1, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFB, 0xE0, 0x3F, 0xFE, 0xF8, 0x07, 0xFF, 0x3E,
  0x00, 0xFF, 0x0F, 0x80, 0x07, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0x9F, 0x80,
  0x3F, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x0F,
  0xC3, 0xF0, 0x3F, 0x87, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0,
  0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7C, 0x03,
  0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F,
  0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xE0,
  0x1F, 0xBF, 0x00, 0xFF, 0x00, 0xFD, 0xF8, 0x07, 0xF8, 0x07, 0xEF, 0xC0,
  0x7F, 0xC0, 0x7E, 0x7E, 0x03, 0xFE, 0x03, 0xF3, 0xF0, 0x1F, 0xF0, 0x3F,
  0x1F, 0x81, 0xFF, 0x81, 0xF8, 0xFC, 0x0F, 0xFC, 0x0F, 0xC7, 0xE0, 0xFB,
  0xE0, 0xFC, 0x3F, 0x07, 0xDF, 0x07, 0xE1, 0xF8, 0x3E, 0xF8, 0x3E, 0x0F,
  0xC3, 0xE7, 0xC3, 0xF0, 0x7E, 0x1F, 0x3E, 0x1F, 0x83, 0xF0, 0xFB, 0xF1,
  0xF8, 0x1F, 0x8F, 0x9F, 0x0F, 0xC0, 0xFC, 0x7C, 0xF8, 0x7C, 0x07, 0xE7,
  0xC7, 0xC7, 0xE0, 0x3F, 0x3E, 0x3E, 0x3F, 0x01, 0xF1, 0xF1, 0xF1, 0xF0,
  0x0F, 0x9F, 0x0F, 0x9F, 0x80, 0x7C, 0xF8, 0x7C, 0xF8, 0x03, 0xEF, 0x83,
  0xEF, 0xC0, 0x1F, 0x7C, 0x1F, 0x7E, 0x00, 0xFB, 0xE0, 0xFB, 0xE0, 0x07,
  0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x0F,
  0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00,
  0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07,
  0xE0, 0x7F, 0x00, 0x3F, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xE0,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x7E,
  0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0x7D, 0xF8, 0x00,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x04, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xBF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFC, 0x80, 0x00, 0xF8, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 18, 49, 16, 0, -48 },
  { 112, 20, 17, 24, 7, -48 },
  { 155, 31, 48, 29, 0, -48 },
  { 341, 28, 55, 27, 0, -51 },
  { 534, 38, 50, 43, 3, -49 },
  { 772, 30, 50, 30, 0, -49 },
  { 960, 9, 17, 14, 7, -48 },
  { 980, 21, 59, 17, 1, -48 },
  { 1135, 21, 59, 17, -5, -48 },
  { 1290, 22, 24, 25, 6, -51 },
  { 1356, 25, 32, 29, 3, -40 },
  { 1456, 12, 17, 14, -3, -8 },
  { 1482, 16, 6, 18, 1, -21 },
  { 1494, 8, 9, 14, 1, -8 },
  { 1503, 31, 48, 23, -3, -48 },
  { 1689, 26, 50, 27, 1, -49 },
  { 1852, 18, 48, 27, 7, -48 },
  { 1960, 29, 49, 27, -2, -49 },
  { 2138, 28, 50, 27, -1, -49 },
  { 2313, 29, 48, 27, -1, -48 },
  { 2487, 29, 49, 27, -1, -48 },
  { 2665, 27, 50, 27, 2, -49 },
  { 2834, 28, 48, 27, 2, -48 },
  { 3002, 28, 50, 27, 0, -49 },
  { 3177, 27, 50, 27, 0, -49 },
  { 3346, 14, 37, 14, 0, -36 },
  { 3411, 17, 45, 14, -3, -36 },
  { 3507, 25, 30, 29, 3, -39 },
  { 3601, 25, 19, 29, 3, -33 },
  { 3661, 25, 30, 29, 3, -39 },
  { 3755, 22, 50, 20, 1, -49 },
  { 3893, 38, 54, 40, 2, -48 },
  { 4150, 28, 48, 28, -4, -48 },
  { 4318, 30, 48, 30, 0, -48 },
  { 4498, 30, 50, 27, 2, -49 },
  { 4686, 31, 48, 32, 0, -48 },
  { 4872, 28, 48, 25, 0, -48 },
  { 5040, 28, 48, 24, 0, -48 },
  { 5208, 33, 50, 34, 2, -49 },
  { 5415, 35, 48, 33, 0, -48 },
  { 5625, 26, 48, 19, -3, -48 },
  { 5781, 27, 61, 14, -10, -48 },
  { 5987, 34, 48, 28, 0, -48 },
  { 6191, 19, 48, 24, 0, -48 },
  { 6305, 46, 48, 44, 0, -48 },
  { 6581, 37, 48, 35, 0, -48 },
  { 6803, 31, 50, 34, 2, -49 },
  { 6997, 30, 48, 28, 0, -48 },
  { 7177, 31, 60, 34, 2, -49 },
  { 7410, 29, 48, 29, 0, -48 },
  { 7584, 30, 50, 26, -1, -49 },
  { 7772, 25, 48, 24, 4, -48 },
  { 7922, 32, 49, 33, 2, -48 },
  { 8118, 28, 48, 28, 6, -48 },
  { 8286, 45, 48, 45, 5, -48 },
  { 8556, 35, 48, 26, -4, -48 },
  { 8766, 26, 48, 25, 5, -48 },
  { 8922, 31, 48, 24, -3, -48 },
  { 9108, 26, 59, 19, -2, -48 },
  { 9300, 11, 48, 23, 7, -48 },
  { 9366, 26, 59, 19, -5, -48 },
  { 9558, 27, 27, 27, 0, -48 },
  { 9650, 22, 4, 21, -6, 6 },
  { 9661, 10, 10, 18, 10, -51 },
  { 9674, 27, 38, 29, 2, -37 },
  { 9803, 27, 52, 29, 0, -51 },
  { 9979, 22, 38, 22, 2, -37 },
  { 10084, 31, 52, 29, 1, -51 },
  { 10286, 23, 38, 26, 2, -37 },
  { 10396, 32, 67, 16, -8, -51 },
  { 10664, 31, 53, 29, -2, -37 },
  { 10870, 27, 51, 28, 0, -51 },
  { 11043, 16, 50, 14, 0, -50 },
  { 11143, 25, 66, 14, -9, -50 },
  { 11350, 29, 51, 25, 0, -51 },
  { 11535, 17, 51, 13, 0, -51 },
  { 11644, 41, 37, 42, 0, -37 },
  { 11834, 27, 37, 28, 0, -37 },
  { 11959, 24, 38, 28, 2, -37 },
  { 12073, 30, 53, 29, -3, -37 },
  { 12272, 28, 53, 29, 1, -37 },
  { 12458, 23, 37, 19, 0, -37 },
  { 12565, 24, 38, 22, -1, -37 },
  { 12679, 17, 45, 17, 2, -44 },
  { 12775, 26, 37, 28, 2, -36 },
  { 12896, 23, 36, 24, 4, -36 },
  { 13000, 37, 36, 38, 4, -36 },
  { 13167, 30, 36, 24, -3, -36 },
  { 13302, 34, 52, 24, -6, -36 },
  { 13523, 24, 36, 20, -2, -36 },
  { 13631, 26, 59, 22, 1, -48 },
  { 13823, 6, 67, 25, 9, -51 },
  { 13874, 25, 59, 22, -4, -48 },
  { 14059, 25, 9, 29, 3, -28 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC67PT7B_H_
