#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC13PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0xA4, 0x82, 0xC0, 0x55, 0xA0, 0x14, 0xA7, 0xCA, 0x53, 0xE5,
  0x28, 0xA0, 0x11, 0xDE, 0xA6, 0x18, 0xE7, 0xF2, 0x10, 0x65, 0x52, 0xA5,
  0xAD, 0xA5, 0x4A, 0xAA, 0xCC, 0x38, 0xA2, 0x8C, 0x67, 0x69, 0xA6, 0xE8,
  0x58, 0x12, 0x64, 0x4C, 0x88, 0x88, 0x40, 0x31, 0x11, 0x11, 0x32, 0x24,
  0xC0, 0x2A, 0x7E, 0x70, 0x66, 0x6F, 0x66, 0x29, 0x40, 0xE0, 0x70, 0x06,
  0x18, 0x20, 0x81, 0x04, 0x08, 0x20, 0xC0, 0x3B, 0x52, 0x94, 0xEE, 0x52,
  0x60, 0x36, 0xA2, 0x26, 0x44, 0x40, 0x78, 0x42, 0x31, 0x11, 0x18, 0xF0,
  0x78, 0x42, 0x27, 0x08, 0x42, 0xE0, 0x08, 0xCA, 0x75, 0x4B, 0xE2, 0x20,
  0x39, 0x10, 0xE5, 0x0C, 0x52, 0xE0, 0x1C, 0x84, 0x1C, 0x5B, 0x2D, 0xB4,
  0x70, 0x7C, 0x20, 0x84, 0x10, 0x82, 0x10, 0xC0, 0x3A, 0x52, 0x67, 0x6A,
  0x72, 0xF0, 0x3A, 0x52, 0x95, 0x9C, 0x46, 0xE0, 0x68, 0x01, 0x30, 0x32,
  0x00, 0x02, 0x44, 0x80, 0x08, 0xDD, 0x83, 0x04, 0xF0, 0xF0, 0x86, 0x1C,
  0x36, 0x40, 0x71, 0x12, 0x64, 0x04, 0xC0, 0x1E, 0x21, 0x4D, 0x55, 0x65,
  0xAA, 0xAA, 0x94, 0x40, 0x78, 0x0C, 0x51, 0x4D, 0x2C, 0xF4, 0xD3, 0xCC,
  0x3C, 0x96, 0xD2, 0x79, 0x24, 0xB6, 0xF0, 0x3C, 0x86, 0x10, 0x43, 0x0C,
  0x10, 0x70, 0x38, 0x96, 0x51, 0x45, 0x34, 0xB6, 0xF0, 0x39, 0x18, 0x97,
  0x21, 0x18, 0xF0, 0x39, 0x18, 0x87, 0x21, 0x18, 0x80, 0x1E, 0x41, 0x82,
  0x04, 0xD8, 0xB3, 0x24, 0x78, 0x26, 0x49, 0x92, 0x27, 0xC9, 0x92, 0x64,
  0x88, 0x3C, 0x41, 0x04, 0x30, 0x82, 0x08, 0xF0, 0x08, 0x46, 0x21, 0x08,
  0x46, 0x21, 0x39, 0x80, 0x26, 0x51, 0xE2, 0x87, 0x0A, 0x14, 0x68, 0x98,
  0x22, 0x64, 0x44, 0x4C, 0xF0, 0x31, 0x99, 0xDC, 0xCA, 0xE5, 0x52, 0xB9,
  0x69, 0x34, 0x92, 0x00, 0x22, 0x65, 0x5A, 0xA5, 0x4A, 0x95, 0x46, 0x88,
  0x3C, 0x94, 0x51, 0x47, 0x1C, 0xD2, 0x70, 0x38, 0xB6, 0xD2, 0x79, 0x04,
  0x30, 0x80, 0x3C, 0x94, 0x51, 0x47, 0x1C, 0xD2, 0x70, 0x41, 0x80, 0x38,
  0xB6, 0xD2, 0x79, 0x45, 0x34, 0x98, 0x3D, 0x04, 0x18, 0x30, 0x41, 0x24,
  0xE0, 0xFB, 0x10, 0x84, 0x23, 0x10, 0x80, 0x26, 0x49, 0x92, 0x24, 0xC9,
  0x32, 0x64, 0x70, 0x8E, 0x29, 0x24, 0xB2, 0x8A, 0x30, 0xC0, 0x89, 0xCC,
  0xA6, 0xD5, 0x4A, 0xA5, 0x63, 0x31, 0x98, 0xC8, 0x00, 0x36, 0x28, 0x60,
  0xC1, 0x05, 0x0A, 0x24, 0xC8, 0x9E, 0xBC, 0xC4, 0x21, 0x18, 0x80, 0x3C,
  0x30, 0x86, 0x10, 0x82, 0x10, 0xF8, 0x39, 0x18, 0x84, 0x21, 0x10, 0x84,
  0x30, 0x89, 0x24, 0x92, 0x60, 0x38, 0x44, 0x21, 0x08, 0x44, 0x21, 0x38,
  0x11, 0x8A, 0x98, 0x80, 0xF0, 0x90, 0x3D, 0x24, 0xB2, 0xDB, 0x47, 0x00,
  0x21, 0x08, 0xB6, 0xA5, 0x39, 0xDF, 0x80, 0x3A, 0x11, 0x8C, 0x61, 0x80,
  0x04, 0x10, 0x4F, 0x49, 0x2C, 0xB2, 0xD1, 0xC0, 0x3A, 0x57, 0xE8, 0x61,
  0xC0, 0x0E, 0x10, 0x20, 0xE1, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x0C,
  0x00, 0x3D, 0x24, 0xB2, 0xDB, 0x47, 0x04, 0x33, 0x80, 0x21, 0x08, 0xB6,
  0xA5, 0x3B, 0x94, 0x80, 0x24, 0x34, 0x96, 0x90, 0x08, 0x40, 0x31, 0x08,
  0x42, 0x21, 0x08, 0x4C, 0x00, 0x20, 0x82, 0x1B, 0x51, 0xC7, 0x1C, 0x92,
  0x40, 0x24, 0xB4, 0x92, 0x90, 0x5F, 0x69, 0x49, 0x4A, 0xD2, 0x92, 0x92,
  0x5B, 0x52, 0x9D, 0xCA, 0x40, 0x3A, 0x53, 0x9C, 0xE9, 0xC0, 0x2C, 0xD2,
  0x49, 0x25, 0xB7, 0x90, 0x43, 0x00, 0x3D, 0x24, 0xB2, 0xDB, 0x47, 0x04,
  0x10, 0xC0, 0x56, 0x44, 0xC8, 0x80, 0x74, 0x46, 0x33, 0xE0, 0x22, 0x74,
  0x44, 0x4C, 0xE0, 0x6D, 0x24, 0x92, 0xDB, 0x4F, 0x00, 0x9B, 0xAA, 0xCC,
  0x80, 0x93, 0x6A, 0xD6, 0xED, 0x9B, 0x24, 0x00, 0x24, 0xA3, 0x84, 0x31,
  0xCD, 0x80, 0x24, 0xB2, 0x8A, 0x30, 0xC2, 0x08, 0x63, 0x00, 0x73, 0x26,
  0x48, 0xE0, 0x19, 0x88, 0x42, 0x61, 0x88, 0x42, 0x18, 0xFF, 0xF8, 0x30,
  0x84, 0x21, 0x0C, 0xC4, 0x23, 0x30, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 4, 3, 5, 1, -9 },
  { 7, 6, 9, 6, 0, -9 },
  { 14, 5, 11, 5, 0, -10 },
  { 21, 7, 9, 8, 1, -9 },
  { 29, 6, 9, 6, 0, -9 },
  { 36, 2, 3, 3, 1, -9 },
  { 37, 4, 11, 3, 0, -9 },
  { 43, 4, 11, 3, -1, -9 },
  { 49, 4, 5, 5, 1, -10 },
  { 52, 4, 6, 6, 1, -8 },
  { 55, 3, 4, 3, -1, -2 },
  { 57, 3, 1, 3, 0, -4 },
  { 58, 2, 2, 3, 0, -2 },
  { 59, 7, 9, 4, -1, -9 },
  { 67, 5, 9, 5, 0, -9 },
  { 73, 4, 9, 5, 1, -9 },
  { 78, 5, 9, 5, 0, -9 },
  { 84, 5, 9, 5, 0, -9 },
  { 90, 5, 9, 5, 0, -9 },
  { 96, 5, 9, 5, 0, -9 },
  { 102, 6, 9, 5, 0, -9 },
  { 109, 6, 9, 5, 0, -9 },
  { 116, 5, 9, 5, 0, -9 },
  { 122, 5, 9, 5, 0, -9 },
  { 128, 3, 7, 3, 0, -7 },
  { 131, 4, 9, 3, -1, -7 },
  { 136, 5, 6, 6, 0, -8 },
  { 140, 4, 3, 6, 1, -6 },
  { 142, 5, 6, 6, 1, -8 },
  { 146, 4, 9, 4, 0, -9 },
  { 151, 8, 10, 8, 0, -9 },
  { 161, 6, 9, 6, -1, -9 },
  { 168, 6, 9, 6, 0, -9 },
  { 175, 6, 9, 5, 0, -9 },
  { 182, 6, 9, 6, 0, -9 },
  { 189, 5, 9, 5, 0, -9 },
  { 195, 5, 9, 5, 0, -9 },
  { 201, 7, 9, 7, 0, -9 },
  { 209, 7, 9, 6, 0, -9 },
  { 217, 6, 9, 4, -1, -9 },
  { 224, 5, 12, 3, -2, -9 },
  { 232, 7, 9, 5, 0, -9 },
  { 240, 4, 9, 5, 0, -9 },
  { 245, 9, 9, 9, 0, -9 },
  { 256, 7, 9, 7, 0, -9 },
  { 264, 6, 9, 7, 0, -9 },
  { 271, 6, 9, 5, 0, -9 },
  { 278, 6, 11, 7, 0, -9 },
  { 287, 6, 9, 6, 0, -9 },
  { 294, 6, 9, 5, 0, -9 },
  { 301, 5, 9, 5, 1, -9 },
  { 307, 7, 9, 6, 0, -9 },
  { 315, 6, 9, 5, 1, -9 },
  { 322, 9, 9, 9, 1, -9 },
  { 333, 7, 9, 5, -1, -9 },
  { 341, 5, 9, 5, 1, -9 },
  { 347, 6, 9, 5, -1, -9 },
  { 354, 5, 11, 4, 0, -9 },
  { 361, 3, 9, 5, 1, -9 },
  { 365, 5, 11, 4, -1, -9 },
  { 372, 5, 5, 5, 0, -9 },
  { 376, 4, 1, 4, -1, 1 },
  { 377, 2, 2, 3, 2, -10 },
  { 378, 6, 7, 6, 0, -7 },
  { 384, 5, 10, 6, 0, -10 },
  { 391, 5, 7, 4, 0, -7 },
  { 396, 6, 10, 6, 0, -10 },
  { 404, 5, 7, 5, 0, -7 },
  { 409, 7, 13, 3, -2, -10 },
  { 421, 6, 10, 6, 0, -7 },
  { 429, 5, 10, 6, 0, -10 },
  { 436, 3, 10, 3, 0, -10 },
  { 440, 5, 13, 3, -2, -10 },
  { 449, 6, 10, 5, 0, -10 },
  { 457, 3, 10, 3, 0, -10 },
  { 461, 8, 7, 8, 0, -7 },
  { 468, 5, 7, 6, 0, -7 },
  { 473, 5, 7, 5, 0, -7 },
  { 478, 6, 10, 6, -1, -7 },
  { 486, 6, 10, 6, 0, -7 },
  { 494, 4, 7, 4, 0, -7 },
  { 498, 4, 7, 4, 0, -7 },
  { 502, 4, 9, 3, 0, -9 },
  { 507, 6, 7, 6, 0, -7 },
  { 513, 4, 7, 5, 1, -7 },
  { 517, 7, 7, 7, 1, -7 },
  { 524, 6, 7, 5, -1, -7 },
  { 530, 6, 10, 5, -1, -7 },
  { 538, 4, 7, 4, 0, -7 },
  { 542, 5, 11, 4, 0, -9 },
  { 549, 1, 13, 5, 2, -10 },
  { 551, 5, 11, 4, -1, -9 },
  { 558, 6, 1, 6, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC13PT7B_H_
