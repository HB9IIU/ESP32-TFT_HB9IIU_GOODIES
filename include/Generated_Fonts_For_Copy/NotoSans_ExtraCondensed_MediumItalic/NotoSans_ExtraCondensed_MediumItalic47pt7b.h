#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC47PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0xC0, 0x7C, 0x0F,
  0xC0, 0xF8, 0x07, 0x80, 0x7C, 0x7D, 0xF1, 0xE7, 0xC7, 0x9E, 0x1E, 0x78,
  0xF9, 0xE3, 0xC7, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0x8E, 0x1E, 0x38,
  0x78, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0x87, 0x80,
  0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x0E, 0x00, 0x1C,
  0x38, 0x00, 0xF0, 0xE0, 0x03, 0x87, 0x00, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0x07, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xE1, 0xE0, 0x03,
  0x87, 0x00, 0x1E, 0x1C, 0x00, 0x70, 0xF0, 0x01, 0xC3, 0x80, 0x07, 0x0E,
  0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x1E, 0x1C, 0x00,
  0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x78, 0x00, 0xE1,
  0xC0, 0x07, 0x87, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0xE0, 0x03, 0xC3, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xD8, 0xC0,
  0x79, 0x84, 0x0F, 0x18, 0x00, 0xF1, 0x80, 0x0F, 0x10, 0x00, 0xF3, 0x00,
  0x0F, 0xB0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xDF, 0x00, 0x0C,
  0xF0, 0x00, 0xCF, 0x80, 0x0C, 0xF0, 0x00, 0xCF, 0x00, 0x18, 0xF0, 0x41,
  0x9F, 0x0F, 0x1B, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x01,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x01, 0xF8, 0x03, 0x80, 0xFF, 0x01,
  0xE0, 0x79, 0xC0, 0x70, 0x1C, 0x70, 0x3C, 0x0F, 0x1C, 0x0E, 0x03, 0x87,
  0x07, 0x80, 0xE1, 0xC1, 0xC0, 0x78, 0x70, 0xF0, 0x1C, 0x1C, 0x38, 0x07,
  0x07, 0x1E, 0x01, 0xC3, 0xC7, 0x00, 0xF0, 0xE3, 0xC0, 0x3C, 0x38, 0xE1,
  0x8F, 0x1E, 0x71, 0xFB, 0xC7, 0x3C, 0xFF, 0xF1, 0xCE, 0x3F, 0xFC, 0xE7,
  0x9C, 0x77, 0xF9, 0xCF, 0x1D, 0xFC, 0xF3, 0x87, 0x3E, 0x38, 0xE1, 0xC0,
  0x1E, 0x78, 0x70, 0x07, 0x1C, 0x1C, 0x03, 0xC7, 0x07, 0x00, 0xE1, 0xC3,
  0xC0, 0x78, 0xF0, 0xF0, 0x1C, 0x3C, 0x38, 0x0F, 0x0F, 0x0E, 0x03, 0x83,
  0xC7, 0x81, 0xE0, 0xF1, 0xC0, 0x70, 0x3C, 0xF0, 0x3C, 0x07, 0xF8, 0x0E,
  0x01, 0xFC, 0x07, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xF0, 0x03, 0xEF, 0x80, 0x1E, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F,
  0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07,
  0x9E, 0x00, 0x3D, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x3E, 0x3D, 0xF1, 0xE3, 0xC7,
  0x8F, 0x3E, 0x3E, 0xF1, 0xE1, 0xF7, 0x9F, 0x07, 0xFC, 0xF0, 0x3F, 0xC7,
  0x81, 0xFE, 0x3C, 0x07, 0xE1, 0xE0, 0x3E, 0x0F, 0x03, 0xF0, 0x7C, 0x3F,
  0xC3, 0xF7, 0xFE, 0x0F, 0xFE, 0xF8, 0x7F, 0xE7, 0xC1, 0xFE, 0x3F, 0x00,
  0x3D, 0xF7, 0xDF, 0x79, 0xE7, 0x9C, 0xF3, 0xCF, 0x38, 0xE0, 0x00, 0x1C,
  0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x61, 0xC0, 0x79, 0xC2, 0x7F, 0xFE,
  0xFF, 0xFE, 0x0F, 0xFE, 0x07, 0xC1, 0x0F, 0xE0, 0x1E, 0xE0, 0x3E, 0xF0,
  0x7C, 0x70, 0x38, 0x78, 0x10, 0x70, 0x00, 0x40, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x87,
  0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x00,
  0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xE0, 0x39, 0xF7, 0xFF, 0xFD, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xE7, 0xC1, 0xF1, 0xF0, 0xF8,
  0x3C, 0x3C, 0x0F, 0x1F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF8, 0x1F,
  0x3E, 0x07, 0xCF, 0x01, 0xF3, 0xC0, 0x79, 0xF0, 0x1E, 0x7C, 0x07, 0x9E,
  0x03, 0xE7, 0x80, 0xF9, 0xE0, 0x3C, 0xF8, 0x0F, 0x3E, 0x03, 0xCF, 0x81,
  0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x03, 0xC3, 0xC1, 0xF0,
  0xF0, 0x78, 0x3E, 0x3E, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F,
  0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x8F, 0xBC, 0xF9, 0xE3, 0x9F, 0x18, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x1E, 0x1F, 0x80,
  0x60, 0x7C, 0x02, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xC1, 0xF0, 0x10, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x0C, 0x03, 0xE0, 0xFD, 0xFE, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xDE, 0x00, 0x3F, 0xE0, 0x03, 0xBC, 0x00, 0x73, 0xC0, 0x07, 0x3C, 0x00,
  0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xC7, 0x80, 0x38, 0x78, 0x07, 0x87, 0x80,
  0x70, 0xF8, 0x0E, 0x0F, 0x01, 0xE0, 0xF0, 0x1C, 0x0F, 0x03, 0xC0, 0xF0,
  0x78, 0x1F, 0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xC0, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x81, 0xFF, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xE1, 0x00, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x79, 0xF8,
  0x0F, 0x7F, 0x81, 0xFF, 0xF8, 0x7F, 0xBF, 0x0F, 0xC3, 0xE1, 0xF0, 0x3C,
  0x3E, 0x07, 0x87, 0x80, 0xF1, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0xC0, 0x78,
  0xF8, 0x1F, 0x1E, 0x03, 0xE3, 0xC0, 0x78, 0x7C, 0x1F, 0x0F, 0x83, 0xE0,
  0xF0, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x10, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x07,
  0xC3, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xE0,
  0xF0, 0x1E, 0x0F, 0x83, 0xE0, 0x78, 0x3C, 0x07, 0x87, 0xC0, 0x7C, 0xF8,
  0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFE,
  0x01, 0xF3, 0xE0, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x0F, 0x0F, 0x80,
  0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x1F, 0x0F, 0x81, 0xE0, 0xFC, 0x7E, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xE0,
  0x7C, 0x7C, 0x0F, 0x07, 0xC3, 0xE0, 0xF8, 0x78, 0x1F, 0x1F, 0x03, 0xE3,
  0xE0, 0x7C, 0x78, 0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x87,
  0x81, 0xF0, 0xF0, 0x3E, 0x1E, 0x0F, 0xC3, 0xE3, 0xF8, 0x7F, 0xFF, 0x07,
  0xFB, 0xC0, 0xFE, 0x78, 0x07, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x39, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x01,
  0x01, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3C, 0x00, 0x00, 0x60, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xF0, 0x1E, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x00, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF1, 0xC3, 0xE2,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0x00, 0x38, 0x03,
  0xC0, 0x03, 0x80, 0xF0, 0x00, 0x70, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0xE1, 0xE0, 0x7C, 0x1C, 0x38, 0x3F, 0xE3, 0x8F, 0x0F, 0xFC, 0x71, 0xC1,
  0xC7, 0x0E, 0x38, 0x70, 0xE1, 0xCE, 0x1E, 0x3C, 0x39, 0xC3, 0x87, 0x87,
  0x38, 0xF0, 0xE1, 0xCE, 0x1C, 0x1C, 0x39, 0xC3, 0x87, 0x87, 0x38, 0x70,
  0xF0, 0xE7, 0x1E, 0x1C, 0x39, 0xE3, 0x83, 0x87, 0x38, 0x70, 0xF0, 0xE7,
  0x0E, 0x1E, 0x38, 0xE1, 0xC7, 0xC7, 0x1C, 0x3D, 0xF9, 0xC3, 0x87, 0xF7,
  0xF0, 0x70, 0x7C, 0x7C, 0x0E, 0x03, 0x02, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x10,
  0x00, 0xF8, 0x0E, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x00, 0x78, 0xF0,
  0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x0F,
  0x03, 0xE0, 0xF0, 0x3E, 0x0F, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xE0,
  0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x78,
  0x01, 0xFF, 0x80, 0x1F, 0x01, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xE0, 0x3E, 0x1F, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78,
  0x0F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xE0, 0x3E, 0x0F, 0x01, 0xE0,
  0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x3E, 0x3F, 0x01, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xC7, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F,
  0x01, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E,
  0x0F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x3C, 0x0F, 0xC1, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xF0, 0x60, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xE7,
  0xF8, 0x0F, 0x87, 0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x1F, 0x07, 0xC0, 0x7C,
  0x1F, 0x01, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E,
  0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x78, 0x7C, 0x01,
  0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1E, 0x00, 0xF8, 0x78, 0x07, 0xC3,
  0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3C, 0x03, 0xE0, 0xF0, 0x0F, 0x83, 0xC0,
  0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x81, 0xE1, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0x83, 0x80, 0xFC, 0x01, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0xF1,
  0xF0, 0x3F, 0xE3, 0xE0, 0x7F, 0xC7, 0xC0, 0xFF, 0x0F, 0x80, 0x1E, 0x1E,
  0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xC1, 0xE0,
  0x07, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x78, 0x0F, 0x80,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x7C,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x1F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xF8, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x0F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x01, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x01, 0xFF, 0x80,
  0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xE0, 0x1F, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x3C, 0x03, 0xE0, 0x7C,
  0x03, 0xE0, 0xF8, 0x03, 0xC1, 0xF0, 0x03, 0xC1, 0xF0, 0x03, 0xC3, 0xE0,
  0x07, 0xC7, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0x8F, 0x80, 0x07, 0x9F, 0x00,
  0x0F, 0x9F, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x3C, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0xF8, 0x0F, 0x00,
  0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xB8,
  0x03, 0xFE, 0x07, 0xB8, 0x03, 0xFC, 0x07, 0xB8, 0x07, 0xBC, 0x07, 0xB8,
  0x07, 0xBC, 0x0F, 0xB8, 0x0F, 0x7C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x3C,
  0x0E, 0x78, 0x0F, 0x3C, 0x1E, 0x78, 0x0F, 0x3C, 0x1E, 0xF8, 0x1F, 0x3C,
  0x3C, 0xF8, 0x1E, 0x3C, 0x3C, 0xF0, 0x1E, 0x3C, 0x78, 0xF0, 0x1E, 0x3C,
  0x78, 0xF0, 0x1E, 0x3C, 0xF1, 0xF0, 0x3E, 0x3C, 0xF1, 0xF0, 0x3C, 0x3D,
  0xE1, 0xE0, 0x3C, 0x3D, 0xE1, 0xE0, 0x3C, 0x3D, 0xC1, 0xE0, 0x3C, 0x3F,
  0xC3, 0xE0, 0x7C, 0x3F, 0xC3, 0xC0, 0x78, 0x3F, 0x83, 0xC0, 0x78, 0x3F,
  0x83, 0xC0, 0x78, 0x3F, 0x03, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0x01, 0xF0, 0x03, 0xC0, 0x7C, 0x00,
  0xF0, 0x1F, 0x80, 0x7C, 0x0F, 0xE0, 0x1E, 0x03, 0xF8, 0x07, 0x80, 0xFE,
  0x01, 0xE0, 0x3F, 0x80, 0xF8, 0x0F, 0xE0, 0x3C, 0x07, 0xBC, 0x0F, 0x01,
  0xEF, 0x03, 0xC0, 0x7B, 0xC0, 0xF0, 0x1E, 0xF0, 0x7C, 0x0F, 0xBC, 0x1E,
  0x03, 0xCF, 0x07, 0x80, 0xF1, 0xE1, 0xE0, 0x3C, 0x78, 0x78, 0x0F, 0x1E,
  0x3E, 0x07, 0xC7, 0x8F, 0x01, 0xE1, 0xE3, 0xC0, 0x78, 0x78, 0xF0, 0x1E,
  0x0E, 0x3C, 0x07, 0x83, 0xDF, 0x03, 0xE0, 0xF7, 0x80, 0xF0, 0x3D, 0xE0,
  0x3C, 0x0F, 0x78, 0x0F, 0x03, 0xDE, 0x03, 0xC0, 0x7F, 0x01, 0xF0, 0x1F,
  0xC0, 0x78, 0x07, 0xF0, 0x1E, 0x01, 0xFC, 0x07, 0x80, 0x7F, 0x03, 0xE0,
  0x1F, 0x80, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7E, 0x1F, 0x83, 0xE0,
  0x7C, 0x3E, 0x03, 0xE1, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xCF,
  0x80, 0x1E, 0x7C, 0x00, 0xF3, 0xC0, 0x07, 0xBE, 0x00, 0x3D, 0xF0, 0x03,
  0xEF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3D, 0xF0,
  0x03, 0xEF, 0x80, 0x1F, 0x78, 0x00, 0xFB, 0xC0, 0x07, 0x9E, 0x00, 0x7C,
  0xF0, 0x03, 0xE7, 0x80, 0x3E, 0x3C, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x81,
  0xF8, 0x7E, 0x1F, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xE0, 0x3E, 0x7F, 0x01, 0xF0, 0xFC, 0x0F, 0x03, 0xE0, 0x78, 0x1F,
  0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xE0, 0x3E, 0x0F, 0x01, 0xF0, 0xF8,
  0x0F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xE0, 0x7C, 0x0F, 0x07, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7E, 0x1F, 0x83, 0xE0,
  0x7C, 0x3E, 0x03, 0xE1, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xCF,
  0x80, 0x1E, 0x7C, 0x00, 0xF3, 0xC0, 0x07, 0xBE, 0x00, 0x3D, 0xF0, 0x03,
  0xEF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3D, 0xF0,
  0x03, 0xEF, 0x80, 0x1F, 0x78, 0x00, 0xFB, 0xC0, 0x07, 0x9E, 0x00, 0x7C,
  0xF0, 0x03, 0xE7, 0x80, 0x3E, 0x3C, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x81,
  0xF8, 0x7E, 0x1F, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3E,
  0x7F, 0x01, 0xE0, 0xF8, 0x0F, 0x03, 0xC0, 0x78, 0x1F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC1, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0xF8, 0x1F, 0x07, 0xC0,
  0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0xFC, 0x0F, 0x3F, 0xC0, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0,
  0x07, 0xC7, 0xC0, 0x3C, 0x3E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x01, 0xE0,
  0xF8, 0x0F, 0x87, 0x80, 0x7C, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x8F, 0x03, 0xF0, 0x10, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x08, 0x01, 0xF0, 0x70, 0x1F,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F,
  0x0F, 0x80, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F,
  0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x1F, 0x07, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0xF8, 0x7C, 0x03, 0xE1,
  0xF0, 0x0F, 0x07, 0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0xC3, 0xE0,
  0x1F, 0x0F, 0x80, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3E,
  0x0F, 0x00, 0xF0, 0x3C, 0x07, 0xC0, 0xF0, 0x1F, 0x03, 0xE0, 0xF8, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0xF8,
  0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x3C, 0xF8, 0x07, 0xCF,
  0x80, 0x7C, 0xF8, 0x07, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x0F, 0x81, 0xF0,
  0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0xF0, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x7C,
  0x0F, 0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1F,
  0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF7,
  0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x78, 0x03, 0xE0, 0x1F, 0x78, 0x03, 0xE0, 0x1E,
  0x78, 0x07, 0xC0, 0x3E, 0x78, 0x07, 0xC0, 0x3E, 0x78, 0x07, 0xC0, 0x3C,
  0x78, 0x0F, 0xC0, 0x7C, 0x78, 0x0F, 0xC0, 0x78, 0x78, 0x0F, 0xC0, 0x78,
  0x78, 0x1F, 0xC0, 0xF8, 0x78, 0x1D, 0xC0, 0xF0, 0x78, 0x3D, 0xC1, 0xF0,
  0x78, 0x3D, 0xC1, 0xE0, 0x78, 0x39, 0xC1, 0xE0, 0x78, 0x7B, 0xC3, 0xE0,
  0x78, 0x7B, 0xC3, 0xC0, 0x78, 0xF3, 0xC7, 0xC0, 0x78, 0xF3, 0xC7, 0x80,
  0x78, 0xE3, 0xC7, 0x80, 0x79, 0xE3, 0xCF, 0x80, 0x79, 0xE3, 0xCF, 0x00,
  0x7B, 0xC3, 0xCF, 0x00, 0x7B, 0xC3, 0xDE, 0x00, 0x7B, 0x83, 0xDE, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0xF7, 0x83, 0xFC, 0x00, 0xF7, 0x03, 0xFC, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x3E,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xE0, 0x01,
  0xE1, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0x78, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xCF, 0x80, 0x03, 0xE7,
  0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF0,
  0x3C, 0x00, 0xF8, 0x1F, 0x00, 0x78, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0xFB, 0xE0, 0x3C,
  0x78, 0x1F, 0x1E, 0x07, 0x87, 0x83, 0xE1, 0xE0, 0xF0, 0x78, 0x7C, 0x1E,
  0x1E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x7D, 0xE0, 0x0F, 0x78, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x78, 0xF0, 0x0F, 0x1E,
  0x03, 0xC3, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x87, 0x80, 0xF1, 0xF0, 0x1E,
  0x3C, 0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF9, 0xF1, 0xE3, 0xE3, 0xC3, 0x87, 0x87, 0x00, 0xF0, 0x00,
  0x7F, 0x3C, 0x1F, 0xF7, 0x83, 0xFE, 0xF0, 0xF8, 0xFE, 0x3E, 0x0F, 0x87,
  0xC1, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0x80, 0xF9, 0xF0, 0x1E, 0x3E,
  0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x78, 0xF8,
  0x0F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0,
  0xFC, 0x3F, 0x3F, 0x83, 0xFE, 0xF0, 0x7F, 0x9C, 0x07, 0xE3, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x1C, 0x03, 0xCF, 0xC0, 0x7B, 0xFC, 0x0F, 0xFF, 0xC3, 0xF8, 0xF8, 0x7E,
  0x0F, 0x0F, 0x81, 0xE1, 0xF0, 0x3C, 0x3C, 0x07, 0x8F, 0x80, 0xF1, 0xE0,
  0x1E, 0x3C, 0x07, 0xC7, 0x80, 0xF9, 0xF0, 0x1F, 0x3C, 0x03, 0xC7, 0x80,
  0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xE7, 0xC0, 0x78, 0xF8, 0x1F, 0x1F, 0x03,
  0xC3, 0xE0, 0xF8, 0x7E, 0x3E, 0x1E, 0xFF, 0x83, 0xDF, 0xE0, 0x79, 0xF8,
  0x00, 0x00, 0x7C, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xC4, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x10, 0x7E, 0xF0, 0x7F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x1E, 0x00,
  0xFE, 0x78, 0x07, 0xFD, 0xE0, 0x1F, 0xFF, 0x80, 0xF8, 0xFE, 0x07, 0xC1,
  0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xF0,
  0x7C, 0x07, 0x81, 0xF0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0xF8,
  0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1F,
  0x03, 0xC0, 0x78, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x80, 0xFC, 0xFE, 0x01,
  0xFF, 0x78, 0x07, 0xF9, 0xC0, 0x0F, 0xC7, 0x00, 0x00, 0x38, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xF8, 0xF8, 0xF8, 0x3C, 0x78, 0x1E, 0x7C,
  0x0F, 0x3C, 0x0F, 0x3E, 0x07, 0x9F, 0x0F, 0x8F, 0x7F, 0xC7, 0xFF, 0x87,
  0xFF, 0x83, 0xFE, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x41, 0xF0, 0x60, 0xFF, 0xF0, 0x3F,
  0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03,
  0xFB, 0xC0, 0x7F, 0xDE, 0x03, 0xFF, 0xF0, 0x3E, 0x3F, 0x83, 0xE0, 0xF8,
  0x1F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x78, 0x0F, 0x87, 0xC0,
  0x78, 0x3E, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x01, 0xF0, 0xF8, 0x0F, 0x87,
  0xC0, 0x78, 0x3E, 0x03, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F,
  0x03, 0xE0, 0xF8, 0x1F, 0x0F, 0xC0, 0xFC, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xEF, 0x00, 0x7E, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x80, 0x7C, 0x07, 0xDF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x1C,
  0x03, 0xCF, 0xE0, 0x7B, 0xFC, 0x0F, 0xFF, 0xC3, 0xF9, 0xF8, 0x7E, 0x1F,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x0F, 0x81, 0xE1, 0xF0, 0x3C,
  0x3C, 0x0F, 0x87, 0x81, 0xF0, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0x80, 0xF0,
  0xF0, 0x3E, 0x1E, 0x07, 0x87, 0xC0, 0xF0, 0xF8, 0x1E, 0x1E, 0x03, 0xC3,
  0xC0, 0xF8, 0x78, 0x1E, 0x1F, 0x03, 0xC3, 0xE0, 0x78, 0x78, 0x1F, 0x00,
  0x00, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01,
  0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x1F, 0x07, 0x83, 0xE0,
  0x78, 0x7C, 0x0F, 0x87, 0x80, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF3, 0xE0,
  0x0F, 0x3C, 0x01, 0xF7, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xF7, 0x80, 0x3E, 0x78, 0x03, 0xC7,
  0x80, 0x7C, 0x7C, 0x07, 0x87, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x78,
  0x3C, 0x0F, 0x83, 0xE0, 0xF0, 0x3E, 0x0F, 0x03, 0xE0, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x7B, 0xF8, 0xFE, 0x07, 0x7F,
  0xDF, 0xF0, 0x77, 0xFF, 0xFF, 0x0F, 0xE7, 0xF9, 0xF0, 0xFC, 0x3F, 0x0F,
  0x0F, 0x83, 0xE0, 0xF0, 0xF0, 0x3C, 0x0F, 0x0F, 0x03, 0xC0, 0xF1, 0xF0,
  0x3C, 0x0F, 0x1E, 0x07, 0xC1, 0xF1, 0xE0, 0x78, 0x1E, 0x1E, 0x07, 0x81,
  0xE1, 0xE0, 0x78, 0x1E, 0x3E, 0x07, 0x81, 0xE3, 0xC0, 0xF8, 0x3E, 0x3C,
  0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x3C, 0x7C, 0x0F, 0x03, 0xC7, 0xC1, 0xF0,
  0x7C, 0x78, 0x1E, 0x07, 0x87, 0x81, 0xE0, 0x78, 0x78, 0x1E, 0x07, 0x8F,
  0x81, 0xE0, 0x78, 0xF0, 0x3E, 0x0F, 0x8F, 0x03, 0xC0, 0xF0, 0x00, 0x07,
  0x00, 0xF3, 0xF0, 0x1C, 0xFF, 0x03, 0xBF, 0xF0, 0xFE, 0x3E, 0x1F, 0x87,
  0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x03, 0xC3, 0xE0, 0x78, 0x7C, 0x0F,
  0x0F, 0x03, 0xE1, 0xE0, 0x7C, 0x3C, 0x0F, 0x0F, 0x81, 0xE1, 0xE0, 0x3C,
  0x3C, 0x0F, 0x87, 0x81, 0xE1, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0x80, 0xF0,
  0xF0, 0x3E, 0x1E, 0x07, 0x87, 0xC0, 0xF0, 0xF8, 0x1E, 0x1E, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0x8F, 0x87,
  0xC1, 0xE1, 0xE0, 0x78, 0xF8, 0x1F, 0x3C, 0x07, 0xCF, 0x01, 0xF7, 0xC0,
  0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xEF, 0x80, 0xFB, 0xE0, 0x3E,
  0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xF3, 0xC0, 0x78, 0xF8, 0x3E, 0x3E,
  0x1F, 0x07, 0xCF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x0F, 0x3F, 0x80, 0x7B, 0xFC, 0x03, 0xBF, 0xF0, 0x3F, 0x8F,
  0x81, 0xF8, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x78, 0x3E,
  0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0x7C,
  0x3E, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x01, 0xF0, 0x78, 0x0F, 0x83, 0xC0,
  0x78, 0x3E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0xC3, 0xE0, 0x7F, 0x7E, 0x07,
  0xFF, 0xE0, 0x3D, 0xFF, 0x01, 0xE7, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x3F, 0xBC, 0x1F, 0xF7, 0x83, 0xFF, 0xF0, 0xF8,
  0xFE, 0x3E, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0xC7, 0x80,
  0xF9, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x3E, 0x03,
  0xC7, 0xC0, 0x78, 0xF8, 0x0F, 0x1F, 0x03, 0xE3, 0xC0, 0x7C, 0x78, 0x0F,
  0x0F, 0x83, 0xE1, 0xF0, 0xFC, 0x3F, 0x3F, 0x83, 0xFF, 0xF0, 0x7F, 0xBC,
  0x07, 0xE7, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x07, 0xBF, 0x07, 0x3E, 0x07,
  0x7E, 0x0F, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03,
  0xFE, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0x06, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x81, 0xF0, 0xF7, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0x80, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x1F, 0xF3,
  0xFF, 0x3F, 0xF4, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x90, 0xFF, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0x03, 0xE1, 0xE0, 0x7C, 0x3C, 0x0F, 0x0F, 0x81, 0xE1, 0xE0, 0x3C,
  0x3C, 0x0F, 0x87, 0x81, 0xE0, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0x80, 0xF0,
  0xF0, 0x3E, 0x1E, 0x07, 0x87, 0xC0, 0xF0, 0xF8, 0x1E, 0x1E, 0x07, 0xC3,
  0xC0, 0xF8, 0x78, 0x1E, 0x1F, 0x03, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F,
  0x87, 0xC1, 0xFB, 0xF8, 0x3F, 0xFF, 0x03, 0xFD, 0xE0, 0x3F, 0x3C, 0x00,
  0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C,
  0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0,
  0xF3, 0xC0, 0xF3, 0xC0, 0xF7, 0xC0, 0xF7, 0x80, 0xF7, 0x80, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x78, 0x1F, 0x03, 0xEF, 0x03, 0xE0, 0x79, 0xE0, 0xFC, 0x1F,
  0x3C, 0x1F, 0x83, 0xC7, 0x83, 0xF0, 0x78, 0xF0, 0xFE, 0x1E, 0x1E, 0x1D,
  0xC3, 0xC3, 0xC7, 0xF8, 0x78, 0x78, 0xFF, 0x1E, 0x0F, 0x1D, 0xE3, 0xC1,
  0xE7, 0xBC, 0xF0, 0x3C, 0xE7, 0x9E, 0x07, 0xBC, 0xF3, 0xC0, 0xF7, 0x9E,
  0xF0, 0x1E, 0xE3, 0xDE, 0x03, 0xFC, 0x7B, 0x80, 0x77, 0x0F, 0xF0, 0x0E,
  0xE1, 0xDE, 0x01, 0xFC, 0x3B, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x1E, 0x0F, 0x80, 0xF0, 0x78, 0x07,
  0xC7, 0xC0, 0x3E, 0x7C, 0x00, 0xF3, 0xC0, 0x07, 0xBE, 0x00, 0x3D, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xBC, 0x00,
  0x7D, 0xE0, 0x03, 0xCF, 0x00, 0x3E, 0x7C, 0x01, 0xE1, 0xE0, 0x1E, 0x0F,
  0x01, 0xF0, 0x78, 0x0F, 0x03, 0xC0, 0xF8, 0x1F, 0x00, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x0F, 0x03, 0xE0, 0x1E, 0x07, 0x80,
  0x3C, 0x1F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE1, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF7, 0x80, 0x00, 0xEF, 0x00, 0x01, 0xDC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x40, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x01,
  0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x5F,
  0xE0, 0x1F, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE8, 0x00,
  0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 12, 34, 11, 0, -34 },
  { 52, 14, 13, 17, 5, -34 },
  { 75, 22, 34, 21, 0, -34 },
  { 169, 20, 39, 19, 0, -36 },
  { 267, 26, 34, 30, 2, -34 },
  { 378, 21, 34, 21, 0, -34 },
  { 468, 6, 13, 10, 5, -34 },
  { 478, 14, 41, 12, 1, -34 },
  { 550, 14, 41, 12, -3, -34 },
  { 622, 16, 17, 18, 4, -36 },
  { 656, 18, 22, 21, 2, -28 },
  { 706, 9, 12, 10, -2, -6 },
  { 720, 11, 4, 13, 1, -15 },
  { 726, 6, 6, 10, 0, -6 },
  { 731, 22, 34, 16, -2, -34 },
  { 825, 18, 34, 19, 1, -34 },
  { 902, 13, 34, 19, 5, -34 },
  { 958, 21, 34, 19, -2, -34 },
  { 1048, 20, 34, 19, -1, -34 },
  { 1133, 20, 34, 19, -1, -34 },
  { 1218, 19, 34, 19, 0, -34 },
  { 1299, 19, 34, 19, 1, -34 },
  { 1380, 20, 34, 19, 1, -34 },
  { 1465, 20, 34, 19, 0, -34 },
  { 1550, 19, 34, 19, 0, -34 },
  { 1631, 10, 26, 10, 0, -26 },
  { 1664, 12, 32, 10, -2, -26 },
  { 1712, 18, 21, 21, 2, -27 },
  { 1760, 18, 13, 21, 2, -23 },
  { 1790, 18, 21, 21, 2, -27 },
  { 1838, 15, 34, 14, 1, -34 },
  { 1902, 27, 38, 28, 1, -34 },
  { 2031, 20, 34, 20, -3, -34 },
  { 2116, 21, 34, 21, 0, -34 },
  { 2206, 20, 34, 19, 2, -34 },
  { 2291, 22, 34, 23, 0, -34 },
  { 2385, 20, 34, 18, 0, -34 },
  { 2470, 20, 34, 17, 0, -34 },
  { 2555, 23, 34, 24, 2, -34 },
  { 2653, 25, 34, 23, 0, -34 },
  { 2760, 18, 34, 13, -2, -34 },
  { 2837, 19, 43, 10, -7, -34 },
  { 2940, 24, 34, 20, 0, -34 },
  { 3042, 13, 34, 17, 0, -34 },
  { 3098, 32, 34, 31, 0, -34 },
  { 3234, 26, 34, 25, 0, -34 },
  { 3345, 21, 34, 24, 2, -34 },
  { 3435, 21, 34, 20, 0, -34 },
  { 3525, 21, 42, 24, 2, -34 },
  { 3636, 21, 34, 20, 0, -34 },
  { 3726, 21, 34, 18, -1, -34 },
  { 3816, 17, 34, 17, 3, -34 },
  { 3889, 22, 34, 23, 2, -34 },
  { 3983, 20, 34, 20, 4, -34 },
  { 4068, 32, 34, 31, 3, -34 },
  { 4204, 25, 34, 18, -3, -34 },
  { 4311, 18, 34, 18, 4, -34 },
  { 4388, 21, 34, 17, -2, -34 },
  { 4478, 18, 42, 13, -1, -34 },
  { 4573, 8, 34, 16, 5, -34 },
  { 4607, 18, 42, 13, -3, -34 },
  { 4702, 19, 19, 19, 0, -34 },
  { 4748, 15, 3, 15, -4, 4 },
  { 4754, 7, 8, 12, 7, -36 },
  { 4761, 19, 26, 20, 1, -26 },
  { 4823, 19, 36, 20, 0, -36 },
  { 4909, 16, 26, 16, 1, -26 },
  { 4961, 22, 36, 20, 1, -36 },
  { 5060, 17, 26, 19, 1, -26 },
  { 5116, 23, 47, 11, -6, -36 },
  { 5252, 21, 37, 20, -1, -26 },
  { 5350, 19, 36, 20, 0, -36 },
  { 5436, 11, 35, 10, 0, -35 },
  { 5485, 17, 46, 10, -6, -35 },
  { 5583, 20, 36, 18, 0, -36 },
  { 5673, 12, 36, 9, 0, -36 },
  { 5727, 28, 26, 30, 0, -26 },
  { 5818, 19, 26, 20, 0, -26 },
  { 5880, 18, 26, 20, 1, -26 },
  { 5939, 21, 37, 20, -2, -26 },
  { 6037, 19, 37, 20, 1, -26 },
  { 6125, 16, 26, 14, 0, -26 },
  { 6177, 16, 26, 15, 0, -26 },
  { 6229, 12, 31, 12, 1, -31 },
  { 6276, 19, 25, 20, 1, -25 },
  { 6336, 16, 25, 17, 3, -25 },
  { 6386, 27, 25, 27, 2, -25 },
  { 6471, 21, 25, 17, -2, -25 },
  { 6537, 23, 36, 17, -4, -25 },
  { 6641, 18, 25, 14, -2, -25 },
  { 6698, 18, 41, 16, 1, -34 },
  { 6791, 3, 47, 17, 7, -36 },
  { 6809, 17, 41, 16, -3, -34 },
  { 6897, 18, 7, 21, 2, -20 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC47PT7B_H_
