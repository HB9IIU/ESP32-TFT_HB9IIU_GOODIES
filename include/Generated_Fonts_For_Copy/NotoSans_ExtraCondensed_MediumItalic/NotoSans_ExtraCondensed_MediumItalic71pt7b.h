#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC71PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xCF, 0xE0,
  0xFE, 0x7F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0xC7,
  0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x1F,
  0x87, 0xE0, 0xFC, 0x3E, 0x07, 0xE1, 0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0xFC,
  0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x78, 0x1F, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFE, 0x70, 0xF0, 0x07, 0xF1, 0xC0, 0x80, 0x1F, 0x87, 0x00, 0x00, 0xFE,
  0x18, 0x00, 0x03, 0xF0, 0xE0, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0x3F, 0x0E,
  0x00, 0x00, 0xFC, 0x38, 0x00, 0x03, 0xF8, 0xC0, 0x00, 0x0F, 0xE7, 0x00,
  0x00, 0x1F, 0xDC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1D, 0xFC, 0x00, 0x00, 0x63,
  0xF8, 0x00, 0x03, 0x8F, 0xE0, 0x00, 0x0E, 0x1F, 0x80, 0x00, 0x38, 0x7E,
  0x00, 0x00, 0xE1, 0xF8, 0x00, 0x03, 0x07, 0xE0, 0x00, 0x1C, 0x3F, 0x81,
  0x00, 0x70, 0xFC, 0x06, 0x01, 0xC7, 0xF0, 0x1C, 0x07, 0x3F, 0xC0, 0x7E,
  0x1B, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xC0,
  0x07, 0xE7, 0xC0, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x1F,
  0x00, 0x1F, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x7E, 0x00, 0x3E,
  0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xC0,
  0xF8, 0x00, 0x7E, 0x07, 0xC1, 0xF8, 0x00, 0x7C, 0x07, 0xC1, 0xF0, 0x00,
  0x7C, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x0F,
  0x87, 0xE0, 0x00, 0x7C, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x0F, 0x8F, 0x81,
  0xF0, 0xFC, 0x1F, 0x0F, 0x87, 0xFC, 0xF8, 0x1F, 0x1F, 0x0F, 0xFE, 0xF8,
  0x3F, 0x1F, 0x1F, 0xFE, 0x7C, 0x3E, 0x3E, 0x1F, 0xFE, 0x7C, 0x7E, 0x3E,
  0x3E, 0x3F, 0x7E, 0xFC, 0x7C, 0x7E, 0x1F, 0x7F, 0xF8, 0x7C, 0x7C, 0x1F,
  0x3F, 0xF8, 0xF8, 0x7C, 0x1F, 0x3F, 0xF1, 0xF8, 0xF8, 0x1F, 0x1F, 0xC1,
  0xF0, 0xF8, 0x1F, 0x00, 0x03, 0xF1, 0xF0, 0x1F, 0x00, 0x03, 0xE1, 0xF0,
  0x1F, 0x00, 0x07, 0xE1, 0xF0, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x3E, 0x00,
  0x0F, 0xC3, 0xE0, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x3E, 0x00, 0x1F, 0x83,
  0xE0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x7C,
  0x00, 0x3E, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0xFC, 0x00, 0x7C,
  0x03, 0xC0, 0xF8, 0x00, 0xF8, 0x03, 0xC0, 0xF8, 0x00, 0xF8, 0x03, 0xE1,
  0xF0, 0x01, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x03, 0xE3, 0xE0, 0x03,
  0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xC0, 0x01,
  0xFF, 0x80, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x7F,
  0x03, 0xFF, 0xE0, 0x7E, 0x07, 0xF7, 0xE0, 0xFE, 0x0F, 0xE7, 0xF0, 0xFC,
  0x1F, 0xC7, 0xF0, 0xFC, 0x1F, 0x83, 0xF1, 0xFC, 0x3F, 0x03, 0xF9, 0xF8,
  0x7F, 0x03, 0xF9, 0xF8, 0x7E, 0x01, 0xFB, 0xF0, 0x7E, 0x01, 0xFF, 0xF0,
  0xFE, 0x01, 0xFF, 0xE0, 0xFE, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0xC0,
  0xFC, 0x00, 0xFF, 0xC0, 0xFC, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xDF, 0xE0,
  0x3F, 0xFF, 0x8F, 0xE0, 0x3F, 0xFF, 0x0F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF0,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xE3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0,
  0xFC, 0x3F, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x08, 0x0F, 0xC0, 0x1C, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xFF, 0x7C, 0x3D,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xBE, 0x00, 0xFE, 0x7E, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x03, 0xC1,
  0xFC, 0x03, 0x01, 0xF0, 0x02, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0,
  0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E,
  0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x00, 0x7F, 0xFF, 0xBF,
  0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x1E, 0x7F,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFC, 0x30, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0,
  0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xF0,
  0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC,
  0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F,
  0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x7F,
  0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03,
  0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x07,
  0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80,
  0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xFB,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF,
  0x7E, 0x3F, 0xCF, 0xCF, 0xF3, 0xF8, 0xFC, 0x7F, 0x0E, 0x0F, 0xC0, 0x81,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xC0, 0xFF, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0x18, 0x00, 0xFE,
  0x00, 0x20, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x3F, 0xC0, 0x0C, 0x00,
  0xFF, 0x00, 0x20, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x20, 0x00, 0x7F, 0x80, 0xC0, 0x03, 0xFE, 0x03, 0xF0, 0x7F, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xBF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xF0, 0x00,
  0x07, 0x9F, 0x80, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07,
  0xCF, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x3E, 0x1F, 0xC0, 0x00, 0xF8, 0x7F, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0xFE, 0x00,
  0x3E, 0x03, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x3F, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xCF, 0xFE, 0x00,
  0x10, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x20, 0x00, 0x7F, 0x80, 0xE0, 0x03, 0xFE, 0x03, 0xF0,
  0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x0F,
  0xE0, 0x01, 0xF9, 0xFF, 0xC0, 0x1F, 0xDF, 0xFE, 0x00, 0xFD, 0xFF, 0xF8,
  0x07, 0xEF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0x07, 0xF8, 0x1F,
  0xF0, 0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x80,
  0x1F, 0x83, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F,
  0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80,
  0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xCF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xF0,
  0x1F, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x0F,
  0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x8F,
  0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x3F,
  0xC3, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F,
  0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF8,
  0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFC, 0x0F,
  0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xFE,
  0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x3F,
  0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7F,
  0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x03,
  0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xF0, 0xFE, 0x01,
  0xFE, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0x07, 0xFE, 0x0F, 0xF9, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xEF, 0xC0, 0x3F, 0xFC, 0xFC, 0x03, 0xFF,
  0x9F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0x18, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x0C, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x10, 0x00, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x1F, 0x80, 0x7F, 0x00, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0x1F, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03,
  0xF3, 0xFE, 0x03, 0x80, 0xFE, 0x02, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x0F, 0xFC, 0x0F, 0x07,
  0xC0, 0x3F, 0xFE, 0x0F, 0x07, 0xC0, 0x7F, 0xFE, 0x0F, 0x0F, 0x80, 0xFF,
  0xFC, 0x0F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0x0F, 0x01, 0xF0, 0x7C, 0x1F,
  0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x3E, 0x0F, 0x80, 0xF8,
  0x1E, 0x3C, 0x0F, 0x81, 0xF0, 0x1E, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x7C,
  0x1F, 0x01, 0xF0, 0x3E, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x78, 0x1F, 0x03,
  0xE0, 0x3C, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0xF8, 0x1E, 0x03, 0xE0, 0x7C,
  0xF8, 0x3E, 0x07, 0xE0, 0x78, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0xF8, 0x3E,
  0x07, 0xC0, 0xF0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0xF0, 0x3E, 0x0F, 0xC1,
  0xE0, 0xF0, 0x3E, 0x1F, 0xC3, 0xE0, 0xF0, 0x3F, 0x3F, 0xEF, 0xC0, 0xF0,
  0x1F, 0xF9, 0xFF, 0x80, 0xF0, 0x1F, 0xF1, 0xFF, 0x00, 0xF0, 0x0F, 0xE0,
  0xFE, 0x00, 0xF8, 0x07, 0xC0, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x80, 0x00, 0x1F,
  0xC0, 0x07, 0x80, 0x00, 0x0F, 0xFC, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0xFC,
  0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0xFC, 0x3F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x3F, 0x1F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF3, 0xFC, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x7F, 0x80, 0x00, 0xFD, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0xFF, 0xC0, 0x07, 0xE0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x07,
  0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x07,
  0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x0F,
  0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x7F,
  0xC0, 0x7F, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x1C, 0x00, 0x7F, 0x80, 0x08,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x03, 0x00, 0x0F,
  0xFC, 0x3E, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x3F, 0xF8, 0x00, 0xFE, 0x03, 0xFE,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F,
  0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x02, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFE, 0x01, 0xF0, 0x03, 0xFE, 0x00, 0x1C, 0x01, 0xFF, 0x00, 0x01,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFC, 0x3F, 0xC0, 0x1F, 0xFF,
  0x0F, 0xE0, 0x07, 0xFF, 0xC3, 0xF8, 0x01, 0xFF, 0xF0, 0xFE, 0x00, 0x7F,
  0xF8, 0x3F, 0x80, 0x3F, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xFE, 0x3F,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x08, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xFC,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0x9F, 0xE0, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xBF, 0x80, 0x00, 0x0F, 0xF1, 0xF8,
  0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0xFC,
  0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x03, 0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x03, 0xFB, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xFD, 0xF0, 0x00, 0xFD, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0xFE,
  0x00, 0x3F, 0x3E, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x9F, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0xCF, 0x80, 0x1F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F,
  0xC0, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xE0, 0x03, 0xF1, 0xF8, 0x0F, 0xC7,
  0xF0, 0x03, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x3F, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x1F, 0x83, 0xF0,
  0xFE, 0x00, 0x7F, 0x0F, 0xC1, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0xF8,
  0x3F, 0x00, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x7C,
  0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x3F,
  0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x9F,
  0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xDF, 0x81, 0xFC, 0x00, 0x7E, 0x07, 0xEF,
  0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xFF, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xFF,
  0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFF, 0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F,
  0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x7F,
  0xC0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x07,
  0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0x1F,
  0xF8, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x80, 0x1F, 0xBF, 0x00,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xF8, 0x01,
  0xF9, 0xF8, 0x07, 0xF0, 0x03, 0xF3, 0xF0, 0x0F, 0xE0, 0x07, 0xE3, 0xE0,
  0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x7E, 0x00,
  0x7E, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x7E,
  0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x1F, 0x80,
  0x1F, 0x81, 0xF8, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x07,
  0xE1, 0xF8, 0x01, 0xFC, 0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0x0F, 0x87, 0xE0,
  0x07, 0xE0, 0x1F, 0x9F, 0xC0, 0x0F, 0xC0, 0x3F, 0x3F, 0x00, 0x1F, 0x80,
  0x7E, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0x01, 0xF9, 0xF8,
  0x01, 0xF8, 0x01, 0xF7, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xF8,
  0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x01, 0xFF,
  0x80, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xFC, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x3F, 0x9F, 0xE0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0xC0,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0xBF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0x0F, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07,
  0xF8, 0x03, 0xF0, 0x1F, 0xF0, 0x07, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xC1, 0xFF,
  0x00, 0x3F, 0x81, 0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0xFC, 0x01, 0xFC,
  0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFE,
  0x03, 0xFC, 0x01, 0xF8, 0x0F, 0xF8, 0x03, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0,
  0x07, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x7C, 0x00, 0x7F, 0x80, 0x1C, 0x00,
  0xFF, 0x00, 0x04, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x40, 0x00, 0x7F, 0x80, 0x70, 0x00, 0xFF, 0x00, 0x7C,
  0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x3F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x03,
  0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE,
  0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x07, 0xDF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7D,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x7E,
  0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x7E,
  0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0xE0, 0x07, 0xF0, 0x7E,
  0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFF, 0xE0, 0x0F, 0xE0, 0x7E,
  0x00, 0xFB, 0xE0, 0x1F, 0xC0, 0x7E, 0x01, 0xFB, 0xE0, 0x1F, 0xC0, 0x7E,
  0x01, 0xFB, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF3, 0xE0, 0x3F, 0x80, 0x7E,
  0x03, 0xF7, 0xE0, 0x3F, 0x80, 0x7E, 0x03, 0xE7, 0xE0, 0x7F, 0x00, 0x7E,
  0x07, 0xE7, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xC7, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC7, 0xE0, 0xFE, 0x00, 0x7E,
  0x0F, 0xC7, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0x00, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x00, 0xFE, 0x1F, 0x07, 0xE3, 0xF8, 0x00, 0xFE,
  0x3F, 0x07, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x07, 0xE3, 0xF0, 0x00, 0xFE,
  0x3E, 0x07, 0xE7, 0xF0, 0x00, 0xFE, 0x7E, 0x07, 0xC7, 0xE0, 0x00, 0xFE,
  0x7C, 0x07, 0xCF, 0xE0, 0x00, 0xFE, 0xFC, 0x07, 0xCF, 0xE0, 0x00, 0xFC,
  0xFC, 0x07, 0xCF, 0xC0, 0x00, 0xFC, 0xF8, 0x07, 0xDF, 0xC0, 0x00, 0xFD,
  0xF8, 0x07, 0xDF, 0x80, 0x00, 0xFD, 0xF0, 0x07, 0xDF, 0x80, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF8,
  0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x00,
  0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07,
  0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7F,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F,
  0x9F, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F,
  0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F,
  0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0x83, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x7C, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xFF, 0x0F, 0xE1,
  0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x0F, 0xC0, 0x1F, 0xFC, 0x7E,
  0x01, 0xFF, 0xF7, 0xE0, 0x1F, 0xFF, 0xBF, 0x01, 0xFF, 0xFD, 0xF8, 0x1F,
  0xF0, 0xFF, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x00,
  0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFC,
  0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF8, 0x7F,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFC,
  0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF8, 0x3F,
  0x00, 0x1F, 0x81, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00,
  0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x07, 0xFC,
  0x07, 0xF8, 0x7F, 0xE0, 0x3F, 0xFF, 0xBF, 0x00, 0xFF, 0xF9, 0xF8, 0x07,
  0xFF, 0xCF, 0x80, 0x1F, 0xFC, 0x7C, 0x00, 0x7F, 0x87, 0xE0, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0xFC, 0x7F, 0xC0, 0x07, 0xE7, 0xFF, 0x00, 0x7F, 0x7F, 0xFC, 0x03,
  0xF7, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x0F, 0xF8,
  0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F,
  0xC0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83,
  0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x0F, 0xE0,
  0x03, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F,
  0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x83,
  0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F,
  0xC1, 0xFF, 0x01, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xE1, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0x7F, 0xFF, 0x01, 0xF9, 0xFF, 0xF0, 0x0F, 0xCF,
  0xFF, 0x00, 0x7C, 0x1F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFC, 0x08, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x80, 0xFF, 0x87, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x83, 0xF8, 0x00, 0x3F, 0xE3, 0xF8, 0x00, 0x7F, 0xF3, 0xF0, 0x00, 0xFF,
  0xFB, 0xF0, 0x01, 0xFF, 0xFB, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xF8,
  0x3F, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80,
  0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0x80, 0x7F, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x01,
  0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0xFE, 0xFC, 0x00, 0x7F, 0xFE, 0xF8, 0x00, 0x7F, 0xFC,
  0xF8, 0x00, 0x3F, 0xF8, 0xF8, 0x00, 0x1F, 0xE0, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xF3, 0xFC, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xF0, 0x07,
  0xE3, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFE, 0x03, 0xFC, 0x7F, 0x07, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x20, 0x3F, 0x80, 0x70,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xF6, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x0F, 0xC0, 0x01, 0xFF, 0xC7, 0xE0, 0x01, 0xFF, 0xF7, 0xE0, 0x01,
  0xFF, 0xFB, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x0F, 0xFC, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF8,
  0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0xFF, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFB, 0xF8, 0x00, 0x7F,
  0xFD, 0xF8, 0x00, 0x1F, 0xFC, 0xFC, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00,
  0xF0, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0xC0, 0x03, 0xFC, 0x00, 0x78, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x7F, 0xC0, 0x0F, 0xDF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xBF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xF0, 0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x03, 0xFC, 0x03,
  0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0,
  0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0,
  0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x03, 0xF8,
  0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0,
  0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F,
  0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x1F, 0x9F, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F,
  0xDF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xDF, 0xC0, 0x01, 0xFE, 0x7F,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x7E,
  0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x1F, 0xF8, 0x3F, 0xF0, 0x03,
  0xE7, 0xFF, 0x8F, 0xFF, 0x00, 0xFD, 0xFF, 0xF3, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF,
  0x87, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x81,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7F,
  0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F,
  0x80, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x01,
  0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x83, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x81, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x87,
  0xFC, 0x00, 0xF9, 0xFF, 0xE0, 0x1F, 0xBF, 0xFE, 0x01, 0xFB, 0xFF, 0xF0,
  0x1F, 0x7F, 0xFF, 0x01, 0xFF, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0x03, 0xFC,
  0x03, 0xF0, 0x3F, 0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F,
  0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x1F,
  0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01,
  0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x03,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00,
  0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F,
  0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF0, 0x01, 0xFD,
  0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0,
  0x03, 0xFB, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xCF,
  0xC0, 0x07, 0xF3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x1F, 0xC3,
  0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC3, 0xFE, 0x00, 0x03, 0xE3, 0xFF, 0x80, 0x03, 0xF3,
  0xFF, 0xE0, 0x01, 0xFB, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x1F,
  0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xF0,
  0x07, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF8, 0x0F, 0xE0, 0x07, 0xFC, 0x0F,
  0xF0, 0x03, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFD, 0xFF,
  0xF8, 0x00, 0xFE, 0xFF, 0xF8, 0x00, 0x7F, 0x3F, 0xF8, 0x00, 0x3F, 0x0F,
  0xF0, 0x00, 0x1F, 0x81, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x8F, 0xC0, 0x1F, 0xFC, 0x7C, 0x01,
  0xFF, 0xF7, 0xE0, 0x1F, 0xFF, 0xBF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0,
  0xFF, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0xFF,
  0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F,
  0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x1F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00,
  0x1F, 0x81, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0xFF,
  0x03, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x07, 0xFC, 0x07,
  0xF8, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xDF, 0x80, 0x1F, 0xFC, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xF0, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0xF8, 0xFF, 0x00, 0xF9, 0xFE, 0x01, 0xF9, 0xFE, 0x01,
  0xFB, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF7, 0xFC, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x04, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0x00, 0x0F, 0xE0,
  0xC0, 0x0F, 0xF0, 0x7C, 0x1F, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xFF, 0xF1,
  0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x84, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x1C,
  0x00, 0x03, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x81, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F,
  0x83, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0xC0, 0xFC, 0x07,
  0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFD, 0xF8, 0x07, 0xFF, 0x9F, 0x00, 0x7F, 0xF1, 0xF0, 0x03, 0xFE,
  0x1F, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07,
  0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x7F, 0x01,
  0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xF0,
  0x7F, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x3E,
  0x0F, 0xC0, 0x1F, 0x0F, 0xE0, 0x0F, 0x87, 0xE0, 0x07, 0xC7, 0xF0, 0x03,
  0xE3, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF9, 0xF8, 0x00, 0x7C, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0xFE, 0x01, 0xFE, 0x00,
  0xFC, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFE, 0x01, 0xF8, 0xFE,
  0x03, 0xFE, 0x03, 0xF8, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0xFC, 0x07, 0xFE,
  0x03, 0xF0, 0xFC, 0x07, 0xFE, 0x07, 0xF0, 0xFC, 0x0F, 0xBE, 0x07, 0xE0,
  0xFC, 0x0F, 0xBE, 0x07, 0xE0, 0xFC, 0x1F, 0xBE, 0x0F, 0xC0, 0xFC, 0x1F,
  0x3E, 0x0F, 0xC0, 0xFC, 0x1F, 0x3E, 0x1F, 0xC0, 0xFC, 0x3F, 0x3E, 0x1F,
  0x80, 0xFC, 0x3E, 0x3E, 0x1F, 0x80, 0xFC, 0x7E, 0x3E, 0x3F, 0x00, 0xFC,
  0x7C, 0x3E, 0x3F, 0x00, 0xFC, 0x7C, 0x3E, 0x3F, 0x00, 0xFC, 0xFC, 0x7E,
  0x7E, 0x00, 0xFC, 0xF8, 0x7E, 0x7E, 0x00, 0xFC, 0xF8, 0x7E, 0xFC, 0x00,
  0xFD, 0xF0, 0x7E, 0xFC, 0x00, 0xFD, 0xF0, 0x7E, 0xFC, 0x00, 0xFF, 0xF0,
  0x7D, 0xF8, 0x00, 0xFF, 0xE0, 0x7D, 0xF8, 0x00, 0xFF, 0xE0, 0x7D, 0xF0,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x27, 0xFF, 0x00, 0x05, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x80, 0x03, 0xFF, 0x90, 0x00, 0x0F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 19, 52, 17, 0, -51 },
  { 125, 21, 19, 25, 7, -51 },
  { 175, 33, 51, 31, 0, -51 },
  { 386, 30, 58, 28, 0, -54 },
  { 604, 40, 52, 45, 3, -51 },
  { 864, 32, 52, 32, 0, -51 },
  { 1072, 10, 19, 14, 7, -51 },
  { 1096, 22, 62, 19, 1, -51 },
  { 1267, 22, 62, 19, -5, -51 },
  { 1438, 23, 25, 27, 7, -54 },
  { 1510, 27, 34, 31, 3, -42 },
  { 1625, 13, 17, 15, -3, -8 },
  { 1653, 17, 6, 19, 1, -22 },
  { 1666, 8, 10, 15, 1, -9 },
  { 1676, 34, 51, 25, -4, -51 },
  { 1893, 28, 52, 28, 1, -51 },
  { 2075, 19, 51, 29, 7, -51 },
  { 2197, 31, 51, 28, -2, -51 },
  { 2395, 30, 52, 28, -1, -51 },
  { 2590, 30, 51, 29, -1, -51 },
  { 2782, 30, 52, 28, -1, -51 },
  { 2977, 29, 52, 28, 2, -51 },
  { 3166, 30, 51, 28, 2, -51 },
  { 3358, 30, 52, 28, 0, -51 },
  { 3553, 28, 52, 28, 0, -51 },
  { 3735, 15, 40, 15, 0, -39 },
  { 3810, 19, 48, 15, -4, -39 },
  { 3924, 27, 32, 31, 3, -41 },
  { 4032, 27, 20, 31, 3, -35 },
  { 4100, 27, 32, 31, 3, -41 },
  { 4208, 24, 52, 21, 1, -51 },
  { 4364, 40, 57, 43, 2, -51 },
  { 4649, 30, 51, 30, -5, -51 },
  { 4841, 32, 51, 31, 0, -51 },
  { 5045, 31, 52, 28, 3, -51 },
  { 5247, 33, 51, 34, 0, -51 },
  { 5458, 30, 51, 27, 0, -51 },
  { 5650, 30, 51, 25, 0, -51 },
  { 5842, 34, 52, 36, 3, -51 },
  { 6063, 37, 51, 35, 0, -51 },
  { 6299, 28, 51, 20, -3, -51 },
  { 6478, 29, 65, 15, -11, -51 },
  { 6714, 36, 51, 30, 0, -51 },
  { 6944, 20, 51, 25, 0, -51 },
  { 7072, 49, 51, 47, 0, -51 },
  { 7385, 39, 51, 37, 0, -51 },
  { 7634, 33, 52, 36, 2, -51 },
  { 7849, 32, 51, 30, 0, -51 },
  { 8053, 33, 63, 36, 2, -51 },
  { 8313, 31, 51, 31, 0, -51 },
  { 8511, 32, 52, 27, -2, -51 },
  { 8719, 26, 51, 25, 5, -51 },
  { 8885, 35, 52, 34, 2, -51 },
  { 9113, 30, 51, 30, 6, -51 },
  { 9305, 48, 51, 47, 5, -51 },
  { 9611, 37, 51, 28, -4, -51 },
  { 9847, 27, 51, 27, 6, -51 },
  { 10020, 32, 51, 25, -3, -51 },
  { 10224, 27, 62, 20, -2, -51 },
  { 10434, 13, 51, 25, 7, -51 },
  { 10517, 27, 62, 20, -5, -51 },
  { 10727, 29, 29, 29, 0, -51 },
  { 10833, 23, 4, 22, -6, 6 },
  { 10845, 11, 11, 19, 10, -54 },
  { 10861, 29, 40, 31, 2, -39 },
  { 11006, 29, 55, 30, 0, -54 },
  { 11206, 24, 40, 24, 2, -39 },
  { 11326, 32, 55, 31, 2, -54 },
  { 11546, 25, 40, 28, 2, -39 },
  { 11671, 35, 71, 17, -9, -54 },
  { 11982, 33, 56, 31, -2, -39 },
  { 12213, 28, 54, 30, 0, -54 },
  { 12402, 17, 53, 14, 0, -53 },
  { 12515, 26, 70, 14, -9, -53 },
  { 12743, 30, 54, 27, 0, -54 },
  { 12946, 18, 54, 14, 0, -54 },
  { 13068, 43, 39, 45, 0, -39 },
  { 13278, 28, 39, 30, 0, -39 },
  { 13415, 26, 40, 30, 2, -39 },
  { 13545, 33, 56, 30, -4, -39 },
  { 13776, 29, 56, 31, 2, -39 },
  { 13979, 24, 39, 21, 0, -39 },
  { 14096, 25, 40, 23, -1, -39 },
  { 14221, 18, 48, 18, 2, -47 },
  { 14329, 28, 39, 30, 2, -38 },
  { 14466, 25, 38, 25, 4, -38 },
  { 14585, 40, 38, 40, 4, -38 },
  { 14775, 32, 38, 26, -3, -38 },
  { 14927, 35, 55, 25, -6, -38 },
  { 15168, 26, 38, 21, -3, -38 },
  { 15292, 27, 62, 24, 1, -51 },
  { 15502, 6, 71, 26, 10, -54 },
  { 15556, 26, 62, 23, -4, -51 },
  { 15758, 27, 10, 31, 3, -30 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic71pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC71PT7B_H_
