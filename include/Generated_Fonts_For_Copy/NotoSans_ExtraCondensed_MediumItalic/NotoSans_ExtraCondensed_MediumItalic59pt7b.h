#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC59PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xE0,
  0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x40, 0x00, 0x3F, 0x0F,
  0x9F, 0x8F, 0xCF, 0x87, 0xE7, 0xC3, 0xF7, 0xE1, 0xF3, 0xE0, 0xF9, 0xF0,
  0x7C, 0xF8, 0x7C, 0x7C, 0x3E, 0x3C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0x8F,
  0x83, 0xC7, 0x83, 0xE3, 0xC1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF8,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x3C, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x1E, 0x0F, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x78,
  0x3C, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0xFC, 0xE3, 0x80, 0x7C, 0x70, 0x40, 0x7E, 0x30, 0x00, 0x3E, 0x18, 0x00,
  0x1F, 0x1C, 0x00, 0x0F, 0x8E, 0x00, 0x07, 0xC6, 0x00, 0x03, 0xF3, 0x00,
  0x01, 0xFD, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0x7E, 0x00, 0x01, 0xBF, 0x00, 0x01,
  0xCF, 0xC0, 0x00, 0xC7, 0xE0, 0x00, 0x61, 0xF0, 0x00, 0x30, 0xF8, 0x00,
  0x38, 0xF8, 0x20, 0x1C, 0x7C, 0x08, 0x0C, 0x7E, 0x07, 0x06, 0x7F, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x3C, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0xFF,
  0xC0, 0x1E, 0x00, 0xFB, 0xE0, 0x1F, 0x00, 0xF8, 0xF0, 0x0F, 0x00, 0x78,
  0x78, 0x0F, 0x80, 0x7C, 0x3C, 0x07, 0x80, 0x3C, 0x1E, 0x07, 0x80, 0x1E,
  0x0F, 0x03, 0xC0, 0x1F, 0x07, 0x83, 0xC0, 0x0F, 0x03, 0xC1, 0xE0, 0x07,
  0x83, 0xE1, 0xE0, 0x03, 0xC1, 0xF1, 0xF0, 0x03, 0xE0, 0xF0, 0xF0, 0x01,
  0xE0, 0x78, 0xF8, 0x00, 0xF0, 0x3C, 0x78, 0x00, 0x78, 0x3C, 0x7C, 0x1C,
  0x3C, 0x1E, 0x3C, 0x3F, 0x9E, 0x1F, 0x3E, 0x3F, 0xEF, 0x0F, 0x1E, 0x3F,
  0xF7, 0x8F, 0x9F, 0x3E, 0x7B, 0xEF, 0x8F, 0x1E, 0x3F, 0xFF, 0xCF, 0x9E,
  0x0F, 0x7F, 0xC7, 0x8F, 0x07, 0x9F, 0xC7, 0xCF, 0x87, 0xC3, 0x03, 0xC7,
  0x83, 0xE0, 0x03, 0xC3, 0xC1, 0xE0, 0x01, 0xE3, 0xE0, 0xF0, 0x01, 0xE1,
  0xE0, 0x78, 0x00, 0xF0, 0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x1E, 0x00, 0xF8,
  0x3C, 0x1F, 0x00, 0x78, 0x1E, 0x0F, 0x00, 0x7C, 0x1F, 0x07, 0x80, 0x3C,
  0x0F, 0x87, 0xC0, 0x3E, 0x07, 0x83, 0xC0, 0x1E, 0x03, 0xE3, 0xE0, 0x1F,
  0x00, 0xF1, 0xE0, 0x0F, 0x00, 0x7F, 0xF0, 0x0F, 0x80, 0x3F, 0xF0, 0x07,
  0x80, 0x0F, 0xF0, 0x07, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x03,
  0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x07, 0xC0,
  0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x9F,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xF0, 0x7C, 0x1F, 0xFC, 0x1F, 0x0F, 0xDF, 0x0F, 0xC7, 0xE7, 0xE3,
  0xE3, 0xF1, 0xF8, 0xF8, 0xF8, 0x3E, 0x7C, 0x7E, 0x0F, 0x9F, 0x1F, 0x03,
  0xFF, 0x8F, 0xC0, 0x7F, 0xE3, 0xE0, 0x1F, 0xF0, 0xF8, 0x07, 0xFC, 0x3E,
  0x00, 0xFE, 0x0F, 0x80, 0x3F, 0x83, 0xE0, 0x0F, 0xC0, 0xFC, 0x07, 0xF8,
  0x3F, 0x03, 0xFE, 0x0F, 0xE3, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE,
  0xFC, 0x0F, 0xFE, 0x1F, 0x81, 0xFF, 0x07, 0xE0, 0x0C, 0x00, 0x00, 0x3F,
  0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8,
  0xF8, 0xF0, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x20, 0x78, 0x03, 0x0F, 0x80, 0x7C, 0xF8, 0x07,
  0xFF, 0x1E, 0x7F, 0xFF, 0xEB, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xBC, 0x03, 0xF3, 0xE0, 0x7F, 0x1E,
  0x03, 0xE1, 0xF0, 0x1C, 0x1F, 0x80, 0x40, 0xE0, 0x00, 0x08, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x1F,
  0x87, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1E,
  0x07, 0xC0, 0xF0, 0x3E, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE,
  0xFF, 0xFB, 0xFF, 0xE0, 0x3E, 0x7E, 0x7F, 0x7E, 0xFE, 0x7E, 0x7C, 0x10,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xDF, 0x80, 0x7E, 0x1F, 0x01,
  0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x01, 0xF8, 0x7E,
  0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF8, 0x07,
  0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x9F, 0x80, 0x3E, 0x3F, 0x00, 0x7C,
  0x7E, 0x01, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x8F,
  0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0xFC,
  0x07, 0xE1, 0xF0, 0x0F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC1,
  0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFE,
  0x1F, 0xFC, 0x7F, 0x7C, 0xFE, 0x7C, 0x7C, 0xFC, 0x78, 0xFC, 0x20, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0x81, 0xFC, 0x01, 0xC0, 0x3F,
  0x00, 0x20, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xC3,
  0xFC, 0x03, 0x80, 0x7E, 0x00, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x08, 0x00,
  0x7F, 0x06, 0x00, 0x7F, 0x03, 0xE1, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x01,
  0xEF, 0xC0, 0x01, 0xE7, 0xE0, 0x00, 0xF3, 0xE0, 0x00, 0xF1, 0xF0, 0x00,
  0xF0, 0xF8, 0x00, 0x78, 0xFC, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x3C, 0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1E, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x0F, 0x01, 0xF8, 0x0F, 0x80, 0xFC,
  0x07, 0x80, 0x7C, 0x07, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x04, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x80, 0x0F, 0xE0,
  0x80, 0x1F, 0xC0, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0x82, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x8F, 0x80,
  0x1F, 0x3F, 0xC0, 0x1F, 0x7F, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xC3, 0xF8, 0x3F, 0x81, 0xF8, 0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xF8,
  0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8,
  0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0,
  0xFC, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x7F, 0x3F, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF8,
  0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0x81, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFD, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xE7, 0xE0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x00,
  0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x3F, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x01, 0xFC, 0xFE, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x3F,
  0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F,
  0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x81, 0xFE,
  0x1F, 0x81, 0xFE, 0x0F, 0xC7, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x07, 0xFE, 0xFC, 0x03, 0xF8, 0xF8, 0x00, 0xE0, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0xE1, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x3F,
  0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x07, 0x80, 0x20, 0x00, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0E, 0x1F, 0xC1, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x7C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x3F, 0x83, 0xC1, 0xE0, 0x3F, 0xF0, 0xF0, 0x78,
  0x1F, 0xFC, 0x3C, 0x3C, 0x0F, 0xDF, 0x0F, 0x0F, 0x07, 0xC7, 0xC3, 0xC7,
  0x81, 0xE1, 0xE0, 0xF1, 0xE0, 0xF0, 0x78, 0x3C, 0x78, 0x3C, 0x1E, 0x0F,
  0x3C, 0x1E, 0x0F, 0x83, 0xCF, 0x07, 0x83, 0xC1, 0xE3, 0xC3, 0xC0, 0xF0,
  0x78, 0xE0, 0xF0, 0x3C, 0x1E, 0x78, 0x3C, 0x1F, 0x07, 0x9E, 0x0F, 0x07,
  0x81, 0xC7, 0x87, 0xC1, 0xE0, 0xF1, 0xE1, 0xE0, 0xF8, 0x3C, 0x78, 0x78,
  0x3E, 0x1E, 0x1E, 0x1E, 0x0F, 0x07, 0x87, 0x07, 0x87, 0xC3, 0xC3, 0xC1,
  0xE1, 0xF0, 0xF0, 0xF0, 0x7C, 0xFE, 0x78, 0x3C, 0x0F, 0xF3, 0xFC, 0x0F,
  0x03, 0xF8, 0xFE, 0x03, 0xC0, 0x7C, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x80, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xDF,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9,
  0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3F,
  0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x07,
  0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01,
  0xF8, 0x1F, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E,
  0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xF0, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x1F,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x3F, 0xC0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xF0, 0xFF, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x03,
  0xE0, 0x3E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3E,
  0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x7F, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xE3, 0xC0, 0x1F, 0xE0, 0x20, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x20,
  0x03, 0xFC, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0x83, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0xFE,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x3F,
  0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x03,
  0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xC1,
  0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x00,
  0x1F, 0x81, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0xFE, 0x03, 0xE0, 0x1F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x7F, 0x80, 0x7E, 0x1F, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xE3, 0xF8, 0x07, 0xF8, 0x03,
  0x80, 0x3F, 0x80, 0x04, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x1F, 0xFC, 0x3F, 0x00, 0xFF, 0xE1, 0xF8, 0x07, 0xFE, 0x0F, 0xC0,
  0x3F, 0xF0, 0xFC, 0x03, 0xFF, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x07, 0xE0,
  0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x07,
  0xC0, 0x3F, 0xC0, 0x3E, 0x00, 0xFF, 0xDF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x03,
  0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x80,
  0x0F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0xFC, 0x01, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x07, 0xE0,
  0x0F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xF0, 0x0F,
  0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x67, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x1F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7C,
  0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x1F, 0xFC, 0x03,
  0xEF, 0x80, 0x3E, 0xFC, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x7C, 0xF8, 0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x79, 0xF8,
  0x07, 0xCF, 0x80, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x0F, 0xCF,
  0x81, 0xF1, 0xF0, 0x0F, 0xCF, 0x81, 0xF3, 0xF0, 0x0F, 0x8F, 0x83, 0xE3,
  0xF0, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0x0F, 0x87, 0x87, 0xC3, 0xE0, 0x1F,
  0x87, 0x87, 0xC3, 0xE0, 0x1F, 0x07, 0x87, 0x87, 0xE0, 0x1F, 0x07, 0x8F,
  0x87, 0xE0, 0x1F, 0x07, 0x8F, 0x07, 0xC0, 0x1F, 0x07, 0x9F, 0x07, 0xC0,
  0x3F, 0x07, 0x9F, 0x07, 0xC0, 0x3E, 0x07, 0xFE, 0x0F, 0xC0, 0x3E, 0x07,
  0xFE, 0x0F, 0xC0, 0x3E, 0x07, 0xFC, 0x0F, 0x80, 0x3E, 0x07, 0xFC, 0x0F,
  0x80, 0x7E, 0x07, 0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xF8, 0x1F, 0x80, 0x7C,
  0x07, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0x0F, 0x80, 0x3F, 0xC0, 0x07,
  0xC0, 0x1F, 0xE0, 0x03, 0xE0, 0x0F, 0xF0, 0x03, 0xF0, 0x07, 0xF8, 0x01,
  0xF0, 0x07, 0xFC, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x80,
  0x7E, 0x00, 0xFF, 0xC0, 0x3F, 0x00, 0x7F, 0xE0, 0x1F, 0x00, 0x7D, 0xF0,
  0x0F, 0x80, 0x3E, 0x78, 0x07, 0xC0, 0x1F, 0x3E, 0x07, 0xE0, 0x0F, 0x9F,
  0x03, 0xF0, 0x07, 0xCF, 0x81, 0xF0, 0x07, 0xE7, 0xC0, 0xF8, 0x03, 0xE3,
  0xE0, 0x7C, 0x01, 0xF0, 0xF0, 0x7E, 0x00, 0xF8, 0x7C, 0x3E, 0x00, 0xFC,
  0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x0F, 0x80, 0x3E, 0x0F, 0x87, 0xC0, 0x1F,
  0x07, 0xC7, 0xE0, 0x0F, 0x81, 0xE3, 0xE0, 0x0F, 0xC0, 0xF9, 0xF0, 0x07,
  0xE0, 0x7C, 0xF8, 0x03, 0xE0, 0x3E, 0x7C, 0x01, 0xF0, 0x1F, 0x7E, 0x00,
  0xF8, 0x0F, 0xBE, 0x00, 0xFC, 0x03, 0xDF, 0x00, 0x7C, 0x01, 0xFF, 0x80,
  0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x3F, 0xE0,
  0x0F, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x0F, 0xF8, 0x03, 0xE0, 0x03, 0xFC,
  0x01, 0xF0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x7C, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01,
  0xFE, 0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x01, 0xF0, 0xFC,
  0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xBF, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF3,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00,
  0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x3F,
  0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F,
  0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0x80, 0xFE,
  0x0F, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x3E, 0x0F, 0xF0, 0x1F, 0x81, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0xFC,
  0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0xE0, 0x7E, 0x03,
  0xF0, 0x1F, 0x01, 0xFC, 0x0F, 0xC1, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFE, 0x7F,
  0x80, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x3E,
  0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x3F, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF3, 0xF0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0x7E,
  0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3E, 0x0F, 0xE0, 0x1F,
  0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xF0,
  0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03,
  0xE0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x1F, 0x07, 0xF8, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x07,
  0xC0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x07, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xC0, 0x70, 0x0F, 0xE0, 0x04, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xC0, 0x07, 0xF0, 0x3C, 0x03, 0xF8, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0,
  0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC0, 0x7C,
  0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x1F,
  0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xF0, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x03,
  0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0,
  0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xC0,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x07, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0,
  0x07, 0xE7, 0xE0, 0x03, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x7E, 0x0F,
  0xC0, 0x3E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x80,
  0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xE0,
  0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0x9F, 0x80, 0x07, 0xCF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF7,
  0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x00,
  0x7E, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0xFE, 0x00, 0x7C, 0x7C,
  0x00, 0xFE, 0x00, 0xFC, 0x7C, 0x00, 0xFE, 0x00, 0xFC, 0x7C, 0x01, 0xFE,
  0x00, 0xF8, 0x7C, 0x01, 0xFE, 0x01, 0xF8, 0x7C, 0x03, 0xFE, 0x01, 0xF0,
  0x7C, 0x03, 0xFE, 0x03, 0xF0, 0x7C, 0x03, 0xFE, 0x03, 0xF0, 0x7C, 0x07,
  0xFE, 0x03, 0xE0, 0x7C, 0x07, 0xBE, 0x07, 0xE0, 0x7C, 0x0F, 0xBE, 0x07,
  0xC0, 0x7C, 0x0F, 0xBE, 0x0F, 0xC0, 0x7C, 0x0F, 0x3E, 0x0F, 0xC0, 0x7C,
  0x1F, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x3C, 0x1F, 0x80, 0x7C, 0x1E, 0x3C,
  0x1F, 0x00, 0x7C, 0x3E, 0x3C, 0x3F, 0x00, 0x7C, 0x3C, 0x3C, 0x3F, 0x00,
  0x7C, 0x7C, 0x3C, 0x3E, 0x00, 0x7C, 0x7C, 0x3C, 0x7E, 0x00, 0x7C, 0x78,
  0x3C, 0x7C, 0x00, 0xFC, 0xF8, 0x3C, 0x7C, 0x00, 0xFC, 0xF8, 0x3C, 0xFC,
  0x00, 0xFD, 0xF0, 0x3C, 0xF8, 0x00, 0xFD, 0xF0, 0x3D, 0xF8, 0x00, 0xFD,
  0xE0, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x7F,
  0xF0, 0x00, 0xFB, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0xE0,
  0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3F, 0x1F, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0xFC,
  0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x00,
  0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x1F, 0xBF, 0x00, 0x7C, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0x87, 0xC0,
  0x7E, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xE1, 0xF8,
  0x1F, 0x87, 0xC0, 0x7E, 0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE7, 0xE0, 0x0F,
  0x9F, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x7C, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x7C,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE0, 0xFC, 0xFC, 0x7E, 0x7E, 0x3E, 0x3E, 0x1F, 0x0F, 0x0F, 0x00, 0x7F,
  0x0F, 0x80, 0x7F, 0xC7, 0x80, 0x7F, 0xF7, 0xC0, 0x7F, 0xFB, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0x07, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x1F,
  0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0x83,
  0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF0,
  0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F,
  0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07,
  0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xC7,
  0xFC, 0x07, 0xFF, 0xBE, 0x01, 0xFF, 0x9E, 0x00, 0xFF, 0x8F, 0x00, 0x3F,
  0x87, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF1, 0xF8,
  0x03, 0xF7, 0xFC, 0x03, 0xEF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFE, 0x7F,
  0x07, 0xF8, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x1F,
  0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F,
  0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0x01, 0xF8,
  0x7F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x8F, 0xE0, 0x7B, 0xFF, 0xC0,
  0xFB, 0xFF, 0xC0, 0xF9, 0xFF, 0x80, 0xF0, 0xFE, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFD,
  0xE0, 0x7E, 0x02, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x02, 0x07, 0xF1, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x3F,
  0xE7, 0xC0, 0x0F, 0xFE, 0xF8, 0x03, 0xFF, 0xDF, 0x00, 0xFF, 0x7F, 0xE0,
  0x1F, 0x83, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x07,
  0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F,
  0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C,
  0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xE0,
  0x7F, 0x00, 0x7E, 0x3F, 0xE0, 0x0F, 0xFF, 0x7C, 0x01, 0xFF, 0xCF, 0x00,
  0x1F, 0xF1, 0xE0, 0x01, 0xFC, 0x3C, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0x1F,
  0x83, 0xF0, 0x7C, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xF8,
  0x07, 0xCF, 0xC0, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x7F, 0x3F, 0x0F, 0xF1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x20, 0xFE, 0x07,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x07, 0xFC, 0x78,
  0x01, 0xFF, 0xDF, 0x00, 0x7F, 0xFB, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xF0,
  0x7F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x01,
  0xF0, 0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x1F,
  0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x3F,
  0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x1F, 0xE0,
  0x0F, 0xC7, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFB, 0xE0, 0x03, 0xFE,
  0x7C, 0x00, 0x3F, 0x8F, 0x80, 0x00, 0x83, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x04, 0x00, 0x7E, 0x00, 0xC0, 0x3F, 0x80, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF3, 0xF8, 0x03,
  0xF7, 0xFC, 0x03, 0xEF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07,
  0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x7E, 0x0F,
  0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0xFC, 0x1F,
  0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x3F, 0x01, 0xF8, 0x3F,
  0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7E,
  0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0xFC,
  0x03, 0xE0, 0xFC, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x00, 0x38, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x7E, 0x01, 0xF0,
  0x7E, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x3E,
  0x3F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0x9F, 0x80, 0x07,
  0xDF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xBE, 0x00, 0x1F, 0x9F, 0x80,
  0x1F, 0x8F, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8,
  0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x0F,
  0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0x80,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x00, 0x01, 0xE3, 0xF8, 0x1F, 0x80, 0x3E, 0x7F, 0xC7, 0xFC,
  0x03, 0xEF, 0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0xFF,
  0xEF, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x7E,
  0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x3E,
  0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0xFC, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C,
  0x07, 0xE0, 0xF8, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xFC, 0x07, 0xC1, 0xF8,
  0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0x80, 0xFC,
  0x1F, 0x00, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF0,
  0x0F, 0x83, 0xE0, 0x1F, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x1F, 0x83, 0xE0,
  0x3F, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0x3F, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xE0,
  0x3E, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0xFC, 0x07, 0xC0, 0x7E, 0x0F, 0x80,
  0x7C, 0x07, 0xE0, 0x01, 0xE3, 0xF8, 0x07, 0xCF, 0xF8, 0x0F, 0xBF, 0xF8,
  0x1E, 0xFF, 0xF0, 0x3D, 0xFF, 0xE0, 0xFF, 0x07, 0xC1, 0xFC, 0x0F, 0x83,
  0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7E,
  0x03, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0,
  0x3E, 0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF8, 0x07,
  0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8,
  0x7E, 0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x07,
  0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3F, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xF9,
  0xF8, 0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0x7C,
  0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8,
  0x01, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7C, 0x00, 0xFD, 0xF0, 0x03,
  0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xCF,
  0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xE1, 0xF0, 0x1F, 0x87, 0xE0,
  0xFC, 0x1F, 0xCF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3C, 0x3F, 0x00, 0x0F, 0x9F,
  0xF0, 0x01, 0xF7, 0xFF, 0x00, 0x3E, 0xFF, 0xE0, 0x07, 0xF8, 0xFE, 0x00,
  0xFE, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x03, 0xF0, 0x1F,
  0x00, 0x7E, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x3E,
  0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF0,
  0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x83,
  0xF8, 0x07, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x7F, 0xF0, 0x07,
  0xEF, 0xFC, 0x00, 0xF8, 0xFE, 0x00, 0x1F, 0x06, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x7F, 0xC7,
  0x80, 0x7F, 0xF7, 0xC0, 0x7F, 0xFB, 0xE0, 0x3F, 0xBF, 0xF0, 0x3F, 0x07,
  0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3F, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0,
  0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x07,
  0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xC7, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xBE, 0x00, 0xFF, 0x9F, 0x00, 0x3F, 0x8F, 0x80, 0x02, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE3, 0xF0, 0x3E, 0x7E, 0x03,
  0xEF, 0xE0, 0x3D, 0xFE, 0x03, 0xDF, 0xE0, 0x7F, 0xE4, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0x0F, 0x03, 0xF0, 0x10, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x30, 0x0F,
  0xE1, 0xF1, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xFF, 0x3F, 0xFE, 0xFF, 0xF9,
  0xFF, 0xF3, 0xFF, 0xE0, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF1, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x04, 0x00, 0x07, 0xE0, 0x1F, 0x07,
  0xE0, 0x3F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F,
  0xC0, 0x7E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F,
  0x80, 0x7C, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F,
  0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3F, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x3E,
  0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7C,
  0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0xFC,
  0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xF7, 0xC0, 0x3F, 0xE7, 0xC0, 0x1F, 0xC7, 0x80, 0x06, 0x00, 0x00, 0xFC,
  0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xE7, 0xC0, 0x3E,
  0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0x83, 0xE0,
  0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x01,
  0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0x3E,
  0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0x7C, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0xBE, 0x03, 0xF8, 0x0F, 0xDF, 0x01, 0xFC, 0x07, 0xCF,
  0x80, 0xFE, 0x03, 0xE7, 0xC0, 0xFF, 0x03, 0xE3, 0xE0, 0x7F, 0x81, 0xF1,
  0xF0, 0x7F, 0xC1, 0xF8, 0xF8, 0x3F, 0xE0, 0xF8, 0x7C, 0x1F, 0xF0, 0x7C,
  0x3E, 0x1F, 0xF8, 0x7C, 0x1F, 0x0F, 0x7C, 0x3E, 0x1F, 0x87, 0xBE, 0x3F,
  0x0F, 0xC7, 0xDE, 0x1F, 0x07, 0xC3, 0xCF, 0x0F, 0x83, 0xE3, 0xE7, 0x8F,
  0x81, 0xF1, 0xE3, 0xC7, 0xC0, 0xF8, 0xF1, 0xE3, 0xE0, 0x7C, 0xF8, 0xF3,
  0xE0, 0x3E, 0x78, 0x79, 0xF0, 0x1F, 0x7C, 0x3D, 0xF0, 0x0F, 0xBC, 0x1E,
  0xF8, 0x07, 0xDE, 0x0F, 0x7C, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0,
  0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x1F, 0x80, 0x03,
  0xE3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x01,
  0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x7C, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x1F,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x02, 0x7F, 0xC0, 0x05, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0x40, 0x03, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 15, 43, 14, 0, -42 },
  { 82, 17, 15, 21, 6, -42 },
  { 114, 27, 42, 26, 0, -42 },
  { 256, 25, 48, 24, 0, -45 },
  { 406, 33, 44, 38, 3, -43 },
  { 588, 26, 44, 27, 0, -43 },
  { 731, 8, 15, 12, 6, -42 },
  { 746, 18, 51, 15, 1, -42 },
  { 861, 18, 52, 15, -4, -43 },
  { 978, 20, 21, 22, 5, -45 },
  { 1031, 23, 28, 26, 2, -35 },
  { 1112, 11, 15, 13, -3, -7 },
  { 1133, 14, 6, 16, 1, -19 },
  { 1144, 8, 8, 13, 0, -7 },
  { 1152, 28, 42, 20, -3, -42 },
  { 1299, 23, 44, 24, 1, -43 },
  { 1426, 16, 42, 24, 6, -42 },
  { 1510, 26, 43, 24, -2, -43 },
  { 1650, 25, 44, 24, -1, -43 },
  { 1788, 25, 42, 24, -1, -42 },
  { 1920, 24, 43, 24, 0, -42 },
  { 2049, 24, 44, 24, 1, -43 },
  { 2181, 24, 42, 24, 2, -42 },
  { 2307, 25, 44, 24, 0, -43 },
  { 2445, 24, 44, 24, 0, -43 },
  { 2577, 12, 33, 13, 0, -32 },
  { 2627, 16, 40, 13, -3, -32 },
  { 2707, 23, 26, 26, 2, -34 },
  { 2782, 23, 17, 26, 2, -29 },
  { 2831, 23, 26, 26, 2, -34 },
  { 2906, 19, 44, 18, 1, -43 },
  { 3011, 34, 48, 36, 1, -43 },
  { 3215, 25, 42, 25, -4, -42 },
  { 3347, 27, 42, 26, 0, -42 },
  { 3489, 26, 44, 24, 2, -43 },
  { 3632, 28, 42, 28, 0, -42 },
  { 3779, 25, 42, 22, 0, -42 },
  { 3911, 25, 42, 21, 0, -42 },
  { 4043, 29, 44, 30, 2, -43 },
  { 4203, 31, 42, 29, 0, -42 },
  { 4366, 24, 42, 16, -3, -42 },
  { 4492, 24, 54, 13, -9, -42 },
  { 4654, 30, 42, 25, 0, -42 },
  { 4812, 17, 42, 21, 0, -42 },
  { 4902, 40, 42, 39, 0, -42 },
  { 5112, 33, 42, 31, 0, -42 },
  { 5286, 27, 44, 30, 2, -43 },
  { 5435, 26, 42, 25, 0, -42 },
  { 5572, 27, 53, 30, 2, -43 },
  { 5751, 26, 42, 25, 0, -42 },
  { 5888, 26, 44, 23, -1, -43 },
  { 6031, 22, 42, 21, 4, -42 },
  { 6147, 28, 43, 29, 2, -42 },
  { 6298, 25, 42, 25, 5, -42 },
  { 6430, 40, 42, 39, 4, -42 },
  { 6640, 30, 42, 23, -3, -42 },
  { 6798, 22, 42, 22, 5, -42 },
  { 6914, 26, 42, 21, -2, -42 },
  { 7051, 23, 51, 17, -2, -42 },
  { 7198, 10, 42, 21, 6, -42 },
  { 7251, 23, 51, 17, -4, -42 },
  { 7398, 24, 23, 24, 0, -42 },
  { 7467, 19, 4, 18, -5, 5 },
  { 7477, 8, 9, 16, 9, -45 },
  { 7486, 25, 33, 26, 1, -32 },
  { 7590, 24, 46, 25, 0, -45 },
  { 7728, 20, 33, 20, 1, -32 },
  { 7811, 27, 46, 26, 1, -45 },
  { 7967, 21, 33, 23, 1, -32 },
  { 8054, 28, 59, 14, -7, -45 },
  { 8261, 27, 46, 26, -1, -32 },
  { 8417, 24, 45, 25, 0, -45 },
  { 8552, 14, 44, 12, 0, -44 },
  { 8629, 22, 58, 12, -8, -44 },
  { 8789, 25, 45, 22, 0, -45 },
  { 8930, 15, 45, 12, 0, -45 },
  { 9015, 36, 32, 37, 0, -32 },
  { 9159, 23, 32, 25, 0, -32 },
  { 9251, 22, 33, 25, 1, -32 },
  { 9342, 27, 46, 25, -3, -32 },
  { 9498, 25, 46, 26, 1, -32 },
  { 9642, 20, 32, 17, 0, -32 },
  { 9722, 21, 33, 19, -1, -32 },
  { 9809, 15, 40, 15, 2, -39 },
  { 9884, 24, 33, 25, 1, -32 },
  { 9983, 21, 32, 21, 3, -32 },
  { 10067, 33, 32, 33, 3, -32 },
  { 10199, 27, 32, 21, -3, -32 },
  { 10307, 29, 46, 21, -5, -32 },
  { 10474, 21, 32, 18, -2, -32 },
  { 10558, 22, 51, 20, 1, -42 },
  { 10699, 5, 59, 22, 8, -45 },
  { 10736, 22, 51, 19, -4, -42 },
  { 10877, 23, 8, 26, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC59PT7B_H_
