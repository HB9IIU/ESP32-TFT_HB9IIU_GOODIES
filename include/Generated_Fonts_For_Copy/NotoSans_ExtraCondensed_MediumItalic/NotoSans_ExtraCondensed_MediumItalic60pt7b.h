#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC60PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7C, 0x00, 0x10, 0x00, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xF8,
  0xF8, 0x7E, 0x3E, 0x1F, 0x9F, 0x87, 0xC7, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C,
  0x1F, 0x1F, 0x0F, 0x87, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F,
  0x0F, 0x03, 0xC3, 0xC1, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x7C, 0x1E,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0xF0, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x0F,
  0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0,
  0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3E,
  0x0F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x78, 0x3E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7E, 0x67, 0xC0, 0x7E,
  0x70, 0xC0, 0x3E, 0x38, 0x00, 0x3F, 0x18, 0x00, 0x1F, 0x0C, 0x00, 0x0F,
  0x86, 0x00, 0x07, 0xC7, 0x00, 0x03, 0xF3, 0x80, 0x01, 0xF9, 0x80, 0x00,
  0x7E, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xBF, 0x80, 0x00, 0xCF, 0xC0, 0x00, 0xE7,
  0xE0, 0x00, 0x71, 0xF0, 0x00, 0x30, 0xF8, 0x00, 0x18, 0x7C, 0x00, 0x0C,
  0x3E, 0x10, 0x0E, 0x3F, 0x06, 0x07, 0x1F, 0x03, 0xC3, 0x3F, 0x83, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x7C, 0x01, 0xFE, 0x00, 0x3C, 0x01, 0xFF, 0x80, 0x3E, 0x01, 0xFF,
  0xC0, 0x1E, 0x00, 0xF1, 0xE0, 0x1F, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0x78,
  0x78, 0x0F, 0x80, 0x78, 0x3C, 0x07, 0x80, 0x3C, 0x1E, 0x07, 0xC0, 0x3E,
  0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x83, 0xE0, 0x0F, 0x03, 0xC1, 0xE0, 0x07,
  0x81, 0xE1, 0xF0, 0x03, 0xC1, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0xF0, 0x01,
  0xE0, 0x78, 0x78, 0x00, 0xF0, 0x3C, 0x78, 0x00, 0x78, 0x3E, 0x7C, 0x3F,
  0x3C, 0x1E, 0x3C, 0x3F, 0xDE, 0x0F, 0x3E, 0x3F, 0xFF, 0x0F, 0x1E, 0x3F,
  0xFF, 0x8F, 0x9F, 0x3E, 0x3F, 0xFF, 0x8F, 0x1E, 0x1E, 0xFF, 0xCF, 0x9F,
  0x0F, 0x7F, 0xC7, 0x8F, 0x07, 0x9F, 0x87, 0xC7, 0x83, 0xC0, 0x03, 0xC7,
  0xC1, 0xE0, 0x03, 0xE3, 0xC0, 0xF0, 0x01, 0xE1, 0xE0, 0x78, 0x01, 0xF0,
  0xF0, 0x7C, 0x00, 0xF0, 0xF8, 0x3C, 0x00, 0xF8, 0x78, 0x1E, 0x00, 0x78,
  0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x0F, 0x80, 0x3C, 0x0F, 0x07, 0x80, 0x3C,
  0x07, 0x83, 0xC0, 0x3E, 0x03, 0xC3, 0xE0, 0x1E, 0x01, 0xE1, 0xE0, 0x1F,
  0x00, 0xF1, 0xF0, 0x0F, 0x00, 0x7D, 0xF0, 0x0F, 0x80, 0x3F, 0xF0, 0x07,
  0x80, 0x0F, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xE1,
  0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF0, 0x00,
  0x3E, 0x7C, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xC1, 0xF8, 0x7E, 0xF8, 0x3E, 0x0F, 0x9F, 0x87,
  0xC3, 0xE3, 0xF1, 0xF8, 0xFC, 0x3E, 0x3E, 0x1F, 0x07, 0xEF, 0xC7, 0xE0,
  0xFD, 0xF0, 0xF8, 0x0F, 0xFE, 0x3F, 0x01, 0xFF, 0x87, 0xE0, 0x3F, 0xF0,
  0xF8, 0x03, 0xFC, 0x1F, 0x00, 0x7F, 0x83, 0xE0, 0x0F, 0xE0, 0x7C, 0x01,
  0xFC, 0x0F, 0xC0, 0x7F, 0x81, 0xF8, 0x1F, 0xF8, 0x3F, 0x8F, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x7E, 0x07, 0xFF, 0x0F, 0xC0, 0x7F, 0xC1,
  0xFC, 0x01, 0x80, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E,
  0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF8, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0xC1, 0xE0,
  0x1E, 0x3C, 0x07, 0xF7, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0x81, 0xFF, 0xF0, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFB, 0xE0,
  0x7E, 0x3E, 0x1F, 0xC7, 0xC0, 0xF0, 0xFC, 0x0C, 0x0F, 0x00, 0x81, 0x80,
  0x00, 0x20, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x00, 0x7F, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE0, 0x08, 0x3E, 0x7F, 0x7F,
  0x7F, 0xFE, 0x7E, 0x7C, 0x10, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xF8, 0x1F, 0x03,
  0xE0, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0xFC,
  0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x00,
  0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xE0, 0x0F,
  0xC7, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xF8,
  0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x1F,
  0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xF8,
  0x0F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x0F, 0x87,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F,
  0xFE, 0x7F, 0x7C, 0xFC, 0x7C, 0x78, 0xFC, 0x30, 0xFC, 0x20, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0x07, 0xF0, 0x07, 0x00, 0xFC, 0x00, 0x80, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3C, 0x0F,
  0xE0, 0x04, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x80, 0x07, 0xF0, 0x30, 0x03, 0xF8, 0x0F, 0xC7, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x07,
  0x9F, 0x80, 0x03, 0xE7, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0x7C, 0x00,
  0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xE0, 0xF8,
  0x00, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0x1E, 0x07, 0xE0, 0x0F, 0x01,
  0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C,
  0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC4, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3C, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x08, 0x00, 0xFE, 0x06, 0x00, 0xFE, 0x03, 0xF7,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0xF0, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x0F,
  0x9F, 0xF0, 0x07, 0xDF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81,
  0xFE, 0x0F, 0xC1, 0xFE, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7F, 0x00, 0xF8,
  0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x1F,
  0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0xFC, 0x03,
  0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0xFC, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x7E, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0x7E, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F,
  0x81, 0xF8, 0x07, 0xE1, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0xFD, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC1, 0xF8,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x0F,
  0xC3, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x3F, 0x83, 0xFC, 0x3F, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x3F,
  0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F,
  0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x81, 0xFE,
  0x0F, 0xC3, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0x7C,
  0x07, 0xFE, 0xFC, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0xF1, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x0F,
  0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x0F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0x80, 0x7C, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x60, 0x7F, 0x04, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x07,
  0x00, 0xF0, 0x7C, 0x07, 0xFE, 0x1E, 0x0F, 0x01, 0xFF, 0xC3, 0xC3, 0xE0,
  0x7F, 0xF0, 0x78, 0x78, 0x1F, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE3,
  0xC0, 0xF0, 0xF8, 0x38, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC1,
  0xE3, 0xC1, 0xE0, 0x78, 0x3C, 0x78, 0x3C, 0x1F, 0x07, 0x8F, 0x0F, 0x83,
  0xC0, 0xF1, 0xE1, 0xE0, 0x78, 0x3C, 0x78, 0x3C, 0x0F, 0x07, 0x8F, 0x07,
  0x83, 0xE0, 0xF1, 0xE0, 0xF0, 0x78, 0x1C, 0x3C, 0x3E, 0x0F, 0x07, 0x87,
  0x87, 0x83, 0xE0, 0xF0, 0xF0, 0xF0, 0x7C, 0x3C, 0x1C, 0x1E, 0x1F, 0x87,
  0x87, 0x83, 0xE3, 0xF1, 0xE0, 0xF0, 0x3F, 0xEF, 0xF8, 0x1E, 0x07, 0xF9,
  0xFF, 0x03, 0xC0, 0xFF, 0x3F, 0xC0, 0x78, 0x0F, 0x83, 0xE0, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x10, 0x00, 0x0F, 0xC0, 0x0E, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3D, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF3,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x07,
  0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x0F,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07,
  0xE0, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xF8, 0x3F, 0xC0, 0x3E, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x1F,
  0x80, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x3F, 0x80, 0xFC, 0x0F, 0xE0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0x80, 0x7E, 0x01,
  0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03,
  0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x3F,
  0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xF8, 0x1F, 0x00, 0x7E,
  0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x0F, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xF0, 0x30,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x08, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xC3,
  0xFC, 0x00, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0,
  0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x03, 0xF0,
  0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F,
  0x03, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x7F, 0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0xF8, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01,
  0xF8, 0x1F, 0x00, 0x3F, 0x83, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7F, 0x03,
  0xF0, 0x0F, 0xE0, 0x3E, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0xC0, 0x7E, 0x07,
  0xF8, 0x07, 0xE1, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0x00, 0x7F, 0x80, 0x08, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x07, 0xFF, 0x07, 0xE0, 0x1F, 0xFC, 0x1F, 0x80, 0x7F, 0xF0, 0x7E,
  0x01, 0xFF, 0xC3, 0xF0, 0x0F, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x01,
  0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC,
  0x0F, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01,
  0xFC, 0x01, 0xF8, 0x07, 0xF8, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0,
  0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xF0,
  0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x01,
  0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x3E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x43, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0x80,
  0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7C, 0x3F, 0x80, 0x03, 0xF0, 0xFC, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xBF, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x7C, 0x1F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x80, 0x3F, 0xF0,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xF7, 0xE0, 0x1F, 0x7C, 0x00, 0xFB,
  0xE0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x07, 0xDF, 0x00, 0x7D, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xFC, 0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x01, 0xF3, 0xE0,
  0x1F, 0x3E, 0x00, 0xF8, 0xF0, 0x1F, 0x1F, 0x00, 0x7C, 0x78, 0x0F, 0x9F,
  0x80, 0x7E, 0x3C, 0x0F, 0x8F, 0xC0, 0x3F, 0x1E, 0x07, 0xC7, 0xC0, 0x1F,
  0x0F, 0x83, 0xE3, 0xE0, 0x0F, 0x87, 0xC3, 0xE3, 0xF0, 0x07, 0xC3, 0xE1,
  0xF1, 0xF8, 0x07, 0xE1, 0xF1, 0xF0, 0xFC, 0x03, 0xF0, 0xF8, 0xF8, 0x7C,
  0x01, 0xF0, 0x7C, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x7C, 0x3F, 0x00, 0x7C,
  0x1F, 0x7C, 0x1F, 0x80, 0x7E, 0x0F, 0xBE, 0x0F, 0xC0, 0x3F, 0x07, 0xFE,
  0x07, 0xC0, 0x1F, 0x03, 0xFF, 0x03, 0xE0, 0x0F, 0x81, 0xFF, 0x83, 0xF0,
  0x07, 0xC0, 0xFF, 0x81, 0xF8, 0x07, 0xE0, 0x7F, 0xC0, 0xF8, 0x03, 0xE0,
  0x3F, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x3F,
  0x80, 0x0F, 0xC0, 0x3F, 0xC0, 0x07, 0xE0, 0x1F, 0xE0, 0x03, 0xE0, 0x0F,
  0xF0, 0x01, 0xF0, 0x07, 0xF8, 0x00, 0xF8, 0x03, 0xFE, 0x00, 0xFC, 0x03,
  0xFF, 0x00, 0x7E, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x00,
  0x7F, 0xE0, 0x0F, 0x80, 0x3F, 0xF0, 0x0F, 0xC0, 0x3F, 0x7C, 0x07, 0xE0,
  0x1F, 0x3E, 0x03, 0xE0, 0x0F, 0x9F, 0x01, 0xF0, 0x07, 0xCF, 0x81, 0xF8,
  0x03, 0xE7, 0xC0, 0xFC, 0x03, 0xF3, 0xE0, 0x7E, 0x01, 0xF0, 0xF8, 0x3E,
  0x00, 0xF8, 0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x0F,
  0xC0, 0x3F, 0x0F, 0x87, 0xC0, 0x1F, 0x07, 0xC3, 0xE0, 0x0F, 0x81, 0xF1,
  0xF0, 0x07, 0xC0, 0xF9, 0xF8, 0x07, 0xE0, 0x7C, 0xFC, 0x03, 0xF0, 0x3E,
  0x7C, 0x01, 0xF0, 0x1F, 0x3E, 0x00, 0xF8, 0x0F, 0x9F, 0x00, 0x7C, 0x03,
  0xEF, 0x80, 0x7E, 0x01, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xC0, 0x1F, 0x00,
  0x7F, 0xE0, 0x0F, 0x80, 0x3F, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xE0,
  0x07, 0xF8, 0x03, 0xE0, 0x03, 0xFC, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0xF8,
  0x00, 0xFF, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x3E,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0,
  0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xF8, 0xFF, 0x80, 0x3E,
  0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x07, 0xE0,
  0x0F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x0F, 0xC0,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x0F,
  0xF0, 0x1F, 0x8F, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0,
  0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x3E, 0x0F, 0xF0, 0x0F, 0x81, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0,
  0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F,
  0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0xE0, 0x7E, 0x03, 0xF0,
  0x1F, 0x81, 0xFC, 0x07, 0xC3, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xE3, 0xF0, 0x01, 0xF8,
  0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xC1, 0xF8, 0x01,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xFC,
  0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFC, 0x0F, 0x00, 0x7F, 0x00, 0x40, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x0C, 0x00, 0x7F, 0x01, 0xE0,
  0x1F, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x80,
  0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07,
  0xE0, 0x3E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x80,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x03, 0xF0,
  0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07,
  0xE0, 0x3E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x80,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x03, 0xF0,
  0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07,
  0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7F, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xDF,
  0x80, 0x07, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E,
  0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F,
  0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03,
  0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0x80, 0x07, 0xEF, 0xC0, 0x03,
  0xF7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3D, 0xF0, 0x00,
  0x1E, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xBF, 0x00,
  0x1F, 0x80, 0x0F, 0x9F, 0x80, 0x0F, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xC0,
  0x07, 0xE7, 0xE0, 0x07, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0x03, 0xF1,
  0xF8, 0x03, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x7C, 0x01,
  0xFE, 0x00, 0xFC, 0x3E, 0x00, 0xFF, 0x00, 0x7C, 0x1F, 0x00, 0x7F, 0x80,
  0x7E, 0x0F, 0x80, 0x7F, 0xC0, 0x3E, 0x07, 0xC0, 0x3D, 0xE0, 0x3F, 0x03,
  0xE0, 0x3E, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0xBE, 0x07, 0xC0, 0x3E, 0x07, 0xDF, 0x07,
  0xE0, 0x1F, 0x07, 0xCF, 0x83, 0xF0, 0x0F, 0x83, 0xE7, 0xC1, 0xF0, 0x07,
  0xC1, 0xE3, 0xE1, 0xF8, 0x03, 0xE1, 0xF1, 0xF0, 0xF8, 0x01, 0xF0, 0xF8,
  0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x3E, 0x3E,
  0x00, 0x3E, 0x3C, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x0F, 0x9F, 0x80, 0x0F,
  0x9F, 0x07, 0xCF, 0x80, 0x07, 0xDF, 0x03, 0xEF, 0xC0, 0x07, 0xEF, 0x81,
  0xE7, 0xC0, 0x03, 0xF7, 0xC0, 0xF7, 0xE0, 0x01, 0xFF, 0xC0, 0x7B, 0xF0,
  0x00, 0xFF, 0xE0, 0x3D, 0xF0, 0x00, 0x7D, 0xE0, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF3, 0xE0,
  0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x3F, 0x03,
  0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3E, 0x03, 0xF0, 0xFC,
  0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x3F, 0x00,
  0x3E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0xF8, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x83, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0xC7, 0xC0, 0x3F, 0xF3, 0xE0, 0x3F, 0xFB,
  0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0x80,
  0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xE0,
  0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3E, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1,
  0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xFC,
  0x0F, 0xC1, 0xFC, 0x07, 0xF3, 0xFE, 0x03, 0xFF, 0xDF, 0x00, 0xFF, 0xCF,
  0x80, 0x7F, 0xC7, 0xC0, 0x1F, 0xC3, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x0F, 0xCF, 0xF0, 0x07, 0xEF,
  0xFC, 0x03, 0xEF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x0F, 0xC0, 0xFF,
  0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F,
  0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC1,
  0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0xFC,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xC1, 0xFC, 0x07,
  0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0xC7, 0xF0, 0x1F, 0xFF,
  0xF8, 0x1F, 0x7F, 0xF8, 0x0F, 0x9F, 0xF8, 0x07, 0x87, 0xF0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFC, 0x30, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x04, 0x07, 0xF9, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x7F, 0x9F,
  0x80, 0x0F, 0xFD, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xF0, 0xFF, 0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7E, 0x03,
  0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x7E, 0x00,
  0x7C, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80,
  0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xC0,
  0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0,
  0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF3, 0xFE, 0x00, 0x7F,
  0xFB, 0xE0, 0x03, 0xFF, 0xBE, 0x00, 0x3F, 0xF3, 0xC0, 0x01, 0xFC, 0x3C,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xC3, 0xF0, 0x7E, 0x07,
  0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x7E, 0x03, 0xF1, 0xF0, 0x0F, 0x8F,
  0xC0, 0x7E, 0x3F, 0x01, 0xF0, 0xF8, 0x1F, 0xC7, 0xEF, 0xFE, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x20, 0x7F, 0x03,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0x10, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFC, 0x7C,
  0x00, 0xFF, 0xCF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xF8,
  0x7F, 0x80, 0x7E, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x01,
  0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x1F,
  0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x0F, 0x80, 0x1F,
  0x01, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x0F, 0xF0,
  0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0xFF, 0x80, 0x3F, 0xFD, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xEF, 0xC0, 0x07, 0xF1, 0xF0, 0x00, 0x10, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x80, 0x0F, 0xC0, 0x18,
  0x03, 0xF8, 0x03, 0xF3, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0xF8, 0x01, 0xF3, 0xFC, 0x03, 0xF7, 0xFE, 0x03, 0xEF, 0xFE, 0x03,
  0xFF, 0xFF, 0x03, 0xFC, 0x7F, 0x07, 0xF8, 0x3F, 0x07, 0xF0, 0x3F, 0x07,
  0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F,
  0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7C, 0x1F,
  0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x1F,
  0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3F, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x3E,
  0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7C,
  0x03, 0xF0, 0x7C, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xF8,
  0x07, 0xE0, 0x00, 0x18, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x10, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3E,
  0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xE1,
  0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x0F,
  0xCF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x1E, 0x3F, 0xC3, 0xFE, 0x03,
  0xEF, 0xFE, 0x7F, 0xE0, 0x3E, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xC7, 0xFC, 0x3F, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x7F, 0x03,
  0xF8, 0x1F, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0x07,
  0xC0, 0x3E, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x03,
  0xE0, 0xF8, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0xF8, 0x07,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC0, 0x7C, 0x1F,
  0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0xFC, 0x3F, 0x00, 0xF8, 0x0F,
  0xC3, 0xF0, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0x83, 0xE0, 0x1F,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x01, 0xF8, 0x7E,
  0x03, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x1F,
  0x07, 0xC0, 0x3E, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xE3,
  0xFC, 0x03, 0xE7, 0xFE, 0x03, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFC,
  0x7F, 0x07, 0xF8, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x3F, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0,
  0x7E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x80,
  0x7C, 0x1F, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x3F, 0x00,
  0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x7E, 0x01,
  0xF0, 0x7E, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03,
  0xE0, 0xFC, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x3E, 0x0F, 0x80, 0x7E,
  0x3F, 0x00, 0xFC, 0x7C, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7,
  0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xF8,
  0x01, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0x9F, 0x80,
  0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xF8, 0x0F,
  0xC1, 0xF0, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xF3, 0xFC, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x03, 0xC7, 0xF8, 0x00, 0x7C, 0xFF, 0xC0, 0x07,
  0xDF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xF8, 0x7E, 0x00, 0x7F, 0x03,
  0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0,
  0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE,
  0x07, 0xE0, 0x0F, 0xF9, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xBF, 0xF8,
  0x01, 0xFB, 0xFF, 0x00, 0x1F, 0x1F, 0xE0, 0x01, 0xF0, 0x20, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0xC7, 0xC0, 0x3F, 0xF3, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE1, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x7E,
  0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07,
  0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xC1, 0xF8, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x0F, 0xC1, 0xFC,
  0x07, 0xF3, 0xFE, 0x03, 0xFF, 0xDF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xEF,
  0xC0, 0x1F, 0xC7, 0xC0, 0x01, 0x83, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x1E, 0x3F, 0x03, 0xE7, 0xF0, 0x3E, 0xFE, 0x03, 0xFF,
  0xE0, 0x3D, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0x81, 0xC0, 0x7C, 0x01, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x30, 0x0F, 0xE0, 0xF8, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xFE, 0x7F, 0xFD, 0xFF, 0xF3, 0xFF, 0xE0, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xE2, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0,
  0x08, 0x00, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x07,
  0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F,
  0x80, 0x7E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F,
  0x80, 0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3F,
  0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x7E,
  0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7C,
  0x07, 0xE0, 0x7C, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0xE0, 0x7E,
  0x3F, 0xE0, 0x7F, 0xFB, 0xC0, 0x7F, 0xF7, 0xC0, 0x3F, 0xE7, 0xC0, 0x1F,
  0xC7, 0xC0, 0x02, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xF8, 0x0F, 0x8F, 0x81,
  0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xE0, 0xF8,
  0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F,
  0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0xBF, 0x00, 0xFB, 0xE0, 0x0F, 0xBE, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xDF, 0x01, 0xFC, 0x03, 0xE7, 0xC0, 0x7F,
  0x01, 0xF9, 0xF0, 0x1F, 0xC0, 0x7C, 0x7C, 0x0F, 0xF0, 0x3F, 0x1F, 0x03,
  0xFC, 0x0F, 0x87, 0xC0, 0xFF, 0x03, 0xE1, 0xF0, 0x7B, 0xC1, 0xF8, 0x7C,
  0x1E, 0xF0, 0x7C, 0x1F, 0x0F, 0xFC, 0x1F, 0x07, 0xC3, 0xDF, 0x0F, 0x81,
  0xF0, 0xF7, 0xC3, 0xE0, 0x7C, 0x7D, 0xF1, 0xF8, 0x1F, 0x1E, 0x7C, 0x7C,
  0x0F, 0xCF, 0x9F, 0x1F, 0x03, 0xF3, 0xE7, 0xCF, 0x80, 0xFC, 0xF1, 0xF3,
  0xE0, 0x3E, 0x7C, 0x7C, 0xF8, 0x0F, 0x9E, 0x1F, 0x7C, 0x03, 0xE7, 0x87,
  0xDF, 0x00, 0xFB, 0xE1, 0xEF, 0x80, 0x3E, 0xF0, 0x7B, 0xE0, 0x0F, 0xFC,
  0x1E, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0x80,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x01, 0xF8,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x7E, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x80,
  0x7C, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x7C, 0x03, 0xF0,
  0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x7C, 0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x02,
  0x7F, 0xE0, 0x05, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x40, 0x00, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 16, 44, 14, 0, -43 },
  { 89, 18, 16, 21, 6, -43 },
  { 125, 28, 43, 26, 0, -43 },
  { 276, 25, 49, 24, 0, -46 },
  { 430, 33, 44, 38, 3, -43 },
  { 612, 27, 44, 27, 0, -43 },
  { 761, 8, 16, 12, 6, -43 },
  { 777, 19, 52, 16, 1, -43 },
  { 901, 18, 52, 16, -4, -43 },
  { 1018, 19, 22, 23, 6, -46 },
  { 1071, 23, 28, 26, 2, -35 },
  { 1152, 11, 15, 13, -3, -7 },
  { 1173, 14, 6, 16, 1, -19 },
  { 1184, 8, 9, 13, 0, -8 },
  { 1193, 28, 43, 21, -3, -43 },
  { 1344, 23, 44, 24, 1, -43 },
  { 1471, 16, 43, 24, 6, -43 },
  { 1557, 26, 43, 24, -2, -43 },
  { 1697, 26, 44, 24, -1, -43 },
  { 1840, 26, 43, 24, -1, -43 },
  { 1980, 25, 44, 24, 0, -43 },
  { 2118, 25, 44, 24, 1, -43 },
  { 2256, 25, 43, 24, 2, -43 },
  { 2391, 25, 44, 24, 0, -43 },
  { 2529, 24, 44, 24, 0, -43 },
  { 2661, 13, 34, 13, 0, -33 },
  { 2717, 16, 41, 13, -3, -33 },
  { 2799, 23, 27, 26, 2, -35 },
  { 2877, 23, 18, 26, 2, -30 },
  { 2929, 23, 27, 26, 2, -35 },
  { 3007, 20, 44, 18, 1, -43 },
  { 3117, 35, 48, 36, 1, -43 },
  { 3327, 26, 43, 25, -4, -43 },
  { 3467, 27, 43, 27, 0, -43 },
  { 3613, 26, 45, 24, 2, -44 },
  { 3760, 28, 43, 29, 0, -43 },
  { 3911, 25, 43, 23, 0, -43 },
  { 4046, 25, 43, 21, 0, -43 },
  { 4181, 30, 45, 30, 2, -44 },
  { 4350, 31, 43, 30, 0, -43 },
  { 4517, 24, 43, 17, -3, -43 },
  { 4646, 24, 55, 13, -9, -43 },
  { 4811, 30, 43, 25, 0, -43 },
  { 4973, 17, 43, 21, 0, -43 },
  { 5065, 41, 43, 40, 0, -43 },
  { 5286, 33, 43, 32, 0, -43 },
  { 5464, 28, 44, 31, 2, -43 },
  { 5618, 27, 43, 25, 0, -43 },
  { 5764, 28, 53, 31, 2, -43 },
  { 5950, 26, 43, 26, 0, -43 },
  { 6090, 27, 44, 23, -1, -43 },
  { 6239, 22, 43, 22, 4, -43 },
  { 6358, 29, 44, 29, 2, -43 },
  { 6518, 25, 43, 25, 5, -43 },
  { 6653, 41, 43, 40, 4, -43 },
  { 6874, 32, 43, 23, -4, -43 },
  { 7046, 23, 43, 23, 5, -43 },
  { 7170, 27, 43, 21, -2, -43 },
  { 7316, 23, 53, 17, -2, -43 },
  { 7469, 11, 43, 21, 6, -43 },
  { 7529, 23, 53, 17, -4, -43 },
  { 7682, 24, 24, 25, 0, -43 },
  { 7754, 19, 4, 19, -5, 5 },
  { 7764, 9, 10, 16, 9, -46 },
  { 7776, 25, 34, 26, 1, -33 },
  { 7883, 25, 47, 26, 0, -46 },
  { 8030, 21, 34, 20, 1, -33 },
  { 8120, 28, 47, 26, 1, -46 },
  { 8285, 22, 34, 24, 1, -33 },
  { 8379, 29, 60, 15, -7, -46 },
  { 8597, 27, 47, 26, -1, -33 },
  { 8756, 24, 46, 26, 0, -46 },
  { 8894, 15, 45, 12, 0, -45 },
  { 8979, 23, 59, 12, -8, -45 },
  { 9149, 26, 46, 23, 0, -46 },
  { 9299, 15, 46, 12, 0, -46 },
  { 9386, 36, 33, 38, 0, -33 },
  { 9535, 24, 33, 26, 0, -33 },
  { 9634, 23, 34, 25, 1, -33 },
  { 9732, 28, 47, 26, -3, -33 },
  { 9897, 25, 47, 26, 1, -33 },
  { 10044, 20, 33, 17, 0, -33 },
  { 10127, 22, 34, 20, -1, -33 },
  { 10221, 15, 41, 15, 2, -40 },
  { 10298, 24, 33, 26, 1, -32 },
  { 10397, 20, 32, 21, 4, -32 },
  { 10477, 34, 32, 34, 3, -32 },
  { 10613, 27, 32, 22, -3, -32 },
  { 10721, 30, 46, 21, -5, -32 },
  { 10894, 22, 32, 18, -2, -32 },
  { 10982, 23, 52, 20, 1, -43 },
  { 11132, 5, 60, 22, 8, -46 },
  { 11170, 22, 52, 20, -4, -43 },
  { 11313, 23, 8, 26, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC60PT7B_H_
