#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC48PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xC0, 0x00, 0x7C, 0x7D, 0xF1,
  0xF7, 0xC7, 0x9E, 0x1E, 0x78, 0x79, 0xE3, 0xE7, 0x8F, 0x3C, 0x3C, 0xF0,
  0xF3, 0xC3, 0x8F, 0x0E, 0x38, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xE0,
  0x03, 0xC3, 0x80, 0x0E, 0x1E, 0x00, 0x38, 0x70, 0x01, 0xE1, 0xC0, 0x07,
  0x0F, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x07, 0x0E, 0x00, 0x3C, 0x38, 0x00,
  0xE1, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xC3,
  0xC0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0x1E, 0x1C, 0x00, 0x70, 0xF0, 0x01, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x38,
  0x78, 0x00, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0xF0,
  0x03, 0xC3, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7E, 0xDE,
  0x07, 0x88, 0x40, 0xF9, 0x80, 0x0F, 0x18, 0x00, 0xF1, 0x80, 0x0F, 0x18,
  0x00, 0xFB, 0x00, 0x0F, 0xB0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x6F, 0x80, 0x0C, 0xF8, 0x00, 0xC7, 0x80, 0x0C, 0x78, 0x00, 0xC7, 0x88,
  0x08, 0xF0, 0x41, 0x8F, 0x0F, 0x9B, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0x7F, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFE, 0x01,
  0xE0, 0x3F, 0xC0, 0x38, 0x07, 0xFC, 0x0F, 0x01, 0xE7, 0x81, 0xC0, 0x38,
  0xF0, 0x78, 0x0F, 0x1E, 0x0E, 0x01, 0xC3, 0xC3, 0xC0, 0x78, 0x78, 0x70,
  0x0F, 0x0F, 0x1E, 0x01, 0xC1, 0xC3, 0x80, 0x38, 0x38, 0xF0, 0x07, 0x0F,
  0x1C, 0x01, 0xE1, 0xE7, 0x80, 0x3C, 0x38, 0xE1, 0xE7, 0x8F, 0x3C, 0xFE,
  0xF1, 0xE7, 0x3F, 0xFE, 0x79, 0xE7, 0x3D, 0xFE, 0x39, 0xE3, 0xBF, 0xCF,
  0x38, 0x73, 0xF3, 0xCF, 0x0E, 0x38, 0x79, 0xC1, 0xC0, 0x1E, 0x38, 0x78,
  0x03, 0x8F, 0x0F, 0x00, 0xF1, 0xE1, 0xE0, 0x1C, 0x38, 0x38, 0x07, 0x87,
  0x07, 0x00, 0xE0, 0xE1, 0xE0, 0x3C, 0x1C, 0x38, 0x07, 0x03, 0x87, 0x01,
  0xE0, 0x71, 0xE0, 0x38, 0x0E, 0x78, 0x0F, 0x01, 0xFF, 0x01, 0xC0, 0x3F,
  0xC0, 0x78, 0x03, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x00,
  0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0x8F,
  0x00, 0x3C, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x1E, 0x3F, 0xF0, 0xF1, 0xE7, 0x8F,
  0x9E, 0x3E, 0x79, 0xF1, 0xF3, 0xCF, 0x07, 0xBC, 0xF8, 0x3F, 0xE7, 0xC1,
  0xFE, 0x3C, 0x07, 0xF1, 0xE0, 0x3F, 0x0F, 0x01, 0xF8, 0x78, 0x0F, 0xC3,
  0xE0, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xF7, 0xC3, 0xFF, 0x3E, 0x0F, 0xF0,
  0xF8, 0x3E, 0x79, 0xF3, 0xE7, 0x8F, 0x1E, 0x3C, 0xF1, 0xE3, 0xC7, 0x00,
  0x00, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x21, 0xE0, 0x79, 0xC0, 0x7F, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0x03, 0xFF,
  0x07, 0xE0, 0x0F, 0xE0, 0x1E, 0xF0, 0x7E, 0x70, 0x3C, 0x78, 0x18, 0x7C,
  0x08, 0x30, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0,
  0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE0,
  0x39, 0xF7, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF,
  0x03, 0xF7, 0xC1, 0xF0, 0xF0, 0x78, 0x3C, 0x3E, 0x0F, 0x0F, 0x03, 0xC7,
  0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x80, 0xF3, 0xC0,
  0x7C, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3E,
  0x78, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xF3, 0xE0, 0x7C, 0xF0, 0x1F, 0x3C,
  0x07, 0x8F, 0x03, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1E, 0x0F, 0x8F,
  0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0xF8,
  0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFF, 0x1F, 0xF9, 0xFF, 0x9F, 0x3C, 0xF1,
  0xE3, 0x1F, 0x10, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0x9F, 0x80, 0x70, 0x7C, 0x02, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xE0, 0x1E, 0x3F, 0x00, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x83, 0x00, 0xFC, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1D, 0xE0, 0x01, 0xEF,
  0x00, 0x0E, 0xF8, 0x00, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x71, 0xE0, 0x07,
  0x9F, 0x00, 0x78, 0xF8, 0x03, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xC1, 0xE0,
  0x1C, 0x1F, 0x01, 0xE0, 0xF8, 0x0E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x01,
  0xE0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x80, 0x3E, 0x08, 0x07, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFC, 0x20, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE3, 0xC0, 0x3C, 0xFE, 0x03, 0xDF, 0xF0, 0x3F,
  0xFF, 0x07, 0xF1, 0xF8, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87,
  0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x0F, 0x80, 0xF0,
  0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x83, 0xE0, 0x78, 0x7C,
  0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xE3, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0xF8,
  0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0xF8, 0x3E, 0x07,
  0x83, 0xC0, 0x7C, 0x7C, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFB, 0xE0, 0x1F, 0x1F, 0x03, 0xE1, 0xF0,
  0x7C, 0x0F, 0x87, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x00, 0x78, 0xF0, 0x0F,
  0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x80, 0xF0, 0xF8, 0x1F, 0x0F, 0xE7,
  0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3E, 0x7E, 0x0F, 0x87, 0xC3,
  0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0x01, 0xE3, 0xE0, 0x3C, 0x7C, 0x07, 0x8F,
  0x00, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x3F, 0x1E,
  0x07, 0xE3, 0xE1, 0xF8, 0x7E, 0xFF, 0x0F, 0xFD, 0xE0, 0xFF, 0x7C, 0x0F,
  0xCF, 0x00, 0x41, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x07, 0xBF,
  0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x03, 0x81, 0xF0,
  0x7C, 0x3F, 0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x1F,
  0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x38, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x0F, 0xC0, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x01, 0xE0,
  0x07, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1E, 0x3E, 0x08, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0F, 0x03, 0xF8, 0xF0, 0xE0,
  0xFF, 0x8F, 0x1E, 0x1F, 0xF8, 0xF1, 0xC3, 0xC7, 0x8E, 0x3C, 0x38, 0x70,
  0xE3, 0x87, 0x87, 0x0E, 0x38, 0x70, 0xF0, 0xE7, 0x87, 0x0F, 0x0E, 0x70,
  0xF0, 0xE0, 0xE7, 0x0E, 0x0E, 0x1C, 0x70, 0xE1, 0xE1, 0xC7, 0x1E, 0x1E,
  0x1C, 0xF1, 0xE1, 0xC3, 0x8F, 0x1E, 0x3C, 0x38, 0xE1, 0xE3, 0xC3, 0x8E,
  0x1E, 0x7C, 0x70, 0xE1, 0xEE, 0xEE, 0x0E, 0x0F, 0xCF, 0xE0, 0xE0, 0xF8,
  0xFC, 0x0E, 0x01, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x80, 0x03, 0xE0,
  0x38, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0,
  0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x00, 0x78, 0xF0, 0x0F, 0x8F,
  0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x0F, 0x03, 0xE0,
  0xF0, 0x3E, 0x0F, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0x80, 0xF1, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x3E,
  0x00, 0xF3, 0xE0, 0x0F, 0x7C, 0x00, 0xF7, 0xC0, 0x0F, 0x78, 0x00, 0xFF,
  0x80, 0x0F, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF,
  0xFE, 0x03, 0xE0, 0xF8, 0x0F, 0x01, 0xF0, 0x3C, 0x07, 0xC0, 0xF0, 0x1F,
  0x07, 0xC0, 0x78, 0x1F, 0x01, 0xE0, 0x78, 0x0F, 0x81, 0xE0, 0x3E, 0x0F,
  0x81, 0xF0, 0x3E, 0x0F, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xFE, 0x01, 0xF0, 0xFC, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xE0,
  0x78, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3C, 0x03, 0xE0, 0xF0,
  0x0F, 0x83, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x7E,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xCE, 0x03, 0xF0, 0x10, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x10, 0x0F, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xE1, 0xF8, 0x0F, 0x83,
  0xF0, 0x3C, 0x07, 0xC0, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0xF0,
  0x7C, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8,
  0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07,
  0x87, 0xC0, 0x3E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xE3, 0xE0, 0x1F, 0x0F,
  0x80, 0x7C, 0x3E, 0x03, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x7C, 0x1F, 0x03,
  0xF0, 0x7C, 0x1F, 0x81, 0xF1, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xCF, 0xC0, 0x7E,
  0x01, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x09, 0xF0, 0x1F, 0xE3,
  0xE0, 0x3F, 0xC7, 0xC0, 0xFF, 0x8F, 0x81, 0xFF, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0,
  0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1F, 0x80, 0xF8, 0x1F, 0x81,
  0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0x7C,
  0x01, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x07,
  0x80, 0x3C, 0x07, 0xC0, 0x1E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x7C, 0x01, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x1F, 0x01, 0xE0, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0xF8, 0x03,
  0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x0F, 0x00,
  0x78, 0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xE0,
  0x0F, 0x81, 0xF0, 0x07, 0x80, 0xF8, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E,
  0x01, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE1, 0xF0,
  0x03, 0xC1, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0xC7, 0xC0, 0x07, 0xC7, 0xC0,
  0x07, 0x8F, 0x80, 0x07, 0x9F, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xBE, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xBC, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1F, 0x00,
  0x3C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x0F, 0x00,
  0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07,
  0xF8, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x03,
  0xDE, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xEF, 0x00, 0xFF, 0x80, 0xF7, 0x80,
  0xF7, 0x80, 0xFB, 0xC0, 0x7B, 0xC0, 0x7D, 0xE0, 0x79, 0xE0, 0x3C, 0xF0,
  0x3D, 0xF0, 0x1E, 0x78, 0x3C, 0xF8, 0x0F, 0x3C, 0x1E, 0x78, 0x0F, 0x9E,
  0x1E, 0x3C, 0x07, 0xCF, 0x0F, 0x1E, 0x03, 0xC7, 0x87, 0x9F, 0x01, 0xE3,
  0xC7, 0x8F, 0x80, 0xF1, 0xE3, 0xC7, 0x80, 0xF8, 0xF3, 0xC3, 0xC0, 0x78,
  0x79, 0xE3, 0xE0, 0x3C, 0x3D, 0xE1, 0xF0, 0x1E, 0x1E, 0xF0, 0xF0, 0x0F,
  0x0F, 0xF0, 0x78, 0x0F, 0x87, 0xF8, 0x3C, 0x07, 0x81, 0xF8, 0x3E, 0x03,
  0xC0, 0xFC, 0x1F, 0x01, 0xE0, 0x7E, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0x80,
  0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x03,
  0xE0, 0x3F, 0x00, 0x78, 0x07, 0xE0, 0x0F, 0x01, 0xFC, 0x03, 0xE0, 0x3F,
  0x80, 0x7C, 0x07, 0xF0, 0x0F, 0x00, 0xFF, 0x01, 0xE0, 0x1F, 0xE0, 0x3C,
  0x07, 0xBC, 0x0F, 0x80, 0xF7, 0x81, 0xE0, 0x1E, 0xF0, 0x3C, 0x03, 0xDE,
  0x07, 0x80, 0xF9, 0xE1, 0xF0, 0x1F, 0x3C, 0x3E, 0x03, 0xC7, 0x87, 0x80,
  0x78, 0xF0, 0xF0, 0x0F, 0x1E, 0x1E, 0x03, 0xE3, 0xC7, 0xC0, 0x7C, 0x3C,
  0xF8, 0x0F, 0x07, 0x9E, 0x01, 0xE0, 0xF3, 0xC0, 0x3C, 0x1E, 0x78, 0x0F,
  0x83, 0xDF, 0x01, 0xE0, 0x7B, 0xE0, 0x3C, 0x07, 0xF8, 0x07, 0x80, 0xFF,
  0x00, 0xF0, 0x1F, 0xE0, 0x3E, 0x03, 0xFC, 0x07, 0x80, 0x7F, 0x00, 0xF0,
  0x0F, 0xE0, 0x1E, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x03, 0xF0,
  0x1E, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x7F, 0xFC, 0x03, 0xFB, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x07, 0xC3,
  0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80,
  0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F,
  0x7C, 0x00, 0x7B, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8,
  0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF0, 0x03,
  0xE3, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0x83,
  0xE0, 0x3E, 0x0F, 0xC3, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xE0,
  0x78, 0x0F, 0x07, 0xC0, 0x78, 0x3E, 0x03, 0xC1, 0xF0, 0x3E, 0x0F, 0x01,
  0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xE0, 0x7C, 0x0F,
  0x0F, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFB,
  0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C,
  0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7D, 0xF0,
  0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7B, 0xE0, 0x03,
  0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xCF,
  0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x8F, 0x80,
  0x3E, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0xC3, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x3E, 0x1F, 0x81,
  0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07,
  0xC1, 0xE0, 0x3E, 0x0F, 0x01, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E,
  0x0F, 0x81, 0xE0, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x80,
  0x3F, 0xF8, 0x01, 0xE3, 0xC0, 0x0F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7,
  0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0xC0, 0xF8, 0x3E, 0x07,
  0xC1, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x1F, 0x01, 0xF0, 0xF8, 0x0F,
  0x87, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xFE,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xF8, 0x18, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x40, 0x0F, 0x83, 0x80,
  0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x78, 0x3E,
  0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xE0, 0x0F, 0x03, 0xC0,
  0x1E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x78, 0x03,
  0xC0, 0xF0, 0x07, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x78,
  0x1E, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83,
  0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x1F, 0x03, 0xC0, 0x3E, 0x07, 0x80,
  0x78, 0x0F, 0x81, 0xF0, 0x1F, 0x07, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1E,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07,
  0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8,
  0x78, 0x0F, 0x8F, 0x80, 0xF8, 0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xE0, 0x0F,
  0xBE, 0x00, 0xFB, 0xE0, 0x0F, 0xBC, 0x00, 0xF7, 0xC0, 0x0F, 0x78, 0x00,
  0xF7, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0xBE, 0x01, 0xF0, 0x07, 0x9F, 0x00, 0xF8, 0x07, 0xCF, 0x00, 0x7C, 0x03,
  0xC7, 0x80, 0x7E, 0x03, 0xE3, 0xC0, 0x3F, 0x01, 0xF1, 0xE0, 0x3F, 0x80,
  0xF0, 0xF0, 0x1F, 0xC0, 0xF8, 0x78, 0x0F, 0xE0, 0x78, 0x3C, 0x0F, 0xF0,
  0x3C, 0x1E, 0x07, 0xF8, 0x3E, 0x0F, 0x07, 0xBC, 0x1E, 0x07, 0x83, 0xDE,
  0x1F, 0x03, 0xC1, 0xCF, 0x0F, 0x81, 0xE1, 0xE7, 0x87, 0x80, 0xF0, 0xF3,
  0xC7, 0xC0, 0x78, 0xF1, 0xC3, 0xC0, 0x3C, 0x78, 0xE3, 0xE0, 0x1E, 0x3C,
  0x71, 0xF0, 0x0F, 0x3C, 0x38, 0xF0, 0x07, 0x9E, 0x1C, 0xF8, 0x03, 0xCE,
  0x0E, 0x78, 0x01, 0xEF, 0x07, 0x3C, 0x00, 0xF7, 0x87, 0xBE, 0x00, 0x7F,
  0x83, 0xDE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x03,
  0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0x80,
  0x1E, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xE0,
  0x01, 0xF1, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x1E, 0xF8,
  0x00, 0x0F, 0x78, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xC7, 0x80, 0x03,
  0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x78, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x7C, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0xF9, 0xE0,
  0x3C, 0x78, 0x1F, 0x1E, 0x07, 0x87, 0x83, 0xE1, 0xE0, 0xF0, 0x78, 0x7C,
  0x1F, 0x1E, 0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x3D, 0xE0, 0x0F, 0x78, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3C, 0x78, 0x07, 0x87, 0x80, 0x78,
  0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x3C, 0x1E, 0x03, 0xC3, 0xC0, 0x1E, 0x3C,
  0x01, 0xE7, 0x80, 0x1E, 0xF8, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF9, 0xF1, 0xF3, 0xE3, 0xC3, 0xC7, 0x87, 0x01, 0xF8, 0xF0, 0x3F,
  0xCF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x87, 0xE1, 0xF0, 0x7E, 0x1F,
  0x03, 0xE3, 0xE0, 0x3C, 0x3E, 0x03, 0xC3, 0xC0, 0x7C, 0x7C, 0x07, 0xC7,
  0xC0, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF8,
  0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3F,
  0x0F, 0x87, 0xE0, 0xFD, 0xFE, 0x07, 0xFD, 0xE0, 0x7F, 0x9E, 0x03, 0xF1,
  0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xCF, 0x80, 0x7B, 0xFC, 0x07, 0xBF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xE1, 0xE0, 0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x01,
  0xF1, 0xF0, 0x1F, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE3, 0xE0,
  0x3E, 0x3E, 0x03, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x7C, 0x7C,
  0x07, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xE1, 0xF0, 0x7F, 0x3E, 0x0F,
  0x7F, 0xE0, 0xF7, 0xFC, 0x0F, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x0F, 0xFE, 0x0F, 0x82, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x10, 0x7E, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x1F, 0x9F, 0x00, 0xFF, 0x7C, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xF8, 0x7E, 0x07, 0xC1, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x0F,
  0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1E, 0x07,
  0x80, 0x78, 0x1E, 0x01, 0xE0, 0xF8, 0x07, 0x83, 0xE0, 0x3E, 0x0F, 0x80,
  0xF0, 0x3E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0,
  0x3E, 0x1F, 0x80, 0xFC, 0xFE, 0x01, 0xFF, 0x78, 0x07, 0xF9, 0xE0, 0x0F,
  0xC7, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xF9, 0xF0, 0xF0,
  0x78, 0xF8, 0x3C, 0x78, 0x1E, 0x7C, 0x0F, 0x3C, 0x0F, 0xBE, 0x07, 0x9F,
  0x0F, 0xCF, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x21, 0xF0, 0x60, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7E,
  0x40, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x09, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7E, 0x3C, 0x03, 0xFC,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xE1, 0xF8, 0x1F, 0x07, 0xE0,
  0x7C, 0x0F, 0x83, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0xC1, 0xF0,
  0x1F, 0x07, 0xC0, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x83, 0xE0, 0x3E,
  0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x7E, 0x03, 0xF7, 0xF8, 0x07, 0xFD,
  0xE0, 0x1F, 0xEF, 0x80, 0x3F, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x80,
  0x7C, 0x03, 0xC7, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x10, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x7E, 0x03, 0xDF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC3, 0xF0, 0xF8, 0x7E, 0x0F, 0x0F, 0x81, 0xE1, 0xF0, 0x7C, 0x3C,
  0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x81, 0xF0, 0xF0,
  0x3E, 0x3E, 0x07, 0x87, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0xC7, 0xC0,
  0xF8, 0xF8, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x1F, 0x1F, 0x03,
  0xE3, 0xE0, 0x78, 0x78, 0x0F, 0x00, 0x00, 0xC0, 0x1F, 0x01, 0xF0, 0x3F,
  0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00,
  0x00, 0x03, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x02, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0x78, 0x7C, 0x0F,
  0x8F, 0x80, 0xF8, 0xF0, 0x0F, 0x1F, 0x00, 0xF3, 0xE0, 0x0F, 0x3C, 0x01,
  0xF7, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xF7, 0x80, 0x3E, 0x7C, 0x03, 0xC7, 0xC0, 0x7C, 0x7C,
  0x07, 0xC3, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xE0, 0x78, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x1E, 0x0F, 0x01, 0xE0, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00,
  0x07, 0x9F, 0x87, 0xE0, 0x3D, 0xFE, 0x7F, 0x81, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFC, 0x3F, 0x0F, 0x87, 0xC1, 0xF8, 0x3C, 0x3E, 0x0F,
  0x83, 0xE1, 0xE0, 0x7C, 0x1F, 0x0F, 0x03, 0xC0, 0xF8, 0xF8, 0x1E, 0x07,
  0x87, 0xC0, 0xF0, 0x3C, 0x3C, 0x0F, 0x81, 0xE1, 0xE0, 0x7C, 0x1F, 0x0F,
  0x03, 0xC0, 0xF0, 0xF8, 0x1E, 0x07, 0x87, 0x80, 0xF0, 0x3C, 0x3C, 0x0F,
  0x81, 0xE1, 0xE0, 0x78, 0x1F, 0x1F, 0x03, 0xC0, 0xF0, 0xF8, 0x1E, 0x07,
  0x87, 0x81, 0xF0, 0x3C, 0x3C, 0x0F, 0x83, 0xE1, 0xE0, 0x78, 0x1F, 0x1F,
  0x03, 0xC0, 0xF0, 0xF8, 0x1E, 0x07, 0x87, 0x81, 0xF0, 0x7C, 0x00, 0x07,
  0x9F, 0x80, 0xF7, 0xF8, 0x1F, 0xFF, 0x83, 0xBF, 0xF0, 0xFC, 0x3E, 0x1F,
  0x83, 0xC3, 0xE0, 0x78, 0x7C, 0x1F, 0x0F, 0x03, 0xE3, 0xE0, 0x78, 0x7C,
  0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x7C, 0x3C, 0x0F, 0x8F, 0x81, 0xE1, 0xF0,
  0x3C, 0x3C, 0x07, 0x87, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0x87, 0x80,
  0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1E, 0x1E, 0x03,
  0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0x87,
  0xC7, 0xC1, 0xF1, 0xE0, 0x7C, 0xF8, 0x1F, 0x3C, 0x07, 0xDF, 0x01, 0xF7,
  0xC0, 0x7D, 0xE0, 0x1F, 0x78, 0x07, 0xDE, 0x01, 0xEF, 0x80, 0x7B, 0xE0,
  0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3E,
  0x3E, 0x1F, 0x87, 0xEF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00,
  0x01, 0xE3, 0xE0, 0x07, 0xBF, 0xC0, 0x1E, 0xFF, 0x80, 0x7F, 0x7E, 0x03,
  0xF8, 0x7C, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0,
  0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78,
  0x1E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C,
  0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x1F,
  0x01, 0xFD, 0xF8, 0x0F, 0xFF, 0xE0, 0x3E, 0xFF, 0x00, 0xF3, 0xF8, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0xF0, 0x3F, 0xCF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x87, 0xE1, 0xF0, 0x7E, 0x1E, 0x03, 0xC3,
  0xE0, 0x3C, 0x3E, 0x07, 0xC3, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x78,
  0x78, 0x07, 0x87, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0xF8, 0xF8, 0x0F,
  0x0F, 0x80, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0x87,
  0xE0, 0xFC, 0xFE, 0x07, 0xFD, 0xE0, 0x7F, 0xBE, 0x03, 0xF3, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x9F, 0x07, 0xBF, 0x07, 0xFE, 0x07, 0x7E, 0x0F,
  0xF2, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0x0F,
  0xFF, 0x1F, 0x9E, 0x1F, 0x02, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x80, 0xF8, 0xF7, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x3F, 0xE7, 0xFE,
  0x3F, 0xF3, 0xFF, 0x83, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xD0, 0x7F, 0x81,
  0xFC, 0x0F, 0xE0, 0x0F, 0x81, 0xE1, 0xE0, 0x3C, 0x3C, 0x0F, 0x87, 0x81,
  0xF1, 0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x3E, 0x1E, 0x07,
  0xC7, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF8, 0xF8, 0x1E,
  0x1F, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x03, 0xE3, 0xE0, 0x78,
  0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xFC, 0x3F, 0x7F, 0x87, 0xFE, 0xE0,
  0x7F, 0xBC, 0x07, 0xE7, 0x80, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xF8, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF3, 0xE0, 0xF3, 0xC0, 0xF3,
  0xC0, 0xF7, 0x80, 0xF7, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x1F, 0x03,
  0xFC, 0x0F, 0xC0, 0xFF, 0x03, 0xF0, 0x7B, 0xC1, 0xFC, 0x1E, 0xF0, 0x7E,
  0x0F, 0xBC, 0x1F, 0x83, 0xCF, 0x0F, 0xE0, 0xF3, 0xC3, 0xB8, 0x78, 0xF1,
  0xEE, 0x1E, 0x3C, 0x7B, 0x8F, 0x8F, 0x1C, 0xE3, 0xC3, 0xCF, 0x38, 0xF0,
  0xF3, 0xCE, 0x78, 0x3C, 0xE3, 0x9E, 0x0F, 0x79, 0xE7, 0x83, 0xDC, 0x7B,
  0xC0, 0xFF, 0x1E, 0xF0, 0x3F, 0xC7, 0xB8, 0x0F, 0xE1, 0xFE, 0x03, 0xF8,
  0x7F, 0x80, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xF8, 0x03,
  0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0xF8, 0x1E, 0x07, 0x80, 0xF0, 0x7C, 0x07, 0xC3, 0xC0, 0x3E, 0x3E, 0x00,
  0xF3, 0xE0, 0x07, 0x9E, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3D, 0xE0, 0x03, 0xEF, 0x00,
  0x1E, 0x7C, 0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x83,
  0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xE0, 0x1F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x7C, 0x01, 0xE0,
  0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE1,
  0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xE3, 0xE0, 0x01, 0xE3, 0xC0, 0x01, 0xE3,
  0xC0, 0x00, 0xE7, 0x80, 0x00, 0xE7, 0x80, 0x00, 0xEF, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x9F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x10, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x0F,
  0xE0, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x3F, 0x00,
  0x5F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 13, 34, 11, 0, -34 },
  { 57, 14, 12, 17, 5, -34 },
  { 78, 22, 34, 21, 0, -34 },
  { 172, 20, 39, 19, 0, -36 },
  { 270, 27, 35, 31, 2, -35 },
  { 389, 21, 35, 22, 0, -35 },
  { 481, 7, 12, 10, 5, -34 },
  { 492, 15, 42, 13, 1, -34 },
  { 571, 15, 43, 13, -4, -35 },
  { 652, 16, 17, 18, 4, -37 },
  { 686, 18, 22, 21, 2, -28 },
  { 736, 9, 12, 10, -2, -6 },
  { 750, 11, 4, 13, 1, -15 },
  { 756, 6, 6, 10, 0, -6 },
  { 761, 22, 34, 17, -2, -34 },
  { 855, 18, 35, 19, 1, -35 },
  { 934, 13, 34, 19, 5, -34 },
  { 990, 21, 35, 19, -2, -35 },
  { 1082, 21, 35, 19, -1, -35 },
  { 1174, 21, 35, 19, -1, -35 },
  { 1266, 20, 34, 19, 0, -34 },
  { 1351, 20, 35, 19, 1, -35 },
  { 1439, 21, 34, 19, 1, -34 },
  { 1529, 20, 35, 19, 0, -35 },
  { 1617, 19, 35, 19, 0, -35 },
  { 1701, 10, 26, 10, 0, -26 },
  { 1734, 13, 32, 10, -3, -26 },
  { 1786, 18, 22, 21, 2, -28 },
  { 1836, 18, 14, 21, 2, -24 },
  { 1868, 18, 22, 21, 2, -28 },
  { 1918, 16, 35, 15, 1, -35 },
  { 1988, 28, 39, 29, 1, -35 },
  { 2125, 20, 34, 20, -3, -34 },
  { 2210, 22, 34, 21, 0, -34 },
  { 2304, 21, 35, 19, 2, -35 },
  { 2396, 22, 34, 23, 0, -34 },
  { 2490, 20, 34, 18, 0, -34 },
  { 2575, 20, 34, 17, 0, -34 },
  { 2660, 23, 35, 24, 2, -35 },
  { 2761, 25, 34, 24, 0, -34 },
  { 2868, 19, 34, 13, -2, -34 },
  { 2949, 19, 44, 10, -7, -34 },
  { 3054, 24, 34, 20, 0, -34 },
  { 3156, 14, 34, 17, 0, -34 },
  { 3216, 33, 34, 32, 0, -34 },
  { 3357, 27, 34, 25, 0, -34 },
  { 3472, 22, 35, 24, 2, -35 },
  { 3569, 21, 34, 20, 0, -34 },
  { 3659, 22, 43, 24, 2, -35 },
  { 3778, 21, 34, 21, 0, -34 },
  { 3868, 21, 35, 19, -1, -35 },
  { 3960, 18, 34, 17, 3, -34 },
  { 4037, 23, 34, 23, 2, -34 },
  { 4135, 20, 34, 20, 4, -34 },
  { 4220, 33, 34, 32, 3, -34 },
  { 4361, 25, 34, 19, -3, -34 },
  { 4468, 18, 34, 18, 4, -34 },
  { 4545, 22, 34, 17, -2, -34 },
  { 4639, 18, 43, 14, -1, -35 },
  { 4736, 8, 34, 17, 5, -34 },
  { 4770, 18, 43, 14, -3, -35 },
  { 4867, 20, 19, 20, 0, -34 },
  { 4915, 15, 3, 15, -4, 4 },
  { 4921, 7, 8, 13, 7, -37 },
  { 4928, 20, 26, 21, 1, -26 },
  { 4993, 20, 36, 21, 0, -36 },
  { 5083, 16, 26, 16, 1, -26 },
  { 5135, 22, 36, 21, 1, -36 },
  { 5234, 17, 26, 19, 1, -26 },
  { 5290, 23, 49, 12, -6, -37 },
  { 5431, 22, 38, 21, -1, -26 },
  { 5536, 19, 36, 20, 0, -36 },
  { 5622, 12, 36, 10, 0, -36 },
  { 5676, 18, 48, 10, -6, -36 },
  { 5784, 20, 36, 18, 0, -36 },
  { 5874, 12, 36, 10, 0, -36 },
  { 5928, 29, 26, 30, 0, -26 },
  { 6023, 19, 26, 20, 0, -26 },
  { 6085, 18, 26, 20, 1, -26 },
  { 6144, 22, 37, 21, -2, -26 },
  { 6246, 20, 37, 21, 1, -26 },
  { 6339, 16, 26, 14, 0, -26 },
  { 6391, 16, 26, 16, 0, -26 },
  { 6443, 13, 32, 12, 1, -32 },
  { 6495, 19, 26, 20, 1, -26 },
  { 6557, 16, 26, 17, 3, -26 },
  { 6609, 26, 26, 27, 3, -26 },
  { 6694, 21, 26, 17, -2, -26 },
  { 6763, 24, 38, 17, -4, -26 },
  { 6877, 18, 26, 14, -2, -26 },
  { 6936, 18, 42, 16, 1, -34 },
  { 7031, 4, 48, 18, 7, -37 },
  { 7055, 18, 42, 16, -3, -34 },
  { 7150, 18, 6, 21, 2, -20 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC48PT7B_H_
