#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC29PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x18,
  0x38, 0x38, 0x30, 0x30, 0x00, 0x00, 0x20, 0x70, 0xF0, 0xE0, 0x73, 0xBB,
  0x99, 0xDC, 0xEE, 0x67, 0x33, 0x19, 0x9C, 0x01, 0x98, 0x18, 0xC0, 0xCC,
  0x06, 0x60, 0x63, 0x03, 0x18, 0xFF, 0xE7, 0xFF, 0x0C, 0x60, 0x66, 0x07,
  0x30, 0x31, 0x81, 0x99, 0x7F, 0xF3, 0xFF, 0x86, 0x60, 0x33, 0x03, 0x18,
  0x19, 0x80, 0xCC, 0x0C, 0x60, 0x00, 0x00, 0x80, 0x08, 0x03, 0xC0, 0xFF,
  0x1F, 0xF1, 0xD2, 0x19, 0x03, 0x90, 0x1A, 0x01, 0xE0, 0x1E, 0x00, 0xF8,
  0x07, 0x80, 0x5C, 0x05, 0xC0, 0x4C, 0x04, 0xC8, 0xDC, 0xFF, 0x8F, 0xF0,
  0x1C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x0E, 0x06, 0x0F, 0x86, 0x0C, 0xC3,
  0x06, 0x63, 0x06, 0x31, 0x83, 0x19, 0x81, 0x8C, 0xC0, 0xCC, 0xC0, 0xE6,
  0xE6, 0x63, 0x67, 0xBB, 0x76, 0xCF, 0xB6, 0x37, 0xBB, 0x38, 0x19, 0x98,
  0x1D, 0x8C, 0x0C, 0xC6, 0x0C, 0x63, 0x06, 0x33, 0x06, 0x19, 0x83, 0x0F,
  0x83, 0x03, 0xC0, 0x03, 0xC0, 0x3F, 0x03, 0xB8, 0x18, 0xC0, 0xC6, 0x06,
  0x70, 0x33, 0x01, 0xB8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7E, 0x77, 0x73,
  0x31, 0xBB, 0x8F, 0x9C, 0x7C, 0xE1, 0xC7, 0x0E, 0x39, 0xF1, 0xFD, 0xC7,
  0xCE, 0x00, 0x77, 0x66, 0xEE, 0xCC, 0x01, 0xC0, 0xE0, 0x70, 0x18, 0x0E,
  0x03, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0,
  0x70, 0x0C, 0x00, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03,
  0x81, 0x81, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x00, 0x0C, 0x06, 0x23,
  0x1D, 0xBF, 0xF8, 0xFC, 0xF0, 0xFC, 0xE7, 0x23, 0x00, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x3F, 0xFF, 0xFF, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x39, 0x9C, 0xE6, 0x63, 0x00, 0x7F, 0xFC,
  0x27, 0xFE, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0x00, 0x07, 0x81, 0xF8, 0x7F, 0x0C, 0x73, 0x8E, 0x61, 0xDC, 0x3B, 0x87,
  0x60, 0xDC, 0x1B, 0x87, 0x70, 0xEE, 0x1D, 0x83, 0x30, 0xE6, 0x1C, 0xC3,
  0x18, 0xE3, 0xB8, 0x7F, 0x07, 0xC0, 0x07, 0x0F, 0x1E, 0x3E, 0x7E, 0xEE,
  0x4E, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x70,
  0x70, 0x70, 0x70, 0x03, 0xE0, 0x3F, 0x83, 0xFC, 0x08, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x07, 0xC1, 0xFE, 0x1E, 0xF1, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x0E, 0x01, 0xC0, 0xF8, 0x1F, 0x00, 0xF8, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x87, 0x8F, 0xF0, 0xFE, 0x00, 0x00, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0D, 0xC0, 0xCC, 0x06,
  0x60, 0x67, 0x07, 0x38, 0x31, 0xC3, 0x0C, 0x18, 0xE1, 0xFF, 0xCF, 0xFE,
  0xFF, 0xE0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x3F, 0x03, 0xF8,
  0x3F, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38,
  0x87, 0x8F, 0xF0, 0xFE, 0x00, 0x01, 0xE0, 0xFC, 0x3C, 0x8E, 0x01, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0x77, 0x8F, 0xF3, 0xCF, 0x70, 0xEE, 0x1D, 0xC3,
  0xB0, 0x76, 0x0C, 0xC3, 0x9C, 0x73, 0x9C, 0x7F, 0x07, 0xC0, 0x3F, 0xF3,
  0xFF, 0x3F, 0xF0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0xFE, 0x1E, 0xF1, 0xC7,
  0x18, 0x71, 0x87, 0x18, 0x71, 0xCE, 0x1D, 0xC0, 0xF8, 0x0F, 0x03, 0xF8,
  0x71, 0xC7, 0x1C, 0xE1, 0xCE, 0x0C, 0xE1, 0xCE, 0x1C, 0xE3, 0x87, 0xF8,
  0x3E, 0x00, 0x03, 0xC0, 0xFE, 0x1E, 0xE1, 0xC6, 0x38, 0x73, 0x87, 0x38,
  0x73, 0x07, 0x30, 0xE3, 0x0E, 0x39, 0xE3, 0xFE, 0x1E, 0xE0, 0x0C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x70, 0x8F, 0x0F, 0xE0, 0xFC, 0x00, 0x08, 0x71,
  0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63, 0xCE, 0x38, 0x03, 0x07,
  0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x18, 0x38, 0x30, 0x70, 0x60, 0xE0, 0x00, 0x20, 0x1C, 0x07, 0x83, 0xE1,
  0xF0, 0xF8, 0x3C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x70, 0x02,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x38, 0x1F, 0x0F, 0x87,
  0xC3, 0xE0, 0x78, 0x0C, 0x00, 0x0F, 0x8F, 0xF1, 0xBC, 0x87, 0x01, 0xC0,
  0x70, 0x18, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0x00, 0x00, 0x08, 0x07, 0x03, 0xC0, 0x60, 0x00, 0x00, 0xF8, 0x03, 0xFC,
  0x07, 0x06, 0x0C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x31, 0xF3, 0x33, 0xB3,
  0x63, 0x33, 0x66, 0x33, 0xC6, 0x63, 0xCC, 0x63, 0xCC, 0x66, 0xCC, 0x66,
  0xCC, 0xE6, 0xCC, 0xEC, 0xCF, 0x78, 0xC6, 0x30, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x71, 0xC0, 0x3F, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x1F,
  0x01, 0xB0, 0x1B, 0x03, 0xB0, 0x33, 0x07, 0x30, 0x73, 0x06, 0x30, 0xE3,
  0x0F, 0xF1, 0xFF, 0x1F, 0xF3, 0x83, 0x38, 0x33, 0x83, 0x70, 0x37, 0x03,
  0xE0, 0x30, 0x0F, 0xC0, 0x7F, 0x83, 0xFE, 0x18, 0x71, 0xC3, 0x8E, 0x1C,
  0x70, 0xE3, 0x8E, 0x18, 0x71, 0xFF, 0x0F, 0xF0, 0x73, 0xC3, 0x8E, 0x18,
  0x31, 0xC1, 0x8E, 0x1C, 0x70, 0xE3, 0x0F, 0x38, 0xF1, 0xFF, 0x0F, 0xF0,
  0x00, 0x01, 0xF0, 0x3F, 0xC3, 0xFC, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x40, 0xFE, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x3F, 0xC0, 0xFF, 0x83, 0x0E, 0x1C, 0x38, 0x70, 0x61, 0xC1,
  0xC7, 0x07, 0x18, 0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xC1,
  0xC7, 0x07, 0x1C, 0x1C, 0x70, 0xE1, 0xC7, 0x0F, 0xFC, 0x3F, 0xC0, 0xFE,
  0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x03, 0xFC, 0x3F, 0xC3, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x3F, 0xC3, 0xFC, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0xF0, 0xFB, 0xC7, 0x82,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x1F,
  0xB8, 0x7C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x18, 0xE0, 0xE3, 0x83,
  0x87, 0x8E, 0x1F, 0xF8, 0x3F, 0xC0, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38,
  0x60, 0x71, 0xC1, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x18, 0x18, 0x7F,
  0xF0, 0xFF, 0xE1, 0xC1, 0xC3, 0x83, 0x86, 0x06, 0x1C, 0x1C, 0x38, 0x38,
  0x70, 0x70, 0xC0, 0xE3, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x00, 0x0F, 0xE1,
  0xFC, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0,
  0x7F, 0x0F, 0xE0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0,
  0xFC, 0x1F, 0x03, 0x80, 0x00, 0x0E, 0x0E, 0x1C, 0x38, 0x38, 0xE0, 0x63,
  0x81, 0xC7, 0x03, 0x9C, 0x07, 0x70, 0x0E, 0xE0, 0x1B, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xFC, 0x03, 0xB8, 0x06, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x71,
  0xC0, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x1C, 0x00, 0x0E, 0x0E, 0x0E,
  0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70,
  0x70, 0x70, 0x60, 0xE0, 0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F,
  0x01, 0xE0, 0xF0, 0x1E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x07, 0xE1,
  0xB0, 0x6C, 0x1B, 0x0F, 0xC3, 0xB0, 0xDC, 0x3B, 0x1D, 0xC3, 0xB1, 0x9C,
  0x33, 0x39, 0x83, 0x3B, 0x38, 0x73, 0xB3, 0x87, 0x3F, 0x38, 0x73, 0xE3,
  0x06, 0x3E, 0x30, 0xE3, 0xC7, 0x0E, 0x3C, 0x70, 0xE3, 0x87, 0x00, 0x0F,
  0x07, 0x0F, 0x07, 0x0F, 0x07, 0x0F, 0x06, 0x1F, 0x06, 0x1F, 0x0E, 0x1F,
  0x8E, 0x1B, 0x8E, 0x1B, 0x8C, 0x39, 0x9C, 0x39, 0x9C, 0x39, 0x9C, 0x31,
  0xD8, 0x31, 0xD8, 0x71, 0xF8, 0x70, 0xF8, 0x70, 0xF8, 0x60, 0xF0, 0xE0,
  0xF0, 0xE0, 0xF0, 0xE0, 0xF0, 0x03, 0xE0, 0x3F, 0x83, 0xDE, 0x38, 0x71,
  0xC3, 0x9C, 0x0C, 0xE0, 0x6E, 0x07, 0x70, 0x3B, 0x81, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0xE7, 0x0F, 0x1C, 0xF0,
  0xFF, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0xFC, 0x18, 0xF1, 0xC3,
  0x8E, 0x1C, 0x70, 0xE3, 0x87, 0x18, 0x71, 0xC3, 0x8E, 0x78, 0x7F, 0x83,
  0xF8, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0xDE, 0x38, 0x71, 0xC3, 0x9C,
  0x0C, 0xE0, 0x6E, 0x07, 0x70, 0x3B, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0xE7, 0x0F, 0x1C, 0xF0, 0xFF, 0x03,
  0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x0F, 0xC0,
  0x7F, 0x03, 0xFC, 0x18, 0xF1, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x8E, 0x18,
  0x71, 0xC7, 0x8F, 0xF8, 0x7F, 0x83, 0xB8, 0x19, 0xC1, 0xCE, 0x0E, 0x70,
  0x71, 0x83, 0x0E, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x00, 0x01, 0xF0, 0x3F,
  0xC3, 0xFE, 0x1C, 0x21, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0xE4, 0x0E, 0x1C, 0xF1, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0xEF, 0xFB, 0xFF,
  0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0x86, 0x0E, 0x38, 0x38, 0xE0, 0xE3,
  0x83, 0x8C, 0x0C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x18, 0x60, 0xE3,
  0x83, 0x8E, 0x0E, 0x38, 0x38, 0xE1, 0xC3, 0x87, 0x0F, 0x38, 0x1F, 0xE0,
  0x3F, 0x00, 0xC0, 0x7C, 0x0E, 0xC0, 0xEC, 0x1C, 0xC1, 0xCC, 0x18, 0xC3,
  0x8C, 0x38, 0xC7, 0x0C, 0x70, 0xC6, 0x0C, 0xE0, 0xCC, 0x0D, 0xC0, 0xDC,
  0x0D, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x00, 0x60, 0x60,
  0x76, 0x0E, 0x0E, 0xE0, 0xE0, 0xEE, 0x0E, 0x0C, 0xE1, 0xE1, 0xCE, 0x1E,
  0x1C, 0xE3, 0xE3, 0x8E, 0x36, 0x38, 0xE3, 0x63, 0x0E, 0x76, 0x70, 0xE6,
  0x67, 0x0E, 0x66, 0x60, 0xEC, 0x6E, 0x0E, 0xC6, 0xE0, 0xFC, 0x7C, 0x0F,
  0x87, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x00,
  0xE0, 0xF0, 0x00, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x70, 0x18, 0xE0, 0x33,
  0x80, 0x76, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xD8, 0x03, 0xB0, 0x0E, 0x60, 0x1C, 0xE0, 0x71,
  0xC0, 0xE3, 0x83, 0x87, 0x0E, 0x0E, 0x00, 0xE0, 0xEC, 0x1D, 0x87, 0x38,
  0xE7, 0x38, 0xE7, 0x1D, 0xC3, 0xB8, 0x7E, 0x07, 0xC0, 0xF0, 0x1C, 0x03,
  0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x00,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x07,
  0xE0, 0xFC, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0xE0, 0xFC, 0x1F, 0x80, 0xC7,
  0x39, 0xCE, 0x31, 0x8C, 0x63, 0x9C, 0xE7, 0x18, 0xC6, 0x31, 0xCE, 0x73,
  0x80, 0x07, 0xE0, 0xFC, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x07, 0xE0, 0xFC, 0x1F,
  0x80, 0x01, 0x80, 0x38, 0x03, 0x80, 0x7C, 0x07, 0xC0, 0xCC, 0x1C, 0xC1,
  0x8E, 0x38, 0x63, 0x06, 0x70, 0x6E, 0x07, 0x7F, 0xFF, 0xF0, 0xE3, 0x9C,
  0x70, 0x0E, 0x71, 0xF6, 0x3D, 0xE3, 0x8E, 0x70, 0xE7, 0x0E, 0xE0, 0xCE,
  0x1C, 0xE1, 0xCE, 0x1C, 0xC1, 0x8C, 0x38, 0xC3, 0x8E, 0x78, 0xFF, 0x87,
  0xB0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1D, 0xC1,
  0xFE, 0x1E, 0xF1, 0xC7, 0x38, 0x73, 0x87, 0x38, 0x73, 0x07, 0x70, 0x67,
  0x0E, 0x70, 0xE7, 0x0E, 0x71, 0xCF, 0x3C, 0xFF, 0x8C, 0xF0, 0x07, 0xC7,
  0xE3, 0xD8, 0xE0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03,
  0x00, 0xE0, 0x38, 0x8F, 0xE1, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x39, 0xC3, 0xEC, 0x3D, 0xE1, 0xC7, 0x1C, 0x38,
  0xE1, 0xCE, 0x0C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xC1, 0x86, 0x1C, 0x30,
  0xE1, 0xCF, 0x0F, 0xF8, 0x3D, 0x80, 0x07, 0x07, 0xE3, 0x9C, 0xC3, 0x71,
  0xD8, 0x7E, 0x3B, 0xFC, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x4F,
  0xF1, 0xF8, 0x00, 0x3C, 0x01, 0xF0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x1F, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x0B,
  0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x03, 0xDC, 0x1F, 0x60, 0xF7, 0x83, 0x8E,
  0x1C, 0x38, 0x70, 0xE3, 0x83, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x06,
  0x0C, 0x38, 0x30, 0xE0, 0xE7, 0x83, 0xFE, 0x07, 0xB0, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0xE7, 0x83, 0xFC, 0x07, 0xC0, 0x00, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1D, 0xC1, 0xFE, 0x1F, 0xF1,
  0xC7, 0x38, 0x63, 0x86, 0x38, 0xE3, 0x0E, 0x30, 0xE7, 0x0C, 0x70, 0xC7,
  0x1C, 0x61, 0xCE, 0x1C, 0xE1, 0x8E, 0x38, 0x04, 0x1C, 0x38, 0x60, 0x00,
  0x07, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x70, 0xE1, 0x87,
  0x0E, 0x1C, 0x00, 0x00, 0x40, 0x1C, 0x03, 0x80, 0x60, 0x00, 0x00, 0x00,
  0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60,
  0x1C, 0x03, 0x82, 0xE0, 0x7C, 0x0F, 0x00, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x71, 0xC7, 0x18, 0xE1, 0x9C, 0x3B, 0x83,
  0xB8, 0x37, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x73, 0x06, 0x30, 0x63, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0x06, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E, 0x1C,
  0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xE1, 0x87, 0x0E, 0x1C, 0x00,
  0x19, 0xC7, 0x06, 0xFB, 0xE1, 0xEF, 0xFC, 0x71, 0xC7, 0x38, 0x61, 0x8E,
  0x38, 0x63, 0x8E, 0x38, 0xC3, 0x8E, 0x70, 0xC3, 0x9C, 0x30, 0xC7, 0x1C,
  0x31, 0xC7, 0x1C, 0x61, 0xC7, 0x38, 0x61, 0xCE, 0x18, 0x63, 0x8E, 0x38,
  0x19, 0xC1, 0xBE, 0x1F, 0xE1, 0xC7, 0x38, 0x63, 0x86, 0x38, 0xE3, 0x0E,
  0x70, 0xE7, 0x0C, 0x70, 0xC7, 0x1C, 0x61, 0xCE, 0x1C, 0xE1, 0x8E, 0x38,
  0x0F, 0x07, 0xE3, 0xFC, 0xC3, 0x70, 0xD8, 0x3E, 0x0F, 0x83, 0xE1, 0xF0,
  0x7C, 0x1F, 0x0E, 0xC3, 0xB9, 0xCF, 0xE1, 0xF0, 0x0C, 0xE0, 0x6F, 0x83,
  0xDE, 0x1C, 0x71, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x07, 0x18, 0x31, 0xC3,
  0x8E, 0x1C, 0x70, 0xE3, 0x8E, 0x3C, 0xF1, 0xFF, 0x0E, 0xF0, 0x60, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0F, 0x71,
  0xF6, 0x3D, 0xE3, 0x8E, 0x70, 0xE6, 0x0E, 0xE0, 0xCE, 0x1C, 0xE1, 0xCE,
  0x1C, 0xC1, 0x8C, 0x38, 0xC3, 0x8E, 0x78, 0xFF, 0x87, 0xB0, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0x19, 0xC6, 0xE1,
  0xF8, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0,
  0x60, 0x38, 0x0E, 0x03, 0x80, 0x0F, 0x87, 0xF3, 0x98, 0xC0, 0x30, 0x0E,
  0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x23, 0xCF, 0xE3,
  0xF0, 0x0C, 0x30, 0x61, 0xF7, 0xEF, 0xCC, 0x38, 0x70, 0xE1, 0x83, 0x0E,
  0x1C, 0x38, 0x60, 0xE1, 0xF3, 0xE0, 0x38, 0x67, 0x1C, 0xC3, 0x98, 0x77,
  0x0C, 0xE1, 0x9C, 0x73, 0x0E, 0xE1, 0xDC, 0x33, 0x8E, 0x71, 0xCC, 0x39,
  0xCF, 0x3F, 0xC7, 0xD8, 0xC1, 0xF0, 0x6C, 0x3B, 0x0C, 0xC7, 0x31, 0xCC,
  0xE3, 0x38, 0xCC, 0x37, 0x0D, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0x80,
  0xC3, 0x87, 0xC3, 0x86, 0xC7, 0x8E, 0xC7, 0x8E, 0xC7, 0x8C, 0xCD, 0x9C,
  0xCD, 0x98, 0xCD, 0xB8, 0xD9, 0xB8, 0xD9, 0xB0, 0xF9, 0xF0, 0xF1, 0xE0,
  0xF1, 0xE0, 0xE1, 0xE0, 0xE1, 0xC0, 0xE3, 0xC0, 0x1C, 0x38, 0xE3, 0x83,
  0x18, 0x19, 0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x77, 0x03, 0xB8, 0x39, 0xC1, 0x8E, 0x1C, 0x38, 0x06, 0x0E,
  0x0C, 0x18, 0x18, 0x70, 0x30, 0xE0, 0x63, 0x80, 0xC7, 0x01, 0x8C, 0x03,
  0x38, 0x07, 0x60, 0x0D, 0xC0, 0x1B, 0x00, 0x36, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x05,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x7F, 0x00, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00,
  0xE0, 0x3F, 0xC7, 0xF8, 0x00, 0x40, 0xF0, 0x7C, 0x1C, 0x0E, 0x03, 0x80,
  0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0xE0, 0xF0, 0x3C, 0x07, 0x00, 0xE0,
  0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x02,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0xF0,
  0x1F, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x1E, 0x07, 0xC1, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x38, 0x07, 0x07, 0xC0, 0xF8, 0x10, 0x00, 0x7C, 0x3F, 0xFF,
  0x1F, 0xC0, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 21, 7, 0, -21 },
  { 22, 9, 8, 10, 3, -21 },
  { 31, 13, 21, 13, 0, -21 },
  { 66, 12, 24, 12, 0, -22 },
  { 102, 17, 21, 18, 1, -21 },
  { 147, 13, 21, 13, 0, -21 },
  { 182, 4, 8, 6, 3, -21 },
  { 186, 10, 26, 8, 0, -21 },
  { 219, 9, 26, 8, -2, -21 },
  { 249, 9, 10, 11, 3, -22 },
  { 261, 11, 14, 13, 1, -17 },
  { 281, 5, 7, 6, -1, -3 },
  { 286, 7, 2, 8, 0, -9 },
  { 288, 4, 4, 6, 0, -4 },
  { 290, 13, 21, 10, -1, -21 },
  { 325, 11, 21, 12, 1, -21 },
  { 354, 8, 21, 12, 3, -21 },
  { 375, 13, 21, 12, -1, -21 },
  { 410, 12, 21, 12, 0, -21 },
  { 442, 13, 21, 12, -1, -21 },
  { 477, 12, 21, 12, 0, -21 },
  { 509, 11, 21, 12, 1, -21 },
  { 538, 12, 21, 12, 1, -21 },
  { 570, 12, 21, 12, 0, -21 },
  { 602, 12, 21, 12, 0, -21 },
  { 634, 6, 16, 6, 0, -16 },
  { 646, 8, 20, 6, -2, -16 },
  { 666, 11, 13, 13, 1, -17 },
  { 684, 11, 8, 13, 1, -14 },
  { 695, 11, 13, 13, 1, -17 },
  { 713, 10, 21, 9, 0, -21 },
  { 740, 16, 23, 18, 1, -21 },
  { 786, 12, 21, 12, -2, -21 },
  { 818, 13, 21, 13, 0, -21 },
  { 853, 13, 21, 12, 1, -21 },
  { 888, 14, 21, 14, 0, -21 },
  { 925, 12, 21, 11, 0, -21 },
  { 957, 12, 21, 10, 0, -21 },
  { 989, 14, 21, 15, 1, -21 },
  { 1026, 15, 21, 14, 0, -21 },
  { 1066, 11, 21, 8, -1, -21 },
  { 1095, 11, 27, 6, -4, -21 },
  { 1133, 15, 21, 12, 0, -21 },
  { 1173, 8, 21, 10, 0, -21 },
  { 1194, 20, 21, 19, 0, -21 },
  { 1247, 16, 21, 15, 0, -21 },
  { 1289, 13, 21, 15, 1, -21 },
  { 1324, 13, 21, 12, 0, -21 },
  { 1359, 13, 26, 15, 1, -21 },
  { 1402, 13, 21, 13, 0, -21 },
  { 1437, 13, 21, 11, -1, -21 },
  { 1472, 11, 21, 10, 2, -21 },
  { 1501, 14, 21, 14, 1, -21 },
  { 1538, 12, 21, 12, 3, -21 },
  { 1570, 20, 21, 19, 2, -21 },
  { 1623, 15, 21, 11, -2, -21 },
  { 1663, 11, 21, 11, 2, -21 },
  { 1692, 13, 21, 10, -1, -21 },
  { 1727, 11, 26, 8, -1, -21 },
  { 1763, 5, 21, 10, 3, -21 },
  { 1777, 11, 26, 8, -2, -21 },
  { 1813, 12, 12, 12, 0, -21 },
  { 1831, 10, 2, 9, -3, 2 },
  { 1834, 5, 4, 8, 4, -22 },
  { 1837, 12, 16, 13, 1, -16 },
  { 1861, 12, 22, 12, 0, -22 },
  { 1894, 10, 16, 10, 1, -16 },
  { 1914, 13, 22, 13, 1, -22 },
  { 1950, 10, 16, 11, 1, -16 },
  { 1970, 14, 29, 7, -4, -22 },
  { 2021, 14, 23, 13, -1, -16 },
  { 2062, 12, 22, 12, 0, -22 },
  { 2095, 7, 22, 6, 0, -22 },
  { 2115, 11, 29, 6, -4, -22 },
  { 2155, 12, 22, 11, 0, -22 },
  { 2188, 7, 22, 6, 0, -22 },
  { 2208, 18, 16, 18, 0, -16 },
  { 2244, 12, 16, 12, 0, -16 },
  { 2268, 10, 16, 12, 1, -16 },
  { 2288, 13, 23, 12, -1, -16 },
  { 2326, 12, 23, 13, 1, -16 },
  { 2361, 10, 16, 8, 0, -16 },
  { 2381, 10, 16, 10, 0, -16 },
  { 2401, 7, 19, 7, 1, -19 },
  { 2418, 11, 16, 12, 1, -16 },
  { 2440, 10, 16, 10, 2, -16 },
  { 2460, 16, 16, 16, 2, -16 },
  { 2492, 13, 16, 11, -1, -16 },
  { 2518, 15, 23, 10, -3, -16 },
  { 2562, 11, 16, 9, -1, -16 },
  { 2584, 10, 26, 10, 1, -21 },
  { 2617, 2, 29, 11, 4, -22 },
  { 2625, 11, 26, 10, -2, -21 },
  { 2661, 11, 4, 13, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC29PT7B_H_
