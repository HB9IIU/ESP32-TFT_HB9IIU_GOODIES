#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC33PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x07, 0x83, 0xC1, 0xE0, 0x39, 0xDE, 0x77, 0x1D, 0xCE, 0x73, 0x98, 0xE6,
  0x3B, 0x8C, 0xE3, 0x00, 0x00, 0xC6, 0x03, 0x9C, 0x06, 0x30, 0x0C, 0x60,
  0x39, 0xC0, 0x63, 0x00, 0xC6, 0x0F, 0xFF, 0x3F, 0xFE, 0x0C, 0x60, 0x38,
  0xC0, 0x63, 0x00, 0xC6, 0x03, 0x8C, 0x06, 0x38, 0x7F, 0xFC, 0xFF, 0xF8,
  0x73, 0x80, 0xC6, 0x01, 0x8C, 0x07, 0x38, 0x0C, 0x60, 0x18, 0xC0, 0x73,
  0x80, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0xFE, 0x0F, 0xFC, 0x3A, 0xE1,
  0xC8, 0x07, 0x20, 0x1D, 0x80, 0x76, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0xB8, 0x02, 0xF0, 0x09, 0xC0, 0x66, 0x21, 0x38,
  0xE5, 0xE3, 0xFF, 0x0F, 0xF8, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x00, 0x0E, 0x03, 0x07, 0xC1, 0xC3, 0x70, 0x61, 0xCC, 0x38, 0x63, 0x0C,
  0x38, 0xC7, 0x0E, 0x31, 0x83, 0x1C, 0xC0, 0xC7, 0x70, 0x31, 0x98, 0x0C,
  0x6E, 0x7B, 0x3B, 0x3F, 0xDD, 0xDC, 0xFE, 0x66, 0x37, 0x3B, 0x8C, 0x0C,
  0xC7, 0x07, 0x31, 0xC1, 0x8C, 0x60, 0xE3, 0x18, 0x31, 0xC6, 0x1C, 0x73,
  0x06, 0x1C, 0xC3, 0x83, 0xE1, 0xC0, 0xF0, 0x01, 0xE0, 0x07, 0xE0, 0x1F,
  0xE0, 0x39, 0xC0, 0xE3, 0x81, 0xC6, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0xE0,
  0x1F, 0x80, 0x1F, 0x00, 0x78, 0x01, 0xF8, 0x27, 0xF3, 0x9E, 0xE7, 0x38,
  0xEE, 0xE1, 0xF9, 0xC3, 0xF3, 0x83, 0xC7, 0x07, 0x0E, 0x1F, 0x1E, 0xFE,
  0x3F, 0xDC, 0x3F, 0x3C, 0x39, 0xDC, 0xE7, 0x39, 0x8C, 0xE0, 0x01, 0xC0,
  0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01,
  0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x00, 0x03,
  0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0x06, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x00,
  0x07, 0x00, 0xC1, 0x18, 0x33, 0x1F, 0xFE, 0x7F, 0xC7, 0x81, 0xF8, 0x73,
  0x0E, 0x70, 0x8E, 0x01, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x1E, 0x38, 0x71, 0xC3, 0x86, 0x1C,
  0x70, 0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xF1, 0xE7,
  0x1C, 0x73, 0x87, 0x38, 0x73, 0x87, 0x70, 0x77, 0x07, 0x70, 0x77, 0x07,
  0xE0, 0xFE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xEE, 0x1C, 0xE1, 0xCE, 0x38,
  0xE3, 0x8F, 0xF0, 0xFE, 0x07, 0xC0, 0x03, 0x83, 0xC3, 0xE3, 0xF3, 0xF3,
  0xFB, 0x9C, 0x8E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38,
  0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x00, 0xF0, 0x0F,
  0xE0, 0xFF, 0xC1, 0x87, 0x04, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xFF, 0x8F,
  0xFE, 0x3F, 0xF8, 0x01, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x30, 0xE0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x88, 0x0E, 0x1E, 0xFC, 0x3F, 0xF0, 0x3F, 0x80,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1B, 0x00,
  0x7E, 0x00, 0xDC, 0x03, 0x38, 0x0E, 0x70, 0x19, 0xC0, 0x73, 0x80, 0xC7,
  0x03, 0x0E, 0x0E, 0x1C, 0x18, 0x70, 0x7F, 0xF8, 0xFF, 0xF3, 0xFF, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x07, 0xFC, 0x1F,
  0xE0, 0xFF, 0x83, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x6C, 0x03, 0xFC, 0x0F, 0xF8, 0x11, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x81, 0xC3, 0xBF, 0x0F,
  0xF8, 0x3F, 0x80, 0x00, 0xF8, 0x1F, 0xC1, 0xFE, 0x1E, 0x00, 0xE0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x03, 0x9E, 0x1F, 0xF0, 0xFF, 0xCF, 0x8E,
  0x78, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x79, 0xC3, 0x8E,
  0x3C, 0x7B, 0xC1, 0xFC, 0x07, 0xC0, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x1F, 0xE0, 0xFF, 0x83, 0x8F, 0x1C, 0x1C, 0x70, 0x71, 0xC3,
  0x87, 0x0E, 0x1C, 0x78, 0x3B, 0xC0, 0xFE, 0x01, 0xE0, 0x0F, 0xC0, 0xF7,
  0x07, 0x8E, 0x1C, 0x38, 0xE0, 0xF3, 0x81, 0xCE, 0x07, 0x38, 0x38, 0xE0,
  0xE3, 0xC7, 0x07, 0xFC, 0x0F, 0xC0, 0x01, 0xE0, 0x3F, 0x83, 0xFE, 0x3C,
  0x71, 0xC3, 0x8E, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x1E,
  0x70, 0xF3, 0xDF, 0x1F, 0xF8, 0x7D, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x67, 0xC3, 0xFC, 0x1F, 0x80, 0x0E, 0x3C, 0x78,
  0xE0, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x78, 0xF1,
  0xC0, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07,
  0x07, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0,
  0xFC, 0x0F, 0x80, 0x70, 0x02, 0x00, 0x00, 0x0F, 0x0F, 0xF3, 0xFC, 0x87,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x1C, 0x0E,
  0x03, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x0F, 0x0E, 0x03, 0x80, 0xE0, 0xE0,
  0x0C, 0x18, 0x01, 0x86, 0x00, 0x39, 0xC7, 0xE7, 0x31, 0xFC, 0xE6, 0x33,
  0x9D, 0x8C, 0x73, 0x31, 0x8C, 0x66, 0x71, 0x8D, 0xCC, 0x71, 0xB1, 0x8E,
  0x76, 0x31, 0x8C, 0xC6, 0x71, 0x98, 0xCE, 0x63, 0x1F, 0xFC, 0x63, 0xCF,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x78, 0x60,
  0x07, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0x70, 0x1D, 0xC0, 0x77, 0x03, 0x9C, 0x0E, 0x70,
  0x39, 0xC1, 0xC7, 0x07, 0x1C, 0x38, 0x70, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC,
  0x70, 0x73, 0x81, 0xCE, 0x07, 0x78, 0x1D, 0xC0, 0x7F, 0x01, 0xF8, 0x07,
  0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x70, 0xF0, 0xE1, 0xE1, 0xC1, 0xC3,
  0x83, 0x8F, 0x0F, 0x1C, 0x1C, 0x38, 0x78, 0x7F, 0xE0, 0xFF, 0x03, 0xFF,
  0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0xE0, 0x71, 0xC1, 0xE3,
  0x83, 0x87, 0x0F, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0xF8, 0x07,
  0xFC, 0x1F, 0xF0, 0x78, 0x40, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0xB8, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0x80, 0x0F, 0xF0, 0x1F, 0xF0,
  0x71, 0xF0, 0xE1, 0xE1, 0xC1, 0xC3, 0x83, 0x8F, 0x07, 0x1C, 0x0E, 0x38,
  0x1C, 0x70, 0x38, 0xE0, 0x73, 0xC0, 0xE7, 0x03, 0xCE, 0x07, 0x1C, 0x0E,
  0x38, 0x3C, 0xF0, 0x71, 0xC1, 0xE3, 0x87, 0x87, 0x1E, 0x1F, 0xFC, 0x3F,
  0xE0, 0x7F, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xFE, 0x07, 0xF8,
  0x3F, 0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0x83, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0x82, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x7E, 0x70, 0xFC, 0xF0, 0xFC, 0xF0, 0x1C, 0xF0, 0x3C, 0xE0,
  0x38, 0xF0, 0x38, 0xF0, 0x38, 0xF0, 0x38, 0x70, 0x78, 0x7F, 0xF0, 0x3F,
  0xF0, 0x1F, 0xE0, 0x07, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0xE1, 0xC0, 0xF0,
  0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x3C, 0x0E, 0x1C, 0x0F, 0x0E, 0x07,
  0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xC0, 0xE0, 0xE0, 0x70, 0x70,
  0x38, 0x38, 0x1C, 0x3C, 0x1E, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x03, 0x87,
  0x81, 0xC3, 0x81, 0xE1, 0xC0, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x07, 0xF8, 0x3F, 0xE0,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x81, 0x3C, 0x0F, 0xC0, 0x7E,
  0x01, 0x80, 0x00, 0x07, 0x07, 0x83, 0x83, 0x81, 0xC3, 0x81, 0xC3, 0xC0,
  0xE1, 0xC0, 0x71, 0xC0, 0x39, 0xE0, 0x3D, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xF7, 0x00, 0x73,
  0x80, 0x39, 0xC0, 0x38, 0xF0, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x07,
  0x87, 0x03, 0x83, 0xC1, 0xC1, 0xE0, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0,
  0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70,
  0x38, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x3E,
  0x0F, 0x00, 0x78, 0x1E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0xC1,
  0xF0, 0x1F, 0x83, 0xE0, 0x7E, 0x0E, 0xC0, 0xFC, 0x1D, 0x81, 0xB8, 0x3B,
  0x07, 0x70, 0x77, 0x0D, 0xE0, 0xEE, 0x3B, 0x83, 0x9C, 0x67, 0x07, 0x39,
  0xCE, 0x0E, 0x73, 0x9C, 0x1C, 0xEE, 0x70, 0x39, 0xDC, 0xE0, 0xE3, 0xF1,
  0xC1, 0xC7, 0xE3, 0x83, 0x8F, 0x87, 0x07, 0x1F, 0x1C, 0x1C, 0x3C, 0x38,
  0x38, 0x78, 0x70, 0x70, 0xF0, 0xE0, 0x07, 0x81, 0xC1, 0xE0, 0x70, 0x78,
  0x1C, 0x3E, 0x07, 0x0F, 0x83, 0x83, 0xE0, 0xE0, 0xDC, 0x38, 0x77, 0x0E,
  0x1D, 0xC3, 0x87, 0x71, 0xC1, 0xCC, 0x70, 0x73, 0x1C, 0x38, 0xE7, 0x0E,
  0x39, 0x83, 0x8E, 0xE0, 0xE3, 0xB8, 0x38, 0xEE, 0x1C, 0x1B, 0x87, 0x07,
  0xC1, 0xC1, 0xF0, 0x70, 0x7C, 0x38, 0x1F, 0x0E, 0x07, 0xC3, 0x80, 0xE0,
  0x00, 0xF0, 0x07, 0xF8, 0x1F, 0xF8, 0x78, 0xF1, 0xE0, 0xE3, 0x81, 0xCF,
  0x03, 0x9C, 0x07, 0x38, 0x0E, 0xF0, 0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x00,
  0xFE, 0x03, 0xFC, 0x07, 0x78, 0x0E, 0xE0, 0x3D, 0xC0, 0x73, 0xC0, 0xE7,
  0x83, 0x87, 0x0F, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x07, 0xC0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x71, 0xE0, 0xE1, 0xE1, 0xC3, 0xC3, 0x87, 0x8F, 0x0F,
  0x1C, 0x1C, 0x38, 0x38, 0x70, 0xF0, 0xE3, 0xC3, 0xFF, 0x07, 0xFC, 0x0F,
  0xF0, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x07, 0xF8, 0x1F, 0xF8,
  0x78, 0xF1, 0xE0, 0xE3, 0x81, 0xCF, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0xF0,
  0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0x78, 0x0E,
  0xE0, 0x3D, 0xC0, 0x73, 0xC0, 0xE7, 0x83, 0x87, 0x0F, 0x0F, 0xFC, 0x1F,
  0xF0, 0x1F, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x1F, 0xE0, 0x7F, 0xC3, 0x8F, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC7, 0x87, 0x1C, 0x1C, 0x70, 0xF1, 0xC3, 0x87, 0x3E,
  0x3F, 0xF0, 0xFF, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC1, 0xC7, 0x07, 0x1E,
  0x1C, 0x38, 0x70, 0xE3, 0xC3, 0x8E, 0x0F, 0x38, 0x3C, 0x00, 0xF8, 0x07,
  0xFC, 0x1F, 0xF8, 0x7C, 0x60, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x84, 0x1E,
  0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xC0, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x70,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x07, 0x0E, 0x07, 0x1E, 0x0F,
  0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x1E, 0x38, 0x1C, 0x38, 0x1C,
  0x38, 0x1C, 0x38, 0x1C, 0x78, 0x3C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38,
  0x70, 0x38, 0xF0, 0x78, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0xF0, 0xF0, 0xE0,
  0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0xE0, 0x3F, 0x80, 0xEE, 0x07, 0xB8,
  0x1C, 0xE0, 0x73, 0x83, 0xCE, 0x0E, 0x38, 0x78, 0xE1, 0xC3, 0x87, 0x0E,
  0x38, 0x38, 0xE0, 0xE7, 0x83, 0x9C, 0x0E, 0x70, 0x3B, 0x80, 0xEE, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0x70, 0x38, 0x0E, 0xE0, 0x70, 0x39, 0xC0, 0xE0, 0x73, 0x83, 0xC1, 0xC7,
  0x07, 0x83, 0x8E, 0x1F, 0x07, 0x1C, 0x3E, 0x1C, 0x38, 0x7C, 0x38, 0x71,
  0xF8, 0xF0, 0xE3, 0x71, 0xC1, 0xCE, 0xE3, 0x83, 0x9D, 0xCE, 0x07, 0x33,
  0x9C, 0x0C, 0xE7, 0x78, 0x19, 0xCE, 0xE0, 0x73, 0x1D, 0xC0, 0xEE, 0x3F,
  0x01, 0xD8, 0x7E, 0x03, 0xF0, 0xDC, 0x07, 0xE1, 0xF0, 0x0F, 0x83, 0xE0,
  0x1F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x03, 0x83, 0x81,
  0xC3, 0xC0, 0xE1, 0xC0, 0x71, 0xE0, 0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0x70,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0x38, 0x07,
  0x1C, 0x03, 0x8E, 0x03, 0x87, 0x03, 0xC3, 0x81, 0xC1, 0xC1, 0xE0, 0xF0,
  0xE0, 0x7E, 0x0F, 0xE0, 0xEE, 0x1E, 0xE1, 0xCE, 0x3C, 0x63, 0x87, 0x78,
  0x77, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xF8, 0x1F,
  0x80, 0xFC, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xE3, 0x86, 0x18,
  0x71, 0xC7, 0x1C, 0x71, 0xC3, 0x0C, 0x38, 0xE3, 0x8E, 0x38, 0xE1, 0x87,
  0x1C, 0x71, 0xC7, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xE0, 0xFC, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xB0, 0x39, 0xC1, 0xCE,
  0x1C, 0x70, 0xE1, 0x8E, 0x0E, 0xE0, 0x77, 0x03, 0xF0, 0x0C, 0xFF, 0xFF,
  0xF8, 0xE7, 0x9C, 0x63, 0x80, 0x07, 0x98, 0xFF, 0xC7, 0xFE, 0x78, 0xF3,
  0x87, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0xE0, 0x77, 0x07, 0x38, 0x39, 0xC1,
  0xCE, 0x1E, 0x70, 0xF3, 0x8F, 0x1E, 0xF8, 0xFF, 0xC3, 0xCE, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xBC, 0x1D, 0xF8, 0x7F, 0xE1, 0xE3, 0x87, 0x0F, 0x1C, 0x3C, 0xE0, 0xE3,
  0x83, 0x8E, 0x0E, 0x38, 0x39, 0xC0, 0xE7, 0x07, 0x1C, 0x1C, 0x70, 0xF1,
  0xC3, 0x8F, 0x9E, 0x3F, 0xF0, 0xEF, 0x80, 0x07, 0xC1, 0xFC, 0x7F, 0x1E,
  0x03, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x98, 0x7F, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x03, 0xDC, 0x1F,
  0xF8, 0x3F, 0xF0, 0xF1, 0xE1, 0xC3, 0x87, 0x07, 0x0E, 0x0E, 0x1C, 0x1C,
  0x70, 0x38, 0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x1E, 0x1C,
  0x38, 0x3D, 0xF0, 0x7F, 0xE0, 0x7D, 0xC0, 0x07, 0xC0, 0xFE, 0x1E, 0xE3,
  0x87, 0x38, 0x67, 0x0E, 0x70, 0xEE, 0x3C, 0xFF, 0x8F, 0xE0, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x18, 0x7F, 0x83, 0xF0, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x7A, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x01, 0xE6, 0x07, 0xFC, 0x1F, 0xF8, 0x78, 0xF0,
  0xE1, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x38, 0x1C, 0x70, 0x70, 0xE0,
  0xE1, 0xC1, 0xC3, 0x87, 0x87, 0x0F, 0x0E, 0x3C, 0x1E, 0xF8, 0x3F, 0xF0,
  0x3E, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x20, 0x70, 0x7F,
  0xE0, 0xFF, 0x80, 0x7C, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xDE, 0x1D, 0xF8, 0xFF, 0xC7, 0x8E, 0x38,
  0x71, 0xC3, 0x9C, 0x1C, 0xE0, 0xE7, 0x0E, 0x38, 0x71, 0xC3, 0x9C, 0x1C,
  0xE1, 0xC7, 0x0E, 0x38, 0x73, 0x83, 0x9C, 0x1C, 0xE1, 0xC0, 0x02, 0x07,
  0x0F, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38,
  0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0x00,
  0x20, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xF8, 0x0F, 0x80, 0xF0,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x87, 0x1C, 0x38, 0x71, 0xC1, 0xCF, 0x07, 0x38, 0x1D, 0xC0,
  0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xB8, 0x1C, 0xF0,
  0x71, 0xC1, 0xC7, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xE0, 0x07, 0x07, 0x07,
  0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0x0C, 0xF1,
  0xE1, 0xDF, 0xFF, 0x1F, 0xFF, 0xF1, 0xE3, 0xC7, 0x1C, 0x38, 0x71, 0xC3,
  0x87, 0x38, 0x38, 0x73, 0x87, 0x0E, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x78,
  0x70, 0xE7, 0x0E, 0x1C, 0x70, 0xE1, 0xC7, 0x0E, 0x1C, 0x70, 0xE1, 0xCE,
  0x0E, 0x1C, 0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0x0C, 0xF0, 0xEF, 0xC7, 0xFE,
  0x3C, 0x71, 0xC3, 0x8E, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x71, 0xC3, 0x9E,
  0x1C, 0xE0, 0xE7, 0x0E, 0x38, 0x71, 0xC3, 0x9C, 0x1C, 0xE0, 0xE7, 0x0E,
  0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xE3, 0x87, 0x38, 0x77, 0x07, 0x70, 0x7F,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1, 0xCF,
  0x78, 0x7F, 0x03, 0xE0, 0x03, 0x3C, 0x07, 0x7E, 0x07, 0xFE, 0x07, 0x8E,
  0x07, 0x0F, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0C, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x1C, 0x38, 0x3E, 0x78,
  0x3B, 0xF0, 0x3B, 0xE0, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0x98, 0x7F, 0xC7,
  0xFE, 0x78, 0xF3, 0x87, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0xE0, 0x77, 0x07,
  0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xF3, 0x8F, 0x1E, 0xF8, 0xFF, 0xC3,
  0xEE, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0x0C, 0xE3, 0xBC, 0x7F, 0x0F, 0x81, 0xE0, 0x38, 0x0F,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x80, 0xE0, 0x1C, 0x00, 0x0F, 0xC3, 0xFC, 0xFB, 0x9C, 0x23, 0x80, 0x70,
  0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x21,
  0xE7, 0x78, 0xFF, 0x1F, 0xC0, 0x0E, 0x0C, 0x0C, 0x1C, 0x3F, 0x7F, 0x7F,
  0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE4, 0xF8, 0x78, 0x1C, 0x39, 0xC1, 0xCE, 0x1C, 0x70, 0xE3, 0x87, 0x18,
  0x39, 0xC1, 0xCE, 0x1C, 0x70, 0xE3, 0x87, 0x38, 0x39, 0xC1, 0xCE, 0x1C,
  0x70, 0xE3, 0x8F, 0x1E, 0xF8, 0xFD, 0xC3, 0xCC, 0x00, 0xE0, 0xFC, 0x1F,
  0x87, 0x70, 0xEE, 0x3D, 0xC7, 0x38, 0xE7, 0x38, 0xE7, 0x1D, 0xC3, 0xB8,
  0x76, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x00, 0xE1, 0xE1,
  0xF8, 0x78, 0x7E, 0x1E, 0x3B, 0x8F, 0x8E, 0xE3, 0xE3, 0xB9, 0xF9, 0xCE,
  0x6E, 0x73, 0x9B, 0xB8, 0xEE, 0xEE, 0x3B, 0x33, 0x8F, 0xCD, 0xC3, 0xF3,
  0x70, 0xD8, 0xD8, 0x3E, 0x3E, 0x0F, 0x0F, 0x83, 0xC3, 0xC0, 0xF0, 0xF0,
  0x38, 0x38, 0x00, 0x07, 0x0E, 0x0E, 0x38, 0x1C, 0x70, 0x39, 0xC0, 0x77,
  0x80, 0x6E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0xEC, 0x03, 0x9C, 0x07, 0x38, 0x1C, 0x70, 0x78, 0xE1, 0xE1,
  0xE0, 0x07, 0x07, 0x83, 0x83, 0x81, 0xC3, 0xC0, 0xE1, 0xC0, 0x70, 0xE0,
  0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x98, 0x01, 0xDC,
  0x00, 0xEE, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xF0, 0xFF,
  0x1F, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0xF8, 0xFF, 0x8F, 0xF0,
  0x00, 0x10, 0x1F, 0x03, 0xF0, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x0F, 0xC0, 0xF0, 0x0F, 0x00,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x7C, 0x03, 0xC0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x3C, 0x07, 0xC0, 0x1E, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x1F, 0x03, 0xC0, 0x78, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x7C, 0x0F, 0x80, 0xF0,
  0x00, 0x3C, 0x0B, 0xF8, 0xFF, 0xFF, 0x07, 0xE8, 0x0C, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 24, 8, 0, -24 },
  { 28, 10, 9, 12, 3, -24 },
  { 40, 15, 24, 14, 0, -24 },
  { 85, 14, 27, 13, 0, -25 },
  { 133, 18, 24, 21, 2, -24 },
  { 187, 15, 24, 15, 0, -24 },
  { 232, 5, 9, 7, 3, -24 },
  { 238, 10, 29, 9, 1, -24 },
  { 275, 10, 29, 9, -2, -24 },
  { 312, 11, 12, 12, 3, -25 },
  { 329, 13, 15, 15, 1, -19 },
  { 354, 7, 8, 7, -2, -4 },
  { 361, 8, 3, 9, 0, -10 },
  { 364, 4, 4, 7, 0, -4 },
  { 366, 16, 24, 11, -2, -24 },
  { 414, 12, 24, 13, 1, -24 },
  { 450, 9, 24, 13, 3, -24 },
  { 477, 14, 24, 13, -1, -24 },
  { 519, 15, 24, 13, -1, -24 },
  { 564, 15, 24, 13, -1, -24 },
  { 609, 14, 24, 13, 0, -24 },
  { 651, 13, 24, 13, 1, -24 },
  { 690, 14, 24, 13, 1, -24 },
  { 732, 14, 24, 13, 0, -24 },
  { 774, 13, 24, 13, 0, -24 },
  { 813, 7, 18, 7, 0, -18 },
  { 829, 9, 22, 7, -2, -18 },
  { 854, 13, 15, 15, 1, -19 },
  { 879, 13, 9, 15, 1, -16 },
  { 894, 13, 15, 15, 1, -19 },
  { 919, 10, 24, 10, 1, -24 },
  { 949, 19, 27, 20, 1, -24 },
  { 1014, 14, 24, 14, -2, -24 },
  { 1056, 15, 24, 15, 0, -24 },
  { 1101, 15, 24, 13, 1, -24 },
  { 1146, 15, 24, 16, 0, -24 },
  { 1191, 14, 24, 12, 0, -24 },
  { 1233, 14, 24, 12, 0, -24 },
  { 1275, 16, 24, 17, 1, -24 },
  { 1323, 17, 24, 16, 0, -24 },
  { 1374, 14, 24, 9, -2, -24 },
  { 1416, 13, 31, 7, -5, -24 },
  { 1467, 17, 24, 14, 0, -24 },
  { 1518, 9, 24, 12, 0, -24 },
  { 1545, 23, 24, 22, 0, -24 },
  { 1614, 18, 24, 17, 0, -24 },
  { 1668, 15, 24, 17, 1, -24 },
  { 1713, 15, 24, 14, 0, -24 },
  { 1758, 15, 30, 17, 1, -24 },
  { 1815, 14, 24, 14, 0, -24 },
  { 1857, 15, 24, 13, -1, -24 },
  { 1902, 12, 24, 12, 2, -24 },
  { 1938, 16, 24, 16, 1, -24 },
  { 1986, 14, 24, 14, 3, -24 },
  { 2028, 23, 24, 22, 2, -24 },
  { 2097, 17, 24, 13, -2, -24 },
  { 2148, 12, 24, 12, 3, -24 },
  { 2184, 15, 24, 12, -1, -24 },
  { 2229, 13, 29, 9, -1, -24 },
  { 2277, 6, 24, 12, 3, -24 },
  { 2295, 12, 29, 9, -2, -24 },
  { 2339, 13, 14, 14, 0, -24 },
  { 2362, 11, 2, 10, -3, 3 },
  { 2365, 5, 5, 9, 5, -25 },
  { 2369, 13, 18, 14, 1, -18 },
  { 2399, 14, 25, 14, 0, -25 },
  { 2443, 11, 18, 11, 1, -18 },
  { 2468, 15, 25, 14, 1, -25 },
  { 2515, 12, 18, 13, 1, -18 },
  { 2542, 16, 33, 8, -4, -25 },
  { 2608, 15, 26, 14, -1, -18 },
  { 2657, 13, 25, 14, 0, -25 },
  { 2698, 8, 25, 7, 0, -25 },
  { 2723, 12, 33, 7, -4, -25 },
  { 2773, 14, 25, 13, 0, -25 },
  { 2817, 8, 25, 7, 0, -25 },
  { 2842, 20, 18, 21, 0, -18 },
  { 2887, 13, 18, 14, 0, -18 },
  { 2917, 12, 18, 14, 1, -18 },
  { 2944, 16, 26, 14, -2, -18 },
  { 2996, 13, 26, 14, 1, -18 },
  { 3039, 11, 18, 10, 0, -18 },
  { 3064, 11, 18, 11, 0, -18 },
  { 3089, 8, 22, 8, 1, -22 },
  { 3111, 13, 18, 14, 1, -18 },
  { 3141, 11, 18, 12, 2, -18 },
  { 3166, 18, 18, 19, 2, -18 },
  { 3207, 15, 18, 12, -2, -18 },
  { 3241, 17, 26, 12, -3, -18 },
  { 3297, 12, 18, 10, -1, -18 },
  { 3324, 12, 29, 11, 1, -24 },
  { 3368, 2, 33, 12, 5, -25 },
  { 3377, 12, 29, 11, -2, -24 },
  { 3421, 13, 5, 15, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC33PT7B_H_
