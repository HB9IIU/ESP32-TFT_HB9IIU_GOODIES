#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC24PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x71, 0xC6, 0x18, 0x63, 0x8C, 0x30, 0xC3, 0x18, 0x00, 0x06,
  0x38, 0xE0, 0x77, 0x66, 0x66, 0x66, 0x4C, 0xCC, 0x06, 0x60, 0xC8, 0x13,
  0x06, 0x60, 0xC8, 0x7F, 0xC6, 0x60, 0xC8, 0x11, 0x06, 0x63, 0xFF, 0x7F,
  0xC2, 0x60, 0xCC, 0x19, 0x02, 0x60, 0xCC, 0x00, 0x01, 0x00, 0x80, 0xFC,
  0x7F, 0x32, 0x4D, 0x03, 0x40, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x2C, 0x0B,
  0x02, 0xCC, 0xB3, 0xF8, 0x7C, 0x04, 0x01, 0x00, 0x3C, 0x30, 0xD0, 0x86,
  0x46, 0x19, 0x10, 0x4C, 0xC3, 0x36, 0x0C, 0xD9, 0x32, 0xDE, 0xDB, 0x69,
  0xDB, 0x30, 0x6C, 0x83, 0x22, 0x0D, 0x98, 0x66, 0x61, 0x99, 0x0C, 0x6C,
  0x60, 0xE0, 0x0F, 0x81, 0xB0, 0x66, 0x0C, 0xC1, 0x98, 0x36, 0x07, 0xC0,
  0x70, 0x3C, 0x2F, 0xD9, 0x9B, 0x73, 0xEC, 0x79, 0x86, 0x31, 0xE7, 0xFC,
  0x79, 0x80, 0x76, 0x66, 0x6C, 0x07, 0x06, 0x0C, 0x18, 0x18, 0x38, 0x30,
  0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x60,
  0x60, 0x60, 0x06, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0x07, 0x07, 0x06,
  0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x60, 0xC0, 0x0C,
  0x98, 0x79, 0xFF, 0x18, 0x3C, 0x6C, 0x26, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC7, 0xFC, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x33, 0x76, 0x6C, 0x7D,
  0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06,
  0x01, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x00, 0xC0, 0x00, 0x07, 0x83, 0xE1, 0x9C, 0xE3, 0x31, 0xCC, 0x77,
  0x19, 0x86, 0x61, 0x98, 0x66, 0x39, 0x8C, 0xE3, 0x39, 0xC6, 0x61, 0xF0,
  0x7C, 0x00, 0x0E, 0x3C, 0xF7, 0xE4, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0xE1,
  0x83, 0x06, 0x0C, 0x38, 0x60, 0x07, 0xC3, 0xF8, 0x23, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x1C, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0x87, 0xF1, 0x1C, 0x07, 0x01, 0xC0,
  0x60, 0x38, 0x78, 0x1E, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC8, 0x73,
  0xF8, 0xFC, 0x00, 0x01, 0xC0, 0xF0, 0x38, 0x1E, 0x0D, 0x83, 0xE1, 0xB0,
  0x4C, 0x33, 0x18, 0xC4, 0x73, 0xFE, 0xFF, 0x81, 0x80, 0x60, 0x38, 0x0C,
  0x00, 0x1F, 0xC7, 0xF1, 0x80, 0x60, 0x38, 0x0C, 0x03, 0xC0, 0xFC, 0x27,
  0x00, 0xC0, 0x38, 0x0C, 0x03, 0x00, 0xC8, 0x73, 0xF8, 0xFC, 0x00, 0x07,
  0x8F, 0xC6, 0x06, 0x07, 0x03, 0x01, 0xB9, 0xFC, 0xE7, 0x61, 0xB0, 0xD8,
  0xEC, 0x76, 0x33, 0x39, 0xF8, 0x78, 0x00, 0x3F, 0xDF, 0xE0, 0x18, 0x0E,
  0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C,
  0x06, 0x03, 0x80, 0xC0, 0x00, 0x0F, 0x87, 0xF3, 0x8C, 0xC3, 0x30, 0xCE,
  0x61, 0xB8, 0x78, 0x1E, 0x0D, 0xC6, 0x33, 0x0C, 0xC3, 0x30, 0xCC, 0x33,
  0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xE3, 0x98, 0xC7, 0x31, 0xDC, 0x77, 0x19,
  0xCE, 0x73, 0x8F, 0x61, 0xB8, 0x0C, 0x03, 0x01, 0x80, 0xE3, 0xF0, 0xF8,
  0x00, 0x19, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x19, 0xCC, 0x00, 0x0C, 0x71,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x61, 0x8C, 0x30, 0x00, 0x81,
  0xC3, 0xC7, 0x8F, 0x07, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xC0, 0x20, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x80, 0x70, 0x1E, 0x03, 0xC0,
  0x78, 0x1C, 0x3C, 0x78, 0xF8, 0x70, 0x20, 0x00, 0x3F, 0x3F, 0x23, 0x03,
  0x03, 0x06, 0x0E, 0x0C, 0x18, 0x30, 0x30, 0x30, 0x00, 0x00, 0x60, 0xE0,
  0xE0, 0x03, 0xE0, 0x71, 0x86, 0x06, 0x60, 0x32, 0x18, 0xB3, 0xE5, 0x13,
  0x39, 0x99, 0xC8, 0x9E, 0xCC, 0xE6, 0x65, 0x33, 0x69, 0xBA, 0x4E, 0xF2,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0xB8, 0x0F, 0x80, 0x01, 0xE0, 0x3C, 0x05,
  0x81, 0xB0, 0x3E, 0x0D, 0xC1, 0xB8, 0x77, 0x0C, 0xE1, 0x9C, 0x7F, 0x8F,
  0xF3, 0x8E, 0x61, 0xDC, 0x3B, 0x87, 0xE0, 0xE0, 0x1F, 0x83, 0xF8, 0x63,
  0x8C, 0x71, 0x8E, 0x71, 0x8C, 0x71, 0xFC, 0x3F, 0x06, 0x31, 0xC6, 0x30,
  0xC6, 0x18, 0xC3, 0x38, 0xE7, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xF1, 0x80,
  0xE0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0E, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x63, 0x8C, 0x31,
  0x86, 0x70, 0xCE, 0x19, 0x83, 0x30, 0xE6, 0x1D, 0xC3, 0x30, 0x66, 0x1C,
  0xC7, 0x39, 0xC7, 0xF0, 0xFC, 0x00, 0x1F, 0xC7, 0xF1, 0x80, 0x60, 0x18,
  0x0E, 0x03, 0x80, 0xFC, 0x3F, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E,
  0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF1, 0x80, 0x60, 0x18, 0x0E, 0x03,
  0x80, 0xC0, 0x3F, 0x0F, 0xC7, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xC0, 0x00, 0x07, 0xF1, 0xFE, 0x1C, 0x23, 0x80, 0x70, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xE3, 0xCC, 0x3C, 0xC1, 0xCC, 0x1C, 0xC1, 0x8C, 0x18, 0xE1,
  0x87, 0xF8, 0x3F, 0x00, 0x1C, 0x38, 0xE1, 0x86, 0x0C, 0x30, 0xE1, 0x87,
  0x1C, 0x30, 0xE1, 0x87, 0xFC, 0x3F, 0xE1, 0x87, 0x1C, 0x30, 0xC1, 0x86,
  0x0C, 0x30, 0xE3, 0x86, 0x1C, 0x30, 0xC1, 0x80, 0x1F, 0x83, 0x01, 0x80,
  0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0,
  0xC0, 0xF0, 0xFC, 0x00, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38,
  0x0C, 0x03, 0x00, 0xC1, 0x70, 0x78, 0x38, 0x00, 0x1C, 0x71, 0xC6, 0x18,
  0xC1, 0x9C, 0x1B, 0x83, 0xB0, 0x37, 0x03, 0x60, 0x3E, 0x03, 0xE0, 0x76,
  0x06, 0x70, 0x67, 0x06, 0x30, 0xE3, 0x0E, 0x30, 0xC3, 0x80, 0x1C, 0x38,
  0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x38, 0x7F,
  0xFE, 0x1E, 0x07, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x3E,
  0x1E, 0x36, 0x36, 0x36, 0x36, 0x36, 0x6E, 0x36, 0x6C, 0x76, 0xCC, 0x66,
  0xCC, 0x66, 0xCC, 0x67, 0x9C, 0xE7, 0x98, 0xC7, 0x18, 0xC7, 0x18, 0x1C,
  0x18, 0xE0, 0xC7, 0x86, 0x3C, 0x71, 0xE3, 0x1F, 0x18, 0xD8, 0xC6, 0x4E,
  0x33, 0x61, 0x9B, 0x1C, 0xD8, 0xC6, 0xC6, 0x36, 0x30, 0xE3, 0x87, 0x18,
  0x38, 0xC1, 0xC0, 0x0F, 0xC3, 0xF8, 0xE3, 0x98, 0x77, 0x06, 0xC0, 0xD8,
  0x3F, 0x07, 0xE0, 0xF8, 0x1B, 0x03, 0x60, 0xEC, 0x19, 0x87, 0x38, 0xC7,
  0xF8, 0x7C, 0x00, 0x1F, 0x83, 0xF8, 0x63, 0x8C, 0x71, 0x8E, 0x71, 0x8E,
  0x31, 0x8E, 0x3F, 0x87, 0xE1, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x00, 0x0F, 0xC3, 0xF8, 0xE3, 0x98, 0x77, 0x06, 0xC0, 0xD8,
  0x3F, 0x07, 0xE0, 0xF8, 0x1B, 0x03, 0x60, 0xEC, 0x19, 0x87, 0x38, 0xC3,
  0xF8, 0x7C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x1F, 0x83, 0xF8, 0x63,
  0x0C, 0x71, 0x8C, 0x71, 0x8C, 0x31, 0x8C, 0x3F, 0x87, 0xC1, 0xD8, 0x33,
  0x06, 0x70, 0xC6, 0x38, 0xC7, 0x18, 0xC3, 0x80, 0x07, 0xE1, 0xFC, 0x70,
  0x8C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xC0, 0x18, 0x07, 0x10, 0xC3, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0x18, 0x38,
  0x38, 0x30, 0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC0,
  0xC0, 0x38, 0x66, 0x0C, 0xC3, 0x98, 0x77, 0x0C, 0xE1, 0x98, 0x33, 0x0E,
  0x61, 0x9C, 0x33, 0x86, 0x60, 0xCC, 0x39, 0x86, 0x31, 0xC7, 0xF0, 0x7C,
  0x00, 0xC1, 0xF0, 0x6C, 0x1B, 0x0E, 0xC3, 0x31, 0xCC, 0x63, 0x18, 0xCC,
  0x33, 0x0D, 0xC3, 0x60, 0xD8, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x00, 0xC1,
  0x87, 0xC3, 0x86, 0xC3, 0x86, 0xC3, 0x8E, 0xC7, 0x8C, 0xC7, 0x9C, 0xCD,
  0x98, 0xCD, 0x98, 0xCD, 0xB8, 0xD9, 0xB0, 0xD9, 0xB0, 0xF1, 0xE0, 0xF1,
  0xE0, 0xF1, 0xE0, 0xE1, 0xC0, 0xE1, 0xC0, 0xC1, 0x80, 0x0C, 0x70, 0xC6,
  0x0C, 0xE0, 0xCC, 0x0D, 0x80, 0xF8, 0x07, 0x00, 0x70, 0x06, 0x00, 0xF0,
  0x1F, 0x01, 0xB0, 0x33, 0x03, 0x30, 0x63, 0x0E, 0x30, 0xC3, 0x80, 0xC3,
  0xF1, 0xB9, 0xDC, 0xC6, 0xE3, 0x61, 0xF0, 0xF0, 0x78, 0x38, 0x18, 0x0C,
  0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x00, 0x0F, 0xE3, 0xFC, 0x03, 0x00,
  0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03,
  0x00, 0xE0, 0x18, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0x87, 0xC3, 0x01, 0x80,
  0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0xC0, 0x60, 0x30, 0x18, 0x0F, 0x0F, 0x80, 0xE3, 0x18, 0xC6, 0x31, 0x8C,
  0x71, 0x8C, 0x63, 0x18, 0xC6, 0x38, 0x07, 0xC3, 0xE0, 0x18, 0x06, 0x03,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC1, 0xE0, 0xF8, 0x00, 0x02, 0x01, 0xC0,
  0xF0, 0x3C, 0x19, 0x86, 0x63, 0x19, 0x86, 0xE0, 0xC0, 0xFF, 0xFE, 0xE7,
  0x30, 0x1D, 0x9F, 0xDC, 0xEC, 0x7E, 0x3E, 0x1B, 0x0D, 0x86, 0xC7, 0x63,
  0x33, 0x9F, 0xCF, 0x60, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x07, 0xE3,
  0x7C, 0xE7, 0x30, 0xCC, 0x33, 0x1D, 0x87, 0x61, 0x98, 0x66, 0x3B, 0x8C,
  0xFF, 0x37, 0x80, 0x1F, 0x3E, 0x70, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xF8, 0x78, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x3B,
  0x0F, 0xE3, 0x9C, 0x63, 0x9C, 0x63, 0x0C, 0x61, 0x8C, 0x31, 0x8E, 0x31,
  0x86, 0x70, 0xFE, 0x1E, 0xC0, 0x1E, 0x3F, 0x73, 0x63, 0xE7, 0xDE, 0xFC,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFC, 0x7C, 0x01, 0xF0, 0x1E, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x7C, 0x0F, 0xC0, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x61, 0xFC, 0x73, 0x8C, 0x73,
  0x8E, 0x61, 0x8C, 0x31, 0x86, 0x31, 0xC6, 0x30, 0xCE, 0x1F, 0xC3, 0xD8,
  0x07, 0x00, 0xC0, 0x18, 0xC7, 0x1F, 0xC0, 0xE0, 0x00, 0x0C, 0x07, 0x01,
  0x80, 0x60, 0x18, 0x07, 0xE3, 0x78, 0xE7, 0x31, 0x8C, 0x63, 0x19, 0xC6,
  0x63, 0x98, 0xC6, 0x33, 0x8C, 0xC3, 0x31, 0xC0, 0x0C, 0x71, 0x80, 0x00,
  0x63, 0x8C, 0x30, 0xC3, 0x1C, 0x61, 0x86, 0x38, 0xC3, 0x00, 0x01, 0x81,
  0xC0, 0xC0, 0x00, 0x00, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0,
  0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x83, 0xC1,
  0xC0, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x33, 0x98, 0xCC, 0x37,
  0x0D, 0x83, 0xC1, 0xF0, 0x7E, 0x19, 0x86, 0x63, 0x98, 0xC6, 0x31, 0xC0,
  0x0C, 0x71, 0x86, 0x18, 0x63, 0x8C, 0x30, 0xC3, 0x1C, 0x61, 0x86, 0x38,
  0xC3, 0x00, 0x17, 0xBC, 0x7F, 0xF8, 0xE7, 0x39, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x98, 0x63, 0x31, 0x8E, 0x63, 0x18, 0xC6, 0x33, 0x8C, 0x66, 0x38,
  0xCC, 0x63, 0x80, 0x17, 0x8F, 0xE3, 0x9C, 0xC6, 0x31, 0x8C, 0x67, 0x19,
  0x8E, 0x63, 0x18, 0xCE, 0x33, 0x0C, 0xC7, 0x00, 0x1E, 0x3F, 0x73, 0x63,
  0xE3, 0xC3, 0xC3, 0xC3, 0xC7, 0xC6, 0xCE, 0xFC, 0x78, 0x09, 0xC3, 0x7C,
  0x73, 0x8C, 0x31, 0x86, 0x31, 0xCC, 0x39, 0x86, 0x30, 0xC6, 0x39, 0xC6,
  0x3F, 0xC6, 0xF0, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00,
  0x1D, 0x9F, 0xDC, 0xEC, 0x7E, 0x36, 0x1B, 0x0D, 0x86, 0xC7, 0x63, 0x33,
  0x9F, 0xCF, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x00, 0x17, 0x37,
  0x3C, 0x38, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0x1F,
  0x3F, 0x70, 0x70, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x0E, 0x8C, 0xFC, 0xF8,
  0x18, 0x43, 0x1F, 0xFD, 0x86, 0x18, 0x63, 0x8C, 0x30, 0xC3, 0x0F, 0x3C,
  0x31, 0xB8, 0xD8, 0xEC, 0x66, 0x37, 0x1B, 0x0D, 0x8E, 0xC6, 0x63, 0x33,
  0x9F, 0xCF, 0x60, 0xE3, 0xF1, 0xB9, 0xDC, 0xC6, 0x63, 0x61, 0xB0, 0xF0,
  0x58, 0x2C, 0x1C, 0x0E, 0x06, 0x00, 0xE3, 0x1F, 0x9C, 0x6E, 0x71, 0xB9,
  0xCC, 0xCF, 0x33, 0x3D, 0xCD, 0xB6, 0x36, 0xD8, 0xD3, 0xC3, 0xCF, 0x0F,
  0x3C, 0x38, 0xE0, 0xE3, 0x80, 0x18, 0xE3, 0x38, 0x66, 0x0F, 0x80, 0xF0,
  0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x06, 0xC1, 0xDC, 0x33, 0x8E, 0x30, 0x0C,
  0x70, 0xC6, 0x0C, 0x60, 0xCC, 0x0C, 0xC0, 0xD8, 0x0D, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30,
  0x0F, 0x00, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x70,
  0x30, 0x38, 0x18, 0x18, 0x1F, 0xCF, 0xC0, 0x03, 0xC1, 0xE0, 0x60, 0x38,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x1E, 0x06, 0x02, 0xC0, 0x38, 0x0E,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x1E, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C,
  0x0E, 0x07, 0x03, 0x0E, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x30, 0x70, 0xF0,
  0xC0, 0x78, 0xFF, 0xE3, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 17, 6, 0, -17 },
  { 14, 8, 6, 9, 2, -17 },
  { 20, 11, 17, 11, 0, -17 },
  { 44, 10, 19, 10, 0, -18 },
  { 68, 14, 17, 15, 1, -17 },
  { 98, 11, 17, 11, 0, -17 },
  { 122, 4, 6, 5, 2, -17 },
  { 125, 8, 21, 6, 0, -17 },
  { 146, 8, 21, 6, -2, -17 },
  { 167, 8, 8, 9, 2, -18 },
  { 175, 9, 11, 11, 1, -14 },
  { 188, 4, 6, 5, -1, -3 },
  { 191, 6, 3, 6, 0, -8 },
  { 194, 3, 3, 5, 0, -3 },
  { 196, 11, 17, 8, -1, -17 },
  { 220, 10, 17, 10, 0, -17 },
  { 242, 7, 17, 10, 2, -17 },
  { 257, 11, 17, 10, -1, -17 },
  { 281, 10, 17, 10, 0, -17 },
  { 303, 10, 17, 10, 0, -17 },
  { 325, 10, 17, 10, 0, -17 },
  { 347, 9, 17, 10, 1, -17 },
  { 367, 10, 17, 10, 1, -17 },
  { 389, 10, 17, 10, 0, -17 },
  { 411, 10, 17, 10, 0, -17 },
  { 433, 5, 13, 5, 0, -13 },
  { 442, 6, 16, 5, -1, -13 },
  { 454, 9, 11, 11, 1, -14 },
  { 467, 9, 7, 11, 1, -12 },
  { 475, 9, 11, 11, 1, -14 },
  { 488, 8, 17, 7, 0, -17 },
  { 505, 13, 19, 15, 1, -17 },
  { 536, 11, 17, 10, -2, -17 },
  { 560, 11, 17, 11, 0, -17 },
  { 584, 10, 17, 10, 1, -17 },
  { 606, 11, 17, 12, 0, -17 },
  { 630, 10, 17, 9, 0, -17 },
  { 652, 10, 17, 9, 0, -17 },
  { 674, 12, 17, 12, 1, -17 },
  { 700, 13, 17, 12, 0, -17 },
  { 728, 9, 17, 7, -1, -17 },
  { 748, 10, 22, 5, -4, -17 },
  { 776, 12, 17, 10, 0, -17 },
  { 802, 7, 17, 8, 0, -17 },
  { 817, 16, 17, 16, 0, -17 },
  { 851, 13, 17, 13, 0, -17 },
  { 879, 11, 17, 12, 1, -17 },
  { 903, 11, 17, 10, 0, -17 },
  { 927, 11, 21, 12, 1, -17 },
  { 956, 11, 17, 10, 0, -17 },
  { 980, 11, 17, 9, -1, -17 },
  { 1004, 8, 17, 9, 2, -17 },
  { 1021, 11, 17, 12, 1, -17 },
  { 1045, 10, 17, 10, 2, -17 },
  { 1067, 16, 17, 16, 2, -17 },
  { 1101, 12, 17, 9, -1, -17 },
  { 1127, 9, 17, 9, 2, -17 },
  { 1147, 11, 17, 8, -1, -17 },
  { 1171, 9, 21, 7, -1, -17 },
  { 1195, 5, 17, 8, 2, -17 },
  { 1206, 10, 21, 7, -2, -17 },
  { 1233, 10, 9, 10, 0, -17 },
  { 1245, 8, 2, 7, -2, 2 },
  { 1247, 4, 3, 6, 3, -18 },
  { 1249, 9, 13, 10, 1, -13 },
  { 1264, 10, 18, 10, 0, -18 },
  { 1287, 8, 13, 8, 1, -13 },
  { 1300, 11, 18, 10, 1, -18 },
  { 1325, 8, 13, 9, 1, -13 },
  { 1338, 12, 24, 6, -3, -18 },
  { 1374, 11, 19, 10, -1, -13 },
  { 1401, 10, 18, 10, 0, -18 },
  { 1424, 6, 18, 5, 0, -18 },
  { 1438, 9, 24, 5, -3, -18 },
  { 1465, 10, 18, 9, 0, -18 },
  { 1488, 6, 18, 5, 0, -18 },
  { 1502, 15, 13, 15, 0, -13 },
  { 1527, 10, 13, 10, 0, -13 },
  { 1544, 8, 13, 10, 1, -13 },
  { 1557, 11, 19, 10, -1, -13 },
  { 1584, 9, 19, 10, 1, -13 },
  { 1606, 8, 13, 7, 0, -13 },
  { 1619, 8, 13, 8, 0, -13 },
  { 1632, 6, 16, 6, 1, -16 },
  { 1644, 9, 13, 10, 1, -13 },
  { 1659, 9, 13, 9, 1, -13 },
  { 1674, 14, 13, 14, 1, -13 },
  { 1697, 11, 13, 9, -1, -13 },
  { 1715, 12, 19, 9, -2, -13 },
  { 1744, 9, 13, 7, -1, -13 },
  { 1759, 10, 21, 8, 0, -17 },
  { 1786, 2, 24, 9, 3, -18 },
  { 1792, 8, 21, 8, -1, -17 },
  { 1813, 9, 3, 11, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC24PT7B_H_
