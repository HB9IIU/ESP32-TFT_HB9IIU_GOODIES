#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC45PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x07,
  0x80, 0x3E, 0x7C, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x78, 0x79, 0xE1, 0xC7,
  0x8F, 0x1E, 0x3C, 0x70, 0xF1, 0xC3, 0x8F, 0x0E, 0x00, 0x00, 0x3C, 0x70,
  0x01, 0xC3, 0x80, 0x0E, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38,
  0x70, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x3C, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C,
  0x00, 0xF1, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0xC7, 0x80, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0x70, 0xE0, 0x03, 0x87, 0x00,
  0x1C, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x8E,
  0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x3C, 0x00, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x3E, 0xCE, 0x0F, 0x98, 0x81, 0xE2, 0x00, 0x3C, 0xC0, 0x07,
  0x98, 0x00, 0xF3, 0x00, 0x1F, 0x60, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xBE, 0x00, 0x33, 0xC0, 0x04, 0x78, 0x01, 0x8F, 0x00, 0x31, 0xE2, 0x06,
  0x78, 0x70, 0xDF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFE,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0x03, 0xF8, 0x07, 0x03, 0xDE,
  0x07, 0x01, 0xC7, 0x03, 0x81, 0xC3, 0x83, 0x80, 0xE1, 0xC3, 0xC0, 0xF0,
  0xE1, 0xC0, 0x70, 0xF1, 0xE0, 0x38, 0x78, 0xE0, 0x1C, 0x38, 0xF0, 0x0E,
  0x1C, 0x70, 0x0F, 0x0E, 0x78, 0x07, 0x0F, 0x38, 0x63, 0x87, 0x3C, 0xFD,
  0xC3, 0x9C, 0xFF, 0xE3, 0x9E, 0x77, 0xFB, 0xCE, 0x71, 0xDF, 0xCF, 0x38,
  0xEF, 0xC7, 0x38, 0x70, 0x87, 0x1C, 0x38, 0x03, 0x8E, 0x1C, 0x03, 0x8E,
  0x0E, 0x01, 0xC7, 0x0F, 0x01, 0xC3, 0x87, 0x01, 0xE1, 0xC3, 0x80, 0xE0,
  0xE1, 0xC0, 0xF0, 0x71, 0xE0, 0x70, 0x38, 0xE0, 0x78, 0x1C, 0xF0, 0x38,
  0x0F, 0xF0, 0x3C, 0x07, 0xF0, 0x1C, 0x01, 0xF0, 0x00, 0x00, 0x18, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xE7, 0x80, 0x3C, 0x78,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x70, 0x03, 0xCF,
  0x00, 0x3C, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0x1F, 0xF0, 0xF3, 0xEF, 0x9E, 0x3C,
  0x79, 0xE7, 0x87, 0xBC, 0x78, 0x7F, 0xCF, 0x03, 0xFC, 0xF0, 0x3F, 0x8F,
  0x03, 0xF0, 0xF0, 0x1F, 0x0F, 0x03, 0xF0, 0xF0, 0x7F, 0x0F, 0x8F, 0xF0,
  0xFF, 0xFF, 0x87, 0xFE, 0xF8, 0x3F, 0x87, 0xC0, 0x7D, 0xE7, 0x9E, 0x7B,
  0xCF, 0x3C, 0xF3, 0x8E, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x02, 0x1E, 0x07, 0x38, 0x0F, 0xF3, 0xBF, 0xFF,
  0x8F, 0xFF, 0x07, 0xFC, 0x1F, 0x80, 0x7F, 0x81, 0xE7, 0x07, 0x8F, 0x07,
  0x1F, 0x04, 0x18, 0x00, 0x20, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x78,
  0x78, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x19, 0xF7, 0xFF, 0xF9,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x7E, 0xF8,
  0x3C, 0x3C, 0x3E, 0x1E, 0x1E, 0x0F, 0x1F, 0x07, 0x8F, 0x03, 0xC7, 0x81,
  0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3D, 0xF0, 0x3E, 0xF0, 0x1E, 0x78,
  0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xDF, 0x03, 0xEF, 0x01, 0xE7, 0x80, 0xF3,
  0xC0, 0x79, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x1E, 0x1E, 0x1F,
  0x0F, 0x0F, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x00,
  0x01, 0xF0, 0x3E, 0x07, 0xE0, 0xFE, 0x1F, 0xE3, 0xDE, 0x7F, 0xCF, 0x3C,
  0xE3, 0xC4, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x00, 0x06, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xF3,
  0xF0, 0x1C, 0x1F, 0x00, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x00,
  0x0C, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3C, 0x3E, 0x02,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x88, 0x03, 0xE1, 0xE1, 0xF8, 0x3F, 0xFE,
  0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xBC, 0x00, 0x7B, 0xC0, 0x07, 0x78, 0x00, 0xE7, 0x80, 0x0E, 0x78,
  0x01, 0xC7, 0x80, 0x38, 0x78, 0x03, 0x8F, 0x00, 0x70, 0xF0, 0x0F, 0x0F,
  0x00, 0xE0, 0xF0, 0x1C, 0x1F, 0x03, 0xC1, 0xE0, 0x38, 0x1E, 0x07, 0x01,
  0xE0, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x40, 0x3E, 0x0F, 0x1F, 0x81, 0xFF,
  0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xF0, 0x07,
  0xFC, 0x03, 0xFF, 0x01, 0xF0, 0x40, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x3F, 0x03, 0xDF, 0xE1, 0xFF, 0xF8, 0x7F, 0x3E, 0x1F, 0x87, 0xC7, 0xC1,
  0xF1, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0x78,
  0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x03, 0xC3, 0xC0, 0xF0, 0xF8, 0x7C, 0x1F,
  0x7E, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x08, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7C,
  0x3C, 0x0F, 0x07, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xE0,
  0x78, 0x3C, 0x0F, 0x07, 0xC3, 0xC0, 0x78, 0xF8, 0x0F, 0xBE, 0x00, 0xFF,
  0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0x1F,
  0x07, 0xC1, 0xE0, 0xF0, 0x3E, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x83, 0xE1, 0xF8, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x3F,
  0xC0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xC7, 0xC1, 0xE1, 0xF0, 0xF0, 0x3C,
  0x3C, 0x0F, 0x1F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E,
  0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3E, 0x1E, 0x1F, 0x87, 0xFF,
  0xE1, 0xFF, 0x78, 0x3F, 0xBE, 0x07, 0xCF, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x01,
  0xF8, 0x20, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x0F, 0x0F, 0x87, 0xC3,
  0xE1, 0xE0, 0x01, 0xE0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0x00,
  0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xC0, 0x00, 0xE0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00,
  0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0x38, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF,
  0xE1, 0xC7, 0xC2, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xE3, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0xF0, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x0E, 0x03, 0xC1,
  0xC3, 0x83, 0xFC, 0x71, 0xC1, 0xFF, 0x1C, 0x70, 0xE3, 0x87, 0x38, 0x78,
  0xE1, 0xCE, 0x1C, 0x38, 0x73, 0x8E, 0x1E, 0x39, 0xC3, 0x87, 0x0E, 0x70,
  0xE1, 0xC3, 0x9C, 0x70, 0x70, 0xE7, 0x1C, 0x3C, 0x33, 0x87, 0x0E, 0x1C,
  0xE1, 0xC3, 0x87, 0x38, 0x71, 0xE3, 0x8E, 0x1C, 0x78, 0xE3, 0x87, 0x3E,
  0x70, 0xE1, 0xFD, 0xFC, 0x38, 0x7E, 0x7E, 0x0E, 0x0F, 0x0E, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x04, 0x00, 0x3E, 0x07, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xEF, 0x00,
  0x3D, 0xE0, 0x07, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x1E, 0x01,
  0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x78, 0x3C, 0x0F,
  0x07, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xE0, 0x78, 0x78,
  0x0F, 0x1F, 0x01, 0xE3, 0xC0, 0x3C, 0xF8, 0x07, 0x9F, 0x00, 0xF3, 0xC0,
  0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0x01, 0xFF, 0x80, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x3C, 0x7F, 0x03, 0xC1, 0xF0, 0x3C, 0x0F, 0x07,
  0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x1F, 0x0F, 0x81, 0xE0,
  0xF8, 0x3E, 0x0F, 0x07, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x01, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x3E, 0x07,
  0xC3, 0xC0, 0x7C, 0x3C, 0x07, 0xC3, 0xC0, 0x7C, 0x3C, 0x07, 0x87, 0xC0,
  0xF8, 0x78, 0x0F, 0x87, 0x81, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0x1C, 0x0F, 0x80, 0x83, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x80, 0xFE, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3C, 0x1F,
  0x01, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x3C,
  0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF0, 0x0F, 0x87, 0x80, 0x7C,
  0x3C, 0x03, 0xE3, 0xE0, 0x1E, 0x1F, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80,
  0x7C, 0x3C, 0x03, 0xE3, 0xE0, 0x1E, 0x1F, 0x01, 0xF0, 0xF0, 0x0F, 0x07,
  0x80, 0xF8, 0x3C, 0x07, 0x83, 0xE0, 0x7C, 0x1E, 0x07, 0xC0, 0xF0, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xF8, 0xF8, 0x1F, 0x80, 0x40,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x1F, 0xE3, 0xE0, 0x7F, 0x8F, 0x01, 0xFE, 0x3C,
  0x08, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x7C, 0x3C, 0x01,
  0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x80, 0x78, 0x3E, 0x03, 0xE0,
  0xFC, 0x0F, 0x01, 0xFC, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x01, 0xE0, 0x1F, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x1E, 0x03,
  0xC0, 0x3E, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x3C, 0x07,
  0x80, 0x3C, 0x07, 0x80, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0x78, 0x0F,
  0x80, 0x78, 0x0F, 0x00, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1E, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x03, 0xE0, 0x3C,
  0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x78,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x07, 0x80, 0xF8, 0x07, 0x80, 0xF0,
  0x0F, 0x80, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x47,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x03, 0xE0, 0x1E, 0x07, 0x80, 0x3C,
  0x1F, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x8F,
  0x80, 0x0F, 0x1E, 0x00, 0x3E, 0x78, 0x00, 0x7D, 0xF0, 0x00, 0xF7, 0xC0,
  0x01, 0xEF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xF3, 0xE0, 0x03, 0xE3, 0xC0, 0x07,
  0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0xF8,
  0x7C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xF0, 0x1F, 0x03,
  0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0x01,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0,
  0x1E, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7B, 0xC0, 0x77, 0x80, 0xF7, 0x81,
  0xEF, 0x01, 0xEF, 0x03, 0x9E, 0x03, 0xDE, 0x0F, 0x3C, 0x0F, 0x3C, 0x1C,
  0xF8, 0x1E, 0x78, 0x79, 0xE0, 0x3C, 0x70, 0xF3, 0xC0, 0x78, 0xE3, 0xC7,
  0x80, 0xF1, 0xC7, 0x8F, 0x03, 0xC3, 0x9E, 0x3C, 0x07, 0x87, 0x3C, 0x78,
  0x0F, 0x0E, 0x70, 0xF0, 0x1E, 0x1D, 0xE1, 0xE0, 0x3C, 0x3B, 0x83, 0xC0,
  0xF0, 0x7F, 0x0F, 0x01, 0xE0, 0xFE, 0x1E, 0x03, 0xC1, 0xF8, 0x3C, 0x07,
  0x83, 0xF0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x83, 0xC0, 0x78,
  0x1E, 0x07, 0x80, 0x01, 0xF0, 0x07, 0x81, 0xF8, 0x07, 0xC0, 0xFC, 0x03,
  0xC0, 0x7E, 0x01, 0xE0, 0x3F, 0x00, 0xF0, 0x1F, 0xC0, 0x78, 0x1F, 0xE0,
  0x78, 0x0F, 0xF0, 0x3C, 0x07, 0xF8, 0x1E, 0x03, 0xDC, 0x0F, 0x03, 0xCE,
  0x07, 0x81, 0xE7, 0x87, 0x80, 0xF3, 0xC3, 0xC0, 0x79, 0xE1, 0xE0, 0x3C,
  0xF0, 0xF0, 0x3C, 0x38, 0x78, 0x1E, 0x1C, 0x78, 0x0F, 0x0F, 0x3C, 0x07,
  0x87, 0x9E, 0x03, 0xC3, 0xCF, 0x03, 0xC1, 0xEF, 0x81, 0xE0, 0x77, 0x80,
  0xF0, 0x3B, 0xC0, 0x78, 0x1F, 0xE0, 0x3C, 0x0F, 0xF0, 0x3C, 0x07, 0xF0,
  0x1E, 0x03, 0xF8, 0x0F, 0x00, 0xFC, 0x07, 0x80, 0x7E, 0x07, 0xC0, 0x3F,
  0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x0C, 0x00, 0x07, 0xF8,
  0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xE3, 0xF0, 0x7C, 0x1F, 0x0F, 0x80,
  0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF3, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xC0,
  0x0F, 0x7C, 0x00, 0xF7, 0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xEF,
  0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0x8F, 0x00, 0xF8,
  0xF0, 0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC,
  0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xC3, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xF0,
  0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1E,
  0x0F, 0x01, 0xE0, 0xF0, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0xFC, 0x1F, 0xFF,
  0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE,
  0x07, 0xE3, 0xF0, 0x7C, 0x1F, 0x0F, 0x80, 0xF1, 0xF0, 0x0F, 0x1E, 0x00,
  0xF3, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x0F, 0x7C, 0x00, 0xF7, 0xC0,
  0x0F, 0x78, 0x00, 0xF7, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xCF,
  0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x81, 0xF0,
  0xF8, 0x3E, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xC3, 0xE0, 0x3C, 0x1F,
  0x07, 0xC1, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0x78, 0x1F, 0x0F, 0x81,
  0xE0, 0xF8, 0x1E, 0x0F, 0x03, 0xE0, 0xF0, 0x7C, 0x0F, 0x0F, 0xC1, 0xFF,
  0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xE7, 0xC0, 0x3E,
  0x7C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3E, 0x07,
  0xC3, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x0F, 0x01, 0xF0, 0x00, 0x06, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E, 0x04, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x08, 0x01, 0xE0, 0x60, 0x3E, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF,
  0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x3C, 0x1F, 0x01, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1E, 0x07,
  0x80, 0x78, 0x3E, 0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3C, 0x0F, 0x00,
  0xF0, 0x3C, 0x03, 0xC1, 0xF0, 0x0F, 0x07, 0x80, 0x7C, 0x1E, 0x01, 0xE0,
  0x78, 0x07, 0x83, 0xE0, 0x1E, 0x0F, 0x80, 0xF8, 0x3C, 0x03, 0xE0, 0xF0,
  0x0F, 0x03, 0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x7C, 0x07, 0xC1, 0xE0, 0x1E,
  0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x0F, 0x83, 0xE0, 0x3C, 0x07,
  0x81, 0xF0, 0x1F, 0x07, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x1F, 0x78,
  0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0x80, 0xF0, 0xF0,
  0x1E, 0x1E, 0x07, 0xC3, 0xC0, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x81, 0xE0,
  0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xC7,
  0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xEF, 0x80, 0x3D, 0xE0, 0x07, 0xBC,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x3E,
  0xF0, 0x0F, 0x80, 0x79, 0xE0, 0x1F, 0x01, 0xF3, 0xC0, 0x3E, 0x03, 0xC7,
  0x80, 0xFC, 0x07, 0x8F, 0x01, 0xF0, 0x1E, 0x1E, 0x07, 0xE0, 0x3C, 0x3C,
  0x0F, 0xC0, 0xF8, 0x78, 0x1F, 0x81, 0xE0, 0xF0, 0x7F, 0x03, 0xC1, 0xE0,
  0xEE, 0x0F, 0x03, 0xC3, 0xDC, 0x1E, 0x07, 0x87, 0xB8, 0x7C, 0x0F, 0x0E,
  0x70, 0xF0, 0x1E, 0x3C, 0xE1, 0xE0, 0x3C, 0x71, 0xC7, 0xC0, 0x79, 0xE3,
  0x8F, 0x01, 0xE3, 0xC7, 0x3E, 0x03, 0xC7, 0x0E, 0x78, 0x07, 0x9E, 0x3C,
  0xF0, 0x0F, 0x38, 0x7B, 0xE0, 0x1E, 0xF0, 0xF7, 0x80, 0x3D, 0xE1, 0xEF,
  0x00, 0x7B, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x7E, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x7C,
  0x00, 0x78, 0x78, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0x79, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xEF, 0x00, 0x03, 0xEF, 0x00, 0x03, 0xCF, 0x00, 0x07, 0xCF, 0x00,
  0x07, 0x8F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x1E, 0x0F, 0x80,
  0x3E, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x7C, 0x07, 0x80, 0xF8, 0x07, 0x80,
  0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x07, 0x9F, 0x03, 0xCF, 0x83, 0xC7, 0xC1,
  0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x0F,
  0x3C, 0x07, 0xBC, 0x03, 0xDE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x7F, 0xC0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xF0, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1E, 0xE0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE3,
  0xC0, 0x78, 0x70, 0x3C, 0x1E, 0x1E, 0x07, 0x87, 0x80, 0xE3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x78, 0x03, 0xFC, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFB, 0xE7, 0x9E, 0x3C, 0x71, 0xC0, 0x00, 0x60, 0x20, 0x7F, 0x38,
  0x1F, 0xEF, 0x07, 0xFF, 0xE0, 0xF8, 0xFC, 0x3E, 0x1F, 0x87, 0x81, 0xE1,
  0xF0, 0x3C, 0x3C, 0x07, 0x8F, 0x80, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x87,
  0x80, 0xF1, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x1E, 0x1E,
  0x03, 0xC3, 0xC0, 0xF8, 0x78, 0x1F, 0x0F, 0x87, 0xC1, 0xF1, 0xF8, 0x1F,
  0xFF, 0x03, 0xFD, 0xE0, 0x3F, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x01, 0xE1, 0x80, 0x7B, 0xF8, 0x1F, 0xFE, 0x0F, 0x7F,
  0xC3, 0xF1, 0xF0, 0xF8, 0x3C, 0x3E, 0x0F, 0x0F, 0x03, 0xC7, 0xC0, 0xF1,
  0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0xF0,
  0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE7, 0xC0, 0xF9, 0xF0, 0x3C, 0x7C, 0x1F,
  0x1F, 0x07, 0x87, 0xE7, 0xE3, 0xDF, 0xF0, 0xF7, 0xF8, 0x38, 0xFC, 0x00,
  0x00, 0x70, 0x03, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xF8, 0x43, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x0F, 0x82, 0x0F, 0x8C, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07,
  0x1F, 0x00, 0xFE, 0xF0, 0x0F, 0xF7, 0x80, 0xFF, 0xFC, 0x07, 0xC7, 0xE0,
  0x7C, 0x3F, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x3C, 0x1F, 0x01,
  0xE0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x83, 0xE0, 0x3C, 0x1F,
  0x01, 0xE0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x7C,
  0x0F, 0x03, 0xE0, 0x7C, 0x3E, 0x03, 0xE3, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xBC, 0x01, 0xF9, 0xC0, 0x00, 0x00, 0x30, 0x01, 0xFC, 0x07, 0xFE, 0x0F,
  0xFF, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78,
  0x1E, 0x78, 0x7C, 0x7F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC0, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x10, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x20, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x18, 0x08, 0x07, 0xF3, 0x80,
  0x7F, 0xBC, 0x07, 0xFF, 0xE0, 0x3E, 0x3F, 0x03, 0xE1, 0xF8, 0x1E, 0x07,
  0x81, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3C,
  0x07, 0x81, 0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0xF0,
  0x3C, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x3F, 0x03, 0xE1,
  0xF0, 0x1F, 0x1F, 0x80, 0x7F, 0xFC, 0x03, 0xFD, 0xE0, 0x0F, 0xDF, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x02, 0x01, 0xF0, 0x18, 0x1F, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE3, 0x80, 0x7B, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0xC3, 0xF1,
  0xF0, 0xF8, 0x3C, 0x3E, 0x0F, 0x0F, 0x03, 0xC7, 0xC1, 0xF1, 0xE0, 0x78,
  0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xC0, 0xF8, 0xF0, 0x3C, 0x3C,
  0x0F, 0x0F, 0x03, 0xC7, 0xC0, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07,
  0x87, 0x81, 0xE3, 0xE0, 0xF8, 0xF0, 0x3C, 0x3C, 0x0F, 0x00, 0x01, 0xE0,
  0x7C, 0x0F, 0x81, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x0F, 0x83, 0xC3, 0xE0, 0xF8,
  0x78, 0x1E, 0x1E, 0x03, 0xC7, 0xC0, 0x79, 0xF0, 0x0F, 0x3C, 0x03, 0xCF,
  0x00, 0x7B, 0xE0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C,
  0x07, 0x87, 0x80, 0xF0, 0xF8, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C,
  0x1E, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0,
  0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0,
  0x1E, 0x00, 0x00, 0x0E, 0x03, 0x00, 0xE7, 0xF3, 0xF8, 0x1D, 0xFE, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0xFC, 0x7F, 0x3E, 0x1F, 0x0F, 0xC3, 0xC3, 0xC1,
  0xF0, 0x78, 0x78, 0x3E, 0x0F, 0x1F, 0x07, 0x81, 0xE3, 0xC0, 0xF0, 0x3C,
  0x78, 0x1E, 0x0F, 0x0F, 0x03, 0xC1, 0xE1, 0xE0, 0xF0, 0x3C, 0x78, 0x1E,
  0x07, 0x8F, 0x03, 0xC1, 0xF1, 0xE0, 0x78, 0x3C, 0x3C, 0x1F, 0x07, 0x8F,
  0x83, 0xC0, 0xF1, 0xE0, 0x78, 0x1E, 0x3C, 0x0F, 0x07, 0x87, 0x81, 0xE0,
  0xF0, 0xF0, 0x78, 0x1E, 0x3C, 0x0F, 0x03, 0xC7, 0x81, 0xE0, 0x78, 0xF0,
  0x3C, 0x1E, 0x00, 0x00, 0x06, 0x01, 0xCF, 0xE0, 0x77, 0xF8, 0x3F, 0xFF,
  0x0F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x3C, 0x0F, 0x1F, 0x07, 0xC7,
  0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x03, 0xC3, 0xC0,
  0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1F, 0x03, 0xC7, 0x81, 0xE1, 0xE0, 0x78,
  0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x83, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0xF0, 0xF0, 0xF0,
  0x7C, 0x78, 0x3E, 0x78, 0x0F, 0x3C, 0x07, 0xBE, 0x03, 0xDE, 0x03, 0xEF,
  0x01, 0xF7, 0x80, 0xF7, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x3E, 0xF0, 0x1E,
  0x78, 0x0F, 0x3C, 0x0F, 0x9E, 0x07, 0x8F, 0x87, 0xC3, 0xC7, 0xC1, 0xFF,
  0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x1C, 0xFE, 0x01,
  0xDF, 0xF0, 0x3D, 0xFF, 0x03, 0xF0, 0xF0, 0x3E, 0x0F, 0x03, 0xE0, 0xF0,
  0x3C, 0x0F, 0x07, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F,
  0x07, 0x80, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01,
  0xE0, 0xF0, 0x3E, 0x1F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x81, 0xF9,
  0xF8, 0x3D, 0xFF, 0x03, 0xDF, 0xE0, 0x3C, 0xFC, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x60, 0x20, 0x7F, 0x38, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0xFC,
  0x3E, 0x1F, 0x87, 0x81, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x8F, 0x80, 0xF1,
  0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF1, 0xF0, 0x1E, 0x3E, 0x03, 0xC7,
  0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF8, 0x78, 0x1F, 0x0F,
  0x87, 0xC1, 0xF1, 0xF8, 0x1F, 0xFF, 0x03, 0xFD, 0xE0, 0x3F, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x0E, 0x7C, 0x1D, 0xF8, 0x7B, 0xE0, 0xFF, 0xC1,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xF1, 0xF0, 0xC3, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x88, 0x1F, 0x1C, 0x7E, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x1F, 0xF3, 0xFE,
  0x7F, 0xE1, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF9, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x0F, 0x03, 0xC3,
  0xC0, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0,
  0x78, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF1, 0xF0, 0x7C,
  0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF8, 0x3E, 0x3C,
  0x0F, 0x0F, 0x07, 0xC3, 0xC1, 0xF0, 0xF9, 0xFC, 0x3F, 0xEE, 0x07, 0xFB,
  0x80, 0xF8, 0xE0, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xF7, 0x83, 0xEF, 0x07,
  0x9E, 0x0F, 0x3C, 0x3C, 0x78, 0x78, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87,
  0x9E, 0x0F, 0x3C, 0x1E, 0xF0, 0x3D, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xDC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0x78, 0x1E, 0x07, 0xDE, 0x0F, 0x81, 0xE7, 0x83, 0xE0, 0xF1, 0xE1, 0xF8,
  0x3C, 0x78, 0x7E, 0x0F, 0x1E, 0x1F, 0x87, 0x87, 0x8F, 0xE1, 0xE1, 0xE3,
  0xB8, 0x70, 0x79, 0xEE, 0x3C, 0x1C, 0x73, 0x8F, 0x07, 0x1C, 0xE7, 0x81,
  0xCF, 0x39, 0xE0, 0x73, 0x8E, 0x70, 0x1C, 0xE3, 0xBC, 0x07, 0x78, 0xEF,
  0x01, 0xDC, 0x7B, 0x80, 0x7F, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1,
  0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F,
  0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x3C, 0x1E, 0x03,
  0xC3, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0x80, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xBC,
  0x00, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x3C, 0x3C, 0x07, 0xC3,
  0xE0, 0x78, 0x1E, 0x0F, 0x81, 0xE0, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78,
  0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00,
  0x78, 0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x07,
  0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0x7B,
  0xC0, 0x00, 0xF7, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x1E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0xBF, 0xC0, 0x7F, 0xFC, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x03, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 12, 32, 11, 0, -32 },
  { 49, 14, 11, 16, 4, -32 },
  { 69, 21, 32, 20, 0, -32 },
  { 153, 19, 37, 18, 0, -34 },
  { 241, 25, 33, 29, 2, -33 },
  { 345, 20, 33, 20, 0, -33 },
  { 428, 6, 11, 9, 5, -32 },
  { 437, 14, 39, 12, 1, -32 },
  { 506, 14, 39, 12, -3, -32 },
  { 575, 15, 16, 17, 4, -34 },
  { 605, 17, 22, 20, 2, -27 },
  { 652, 8, 11, 10, -2, -5 },
  { 663, 10, 4, 12, 1, -14 },
  { 668, 6, 6, 10, 0, -6 },
  { 673, 21, 32, 16, -2, -32 },
  { 757, 17, 33, 18, 1, -33 },
  { 828, 12, 32, 18, 5, -32 },
  { 876, 20, 33, 18, -2, -33 },
  { 959, 19, 33, 18, -1, -33 },
  { 1038, 20, 32, 18, -1, -32 },
  { 1118, 19, 32, 18, 0, -32 },
  { 1194, 18, 33, 18, 1, -33 },
  { 1269, 19, 32, 18, 1, -32 },
  { 1345, 19, 33, 18, 0, -33 },
  { 1424, 18, 33, 18, 0, -33 },
  { 1499, 9, 24, 10, 0, -24 },
  { 1526, 12, 30, 10, -2, -24 },
  { 1571, 17, 20, 20, 2, -26 },
  { 1614, 17, 13, 20, 2, -22 },
  { 1642, 17, 20, 20, 2, -26 },
  { 1685, 15, 33, 14, 1, -33 },
  { 1747, 26, 36, 27, 1, -32 },
  { 1864, 19, 32, 19, -3, -32 },
  { 1940, 20, 32, 20, 0, -32 },
  { 2020, 19, 33, 18, 2, -33 },
  { 2099, 21, 32, 22, 0, -32 },
  { 2183, 19, 32, 17, 0, -32 },
  { 2259, 19, 32, 16, 0, -32 },
  { 2335, 22, 33, 23, 2, -33 },
  { 2426, 24, 32, 22, 0, -32 },
  { 2522, 18, 32, 12, -2, -32 },
  { 2594, 18, 41, 10, -7, -32 },
  { 2687, 23, 32, 19, 0, -32 },
  { 2779, 13, 32, 16, 0, -32 },
  { 2831, 31, 32, 30, 0, -32 },
  { 2955, 25, 32, 24, 0, -32 },
  { 3055, 20, 33, 23, 2, -33 },
  { 3138, 20, 32, 19, 0, -32 },
  { 3218, 20, 41, 23, 2, -33 },
  { 3321, 20, 32, 19, 0, -32 },
  { 3401, 20, 33, 17, -1, -33 },
  { 3484, 17, 32, 16, 3, -32 },
  { 3552, 22, 32, 22, 1, -32 },
  { 3640, 19, 32, 19, 4, -32 },
  { 3716, 31, 32, 30, 3, -32 },
  { 3840, 24, 32, 18, -3, -32 },
  { 3936, 17, 32, 17, 4, -32 },
  { 4004, 21, 32, 16, -2, -32 },
  { 4088, 17, 39, 13, -1, -32 },
  { 4171, 8, 32, 16, 4, -32 },
  { 4203, 17, 39, 13, -3, -32 },
  { 4286, 18, 18, 18, 0, -32 },
  { 4327, 14, 3, 14, -4, 4 },
  { 4333, 6, 7, 12, 7, -34 },
  { 4339, 19, 25, 20, 1, -25 },
  { 4399, 18, 34, 19, 0, -34 },
  { 4476, 15, 25, 15, 1, -25 },
  { 4523, 21, 34, 20, 1, -34 },
  { 4613, 16, 25, 18, 1, -25 },
  { 4663, 21, 45, 11, -5, -34 },
  { 4782, 21, 36, 20, -1, -25 },
  { 4877, 18, 34, 19, 0, -34 },
  { 4954, 11, 33, 9, 0, -33 },
  { 5000, 17, 44, 9, -6, -33 },
  { 5094, 19, 34, 17, 0, -34 },
  { 5175, 11, 34, 9, 0, -34 },
  { 5222, 27, 25, 28, 0, -25 },
  { 5307, 18, 25, 19, 0, -25 },
  { 5364, 17, 25, 19, 1, -25 },
  { 5418, 20, 36, 19, -2, -25 },
  { 5508, 19, 36, 19, 1, -25 },
  { 5594, 15, 25, 13, 0, -25 },
  { 5641, 15, 25, 15, 0, -25 },
  { 5688, 12, 30, 11, 1, -30 },
  { 5733, 18, 24, 19, 1, -24 },
  { 5787, 15, 24, 16, 3, -24 },
  { 5832, 26, 24, 25, 2, -24 },
  { 5910, 20, 24, 16, -2, -24 },
  { 5970, 23, 35, 16, -4, -24 },
  { 6071, 17, 24, 13, -2, -24 },
  { 6122, 17, 39, 15, 1, -32 },
  { 6205, 4, 45, 17, 6, -34 },
  { 6228, 17, 39, 15, -3, -32 },
  { 6311, 17, 6, 20, 2, -19 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC45PT7B_H_
