#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC9PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x20, 0xF8, 0x37, 0x6F, 0xAC, 0x27, 0x44, 0x2E, 0x44, 0x23,
  0x6D, 0x57, 0x9D, 0x60, 0x25, 0x64, 0xBA, 0xF0, 0xC0, 0x6A, 0x49, 0x20,
  0x24, 0x92, 0x56, 0x5F, 0x00, 0x2F, 0x22, 0xC0, 0xC0, 0x80, 0x32, 0x44,
  0x88, 0x25, 0x59, 0xAA, 0xC0, 0x75, 0xA0, 0x25, 0x12, 0x48, 0xE0, 0x25,
  0x16, 0x22, 0xE0, 0x32, 0x6A, 0xE2, 0x74, 0x62, 0x2C, 0x34, 0x4E, 0xAA,
  0xE0, 0x72, 0x24, 0x48, 0x25, 0x56, 0xAA, 0xE0, 0x25, 0x9A, 0x62, 0xC0,
  0x40, 0x80, 0x40, 0xA0, 0x3C, 0x61, 0xFF, 0xC3, 0x68, 0x54, 0xA4, 0x20,
  0x7A, 0xEF, 0xBB, 0xC1, 0x80, 0x13, 0x37, 0x5D, 0x75, 0x69, 0x9E, 0x17,
  0x48, 0x88, 0x60, 0x75, 0x59, 0x9E, 0x74, 0x68, 0x8E, 0x74, 0x68, 0x88,
  0x13, 0x51, 0x0B, 0x49, 0xC0, 0x4A, 0x9D, 0x29, 0x58, 0x69, 0x29, 0x80,
  0x24, 0xA4, 0x94, 0x5B, 0x19, 0x4A, 0x50, 0x49, 0x49, 0xC0, 0x65, 0xB6,
  0xEE, 0xAA, 0xA0, 0x4B, 0x5D, 0x6B, 0x48, 0x35, 0x59, 0x99, 0x60, 0x75,
  0x56, 0x88, 0x35, 0x59, 0x99, 0x62, 0x20, 0x75, 0x7A, 0xAA, 0x25, 0x44,
  0x22, 0xE0, 0xF2, 0x49, 0x00, 0x5A, 0x95, 0x29, 0x70, 0xBA, 0xCC, 0x88,
  0xAE, 0xAE, 0xBC, 0xB2, 0x80, 0x29, 0x8C, 0x65, 0x68, 0xBB, 0x49, 0x00,
  0x72, 0x44, 0x8E, 0x69, 0x49, 0x30, 0xFC, 0x31, 0x22, 0x22, 0xC0, 0x26,
  0x90, 0xE0, 0x90, 0x75, 0x9A, 0xE0, 0x44, 0x65, 0x9A, 0xE0, 0x6A, 0x4C,
  0x11, 0x75, 0x9A, 0xE0, 0x6F, 0xCE, 0x12, 0x72, 0x44, 0x44, 0x80, 0x75,
  0x9A, 0xE2, 0xC0, 0x44, 0x65, 0xAA, 0xA0, 0x45, 0xA8, 0x20, 0x94, 0x92,
  0x80, 0x44, 0x56, 0x4A, 0xA0, 0x55, 0xA8, 0x6A, 0xEB, 0x5A, 0x80, 0x65,
  0xAA, 0xA0, 0x65, 0x9A, 0xE0, 0x75, 0x9A, 0xE8, 0x80, 0x75, 0x9A, 0xE2,
  0x20, 0x6A, 0x48, 0x71, 0x1C, 0x5D, 0x49, 0x80, 0x55, 0xAA, 0xE0, 0xBB,
  0x48, 0xAE, 0xAD, 0x94, 0xD0, 0x76, 0x4C, 0xA0, 0x4A, 0x8C, 0x42, 0x23,
  0x00, 0x69, 0x4C, 0x34, 0x48, 0x44, 0x40, 0xFF, 0x80, 0x22, 0x21, 0x24,
  0xC0, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 3, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 8, 4, 0, -7 },
  { 11, 5, 7, 6, 0, -7 },
  { 16, 4, 7, 4, 0, -7 },
  { 20, 1, 2, 2, 1, -6 },
  { 21, 3, 7, 2, 0, -6 },
  { 24, 3, 8, 2, -1, -7 },
  { 27, 3, 3, 3, 1, -7 },
  { 29, 4, 4, 4, 0, -5 },
  { 31, 1, 2, 2, 0, -1 },
  { 32, 2, 1, 2, 0, -3 },
  { 33, 1, 1, 2, 0, -1 },
  { 34, 4, 6, 3, 0, -6 },
  { 37, 4, 7, 4, 0, -7 },
  { 41, 2, 6, 4, 1, -6 },
  { 43, 4, 7, 4, 0, -7 },
  { 47, 4, 7, 4, 0, -7 },
  { 51, 4, 6, 4, 0, -6 },
  { 54, 4, 6, 4, 0, -6 },
  { 57, 4, 7, 4, 0, -7 },
  { 61, 4, 6, 4, 0, -6 },
  { 64, 4, 7, 4, 0, -7 },
  { 68, 4, 7, 4, 0, -7 },
  { 72, 2, 5, 2, 0, -5 },
  { 74, 2, 6, 2, 0, -5 },
  { 76, 4, 4, 4, 0, -5 },
  { 78, 4, 2, 4, 0, -4 },
  { 79, 4, 4, 4, 0, -5 },
  { 81, 3, 7, 3, 0, -7 },
  { 84, 5, 7, 5, 0, -6 },
  { 89, 4, 6, 4, -1, -6 },
  { 92, 4, 6, 4, 0, -6 },
  { 95, 4, 7, 4, 0, -7 },
  { 99, 4, 6, 4, 0, -6 },
  { 102, 4, 6, 3, 0, -6 },
  { 105, 4, 6, 3, 0, -6 },
  { 108, 5, 7, 5, 0, -7 },
  { 113, 5, 6, 4, 0, -6 },
  { 117, 3, 6, 3, 0, -6 },
  { 120, 3, 8, 2, -1, -6 },
  { 123, 5, 6, 4, 0, -6 },
  { 127, 3, 6, 3, 0, -6 },
  { 130, 6, 6, 6, 0, -6 },
  { 135, 5, 6, 5, 0, -6 },
  { 139, 4, 7, 5, 0, -7 },
  { 143, 4, 6, 4, 0, -6 },
  { 146, 4, 9, 5, 0, -7 },
  { 151, 4, 6, 4, 0, -6 },
  { 154, 4, 7, 3, 0, -7 },
  { 158, 3, 6, 3, 1, -6 },
  { 161, 5, 6, 4, 0, -6 },
  { 165, 4, 6, 4, 1, -6 },
  { 168, 6, 6, 6, 1, -6 },
  { 173, 5, 6, 4, -1, -6 },
  { 177, 3, 6, 3, 1, -6 },
  { 180, 4, 6, 3, 0, -6 },
  { 183, 3, 7, 3, 0, -6 },
  { 186, 1, 6, 3, 1, -6 },
  { 187, 4, 7, 3, -1, -6 },
  { 191, 4, 3, 4, 0, -6 },
  { 193, 3, 1, 3, -1, 1 },
  { 194, 2, 2, 2, 1, -7 },
  { 195, 4, 5, 4, 0, -5 },
  { 198, 4, 7, 4, 0, -7 },
  { 202, 3, 5, 3, 0, -5 },
  { 204, 4, 7, 4, 0, -7 },
  { 208, 3, 5, 4, 0, -5 },
  { 210, 4, 9, 2, -1, -7 },
  { 215, 4, 7, 4, 0, -5 },
  { 219, 4, 7, 4, 0, -7 },
  { 223, 2, 7, 2, 0, -7 },
  { 225, 3, 9, 2, -1, -7 },
  { 229, 4, 7, 3, 0, -7 },
  { 233, 2, 7, 2, 0, -7 },
  { 235, 5, 5, 6, 0, -5 },
  { 239, 4, 5, 4, 0, -5 },
  { 242, 4, 5, 4, 0, -5 },
  { 245, 4, 7, 4, 0, -5 },
  { 249, 4, 7, 4, 0, -5 },
  { 253, 3, 5, 3, 0, -5 },
  { 255, 3, 5, 3, 0, -5 },
  { 257, 3, 6, 2, 0, -6 },
  { 260, 4, 5, 4, 0, -5 },
  { 263, 3, 5, 3, 1, -5 },
  { 265, 6, 5, 5, 0, -5 },
  { 269, 4, 5, 3, 0, -5 },
  { 272, 5, 7, 3, -1, -5 },
  { 277, 3, 5, 3, 0, -5 },
  { 279, 4, 7, 3, 0, -6 },
  { 283, 1, 9, 3, 1, -7 },
  { 285, 4, 7, 3, -1, -6 },
  { 289, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC9PT7B_H_
