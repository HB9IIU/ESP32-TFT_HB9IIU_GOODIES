#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC41PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0x70, 0x0E, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F,
  0x03, 0xE0, 0x7C, 0x07, 0x00, 0x3C, 0xF7, 0x8F, 0x78, 0xF7, 0x8E, 0x71,
  0xE7, 0x1E, 0x71, 0xCF, 0x1C, 0xE1, 0xCE, 0x1C, 0x00, 0x71, 0xE0, 0x0E,
  0x38, 0x01, 0x87, 0x00, 0x70, 0xC0, 0x0E, 0x38, 0x01, 0x87, 0x00, 0x70,
  0xC0, 0x0E, 0x38, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x81, 0xC7,
  0x00, 0x70, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x18,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x81, 0xC7, 0x00, 0x30, 0xE0,
  0x0E, 0x18, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0E, 0x1C, 0x01, 0xC7, 0x00,
  0x38, 0xE0, 0x0E, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x0F, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x1E, 0x62, 0x0E, 0x20,
  0x07, 0x30, 0x03, 0x98, 0x01, 0xCC, 0x00, 0xF4, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x37, 0x80,
  0x19, 0xC0, 0x0C, 0xE0, 0x04, 0x70, 0x06, 0x38, 0xC3, 0x3C, 0x79, 0xFC,
  0x3F, 0xFE, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x08, 0x1F, 0x80, 0xE0, 0x7F, 0x01,
  0xC0, 0xEE, 0x07, 0x03, 0x8E, 0x0E, 0x07, 0x1C, 0x38, 0x1C, 0x38, 0x70,
  0x38, 0x61, 0xC0, 0x71, 0xC7, 0x01, 0xC3, 0x8E, 0x03, 0x87, 0x38, 0x07,
  0x0E, 0x70, 0x0E, 0x39, 0xC7, 0x9C, 0x73, 0x9F, 0xB8, 0xEE, 0x7F, 0x73,
  0x9C, 0xE7, 0xFE, 0x73, 0x8E, 0xFC, 0xE7, 0x1C, 0x63, 0x9C, 0x38, 0x07,
  0x38, 0x70, 0x1C, 0x71, 0xC0, 0x38, 0xC3, 0x80, 0xE3, 0x87, 0x01, 0xC7,
  0x0E, 0x07, 0x0E, 0x38, 0x1E, 0x1C, 0x70, 0x38, 0x38, 0xE0, 0xF0, 0x7B,
  0x81, 0xC0, 0x7E, 0x07, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x0F, 0x3C, 0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E,
  0x38, 0x07, 0x8E, 0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x1E, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0xE3, 0xCF, 0x78, 0xF3,
  0x8F, 0x39, 0xE3, 0xDE, 0x70, 0xF7, 0x3C, 0x1F, 0xCF, 0x07, 0xE3, 0xC1,
  0xF8, 0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x0F, 0xE3, 0xFF, 0xF8, 0x7F, 0xDF,
  0x0F, 0xC3, 0xC0, 0x3C, 0xE7, 0x9E, 0x79, 0xC7, 0x1C, 0xF3, 0x80, 0x00,
  0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x8E, 0x0F, 0x70, 0xFF,
  0xFD, 0xFF, 0xE1, 0xFF, 0x1F, 0x81, 0xFC, 0x1E, 0x71, 0xF3, 0x83, 0x1E,
  0x10, 0x40, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x0F, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xF7, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x03, 0xF8, 0x0F, 0xF8,
  0x3F, 0xF0, 0x79, 0xE1, 0xE1, 0xC7, 0x83, 0x8F, 0x07, 0x1C, 0x0E, 0x78,
  0x1C, 0xF0, 0x39, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F,
  0x70, 0x1D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0x9E, 0x0F, 0x3C,
  0x1E, 0x78, 0x78, 0xF0, 0xF1, 0xE3, 0xC3, 0xCF, 0x87, 0xFE, 0x07, 0xF8,
  0x07, 0xE0, 0x00, 0x01, 0xE0, 0x7C, 0x1F, 0x87, 0xF1, 0xFC, 0xFF, 0xBE,
  0xF3, 0x9E, 0x23, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x3F, 0xC0,
  0x3F, 0xF8, 0x1F, 0xFE, 0x03, 0x87, 0x80, 0x81, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE,
  0x03, 0x07, 0xC0, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xFF, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x20,
  0x1F, 0x0C, 0x0F, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0xEF, 0x00, 0x73, 0xC0, 0x1C, 0xF0,
  0x0E, 0x38, 0x03, 0x1E, 0x01, 0xC7, 0x80, 0xE1, 0xE0, 0x38, 0x70, 0x1C,
  0x1C, 0x0E, 0x0F, 0x03, 0x83, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF,
  0xCF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x61,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x80, 0xF8, 0x60, 0xF8,
  0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0xC0, 0x3F, 0xE0, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x8C, 0x03, 0x9F, 0x83, 0xDF,
  0xC1, 0xFF, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E,
  0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0, 0x78,
  0x78, 0x78, 0x3E, 0x7C, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xF8, 0x78,
  0x78, 0x3C, 0x3C, 0x1E, 0x1C, 0x0F, 0x0E, 0x07, 0x87, 0x83, 0x83, 0xC3,
  0xC1, 0xE3, 0xC0, 0x7B, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F,
  0xF8, 0x1F, 0x3C, 0x1F, 0x0F, 0x0F, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0xE3,
  0xC0, 0x71, 0xE0, 0x38, 0xF0, 0x3C, 0x78, 0x1E, 0x3E, 0x1E, 0x0F, 0xFF,
  0x07, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x38, 0x01, 0xFC, 0x03, 0xFE, 0x07,
  0xFF, 0x0F, 0x8F, 0x0F, 0x0F, 0x1E, 0x07, 0x1E, 0x07, 0x1E, 0x07, 0x1C,
  0x07, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x3C, 0x1F, 0x3E,
  0x3F, 0x1F, 0xEE, 0x1F, 0xFE, 0x0F, 0x9E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x83, 0xE0, 0xFF,
  0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0x07, 0xC3, 0xE1, 0xE0, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0x80, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x78,
  0x0F, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC,
  0x01, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3C,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x00, 0xF0,
  0x01, 0x80, 0x02, 0x00, 0x00, 0x03, 0x80, 0x7F, 0x8F, 0xFC, 0x3F, 0xF1,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xE0, 0x07, 0x81, 0xE0, 0x1C, 0x01, 0xC0, 0x70, 0x01, 0xC1,
  0xC0, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x06, 0x06, 0x38, 0x3F, 0x8C, 0x70,
  0xFF, 0x19, 0xC3, 0x8C, 0x33, 0x8E, 0x38, 0x66, 0x1C, 0x71, 0xDC, 0x70,
  0xE3, 0xB8, 0xE1, 0xC7, 0x61, 0xC7, 0x0E, 0xC7, 0x0E, 0x1B, 0x8E, 0x1C,
  0x77, 0x1C, 0x78, 0xEE, 0x38, 0xE1, 0x9C, 0x71, 0xC7, 0x38, 0xE7, 0xDC,
  0x71, 0xFB, 0xF0, 0xE1, 0xE3, 0xC1, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xBC, 0x01, 0xEF, 0x00,
  0x7B, 0xC0, 0x1C, 0xF0, 0x0F, 0x3C, 0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x78,
  0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x0F, 0x03, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3C,
  0x03, 0xCF, 0x00, 0xF7, 0xC0, 0x3D, 0xE0, 0x0F, 0xF8, 0x03, 0xC0, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x1E, 0x1F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x78,
  0x3C, 0x3C, 0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x78, 0xF8, 0x1C,
  0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0E, 0x03,
  0xC7, 0x80, 0xF1, 0xE0, 0x78, 0x78, 0x3E, 0x1E, 0x3F, 0x0F, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xF0, 0x1F, 0xFC,
  0x0F, 0xFE, 0x03, 0xE0, 0x81, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0xC3, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x03, 0xC7, 0xE0, 0x78,
  0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0,
  0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80,
  0xF8, 0xF0, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x03,
  0xC3, 0xC0, 0xF8, 0x78, 0x1E, 0x1E, 0x07, 0xC3, 0xC1, 0xF0, 0x78, 0x7C,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3E, 0x06, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x7F, 0x0F, 0x03, 0xF8, 0x78, 0x3F, 0xC3, 0xC1,
  0xFE, 0x1E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x7C, 0x03, 0xC1,
  0xE0, 0x1E, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x83,
  0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xC0, 0x78,
  0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x1E, 0x03, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x01, 0xE0, 0x78,
  0x0F, 0x03, 0xC0, 0x78, 0x1C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x01, 0xE0,
  0x78, 0x0F, 0x03, 0xC0, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x01,
  0xE0, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3F, 0xA0, 0xFF, 0xC0, 0xFF, 0xC0,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x5F, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x03, 0xC0, 0xF8, 0x1E, 0x0F, 0x80, 0xE0, 0x78, 0x0F, 0x07,
  0x80, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x0F,
  0x3E, 0x00, 0x79, 0xE0, 0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xF7,
  0x80, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1C, 0x3C, 0x01,
  0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x0F,
  0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xFF, 0xFF,
  0xFE, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x03, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE,
  0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x1D, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3B, 0xC0, 0xE7, 0x07, 0xBC, 0x1E, 0x70, 0x73,
  0x81, 0xE7, 0x0F, 0x78, 0x1E, 0x70, 0xE7, 0x81, 0xC7, 0x1E, 0x78, 0x1C,
  0x71, 0xC7, 0x83, 0xC7, 0x1C, 0x70, 0x3C, 0x73, 0xCF, 0x03, 0xC7, 0x38,
  0xF0, 0x38, 0x77, 0x8F, 0x03, 0x87, 0x70, 0xE0, 0x78, 0x7F, 0x0E, 0x07,
  0x87, 0xE1, 0xE0, 0x78, 0x7E, 0x1E, 0x07, 0x07, 0xC1, 0xE0, 0xF0, 0x7C,
  0x1C, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x00, 0x03, 0xE0, 0x1E,
  0x07, 0xC0, 0x38, 0x0F, 0x80, 0xF0, 0x3F, 0x01, 0xE0, 0x7E, 0x03, 0xC0,
  0xFE, 0x07, 0x01, 0xFC, 0x0E, 0x07, 0xB8, 0x3C, 0x0F, 0x70, 0x78, 0x1E,
  0xE0, 0xF0, 0x39, 0xC1, 0xC0, 0x73, 0xC7, 0x81, 0xE7, 0x8F, 0x03, 0xC7,
  0x1E, 0x07, 0x8E, 0x3C, 0x0E, 0x1C, 0x70, 0x1C, 0x39, 0xE0, 0x78, 0x7B,
  0xC0, 0xF0, 0xF7, 0x81, 0xE0, 0xEE, 0x03, 0x81, 0xDC, 0x07, 0x03, 0xB8,
  0x1E, 0x07, 0xF0, 0x3C, 0x0F, 0xE0, 0x78, 0x1F, 0x80, 0xE0, 0x1F, 0x03,
  0xC0, 0x3E, 0x07, 0x80, 0x7C, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x0F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7C, 0x3E, 0x0F, 0x03, 0xC3,
  0xC0, 0x78, 0x78, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E,
  0x00, 0xF3, 0xC0, 0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78,
  0x03, 0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x80, 0x79, 0xF0,
  0x0F, 0x3E, 0x03, 0xE3, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x07, 0xC1, 0xF1,
  0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x1E, 0x3F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1E,
  0x1E, 0x0F, 0x87, 0x87, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF8, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x01, 0xFF,
  0xE0, 0x7C, 0x3E, 0x0F, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x1E, 0x01,
  0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0xF8, 0x03,
  0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xEF, 0x00, 0x79, 0xE0, 0x0F,
  0x7C, 0x01, 0xEF, 0x80, 0x79, 0xF0, 0x0F, 0x3E, 0x03, 0xE3, 0xC0, 0x78,
  0x78, 0x1F, 0x0F, 0x07, 0xC1, 0xF1, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x00,
  0x3F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xF8, 0x1E, 0x3F, 0x07, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C,
  0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x0F,
  0x07, 0x8F, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x0F, 0x3C, 0x03,
  0xC7, 0x00, 0xF1, 0xE0, 0x3C, 0x78, 0x0E, 0x1E, 0x07, 0x87, 0x81, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3E,
  0x00, 0x00, 0x1C, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xE1,
  0x81, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x10, 0x1F, 0x0F,
  0x1F, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xE0,
  0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0E, 0x01, 0xE1, 0xE0, 0x3C,
  0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07,
  0x83, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x07, 0x07, 0x80,
  0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x01, 0xE0, 0xF0,
  0x1E, 0x0F, 0x01, 0xE0, 0xF8, 0x3C, 0x07, 0xC7, 0xC0, 0x7F, 0xF8, 0x03,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x0F, 0xF0, 0x07, 0xB8, 0x07, 0xDC,
  0x03, 0xCE, 0x01, 0xE7, 0x01, 0xE3, 0x80, 0xF1, 0xC0, 0xF0, 0xE0, 0x78,
  0x70, 0x3C, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x1E, 0x07, 0x0F, 0x03, 0x87,
  0x01, 0xC7, 0x80, 0xE3, 0xC0, 0x73, 0xC0, 0x39, 0xE0, 0x1C, 0xE0, 0x0E,
  0xF0, 0x07, 0x70, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x0F, 0x01, 0xF7, 0x00,
  0xF0, 0x1E, 0x70, 0x1F, 0x01, 0xEF, 0x01, 0xF0, 0x3C, 0xF0, 0x1F, 0x03,
  0xCF, 0x03, 0xF0, 0x38, 0xF0, 0x3F, 0x07, 0x8F, 0x07, 0xF0, 0x78, 0xF0,
  0x7F, 0x0F, 0x0F, 0x07, 0xE0, 0xF0, 0xF0, 0xEE, 0x0E, 0x0F, 0x0E, 0xE1,
  0xE0, 0xF1, 0xEE, 0x1E, 0x0F, 0x1C, 0xE3, 0xC0, 0xF1, 0xCE, 0x3C, 0x0F,
  0x3C, 0xE3, 0x80, 0xF3, 0x8E, 0x78, 0x0F, 0x78, 0xE7, 0x80, 0xF7, 0x0E,
  0xF0, 0x0F, 0x70, 0xEF, 0x00, 0xFF, 0x0E, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0xEE, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0,
  0xFC, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0xF8, 0x0F, 0x07, 0x80, 0x78, 0x78, 0x03, 0xC3, 0xC0,
  0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x9E, 0x00, 0x1C, 0xF0, 0x00, 0xEF,
  0x00, 0x07, 0x70, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0x73, 0xC0, 0x07, 0x9E, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x80, 0x3C, 0x1C, 0x01, 0xE0, 0xF0, 0x1E, 0x07, 0x81,
  0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x3C, 0x78, 0x38, 0x78, 0x78, 0x78, 0x70, 0x78, 0xF0, 0x38, 0xE0,
  0x39, 0xE0, 0x39, 0xC0, 0x3B, 0xC0, 0x3B, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x80, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xF1, 0xE3, 0xC3,
  0x87, 0x0E, 0x1C, 0x3C, 0x78, 0xF1, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x3C,
  0x78, 0xF0, 0xE1, 0xC3, 0x87, 0x0F, 0x1E, 0x3C, 0x78, 0x70, 0xE0, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0E, 0xE0,
  0x0E, 0x70, 0x0F, 0x3C, 0x07, 0x1E, 0x07, 0x87, 0x03, 0x83, 0x83, 0xC1,
  0xE3, 0xC0, 0xF1, 0xC0, 0x39, 0xE0, 0x1D, 0xE0, 0x0F, 0x7F, 0xFD, 0xFF,
  0xEF, 0xFF, 0x80, 0xF9, 0xE7, 0x8E, 0x3C, 0x70, 0x00, 0x80, 0x01, 0xF3,
  0xC1, 0xFD, 0xE1, 0xFE, 0xE1, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0x7C, 0x78,
  0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xCF, 0x01, 0xC7,
  0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x7C, 0x78, 0x3C, 0x3C, 0x3E,
  0x1E, 0x3F, 0x0F, 0xFF, 0x83, 0xFB, 0x80, 0xF9, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x08, 0x07, 0x9F, 0x03, 0xDF, 0xC1, 0xFF, 0xE0, 0xF8,
  0xF8, 0x78, 0x3C, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8E, 0x03, 0xC7,
  0x01, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x3C,
  0x78, 0x1E, 0x3C, 0x1F, 0x1E, 0x0F, 0x0F, 0x8F, 0x0F, 0xFF, 0x87, 0x7F,
  0x83, 0x9F, 0x80, 0x00, 0x40, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0x08,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3E, 0x10, 0x7F, 0xC1, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x87, 0x80, 0x7C, 0xF0, 0x1F, 0xDC, 0x07, 0xFF,
  0x81, 0xF1, 0xF0, 0x3C, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x78, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x38, 0x0F, 0x0F, 0x01, 0xC1, 0xE0, 0x38,
  0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x38, 0x1E, 0x0F, 0x03, 0xC3, 0xE0,
  0x78, 0x7C, 0x0F, 0xFF, 0x80, 0xFE, 0xE0, 0x0F, 0x9C, 0x00, 0x03, 0xF8,
  0x0F, 0xF8, 0x3F, 0xF0, 0xF0, 0xE1, 0xC1, 0xE7, 0x83, 0x8E, 0x07, 0x3C,
  0x1E, 0x78, 0x78, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x83, 0xFF, 0x07,
  0xFE, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x1F, 0xBC, 0x07, 0xF7, 0x81, 0xFF, 0xE0, 0x7C, 0x7C, 0x0F,
  0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78,
  0x1E, 0x0F, 0x03, 0xC3, 0xC0, 0x70, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0,
  0x78, 0x3C, 0x1F, 0x07, 0x83, 0xC0, 0xF0, 0xF8, 0x1E, 0x3F, 0x03, 0xFF,
  0xE0, 0x3F, 0xB8, 0x03, 0xEF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x08, 0x0F, 0x01, 0xE7, 0xE0, 0x3F, 0xF8,
  0x07, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x08,
  0x0F, 0x7E, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0x8F, 0x0F, 0x0F, 0x1F, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E,
  0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C,
  0x70, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0x00, 0x80, 0xF0, 0x3C,
  0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x00,
  0x04, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x83, 0xC3, 0xC3, 0xC1, 0xE1, 0xE0, 0xF1, 0xE0, 0x71, 0xE0, 0x79, 0xE0,
  0x3C, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xF7, 0x00, 0xF3, 0xC0, 0x71, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E,
  0x3C, 0x0E, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE0, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F,
  0x00, 0x00, 0x08, 0x08, 0x07, 0xBF, 0x1F, 0x83, 0xBF, 0xDF, 0xC1, 0xFF,
  0xFF, 0xF0, 0xF8, 0xFC, 0x78, 0x78, 0x7C, 0x3C, 0x78, 0x3C, 0x1E, 0x3C,
  0x1E, 0x0E, 0x1E, 0x0F, 0x07, 0x0E, 0x07, 0x07, 0x87, 0x07, 0x83, 0xC7,
  0x83, 0xC1, 0xE3, 0xC1, 0xE0, 0xE1, 0xE0, 0xF0, 0x70, 0xE0, 0x70, 0x78,
  0xF0, 0x78, 0x3C, 0x78, 0x3C, 0x1E, 0x3C, 0x1E, 0x0E, 0x1E, 0x0E, 0x0F,
  0x0E, 0x07, 0x07, 0x8F, 0x07, 0x83, 0xC7, 0x83, 0xC1, 0xE3, 0xC1, 0xE1,
  0xE0, 0x00, 0x08, 0x0F, 0x7E, 0x0E, 0xFF, 0x0E, 0xFF, 0x0F, 0x8F, 0x0F,
  0x0F, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0E, 0x3C,
  0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x3C, 0x70, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0x00,
  0x40, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xE1, 0xE1, 0xE3, 0xC3, 0xCF, 0x07,
  0x9C, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0xF3, 0xC3, 0xE7, 0xC7,
  0x87, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x79, 0xF0,
  0x0E, 0x7F, 0x01, 0xDF, 0xE0, 0x3E, 0x3E, 0x07, 0x83, 0xC1, 0xF0, 0x78,
  0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xE0, 0x3C, 0x1C, 0x07, 0x07, 0x81, 0xE0,
  0xF0, 0x3C, 0x1E, 0x07, 0x83, 0x80, 0xF0, 0x70, 0x3C, 0x1E, 0x07, 0x83,
  0xC1, 0xF0, 0x78, 0x3C, 0x0F, 0x8F, 0x83, 0xFF, 0xE0, 0x7B, 0xF8, 0x0F,
  0x7E, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x80, 0x01, 0xFB, 0xC1, 0xFD, 0xC1, 0xFF, 0xE1, 0xF1,
  0xF0, 0xF0, 0xF8, 0xF0, 0x7C, 0x78, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E,
  0x07, 0x8E, 0x03, 0xCF, 0x01, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78,
  0xF0, 0x7C, 0x78, 0x3C, 0x3C, 0x3E, 0x1E, 0x3F, 0x0F, 0xFF, 0x83, 0xFB,
  0x80, 0xFB, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x00, 0x01, 0x08, 0x39, 0xF0, 0xEF, 0x83, 0xBE, 0x0F, 0xF8, 0x3E, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x1F, 0xE0, 0xFF, 0xC7,
  0xFE, 0x1E, 0x08, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x20, 0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x00, 0x03,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x3F, 0xDF, 0xF3, 0xFE, 0x1E, 0x03,
  0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFE, 0x1F, 0xC1, 0xF8,
  0x00, 0x1E, 0x07, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x0E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x3C, 0x70, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0,
  0xF8, 0xF1, 0xF0, 0xFF, 0xF0, 0x7F, 0x70, 0x7E, 0x70, 0xF0, 0x1F, 0xE0,
  0x7B, 0xC0, 0xF7, 0x83, 0xC7, 0x07, 0x8E, 0x1E, 0x1C, 0x3C, 0x38, 0x70,
  0x71, 0xE0, 0xE3, 0x81, 0xCF, 0x03, 0x9E, 0x07, 0x38, 0x0E, 0xF0, 0x1D,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x00, 0x70, 0x3C, 0x1E, 0xE0, 0xF8, 0x3D, 0xC1, 0xF0, 0xF3,
  0x87, 0xE1, 0xEF, 0x0F, 0xC3, 0x9E, 0x1F, 0x8F, 0x3C, 0x77, 0x1E, 0x78,
  0xEE, 0x38, 0xF3, 0x9C, 0xF1, 0xE7, 0x79, 0xC3, 0xCE, 0xF7, 0x87, 0xB9,
  0xEF, 0x0F, 0x73, 0x9C, 0x1F, 0xE7, 0x78, 0x3F, 0x8E, 0xE0, 0x7F, 0x1D,
  0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xC1, 0xF0,
  0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0x83, 0xC1, 0xE1, 0xE0,
  0x38, 0x78, 0x0E, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x3D, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x77, 0x00, 0x3D, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x03,
  0xC3, 0x80, 0xF0, 0xE0, 0x78, 0x3C, 0x3C, 0x0F, 0x00, 0x01, 0xC0, 0x78,
  0x0E, 0x07, 0x80, 0x70, 0x3C, 0x03, 0x83, 0xC0, 0x1C, 0x1E, 0x00, 0xE0,
  0xE0, 0x07, 0x0F, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x80, 0x0E, 0x3C, 0x00,
  0x71, 0xC0, 0x03, 0x9E, 0x00, 0x1C, 0xE0, 0x00, 0xEF, 0x00, 0x07, 0x70,
  0x00, 0x3B, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0xFE,
  0x01, 0xE0, 0x03, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x7E, 0x00,
  0x38, 0x03, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xFF,
  0x0F, 0xFF, 0xFE, 0x1F, 0xF8, 0x0F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 11, 29, 10, 0, -29 },
  { 41, 12, 10, 15, 4, -29 },
  { 56, 19, 29, 18, 0, -29 },
  { 125, 17, 33, 16, 0, -31 },
  { 196, 23, 30, 26, 2, -30 },
  { 283, 18, 30, 19, 0, -30 },
  { 351, 6, 10, 8, 4, -29 },
  { 359, 12, 35, 11, 1, -29 },
  { 412, 13, 36, 11, -3, -30 },
  { 471, 13, 14, 15, 4, -31 },
  { 494, 15, 19, 18, 2, -24 },
  { 530, 8, 10, 9, -2, -5 },
  { 540, 9, 4, 11, 1, -13 },
  { 545, 5, 5, 9, 0, -5 },
  { 549, 19, 29, 14, -2, -29 },
  { 618, 15, 30, 16, 1, -30 },
  { 675, 11, 29, 17, 4, -29 },
  { 715, 18, 30, 16, -1, -30 },
  { 783, 18, 30, 16, -1, -30 },
  { 851, 18, 29, 17, -1, -29 },
  { 917, 17, 29, 16, 0, -29 },
  { 979, 17, 30, 16, 1, -30 },
  { 1043, 17, 29, 16, 1, -29 },
  { 1105, 17, 30, 16, 0, -30 },
  { 1169, 16, 30, 16, 0, -30 },
  { 1229, 9, 22, 9, 0, -22 },
  { 1254, 11, 27, 9, -2, -22 },
  { 1292, 15, 19, 18, 2, -24 },
  { 1328, 15, 11, 18, 2, -20 },
  { 1349, 15, 19, 18, 2, -24 },
  { 1385, 13, 30, 12, 1, -30 },
  { 1434, 23, 33, 25, 1, -30 },
  { 1529, 18, 29, 17, -3, -29 },
  { 1595, 18, 29, 18, 0, -29 },
  { 1661, 18, 30, 16, 1, -30 },
  { 1729, 19, 29, 20, 0, -29 },
  { 1798, 17, 29, 15, 0, -29 },
  { 1860, 17, 29, 15, 0, -29 },
  { 1922, 21, 30, 21, 1, -30 },
  { 2001, 21, 29, 20, 0, -29 },
  { 2078, 16, 29, 11, -2, -29 },
  { 2136, 16, 37, 9, -6, -29 },
  { 2210, 21, 29, 17, 0, -29 },
  { 2287, 12, 29, 14, 0, -29 },
  { 2331, 28, 29, 27, 0, -29 },
  { 2433, 23, 29, 22, 0, -29 },
  { 2517, 19, 30, 21, 1, -30 },
  { 2589, 18, 29, 17, 0, -29 },
  { 2655, 19, 37, 21, 1, -30 },
  { 2743, 18, 29, 18, 0, -29 },
  { 2809, 18, 30, 16, -1, -30 },
  { 2877, 15, 29, 15, 3, -29 },
  { 2932, 20, 29, 20, 1, -29 },
  { 3005, 17, 29, 17, 4, -29 },
  { 3067, 28, 29, 27, 3, -29 },
  { 3169, 21, 29, 16, -2, -29 },
  { 3246, 16, 29, 15, 3, -29 },
  { 3304, 19, 29, 14, -2, -29 },
  { 3373, 15, 36, 12, -1, -29 },
  { 3441, 7, 29, 14, 4, -29 },
  { 3467, 16, 36, 12, -3, -29 },
  { 3539, 17, 16, 17, 0, -29 },
  { 3573, 14, 3, 13, -4, 3 },
  { 3579, 6, 6, 11, 6, -31 },
  { 3584, 17, 23, 18, 1, -23 },
  { 3633, 17, 31, 18, 0, -31 },
  { 3699, 14, 23, 14, 1, -23 },
  { 3740, 19, 31, 18, 1, -31 },
  { 3814, 15, 22, 16, 1, -22 },
  { 3856, 20, 41, 10, -5, -31 },
  { 3959, 19, 33, 18, -1, -23 },
  { 4038, 16, 31, 17, 0, -31 },
  { 4100, 10, 31, 8, 0, -31 },
  { 4139, 15, 41, 8, -5, -31 },
  { 4216, 17, 31, 16, 0, -31 },
  { 4282, 10, 31, 8, 0, -31 },
  { 4321, 25, 23, 26, 0, -23 },
  { 4393, 16, 23, 17, 0, -23 },
  { 4439, 15, 23, 17, 1, -23 },
  { 4483, 19, 33, 18, -2, -23 },
  { 4562, 17, 33, 18, 1, -23 },
  { 4633, 14, 23, 12, 0, -23 },
  { 4674, 14, 23, 13, 0, -23 },
  { 4715, 11, 27, 10, 1, -27 },
  { 4753, 16, 22, 17, 1, -22 },
  { 4797, 15, 22, 15, 2, -22 },
  { 4839, 23, 22, 23, 2, -22 },
  { 4903, 18, 22, 15, -2, -22 },
  { 4953, 21, 32, 15, -4, -22 },
  { 5037, 16, 22, 12, -2, -22 },
  { 5081, 15, 35, 14, 1, -29 },
  { 5147, 3, 41, 15, 6, -31 },
  { 5163, 15, 35, 14, -2, -29 },
  { 5229, 15, 5, 18, 2, -17 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC41PT7B_H_
