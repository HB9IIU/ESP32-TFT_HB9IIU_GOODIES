#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC18PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x8C, 0x63, 0x10, 0x8C, 0x60, 0x01, 0x8C, 0x00, 0xDE, 0xF7,
  0x29, 0x00, 0x09, 0x0B, 0x1A, 0x12, 0x7F, 0x34, 0x24, 0x24, 0xFE, 0x48,
  0x48, 0x58, 0xD0, 0x04, 0x04, 0x1F, 0x3A, 0x28, 0x28, 0x30, 0x18, 0x1C,
  0x14, 0x14, 0xDC, 0xF8, 0x20, 0x20, 0x31, 0x96, 0x4D, 0xB2, 0x48, 0x96,
  0x25, 0x6A, 0xFF, 0xA9, 0x1A, 0x45, 0xB2, 0x48, 0x9A, 0x43, 0x00, 0x1C,
  0x16, 0x36, 0x36, 0x34, 0x18, 0x38, 0x7B, 0xCA, 0xCE, 0xCC, 0xDE, 0x76,
  0x7E, 0x80, 0x0C, 0x61, 0x0C, 0x21, 0x86, 0x10, 0x43, 0x0C, 0x30, 0xC3,
  0x04, 0x18, 0x18, 0xC2, 0x10, 0x84, 0x23, 0x18, 0xC4, 0x62, 0x31, 0x10,
  0x31, 0xBA, 0xF7, 0x6C, 0x40, 0x30, 0x60, 0xC1, 0x8F, 0xE6, 0x0C, 0x18,
  0x30, 0x36, 0x4C, 0x7F, 0xF0, 0x01, 0x81, 0x80, 0x80, 0xC0, 0x40, 0x60,
  0x20, 0x30, 0x10, 0x18, 0x18, 0x08, 0x0C, 0x00, 0x0E, 0x3C, 0xC9, 0x16,
  0x2C, 0xD1, 0xA3, 0xC5, 0x9B, 0x32, 0xC7, 0x00, 0x19, 0x9D, 0x63, 0x18,
  0x8C, 0x63, 0x18, 0x8C, 0x00, 0x0E, 0x1B, 0x11, 0x03, 0x03, 0x02, 0x06,
  0x0C, 0x18, 0x10, 0x20, 0x7E, 0xFC, 0x1E, 0x6C, 0x08, 0x10, 0x61, 0x8E,
  0x06, 0x0C, 0x18, 0x34, 0xCF, 0x00, 0x06, 0x0C, 0x38, 0xF1, 0x44, 0x8B,
  0x26, 0xCD, 0xFC, 0x20, 0xC1, 0x80, 0x1E, 0x7C, 0xC1, 0x02, 0x0F, 0x1F,
  0x06, 0x04, 0x18, 0x34, 0xCF, 0x00, 0x0F, 0x1D, 0x30, 0x30, 0x60, 0x7C,
  0x66, 0x66, 0x46, 0xC4, 0xCC, 0x6C, 0x78, 0x7E, 0xFC, 0x10, 0x60, 0x83,
  0x04, 0x18, 0x20, 0xC1, 0x06, 0x0C, 0x00, 0x1E, 0x6C, 0x89, 0x12, 0x67,
  0x8E, 0x36, 0xC5, 0x8B, 0x16, 0x67, 0x80, 0x1C, 0x6C, 0x8B, 0x16, 0x6C,
  0xDB, 0xBF, 0x04, 0x18, 0x24, 0xCF, 0x00, 0x33, 0x20, 0x00, 0x00, 0xCC,
  0x18, 0xC4, 0x00, 0x00, 0x00, 0x23, 0x11, 0x80, 0x02, 0x0C, 0x73, 0x8C,
  0x0C, 0x0E, 0x07, 0x02, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x81, 0x83, 0xC1,
  0xC0, 0xE3, 0x9C, 0x60, 0x80, 0x3C, 0xB0, 0x43, 0x08, 0x63, 0x08, 0x60,
  0x00, 0x30, 0xC0, 0x07, 0x81, 0x98, 0x41, 0x11, 0x32, 0x72, 0x92, 0xD2,
  0xD2, 0xD2, 0x52, 0x5A, 0xD3, 0x6E, 0x20, 0x04, 0x00, 0x7C, 0x02, 0x00,
  0x06, 0x0C, 0x38, 0x51, 0xA3, 0x44, 0x99, 0x3E, 0xC5, 0x8E, 0x1C, 0x20,
  0x1E, 0x3F, 0x33, 0x33, 0x23, 0x26, 0x7C, 0x66, 0x66, 0x46, 0x46, 0xDC,
  0xF8, 0x1F, 0x3E, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0xC0,
  0xC8, 0x78, 0x1E, 0x3F, 0x33, 0x31, 0x31, 0x21, 0x63, 0x63, 0x63, 0x46,
  0x46, 0xFC, 0xF8, 0x1F, 0x3E, 0x30, 0x30, 0x30, 0x20, 0x7C, 0x60, 0x60,
  0x40, 0x40, 0xF8, 0xF8, 0x1F, 0x3E, 0x30, 0x30, 0x30, 0x20, 0x7C, 0x7C,
  0x60, 0x40, 0x40, 0xC0, 0xC0, 0x0F, 0x3F, 0x70, 0x60, 0xC0, 0xC0, 0xCE,
  0xCE, 0x86, 0x86, 0xC6, 0xEC, 0x7C, 0x10, 0x98, 0xCC, 0x66, 0x33, 0x11,
  0x09, 0xFC, 0xC6, 0x63, 0x21, 0x11, 0x98, 0xCC, 0x60, 0x1E, 0x18, 0x20,
  0x41, 0x83, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x0F, 0x80, 0x02, 0x0C, 0x18,
  0x30, 0x60, 0x83, 0x06, 0x0C, 0x10, 0x20, 0xC1, 0x83, 0x0C, 0x78, 0x40,
  0x11, 0x99, 0x8C, 0x86, 0xC2, 0xC1, 0x41, 0xE0, 0xD0, 0x6C, 0x26, 0x13,
  0x19, 0x8C, 0x60, 0x11, 0x8C, 0x62, 0x11, 0x8C, 0x62, 0x11, 0xFF, 0x80,
  0x18, 0x33, 0x87, 0x38, 0x73, 0x8F, 0x28, 0xA2, 0x8A, 0x69, 0xE6, 0x96,
  0x6B, 0x64, 0xA4, 0x4E, 0xCC, 0xCC, 0xCC, 0xC0, 0x18, 0xCE, 0x33, 0x88,
  0xE2, 0x29, 0x8B, 0x66, 0xD9, 0xB4, 0x65, 0x11, 0xC4, 0x73, 0x1C, 0xC6,
  0x00, 0x1E, 0x3F, 0x63, 0x63, 0xC3, 0xC3, 0xC3, 0xC2, 0x86, 0x86, 0xCC,
  0xDC, 0x78, 0x1E, 0x3F, 0x33, 0x33, 0x23, 0x23, 0x6E, 0x7C, 0x60, 0x40,
  0x40, 0xC0, 0xC0, 0x1E, 0x3F, 0x63, 0x63, 0xC3, 0xC3, 0xC3, 0xC2, 0x86,
  0x86, 0xCC, 0xDC, 0x78, 0x10, 0x18, 0x18, 0x1E, 0x3F, 0x33, 0x33, 0x23,
  0x26, 0x7E, 0x78, 0x6C, 0x4C, 0x4C, 0xCC, 0xC4, 0x1F, 0x3E, 0x20, 0x60,
  0x60, 0x30, 0x18, 0x1C, 0x0C, 0x0C, 0x0C, 0xD8, 0xF8, 0x7F, 0xFC, 0xC1,
  0x83, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x02, 0x0C, 0x00, 0x23, 0x63, 0x63,
  0x63, 0x42, 0xC6, 0xC6, 0xC6, 0xC4, 0x8C, 0x8C, 0xD8, 0xF8, 0x87, 0x0E,
  0x34, 0x68, 0x93, 0x24, 0x58, 0xB1, 0x43, 0x86, 0x0C, 0x00, 0x42, 0x14,
  0x63, 0x46, 0x3C, 0xE6, 0xCA, 0x6C, 0xA4, 0xDA, 0xCD, 0x2C, 0xD2, 0x8F,
  0x38, 0xE3, 0x0E, 0x70, 0xC7, 0x00, 0x19, 0x8C, 0xC6, 0xC3, 0x40, 0xE0,
  0x60, 0x30, 0x38, 0x1C, 0x1A, 0x19, 0x0C, 0xCC, 0x60, 0x46, 0x8D, 0x33,
  0x67, 0x8E, 0x1C, 0x30, 0x60, 0xC1, 0x82, 0x0C, 0x00, 0x1F, 0x1F, 0x03,
  0x06, 0x04, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x7C, 0xFC, 0x0E, 0x10,
  0x60, 0xC1, 0x02, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x06, 0x08, 0x10, 0x78,
  0x93, 0x6D, 0x92, 0x4D, 0xB6, 0x1E, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04,
  0x18, 0x30, 0x40, 0x83, 0x06, 0x0C, 0x70, 0x0C, 0x18, 0x71, 0xA2, 0x6C,
  0xF0, 0x80, 0xFC, 0xF4, 0x1B, 0x3F, 0x66, 0x66, 0x66, 0x46, 0xC6, 0xCC,
  0x4C, 0x7C, 0x10, 0x20, 0xC1, 0x83, 0xE7, 0xC8, 0xB1, 0x62, 0x8D, 0x1E,
  0x2E, 0xD7, 0x00, 0x1E, 0x79, 0x83, 0x04, 0x08, 0x30, 0x60, 0x68, 0xF0,
  0x01, 0x80, 0x80, 0x40, 0x61, 0xB1, 0xF9, 0x98, 0xCC, 0x66, 0x23, 0x31,
  0x19, 0x8C, 0xC3, 0xE0, 0x1C, 0x6D, 0x9B, 0x37, 0xCE, 0x30, 0x60, 0x44,
  0xF0, 0x03, 0x07, 0x04, 0x0C, 0x0E, 0x1E, 0x08, 0x18, 0x18, 0x18, 0x10,
  0x10, 0x30, 0x30, 0x30, 0x20, 0x60, 0xE0, 0x1B, 0x3F, 0x66, 0x66, 0x66,
  0x46, 0xC6, 0xCC, 0xCC, 0x7C, 0x0C, 0x08, 0x98, 0xF0, 0x18, 0x20, 0xC1,
  0x83, 0xE7, 0xC9, 0xB3, 0x66, 0xCD, 0x16, 0x2C, 0xD9, 0x80, 0x31, 0x03,
  0x22, 0x66, 0x64, 0xCC, 0xC0, 0x0C, 0x10, 0x03, 0x08, 0x21, 0x86, 0x18,
  0x43, 0x0C, 0x30, 0xC2, 0x18, 0xC0, 0x18, 0x10, 0x30, 0x30, 0x33, 0x26,
  0x2C, 0x68, 0x78, 0x78, 0x58, 0xC8, 0xC8, 0xCC, 0x18, 0x8C, 0x63, 0x10,
  0x8C, 0x63, 0x11, 0x8C, 0x60, 0x2E, 0xC7, 0xFC, 0x99, 0xB3, 0x36, 0x64,
  0xC8, 0x91, 0x36, 0x66, 0xCC, 0xD9, 0x90, 0x2E, 0x7C, 0x9B, 0x36, 0x6C,
  0xD1, 0x62, 0xCD, 0x98, 0x1C, 0x7D, 0x9B, 0x34, 0x68, 0xF1, 0xE6, 0x4C,
  0xF0, 0x17, 0x1F, 0x19, 0x31, 0x31, 0x33, 0x23, 0x22, 0x76, 0x7C, 0x60,
  0x40, 0xC0, 0xC0, 0x1B, 0x3F, 0x26, 0x66, 0x46, 0x46, 0xC4, 0xCC, 0xCC,
  0x7C, 0x0C, 0x08, 0x08, 0x18, 0x2C, 0xF3, 0x18, 0x61, 0x84, 0x30, 0xC3,
  0x00, 0x3D, 0xF6, 0x18, 0x70, 0xE1, 0x86, 0x9B, 0xC0, 0x10, 0x8E, 0xF2,
  0x31, 0x8C, 0x42, 0x30, 0xC0, 0x33, 0x22, 0x22, 0x66, 0x66, 0x66, 0x44,
  0xCC, 0xCC, 0x7C, 0xC7, 0x3C, 0xB6, 0xD3, 0xCF, 0x38, 0xE3, 0x00, 0xCC,
  0xF3, 0x3D, 0xCB, 0x56, 0xD5, 0x3B, 0xCA, 0xF3, 0xB8, 0xCE, 0x33, 0x00,
  0x33, 0x12, 0x16, 0x1C, 0x1C, 0x18, 0x3C, 0x2C, 0x6C, 0xCC, 0x18, 0x8C,
  0xC6, 0x43, 0x61, 0xB0, 0xD0, 0x78, 0x38, 0x1C, 0x0C, 0x06, 0x02, 0x03,
  0x07, 0x00, 0x1E, 0x7C, 0x30, 0x41, 0x82, 0x0C, 0x30, 0x61, 0xF0, 0x06,
  0x1C, 0x60, 0xC1, 0x82, 0x0C, 0x30, 0xE0, 0x40, 0x81, 0x06, 0x0C, 0x1C,
  0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x38, 0x30, 0x60, 0x81, 0x06,
  0x07, 0x0C, 0x30, 0xC1, 0x83, 0x04, 0x38, 0x60, 0x43, 0xFE, 0x70,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 13, 4, 0, -13 },
  { 10, 5, 5, 6, 2, -13 },
  { 14, 8, 13, 8, 0, -13 },
  { 27, 8, 15, 7, 0, -14 },
  { 42, 10, 13, 11, 1, -13 },
  { 59, 8, 13, 8, 0, -13 },
  { 72, 2, 5, 4, 2, -13 },
  { 74, 6, 16, 5, 0, -13 },
  { 86, 5, 16, 5, -1, -13 },
  { 96, 5, 7, 7, 2, -14 },
  { 101, 7, 9, 8, 1, -11 },
  { 109, 4, 4, 4, -1, -2 },
  { 111, 4, 2, 5, 0, -6 },
  { 112, 2, 2, 4, 0, -2 },
  { 113, 9, 13, 6, -1, -13 },
  { 128, 7, 13, 7, 0, -13 },
  { 140, 5, 13, 7, 2, -13 },
  { 149, 8, 13, 7, -1, -13 },
  { 162, 7, 13, 7, 0, -13 },
  { 174, 7, 13, 7, 0, -13 },
  { 186, 7, 13, 7, 0, -13 },
  { 198, 8, 13, 7, 0, -13 },
  { 211, 7, 13, 7, 1, -13 },
  { 223, 7, 13, 7, 0, -13 },
  { 235, 7, 13, 7, 0, -13 },
  { 247, 4, 10, 4, 0, -10 },
  { 252, 5, 12, 4, -1, -10 },
  { 260, 7, 9, 8, 1, -11 },
  { 268, 7, 5, 8, 1, -9 },
  { 273, 7, 9, 8, 1, -11 },
  { 281, 6, 13, 5, 0, -13 },
  { 291, 11, 15, 11, 0, -13 },
  { 312, 7, 13, 8, -1, -13 },
  { 324, 8, 13, 8, 0, -13 },
  { 337, 8, 13, 7, 1, -13 },
  { 350, 8, 13, 9, 0, -13 },
  { 363, 8, 13, 7, 0, -13 },
  { 376, 8, 13, 6, 0, -13 },
  { 389, 8, 13, 9, 1, -13 },
  { 402, 9, 13, 9, 0, -13 },
  { 417, 7, 13, 5, -1, -13 },
  { 429, 7, 17, 4, -3, -13 },
  { 444, 9, 13, 8, 0, -13 },
  { 459, 5, 13, 6, 0, -13 },
  { 468, 12, 13, 12, 0, -13 },
  { 488, 10, 13, 9, 0, -13 },
  { 505, 8, 13, 9, 1, -13 },
  { 518, 8, 13, 8, 0, -13 },
  { 531, 8, 16, 9, 1, -13 },
  { 547, 8, 13, 8, 0, -13 },
  { 560, 8, 13, 7, 0, -13 },
  { 573, 7, 13, 6, 1, -13 },
  { 585, 8, 13, 9, 1, -13 },
  { 598, 7, 13, 8, 2, -13 },
  { 610, 12, 13, 12, 1, -13 },
  { 630, 9, 13, 7, -1, -13 },
  { 645, 7, 13, 7, 1, -13 },
  { 657, 8, 13, 6, -1, -13 },
  { 670, 7, 16, 5, -1, -13 },
  { 684, 3, 13, 6, 2, -13 },
  { 689, 7, 16, 5, -1, -13 },
  { 703, 7, 7, 7, 0, -13 },
  { 710, 6, 1, 6, -2, 2 },
  { 711, 2, 3, 5, 3, -14 },
  { 712, 8, 10, 8, 0, -10 },
  { 722, 7, 14, 8, 0, -14 },
  { 735, 7, 10, 6, 0, -10 },
  { 744, 9, 14, 8, 0, -14 },
  { 760, 7, 10, 7, 0, -10 },
  { 769, 8, 18, 4, -2, -14 },
  { 787, 8, 14, 8, 0, -10 },
  { 801, 7, 14, 8, 0, -14 },
  { 814, 4, 13, 4, 0, -13 },
  { 821, 6, 17, 4, -2, -13 },
  { 834, 8, 14, 7, 0, -14 },
  { 848, 5, 14, 4, 0, -14 },
  { 857, 11, 10, 11, 0, -10 },
  { 871, 7, 10, 8, 0, -10 },
  { 880, 7, 10, 8, 0, -10 },
  { 889, 8, 14, 8, -1, -10 },
  { 903, 8, 14, 8, 0, -10 },
  { 917, 6, 10, 5, 0, -10 },
  { 925, 6, 10, 6, 0, -10 },
  { 933, 5, 12, 5, 0, -12 },
  { 941, 8, 10, 8, 0, -10 },
  { 951, 6, 10, 6, 1, -10 },
  { 959, 10, 10, 10, 1, -10 },
  { 972, 8, 10, 7, -1, -10 },
  { 982, 9, 14, 6, -2, -10 },
  { 998, 7, 10, 5, -1, -10 },
  { 1007, 7, 16, 6, 0, -13 },
  { 1021, 2, 18, 7, 2, -14 },
  { 1026, 7, 16, 6, -1, -13 },
  { 1040, 7, 3, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC18PT7B_H_
