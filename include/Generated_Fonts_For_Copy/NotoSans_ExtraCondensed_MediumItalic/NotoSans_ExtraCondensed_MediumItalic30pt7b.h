#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC30PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18,
  0x38, 0x38, 0x30, 0x30, 0x00, 0x00, 0x60, 0xF0, 0xF0, 0xE0, 0x73, 0xB9,
  0x99, 0xCC, 0xEE, 0x77, 0x33, 0x18, 0x01, 0x9C, 0x0C, 0x60, 0x31, 0x80,
  0xCC, 0x06, 0x30, 0x18, 0xC3, 0xFF, 0xCF, 0xFF, 0x0C, 0x60, 0x33, 0x01,
  0xCC, 0x06, 0x30, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x0C, 0x60, 0x33, 0x01,
  0x8C, 0x06, 0x30, 0x19, 0x80, 0xC6, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x0F, 0xF0, 0xFF, 0x0E, 0x98, 0x64, 0x03, 0x20, 0x19, 0x00, 0xF8, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0x00, 0x9C, 0x04, 0xE0, 0x26,
  0x31, 0x71, 0xFF, 0x0F, 0xF0, 0x0E, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00,
  0x06, 0x01, 0x0F, 0x83, 0x0E, 0xC3, 0x86, 0x61, 0x87, 0x31, 0x83, 0x18,
  0xC1, 0x8C, 0xC0, 0xC6, 0x60, 0x67, 0x60, 0x73, 0x33, 0xB9, 0xB3, 0xED,
  0x9B, 0x37, 0xD9, 0x99, 0x9D, 0x8C, 0x0C, 0xC6, 0x0E, 0x63, 0x06, 0x33,
  0x87, 0x39, 0x83, 0x18, 0xC3, 0x8E, 0xC1, 0x83, 0xE1, 0xC1, 0xE0, 0x01,
  0x80, 0x3F, 0x01, 0xF8, 0x1C, 0xE0, 0xC6, 0x06, 0x30, 0x33, 0x81, 0x98,
  0x0F, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xF3, 0xB9, 0xDD, 0x8E, 0xDC,
  0x7E, 0xE1, 0xE7, 0x0F, 0x38, 0x71, 0xC7, 0xCF, 0xFE, 0x3E, 0x78, 0x77,
  0x66, 0xEE, 0xC0, 0x03, 0x81, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0xE0, 0x70,
  0x30, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x00, 0x07, 0x01,
  0x80, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x60,
  0x70, 0x70, 0x30, 0x30, 0x00, 0x0E, 0x06, 0x23, 0x1D, 0x9F, 0xF9, 0xFC,
  0xF0, 0xEC, 0xE6, 0x33, 0x81, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x39, 0xCE, 0xE7, 0x33, 0x98, 0x7F, 0xFC, 0x67, 0xFE,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0xF8, 0x3F, 0x8E, 0x73,
  0x8E, 0x71, 0xCC, 0x3B, 0x87, 0x70, 0xEC, 0x1F, 0x83, 0xF0, 0x6E, 0x1D,
  0xC3, 0xB8, 0x76, 0x0C, 0xC3, 0x98, 0x73, 0x1C, 0x77, 0x8F, 0xE0, 0xF8,
  0x00, 0x07, 0x0F, 0x3F, 0x7E, 0xEE, 0x4E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C,
  0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x01, 0xC0,
  0x3F, 0x83, 0xFE, 0x18, 0x70, 0x43, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xFF, 0x8F, 0xFC, 0x7F, 0xE0, 0x01, 0x80,
  0xFE, 0x1F, 0xF0, 0x87, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0x3C, 0x0F, 0x81, 0xF8, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0xC8, 0x78, 0xFF, 0x0F, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0xD8, 0x07, 0xC0, 0x6E, 0x06, 0x70, 0x33, 0x03,
  0x38, 0x39, 0xC1, 0x8E, 0x18, 0x71, 0xC3, 0x0F, 0xFE, 0x7F, 0xF4, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xF0, 0xFF, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x3F, 0x83, 0xFC, 0x23, 0xC0,
  0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0xC7, 0x8F,
  0xF0, 0xFE, 0x00, 0x00, 0xF0, 0x3F, 0x07, 0xE0, 0xE0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x73, 0x07, 0xF8, 0x7F, 0xCF, 0x1C, 0xE1, 0xCE, 0x1C,
  0xE1, 0xCE, 0x1C, 0xE1, 0xCC, 0x38, 0xE3, 0x8E, 0x70, 0x7F, 0x07, 0xE0,
  0x3F, 0xF3, 0xFF, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x7E, 0x0F,
  0xF1, 0xC7, 0x1C, 0x31, 0x83, 0x18, 0x71, 0xC7, 0x1C, 0xE0, 0xFC, 0x0F,
  0x81, 0xF8, 0x3F, 0xC7, 0x1C, 0x61, 0xCE, 0x0E, 0xE0, 0xEE, 0x0C, 0xE1,
  0xCE, 0x3C, 0x7F, 0x83, 0xF0, 0x01, 0x80, 0x7E, 0x0F, 0xE1, 0xC7, 0x1C,
  0x73, 0x87, 0x38, 0x73, 0x87, 0x30, 0x73, 0x0F, 0x38, 0xF3, 0x9E, 0x3F,
  0xE1, 0xEE, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x88, 0xF0, 0xFE,
  0x0F, 0xC0, 0x1C, 0x71, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63,
  0xCF, 0x38, 0x07, 0x07, 0x07, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x70, 0x60, 0xE0, 0x00, 0x30,
  0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x0E, 0x00, 0x80, 0x00, 0x0E, 0x1F, 0xCF, 0xE4, 0x70, 0x18, 0x0C, 0x0E,
  0x06, 0x07, 0x07, 0x07, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x00, 0x00,
  0x10, 0x1C, 0x0E, 0x06, 0x00, 0x00, 0x30, 0x00, 0xFF, 0x00, 0xE3, 0x81,
  0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x0C, 0xC3, 0xC6, 0x63, 0xF3, 0x63, 0x39,
  0xB1, 0x98, 0xD9, 0x8C, 0x78, 0xC6, 0x6C, 0x67, 0x36, 0x63, 0x1B, 0x31,
  0x89, 0x99, 0xCC, 0xCE, 0xEC, 0x63, 0x9E, 0x30, 0x84, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xE3, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x06, 0xE0, 0x77, 0x03, 0x38, 0x39,
  0xC1, 0xCE, 0x1C, 0x70, 0xE3, 0x87, 0xFC, 0x7F, 0xE3, 0xFF, 0x38, 0x39,
  0xC1, 0xCE, 0x0E, 0xE0, 0x77, 0x03, 0xF0, 0x1C, 0x0F, 0xF0, 0x3F, 0xE0,
  0xE3, 0x83, 0x8F, 0x1C, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x1E, 0x18, 0xF0,
  0xFF, 0x03, 0xFE, 0x0E, 0x38, 0x38, 0x70, 0xC1, 0xC7, 0x07, 0x1C, 0x1C,
  0x70, 0xE1, 0xC3, 0x8E, 0x7C, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0xE0, 0x1F,
  0xC1, 0xFE, 0x1C, 0x21, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xF3, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F,
  0xE0, 0xE7, 0x83, 0x8F, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1C,
  0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0E, 0x38, 0x38, 0xC0, 0xE7, 0x07, 0x1C,
  0x1C, 0x70, 0xE1, 0xC7, 0x8F, 0xFC, 0x3F, 0xE0, 0xFE, 0x00, 0x0F, 0xF8,
  0x7F, 0x83, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xFE, 0x0F, 0xF0, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F,
  0x83, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xFC,
  0x1F, 0xF0, 0x78, 0x61, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC3, 0xE7, 0x07, 0xCE, 0x1F, 0x9C, 0x06, 0x38, 0x1C,
  0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0xC1, 0x83, 0xC7, 0x07, 0xFE, 0x03,
  0xF8, 0x00, 0x0E, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x0E,
  0x1C, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3F, 0xFC, 0x3F, 0xF8,
  0x38, 0x38, 0x38, 0x38, 0x30, 0x38, 0x70, 0x38, 0x70, 0x70, 0x70, 0x70,
  0x70, 0x70, 0xE0, 0x70, 0xE0, 0x60, 0xE0, 0xE0, 0x0F, 0xE0, 0xF8, 0x0E,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x7F, 0x0F,
  0xE0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0xFC, 0x1F,
  0x03, 0xC0, 0x00, 0x0E, 0x1E, 0x1C, 0x38, 0x38, 0xE0, 0x73, 0xC1, 0xC7,
  0x03, 0x9C, 0x07, 0x70, 0x0E, 0xE0, 0x1B, 0x80, 0x7E, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xB8, 0x06, 0x70, 0x1C, 0x60, 0x38, 0xE0, 0x71, 0xC0, 0xE3,
  0x83, 0x87, 0x07, 0x07, 0x0E, 0x0E, 0x00, 0x0E, 0x07, 0x03, 0x81, 0xC1,
  0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x3F, 0xFF, 0xEF, 0xF0, 0x0F, 0x00, 0xF8, 0x78, 0x07,
  0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xB0, 0x7E,
  0x1F, 0x83, 0xF0, 0xDC, 0x1B, 0x8E, 0xE1, 0xDC, 0x76, 0x0E, 0xE3, 0x70,
  0x77, 0x3B, 0x83, 0x39, 0x9C, 0x19, 0xDC, 0xE1, 0xCE, 0xC6, 0x0E, 0x7E,
  0x70, 0x71, 0xE3, 0x83, 0x0F, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x86, 0x0E,
  0x1C, 0x70, 0x00, 0x0F, 0x03, 0x87, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE1,
  0xF8, 0x70, 0xFC, 0x30, 0x7E, 0x38, 0x33, 0x1C, 0x19, 0x8E, 0x1C, 0xC6,
  0x0E, 0x73, 0x07, 0x3B, 0x83, 0x1D, 0xC1, 0x86, 0xE1, 0xC3, 0x60, 0xE1,
  0xB0, 0x70, 0xF8, 0x30, 0x7C, 0x38, 0x3E, 0x1C, 0x0E, 0x0E, 0x07, 0x00,
  0x01, 0xC0, 0x1F, 0xC0, 0xFF, 0x83, 0x8F, 0x1C, 0x1C, 0xE0, 0x73, 0x81,
  0xDE, 0x07, 0x70, 0x1D, 0xC0, 0x77, 0x01, 0xFC, 0x0E, 0xE0, 0x3B, 0x80,
  0xEE, 0x03, 0xB8, 0x1C, 0xE0, 0x73, 0x83, 0x8E, 0x0E, 0x1E, 0xF0, 0x7F,
  0x80, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xC3, 0x9E, 0x1C, 0x71, 0xC3, 0x8E,
  0x1C, 0x70, 0xE3, 0x87, 0x18, 0x79, 0xC7, 0x8F, 0xF8, 0x7F, 0x83, 0xF0,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x1F, 0xC0, 0xFF, 0x83, 0x8F, 0x1C, 0x1C, 0xE0,
  0x73, 0x81, 0xDE, 0x07, 0x70, 0x1D, 0xC0, 0x77, 0x01, 0xFC, 0x0E, 0xE0,
  0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x1C, 0xE0, 0x73, 0x83, 0x8E, 0x0E, 0x1E,
  0xF0, 0x7F, 0x80, 0xFC, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x0F, 0xE0, 0x7F, 0x83, 0x9E, 0x18, 0x71, 0xC3, 0x8E, 0x1C,
  0x70, 0xE3, 0x87, 0x18, 0x71, 0xC7, 0x8F, 0xF8, 0x7F, 0x03, 0xB8, 0x19,
  0xC1, 0xC6, 0x0E, 0x38, 0x71, 0xC3, 0x8E, 0x38, 0x71, 0xC3, 0x8E, 0x0E,
  0x00, 0x00, 0xE0, 0x0F, 0xF0, 0x7F, 0x83, 0xC6, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x88, 0x1E, 0x1D, 0xF0,
  0xFF, 0x81, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x38, 0x07, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x00, 0x1C, 0x1C, 0x70,
  0x71, 0xC1, 0xC6, 0x07, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x70,
  0x39, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x73, 0x81, 0x8E, 0x0E, 0x38,
  0x38, 0xE0, 0xE3, 0x87, 0x0F, 0x3C, 0x1F, 0xE0, 0x3F, 0x00, 0xC0, 0x7C,
  0x0E, 0xC0, 0xEC, 0x0C, 0xC1, 0xCC, 0x1C, 0xC3, 0x8C, 0x38, 0xC7, 0x0C,
  0x70, 0xC7, 0x0C, 0xE0, 0xCE, 0x0D, 0xC0, 0xDC, 0x0D, 0x80, 0xF8, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x60, 0x70, 0x76, 0x07, 0x07, 0x60,
  0xF0, 0xE6, 0x0F, 0x0E, 0xE1, 0xF0, 0xEE, 0x1F, 0x1C, 0xE1, 0xF1, 0xCE,
  0x3F, 0x38, 0xE3, 0x63, 0x8E, 0x76, 0x38, 0xE6, 0x67, 0x0E, 0x66, 0x70,
  0xEE, 0x66, 0x0E, 0xC6, 0xE0, 0xFC, 0x6E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C,
  0x0F, 0x87, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x00, 0x07,
  0x0F, 0x07, 0x0E, 0x03, 0x1C, 0x03, 0x9C, 0x03, 0xB8, 0x03, 0xB8, 0x03,
  0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x06, 0xC0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38,
  0xE0, 0x70, 0xE0, 0xF0, 0x70, 0x70, 0xF7, 0x0E, 0x71, 0xC7, 0x1C, 0x73,
  0x87, 0x38, 0x77, 0x07, 0x70, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x11, 0xFF, 0x0F, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0F, 0xC0, 0xFC, 0x00, 0xE7, 0x39, 0xC6, 0x31, 0x8C, 0x73, 0x9C,
  0xE3, 0x18, 0xC6, 0x39, 0xCE, 0x71, 0x8C, 0x03, 0xE0, 0xFC, 0x1F, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x80, 0x70, 0x0C, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0x80, 0x3C,
  0x03, 0xC0, 0x7C, 0x0E, 0xC0, 0xCE, 0x1C, 0xE1, 0x86, 0x38, 0x67, 0x07,
  0xE0, 0x70, 0xFF, 0xC0, 0xF3, 0x9C, 0x71, 0x80, 0x0F, 0x71, 0xFF, 0x38,
  0xE7, 0x8E, 0x70, 0xE7, 0x0E, 0xE0, 0xEE, 0x0C, 0xE1, 0xCE, 0x1C, 0xE1,
  0xCE, 0x3C, 0xE3, 0x8E, 0x78, 0xFF, 0x87, 0xB8, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xDE, 0x1F, 0xF1, 0xE7, 0x1C,
  0x73, 0x87, 0x38, 0x73, 0x87, 0x30, 0x77, 0x07, 0x70, 0x77, 0x0E, 0x70,
  0xE7, 0x1C, 0xF1, 0xCF, 0xF8, 0xCF, 0x00, 0x0F, 0xC7, 0xE3, 0x89, 0xC0,
  0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x8F, 0xE1, 0xF8, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x01, 0xC1, 0xEE, 0x1F, 0xF1, 0xC7, 0x1C, 0x38, 0xE1, 0xC7, 0x0E,
  0x70, 0x73, 0x83, 0x1C, 0x18, 0xE1, 0xC7, 0x0E, 0x30, 0x71, 0xC7, 0x0E,
  0x78, 0x7E, 0xC1, 0xEE, 0x00, 0x0F, 0x87, 0xF3, 0x8D, 0xC3, 0x70, 0xD8,
  0x7E, 0x7B, 0xFC, 0xF8, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x4F, 0xF1,
  0xFC, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xD0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x03, 0xDC,
  0x1F, 0xF0, 0xE3, 0x87, 0x8E, 0x1C, 0x38, 0x70, 0xE3, 0x83, 0x8E, 0x0C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x3C, 0x38, 0xE0, 0xE7, 0x83, 0xFE,
  0x07, 0xB8, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0xC7, 0x83, 0xFC,
  0x07, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0xDE, 0x1F, 0xF1, 0xE7, 0x1C, 0x73, 0x87, 0x38, 0x73, 0x86,
  0x30, 0xE3, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xC6, 0x1C, 0xE1, 0xCE, 0x1C,
  0xE1, 0x80, 0x0E, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x1C, 0x30, 0xE1,
  0xC3, 0x86, 0x1C, 0x38, 0x70, 0xE1, 0x87, 0x0E, 0x1C, 0x00, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x30,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x82, 0xF0, 0x7C,
  0x0F, 0x00, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x03, 0x8F, 0x1C, 0x70, 0xE7, 0x06, 0x70, 0x77, 0x03, 0xB8, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x7B, 0x03, 0x9C, 0x1C, 0xE0, 0xC7, 0x0E, 0x38,
  0x71, 0xC3, 0x87, 0x00, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x60,
  0xE0, 0xE0, 0xE0, 0x1F, 0xE7, 0xC6, 0xFF, 0xF1, 0xC7, 0x9C, 0x71, 0xC7,
  0x38, 0x71, 0xCE, 0x18, 0x73, 0x8E, 0x1C, 0xC3, 0x86, 0x70, 0xE3, 0x9C,
  0x38, 0xE7, 0x0C, 0x39, 0xC7, 0x0C, 0x61, 0xC3, 0x38, 0x71, 0xCE, 0x18,
  0x73, 0x8E, 0x1C, 0x1D, 0xE1, 0xBF, 0x1E, 0x71, 0xC7, 0x38, 0x73, 0x87,
  0x38, 0x63, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0C, 0x61, 0xCE, 0x1C,
  0xE1, 0xCE, 0x18, 0x0F, 0x83, 0xF8, 0xE3, 0xB8, 0x77, 0x0E, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xDC, 0x3B, 0x07, 0x60, 0xEE, 0x39, 0xCF, 0x3F, 0xC3,
  0xF0, 0x07, 0x78, 0x1B, 0xF0, 0x79, 0xC1, 0xC7, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x07, 0x0C, 0x1C, 0x70, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x70,
  0xF1, 0xC3, 0xFE, 0x0E, 0xF0, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0F, 0x71, 0xFF, 0x38, 0xE3, 0x0E,
  0x70, 0xE7, 0x0E, 0xE0, 0xEE, 0x0C, 0xE0, 0xCE, 0x1C, 0xE1, 0xCC, 0x1C,
  0xE3, 0x8E, 0x78, 0xFF, 0x87, 0xB8, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0x19, 0xC6, 0xF1, 0xF8, 0x70, 0x3C, 0x0E,
  0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03,
  0x80, 0x1F, 0xCF, 0xF3, 0x88, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x23, 0xCF, 0xE3, 0xF0, 0x0C, 0x0C, 0x18,
  0x19, 0x7E, 0x7E, 0x38, 0x30, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xF8, 0xF8, 0x38, 0x73, 0x86, 0x30, 0xE3, 0x0E, 0x70,
  0xE7, 0x0E, 0x70, 0xC6, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0x8E, 0x38, 0xE3,
  0x8E, 0x78, 0xFF, 0x87, 0xB0, 0xC1, 0xF0, 0x6C, 0x3B, 0x0E, 0xC7, 0x31,
  0xCC, 0x63, 0x38, 0xCC, 0x37, 0x0D, 0x83, 0x60, 0xF8, 0x3C, 0x0F, 0x03,
  0x80, 0xE3, 0xC7, 0xE3, 0xC7, 0xC3, 0xC6, 0xC7, 0xCE, 0xC7, 0xCE, 0xCF,
  0x9C, 0xCD, 0x9C, 0xCD, 0x98, 0xD9, 0xB8, 0xD9, 0xB8, 0xF9, 0xB0, 0xF1,
  0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xE1, 0xE0, 0xE1, 0xC0, 0x1C, 0x38, 0x63,
  0x83, 0x18, 0x1D, 0xC0, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0xE0, 0x77, 0x03, 0xB8, 0x39, 0xC1, 0x86, 0x1C, 0x38, 0x07,
  0x0E, 0x0E, 0x1C, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0x80, 0xE7, 0x01, 0xCC,
  0x03, 0xB8, 0x07, 0x70, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x09, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x07, 0x00,
  0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x3F, 0xC7, 0xF8, 0x01, 0xE0, 0x78, 0x1C, 0x03, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x7C, 0x0E, 0x01, 0xE0,
  0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0xE0, 0x3C, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0xF8, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xF0, 0x0E, 0x07,
  0xC1, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x07, 0xE0, 0xF8, 0x18, 0x00, 0x10, 0x17, 0xE3, 0xFF, 0xF8, 0x7E, 0x80,
  0x00,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 21, 7, 0, -21 },
  { 22, 9, 7, 11, 3, -21 },
  { 30, 14, 21, 13, 0, -21 },
  { 67, 13, 25, 12, 0, -23 },
  { 108, 17, 22, 19, 1, -22 },
  { 155, 13, 22, 14, 0, -22 },
  { 191, 4, 7, 6, 3, -21 },
  { 195, 9, 27, 8, 1, -22 },
  { 226, 9, 27, 8, -2, -22 },
  { 257, 9, 11, 11, 3, -23 },
  { 270, 12, 14, 13, 1, -18 },
  { 291, 5, 8, 6, -1, -4 },
  { 296, 7, 2, 8, 0, -9 },
  { 298, 4, 4, 6, 0, -4 },
  { 300, 15, 22, 10, -2, -22 },
  { 342, 11, 22, 12, 1, -22 },
  { 373, 8, 21, 12, 3, -21 },
  { 394, 13, 22, 12, -1, -22 },
  { 430, 12, 22, 12, 0, -22 },
  { 463, 13, 22, 12, -1, -22 },
  { 499, 12, 21, 12, 0, -21 },
  { 531, 12, 22, 12, 1, -22 },
  { 564, 12, 21, 12, 1, -21 },
  { 596, 12, 22, 12, 0, -22 },
  { 629, 12, 22, 12, 0, -22 },
  { 662, 6, 16, 6, 0, -16 },
  { 674, 8, 20, 6, -2, -16 },
  { 694, 12, 13, 13, 1, -17 },
  { 714, 12, 9, 13, 1, -15 },
  { 728, 12, 13, 13, 1, -17 },
  { 748, 9, 22, 9, 1, -22 },
  { 773, 17, 24, 18, 1, -22 },
  { 824, 13, 22, 13, -2, -22 },
  { 860, 14, 21, 13, 0, -21 },
  { 897, 13, 22, 12, 1, -22 },
  { 933, 14, 21, 14, 0, -21 },
  { 970, 13, 21, 11, 0, -21 },
  { 1005, 13, 21, 11, 0, -21 },
  { 1040, 15, 22, 15, 1, -22 },
  { 1082, 16, 21, 15, 0, -21 },
  { 1124, 11, 21, 8, -1, -21 },
  { 1153, 11, 27, 6, -4, -21 },
  { 1191, 15, 21, 13, 0, -21 },
  { 1231, 9, 21, 11, 0, -21 },
  { 1255, 21, 21, 20, 0, -21 },
  { 1311, 17, 21, 16, 0, -21 },
  { 1356, 14, 22, 15, 1, -22 },
  { 1395, 13, 21, 13, 0, -21 },
  { 1430, 14, 27, 15, 1, -22 },
  { 1478, 13, 21, 13, 0, -21 },
  { 1513, 14, 22, 12, -1, -22 },
  { 1552, 11, 21, 11, 2, -21 },
  { 1581, 14, 21, 15, 1, -21 },
  { 1618, 12, 21, 13, 3, -21 },
  { 1650, 20, 21, 20, 2, -21 },
  { 1703, 16, 21, 12, -2, -21 },
  { 1745, 12, 21, 11, 2, -21 },
  { 1777, 13, 21, 11, -1, -21 },
  { 1812, 12, 27, 8, -1, -22 },
  { 1853, 5, 22, 11, 3, -22 },
  { 1867, 11, 27, 8, -2, -22 },
  { 1905, 12, 11, 12, 0, -21 },
  { 1922, 10, 1, 9, -3, 3 },
  { 1924, 5, 5, 8, 4, -23 },
  { 1928, 12, 16, 13, 1, -16 },
  { 1952, 12, 23, 13, 0, -23 },
  { 1987, 10, 16, 10, 1, -16 },
  { 2007, 13, 23, 13, 1, -23 },
  { 2045, 10, 16, 12, 1, -16 },
  { 2065, 15, 30, 7, -4, -23 },
  { 2122, 14, 23, 13, -1, -16 },
  { 2163, 12, 23, 13, 0, -23 },
  { 2198, 7, 22, 6, 0, -22 },
  { 2218, 11, 29, 6, -4, -22 },
  { 2258, 13, 23, 11, 0, -23 },
  { 2296, 8, 23, 6, 0, -23 },
  { 2319, 18, 16, 19, 0, -16 },
  { 2355, 12, 16, 13, 0, -16 },
  { 2379, 11, 16, 13, 1, -16 },
  { 2401, 14, 23, 13, -2, -16 },
  { 2442, 12, 23, 13, 1, -16 },
  { 2477, 10, 16, 9, 0, -16 },
  { 2497, 10, 16, 10, 0, -16 },
  { 2517, 8, 20, 8, 1, -20 },
  { 2537, 12, 16, 13, 1, -16 },
  { 2561, 10, 16, 11, 2, -16 },
  { 2581, 16, 16, 17, 2, -16 },
  { 2613, 13, 16, 11, -1, -16 },
  { 2639, 15, 23, 11, -3, -16 },
  { 2683, 11, 16, 9, -1, -16 },
  { 2705, 11, 26, 10, 1, -21 },
  { 2741, 3, 30, 11, 4, -23 },
  { 2753, 11, 26, 10, -2, -21 },
  { 2789, 12, 5, 13, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC30PT7B_H_
