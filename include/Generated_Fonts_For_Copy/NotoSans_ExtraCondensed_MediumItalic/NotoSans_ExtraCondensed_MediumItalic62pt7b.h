#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC62PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x10, 0x00, 0x3F, 0x8F, 0xE7, 0xE1, 0xF8,
  0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F, 0x1F, 0x87, 0xE3,
  0xF0, 0xFC, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87,
  0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xE0, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x78, 0x3E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x1E, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x1F, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x3E, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xF0, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0x9C,
  0xF0, 0x0F, 0xC6, 0x0C, 0x03, 0xE1, 0x80, 0x00, 0xF8, 0xE0, 0x00, 0x7E,
  0x38, 0x00, 0x1F, 0x8E, 0x00, 0x07, 0xE3, 0x00, 0x01, 0xF8, 0xC0, 0x00,
  0x7F, 0x70, 0x00, 0x0F, 0xDC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0x7E, 0x00, 0x01, 0x8F, 0xC0, 0x00, 0x63, 0xF0, 0x00, 0x38, 0xFC,
  0x00, 0x0E, 0x3F, 0x00, 0x03, 0x8F, 0xC0, 0x00, 0xC3, 0xE0, 0x40, 0x30,
  0xF8, 0x18, 0x1C, 0x7E, 0x07, 0xC7, 0x7F, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x0F, 0xF8, 0x00, 0xF0,
  0x03, 0xFF, 0x00, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0x80, 0x1E, 0x1E, 0x01,
  0xF0, 0x07, 0xC3, 0xC0, 0x3C, 0x00, 0xF0, 0x78, 0x0F, 0x80, 0x3E, 0x0F,
  0x03, 0xE0, 0x07, 0x81, 0xE0, 0x7C, 0x00, 0xF0, 0x3C, 0x1F, 0x00, 0x3E,
  0x0F, 0x83, 0xC0, 0x07, 0xC1, 0xF0, 0xF8, 0x00, 0xF0, 0x3C, 0x1E, 0x00,
  0x1E, 0x07, 0x87, 0xC0, 0x07, 0xC0, 0xF0, 0xF0, 0x00, 0xF8, 0x3E, 0x3E,
  0x00, 0x1F, 0x07, 0xC7, 0x80, 0x03, 0xC0, 0xF1, 0xF0, 0xFC, 0x78, 0x3E,
  0x3C, 0x3F, 0xCF, 0x07, 0x8F, 0x8F, 0xFD, 0xE0, 0xF1, 0xE3, 0xFF, 0xBE,
  0x3E, 0x7C, 0xF8, 0xF7, 0xCF, 0x8F, 0x1E, 0x1E, 0x7F, 0xE3, 0xE7, 0xC3,
  0xCF, 0xF8, 0x78, 0xF0, 0x7C, 0xFE, 0x1F, 0x1E, 0x0F, 0x0F, 0x87, 0xC7,
  0xC1, 0xE0, 0x00, 0xF8, 0xF0, 0x3C, 0x00, 0x3E, 0x1E, 0x07, 0x80, 0x07,
  0x87, 0xC0, 0xF0, 0x01, 0xF0, 0xF8, 0x3E, 0x00, 0x3C, 0x1E, 0x07, 0xC0,
  0x0F, 0x83, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x1E, 0x00, 0x7C, 0x0F, 0x07,
  0xC0, 0x0F, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x1E, 0x00, 0x78, 0x0F,
  0x87, 0xC0, 0x1F, 0x01, 0xF0, 0xF0, 0x03, 0xC0, 0x1E, 0x3E, 0x00, 0xF8,
  0x03, 0xFF, 0x80, 0x1E, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x07, 0xFC, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xF8, 0x3E, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8,
  0xFC, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0x07, 0xFF, 0x83,
  0xE0, 0xFD, 0xF8, 0x7E, 0x1F, 0x9F, 0x87, 0xE3, 0xF0, 0xFC, 0x7C, 0x3F,
  0x0F, 0xCF, 0xC7, 0xE0, 0xFC, 0xF8, 0x7E, 0x07, 0xFF, 0x87, 0xC0, 0x7F,
  0xF0, 0xFC, 0x07, 0xFF, 0x0F, 0xC0, 0x3F, 0xE0, 0xFC, 0x03, 0xFE, 0x0F,
  0x80, 0x3F, 0xC0, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0xC0, 0xFC, 0x07,
  0xFC, 0x0F, 0xC0, 0xFF, 0xC0, 0xFF, 0x3F, 0xFE, 0x07, 0xFF, 0xF7, 0xE0,
  0x7F, 0xFE, 0x7E, 0x03, 0xFF, 0xC7, 0xF0, 0x1F, 0xF0, 0x3F, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x7E,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x40,
  0xF8, 0x07, 0x0F, 0x80, 0x7C, 0xF0, 0x0F, 0xFF, 0x1E, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0xFC, 0x03, 0xF3, 0xE0, 0x7F, 0x3E, 0x07, 0xE1, 0xF0, 0x3C, 0x1F,
  0x81, 0xC1, 0xF0, 0x08, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8,
  0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E, 0x3F,
  0x7F, 0x7F, 0x7F, 0xFF, 0x7E, 0x7C, 0x10, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFC, 0x3F,
  0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x3F,
  0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xE0,
  0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x1F, 0x80,
  0x7E, 0x3F, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xBE, 0x3F, 0xBF, 0x3F, 0x9F, 0x8F, 0x8F, 0xC3, 0x07,
  0xC0, 0x87, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFE, 0x7F, 0xC0, 0x1F, 0x03, 0xF8, 0x01, 0x80, 0x3F, 0x00, 0x20,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x0F, 0xF0, 0x07,
  0x01, 0xFC, 0x01, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x08, 0x00, 0x7F, 0x03, 0x80, 0x3F,
  0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x1F, 0x7C,
  0x00, 0x07, 0xBF, 0x00, 0x03, 0xCF, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x78,
  0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x1F, 0x80, 0x07, 0x87, 0xE0, 0x03,
  0xE1, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x3F, 0x00, 0x3E, 0x0F, 0xC0,
  0x0F, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x1F,
  0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x0F, 0x00, 0x7C, 0x07, 0xC0,
  0x1F, 0x01, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0x80, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x81, 0x00, 0x0F, 0xE0, 0x38, 0x03, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x03, 0xFC, 0x18, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xF8, 0x07, 0xDF, 0xFC, 0x07, 0xEF,
  0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0xFF,
  0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F,
  0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xF0,
  0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7C,
  0x0F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F,
  0xC0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x03, 0xE0,
  0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x03,
  0xF0, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0xFE,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0xC3,
  0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x0F,
  0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x83, 0xF8, 0x0F, 0xC0, 0xFF, 0x8F, 0xF0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xF3, 0xF8, 0x07, 0xE0, 0xFC, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0,
  0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E,
  0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F,
  0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x3F, 0x07,
  0xFC, 0x1F, 0xC7, 0xFC, 0x0F, 0xFF, 0xBE, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xDF, 0x80, 0x7F, 0x8F, 0x80, 0x0F, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xC0, 0x7C, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x7C, 0x07, 0xE0,
  0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xE0, 0x04, 0x00, 0x00, 0x0E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x78, 0x7F, 0x06, 0x03, 0xF0, 0x40, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x3C, 0x03,
  0xFF, 0x0F, 0x07, 0x80, 0xFF, 0xF0, 0xF0, 0x78, 0x1F, 0xFE, 0x0F, 0x0F,
  0x03, 0xE1, 0xE0, 0xF0, 0xF0, 0x3C, 0x1E, 0x0F, 0x1F, 0x07, 0x83, 0xE0,
  0xF1, 0xE0, 0x78, 0x3C, 0x0F, 0x1E, 0x0F, 0x03, 0xC1, 0xE3, 0xE0, 0xF0,
  0x7C, 0x1E, 0x3C, 0x1F, 0x07, 0xC1, 0xE3, 0xC1, 0xE0, 0x78, 0x1E, 0x3C,
  0x1E, 0x07, 0x81, 0xE7, 0xC3, 0xE0, 0xF8, 0x3C, 0x78, 0x3C, 0x0F, 0x83,
  0xC7, 0x83, 0xC0, 0xF0, 0x3C, 0x78, 0x3C, 0x0F, 0x07, 0x87, 0x83, 0xC1,
  0xF0, 0x78, 0x78, 0x3C, 0x1F, 0x07, 0x87, 0x83, 0xC3, 0xF0, 0xF0, 0x78,
  0x3C, 0x3F, 0x1F, 0x07, 0x83, 0xC7, 0xF1, 0xE0, 0xF8, 0x3F, 0xEF, 0xFC,
  0x0F, 0x83, 0xFE, 0x7F, 0x80, 0xF8, 0x1F, 0xC7, 0xF0, 0x07, 0x80, 0xF8,
  0x3E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x02, 0x00, 0x01, 0xF8, 0x01,
  0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00,
  0x07, 0xE7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xFC,
  0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x01,
  0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF3,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xDF, 0x80, 0x03,
  0xF7, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xC0, 0xFF, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x3F, 0x01,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80,
  0x3F, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x3E, 0x03, 0xF8, 0x07, 0xE3,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0xFC, 0x3F, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F,
  0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7F, 0x03, 0xF0, 0x07,
  0xE0, 0x3E, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x07, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xDF, 0x00, 0x3F, 0xC0, 0x60, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x06, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x7E, 0x0F, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xC1, 0xF8,
  0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01,
  0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0,
  0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0,
  0x7E, 0x01, 0xFC, 0x03, 0xE0, 0x1F, 0xC0, 0x3F, 0x03, 0xFC, 0x01, 0xF8,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0xFF,
  0x00, 0x08, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xFC, 0x1F, 0x80, 0x3F, 0xF8,
  0x3F, 0x00, 0x7F, 0xF0, 0x7E, 0x01, 0xFF, 0xE0, 0xFC, 0x03, 0xFF, 0x83,
  0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFC, 0x1F,
  0x80, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0,
  0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x1F, 0xE0, 0x3F, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF0,
  0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0,
  0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80,
  0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80,
  0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x43, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01,
  0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xDF, 0x00, 0x1F,
  0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0x7C, 0x00, 0xFF, 0xF0,
  0x07, 0xEF, 0x80, 0x1F, 0x7E, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x80, 0x1F,
  0xBE, 0x00, 0xFB, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x7E, 0x00, 0x7C, 0xF8,
  0x07, 0xCF, 0xC0, 0x1F, 0x9F, 0x00, 0xF9, 0xF8, 0x03, 0xF3, 0xE0, 0x3E,
  0x3E, 0x00, 0x7C, 0x7C, 0x07, 0xCF, 0xC0, 0x0F, 0x8F, 0x81, 0xF9, 0xF8,
  0x03, 0xF1, 0xF0, 0x3E, 0x3F, 0x00, 0x7E, 0x3E, 0x0F, 0xC7, 0xC0, 0x0F,
  0xC7, 0xC1, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x3E, 0x3F, 0x00, 0x3E, 0x1F,
  0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xE1, 0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x7C,
  0x1F, 0x00, 0x3F, 0x0F, 0x8F, 0x83, 0xE0, 0x07, 0xC1, 0xF3, 0xE0, 0xFC,
  0x00, 0xF8, 0x3E, 0x7C, 0x1F, 0x80, 0x3F, 0x07, 0xDF, 0x83, 0xF0, 0x07,
  0xE0, 0xFB, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0xFC, 0x1F, 0x80, 0x1F, 0x01,
  0xFF, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xF8,
  0x0F, 0xC0, 0x1F, 0x80, 0xFF, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0xC0, 0x7E,
  0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x07, 0xC0, 0x1F, 0xC0, 0x03, 0xF0, 0x07, 0xF8, 0x00, 0xFC,
  0x03, 0xFE, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x3F, 0xE0, 0x07,
  0xE0, 0x0F, 0xF8, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0x7E, 0x01, 0xFF, 0xC0,
  0x1F, 0x00, 0x7F, 0xF0, 0x07, 0xC0, 0x1F, 0x7C, 0x03, 0xF0, 0x07, 0xDF,
  0x00, 0xFC, 0x01, 0xF7, 0xC0, 0x3F, 0x00, 0xFD, 0xF0, 0x0F, 0x80, 0x3F,
  0x7E, 0x03, 0xE0, 0x0F, 0x8F, 0x81, 0xF8, 0x03, 0xE3, 0xE0, 0x7E, 0x00,
  0xF8, 0xF8, 0x1F, 0x80, 0x7E, 0x3E, 0x07, 0xC0, 0x1F, 0x8F, 0x83, 0xF0,
  0x07, 0xC3, 0xF0, 0xFC, 0x01, 0xF0, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0x0F,
  0x80, 0x3F, 0x07, 0xC3, 0xE0, 0x0F, 0xC1, 0xF1, 0xF8, 0x03, 0xE0, 0x7C,
  0x7E, 0x00, 0xF8, 0x1F, 0x1F, 0x80, 0x7E, 0x03, 0xE7, 0xC0, 0x1F, 0x80,
  0xF9, 0xF0, 0x07, 0xE0, 0x3E, 0x7C, 0x01, 0xF0, 0x0F, 0xBF, 0x00, 0x7C,
  0x03, 0xEF, 0xC0, 0x3F, 0x00, 0xFB, 0xE0, 0x0F, 0xC0, 0x1F, 0xF8, 0x03,
  0xE0, 0x07, 0xFE, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0x7F, 0xC0,
  0x1F, 0x80, 0x1F, 0xF0, 0x07, 0xE0, 0x07, 0xFC, 0x01, 0xF0, 0x00, 0xFF,
  0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x03,
  0xF8, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xEF, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x03,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x3F, 0x80,
  0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80,
  0x03, 0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xC1, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00,
  0x7E, 0x03, 0xF0, 0x0F, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xC0,
  0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x80, 0x7E, 0x1F, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xEF,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x3F, 0x1F, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFE,
  0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xF9, 0xF8,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x3F, 0x3F, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFE,
  0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF8, 0xFC,
  0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xF8, 0x3F, 0xC0, 0x3F,
  0x03, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x07, 0xE0,
  0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0x7C, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x3F, 0xC0, 0x7E, 0x0F,
  0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xF8,
  0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83,
  0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0xE0, 0x0F, 0xE0, 0x04, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x81,
  0x00, 0x07, 0xF0, 0x38, 0x01, 0xFC, 0x07, 0xC0, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07,
  0xE0, 0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F,
  0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0,
  0x01, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x3F, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xE0,
  0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x1F, 0x00, 0xFC,
  0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x1F, 0x01,
  0xF8, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0x07, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3F, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xFC,
  0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x7D,
  0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xC0, 0x03,
  0xF7, 0xE0, 0x03, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x7E,
  0x00, 0x7F, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07,
  0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFF, 0x00,
  0x7E, 0x1F, 0x80, 0x3F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xF0, 0x0F, 0xC1,
  0xF8, 0x07, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xFF, 0x01, 0xF8, 0x1F, 0x80,
  0xFF, 0xC0, 0x7E, 0x07, 0xE0, 0x3D, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x7C,
  0x0F, 0xC0, 0x7E, 0x07, 0xDF, 0x03, 0xF0, 0x1F, 0x83, 0xE7, 0xC0, 0xF8,
  0x07, 0xC0, 0xF9, 0xF0, 0x7E, 0x01, 0xF0, 0x3E, 0x7C, 0x1F, 0x80, 0x7C,
  0x1F, 0x1F, 0x0F, 0xC0, 0x1F, 0x07, 0xC7, 0xC3, 0xF0, 0x07, 0xC3, 0xE1,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x7C, 0x7E, 0x00, 0x7C, 0x3E, 0x1F, 0x1F,
  0x80, 0x1F, 0x1F, 0x07, 0xCF, 0xC0, 0x07, 0xC7, 0xC1, 0xF3, 0xF0, 0x01,
  0xF3, 0xE0, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x1E, 0x7E, 0x00, 0x1F, 0x3E,
  0x07, 0x9F, 0x80, 0x07, 0xDF, 0x01, 0xE7, 0xC0, 0x01, 0xF7, 0xC0, 0x7B,
  0xF0, 0x00, 0x7D, 0xF0, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xBE, 0x00,
  0x07, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xC0,
  0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x01, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x7C, 0x00,
  0x7E, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01,
  0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F,
  0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x1F, 0x83, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0xC0, 0xF8,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x83, 0xE0, 0x07,
  0xC3, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xFD, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xF8, 0x7E, 0x1F, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF1, 0xF0, 0x0F, 0xFE, 0xFC, 0x07,
  0xFF, 0xBE, 0x03, 0xFF, 0xEF, 0x81, 0xFE, 0x3F, 0xE0, 0x7F, 0x07, 0xF8,
  0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xF8, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xF0,
  0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x07,
  0xE0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x3F,
  0x07, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00,
  0xFE, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0x7E, 0x0F, 0xF0, 0x1F,
  0xEF, 0x7C, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xEF, 0x80, 0x3F, 0xF3, 0xE0,
  0x07, 0xF8, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC7, 0xC0, 0x07, 0xCF, 0xF8, 0x07, 0xEF, 0xFE, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0x8F, 0xE0, 0x7F, 0x03, 0xF0, 0x7F, 0x01,
  0xF8, 0x3F, 0x80, 0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xC0,
  0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0xF8,
  0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x1F,
  0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0xC3,
  0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFE, 0x03, 0xF8,
  0x7F, 0x01, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xF3, 0xFC, 0x0F, 0xFF, 0xFC,
  0x0F, 0x9F, 0xFC, 0x07, 0xCF, 0xFC, 0x03, 0xE3, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x01, 0xFC, 0x18, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x20, 0x3F, 0xCF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x87, 0xE0,
  0x01, 0xFF, 0x3F, 0x00, 0x1F, 0xFD, 0xF8, 0x01, 0xFF, 0xEF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0xFE, 0x3F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01,
  0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x00, 0x3E, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFE, 0x07,
  0xF0, 0x03, 0xF0, 0x7F, 0x80, 0x1F, 0xCF, 0xFC, 0x00, 0xFF, 0xFB, 0xE0,
  0x03, 0xFF, 0x9E, 0x00, 0x1F, 0xF9, 0xF0, 0x00, 0x7F, 0x8F, 0x80, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7E, 0x0F, 0x81, 0xF8, 0x1F, 0x07,
  0xE0, 0x3F, 0x0F, 0xC0, 0x7C, 0x3F, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0xF8,
  0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x0F, 0x83, 0xFC, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x04, 0x0F, 0xF0, 0x78, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x8F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x1F, 0x00, 0x3F, 0xFB, 0xF0,
  0x07, 0xFF, 0xBE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xE3, 0xFE, 0x01, 0xFC,
  0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0xFC,
  0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0x81, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F,
  0x80, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07,
  0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x01, 0xFE, 0x03,
  0xF8, 0x1F, 0xC0, 0x1F, 0x83, 0xFC, 0x01, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xEF, 0x80, 0x0F, 0xFC, 0xF8, 0x00, 0x7F, 0x9F, 0x80,
  0x01, 0xC1, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x80, 0x1F, 0xC0, 0x0F, 0x03, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC7,
  0xC0, 0x07, 0xCF, 0xF8, 0x03, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xF7,
  0xFF, 0xC0, 0xFF, 0x8F, 0xE0, 0x7F, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x3F,
  0x80, 0xFC, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x3F, 0x07,
  0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xE0,
  0x7C, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7C,
  0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC1, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x47, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x7E, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x83, 0xF0,
  0x03, 0xE1, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x1F,
  0x80, 0x07, 0xCF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3E,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF3, 0xE0, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE0,
  0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07,
  0xC0, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x3F, 0x00, 0xFC,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0x8F, 0xF8, 0x7F, 0xC0,
  0x1E, 0x7F, 0xF3, 0xFF, 0x80, 0xFB, 0xFF, 0xDF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xF0, 0xFF, 0x87, 0xE0, 0x3F, 0x83, 0xFC, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x3E, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x1F, 0x80, 0xFC,
  0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xF0, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x3E, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0xFC, 0x07, 0xE0,
  0x1F, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x7E,
  0x01, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x3F, 0x00,
  0xF8, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x1F, 0x83, 0xF0,
  0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x0F,
  0xC0, 0xF8, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x1F, 0x80,
  0x7C, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0x7E,
  0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0xFC, 0x03,
  0xE0, 0x1F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0xF1, 0xFF, 0x00, 0x79, 0xFF, 0xC0, 0x7D, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xF1, 0xFC, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x1F,
  0x83, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x03,
  0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80,
  0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF0,
  0x07, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F,
  0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07,
  0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7E, 0x1F,
  0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x3E, 0x3F, 0x00, 0x7C,
  0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xCF,
  0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8,
  0x01, 0xFB, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x9F, 0x00,
  0x3F, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xF8, 0x07, 0xE1, 0xF0, 0x0F,
  0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0xFE, 0x0F, 0xF7, 0xF8, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x02, 0x1F, 0x00, 0x03, 0xC3, 0xFC, 0x00, 0x3C, 0xFF, 0xE0, 0x07,
  0xCF, 0xFE, 0x00, 0x7D, 0xFF, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x03,
  0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80,
  0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x03, 0xF0,
  0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0,
  0x07, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x9F, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFB, 0xFF, 0x80, 0x1F, 0x9F, 0xF0, 0x01, 0xF9, 0xFE, 0x00, 0x1F,
  0x03, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF1, 0xF0, 0x0F,
  0xFE, 0xFC, 0x07, 0xFF, 0xBE, 0x03, 0xFF, 0xFF, 0x80, 0xFE, 0x3F, 0xE0,
  0x7E, 0x07, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F,
  0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x0F, 0xC0,
  0x0F, 0x83, 0xF0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x07, 0xE0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC,
  0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E,
  0x0F, 0xF0, 0x1F, 0xEF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xEF, 0x80,
  0x3F, 0xF3, 0xE0, 0x07, 0xF9, 0xF8, 0x00, 0x70, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F,
  0x1F, 0xC0, 0x79, 0xFC, 0x07, 0xDF, 0xE0, 0x3E, 0xFF, 0x01, 0xFF, 0xF0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0xC0, 0x7E, 0x01, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x20, 0x07, 0xF0, 0xE0, 0x3F, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE1, 0x0F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x7F, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFE, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xC0, 0x0E, 0x00, 0x03, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07,
  0xE0, 0xFC, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0,
  0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x7C,
  0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x0F,
  0x80, 0x3E, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1,
  0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x03, 0xF8,
  0x3F, 0x03, 0xFC, 0x1F, 0xC1, 0xFC, 0x07, 0xF7, 0xFE, 0x03, 0xFF, 0xDF,
  0x01, 0xFF, 0xEF, 0x80, 0x7F, 0xE7, 0x80, 0x1F, 0xC3, 0xC0, 0x03, 0x80,
  0x00, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0, 0x07,
  0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xF3, 0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8,
  0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xE0,
  0x7C, 0x1F, 0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xC7,
  0xC0, 0x3E, 0x7E, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7D, 0xF8, 0x03,
  0xEF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x03, 0xF8, 0x07, 0xEF, 0x80, 0x7F,
  0x00, 0xF9, 0xF0, 0x0F, 0xE0, 0x3F, 0x3E, 0x03, 0xFC, 0x07, 0xC7, 0xC0,
  0x7F, 0x81, 0xF8, 0xF8, 0x1F, 0xF0, 0x3F, 0x1F, 0x03, 0xFE, 0x07, 0xC3,
  0xE0, 0x7F, 0xC1, 0xF8, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0x83, 0xDF, 0x07,
  0xC1, 0xF0, 0x7B, 0xE1, 0xF8, 0x3E, 0x1F, 0x7C, 0x3E, 0x07, 0xC3, 0xCF,
  0x8F, 0xC0, 0xF8, 0xF9, 0xF1, 0xF0, 0x1F, 0x1F, 0x3E, 0x3E, 0x03, 0xE3,
  0xC7, 0xCF, 0xC0, 0x7C, 0xF8, 0xF1, 0xF0, 0x0F, 0x9E, 0x1E, 0x3E, 0x01,
  0xF7, 0xC3, 0xCF, 0x80, 0x3E, 0xF8, 0x79, 0xF0, 0x07, 0xDE, 0x0F, 0x7E,
  0x01, 0xFF, 0xC1, 0xEF, 0x80, 0x3E, 0xF8, 0x3D, 0xF0, 0x07, 0xDE, 0x07,
  0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0,
  0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x80,
  0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E,
  0x7C, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7E, 0x3F,
  0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x03,
  0xF0, 0x1F, 0x00, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC,
  0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0xE0,
  0x3F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3E,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0x1F, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x02, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x01, 0x3F, 0xF0, 0x01, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFE, 0x80, 0x03, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 16, 45, 15, 0, -44 },
  { 91, 19, 16, 22, 6, -44 },
  { 129, 29, 44, 27, 0, -44 },
  { 289, 26, 51, 25, 0, -47 },
  { 455, 35, 46, 39, 3, -45 },
  { 657, 28, 46, 28, 0, -45 },
  { 818, 9, 16, 13, 6, -44 },
  { 836, 19, 55, 16, 1, -45 },
  { 967, 20, 55, 16, -5, -45 },
  { 1105, 20, 22, 23, 6, -47 },
  { 1160, 24, 30, 27, 2, -37 },
  { 1250, 12, 15, 13, -3, -7 },
  { 1273, 14, 5, 17, 1, -19 },
  { 1282, 8, 9, 13, 0, -8 },
  { 1291, 29, 45, 21, -3, -45 },
  { 1455, 24, 46, 25, 1, -45 },
  { 1593, 17, 44, 25, 6, -44 },
  { 1687, 27, 45, 25, -2, -45 },
  { 1839, 26, 46, 25, -1, -45 },
  { 1989, 26, 45, 25, -1, -45 },
  { 2136, 27, 45, 25, -1, -44 },
  { 2288, 25, 46, 25, 2, -45 },
  { 2432, 26, 44, 25, 2, -44 },
  { 2575, 26, 46, 25, 0, -45 },
  { 2725, 25, 46, 25, 0, -45 },
  { 2869, 13, 35, 13, 0, -34 },
  { 2926, 16, 42, 13, -3, -34 },
  { 3010, 24, 28, 27, 2, -36 },
  { 3094, 24, 18, 27, 2, -31 },
  { 3148, 24, 28, 27, 2, -36 },
  { 3232, 20, 46, 19, 1, -45 },
  { 3347, 36, 50, 37, 1, -45 },
  { 3572, 26, 44, 26, -4, -44 },
  { 3715, 28, 44, 27, 0, -44 },
  { 3869, 27, 46, 25, 2, -45 },
  { 4025, 29, 44, 30, 0, -44 },
  { 4185, 26, 44, 23, 0, -44 },
  { 4328, 26, 44, 22, 0, -44 },
  { 4471, 31, 46, 31, 2, -45 },
  { 4650, 32, 44, 31, 0, -44 },
  { 4826, 25, 44, 17, -3, -44 },
  { 4964, 24, 56, 13, -9, -44 },
  { 5132, 31, 44, 26, 0, -44 },
  { 5303, 18, 44, 22, 0, -44 },
  { 5402, 43, 44, 41, 0, -44 },
  { 5639, 34, 44, 33, 0, -44 },
  { 5826, 29, 46, 32, 2, -45 },
  { 5993, 28, 44, 26, 0, -44 },
  { 6147, 29, 56, 32, 2, -45 },
  { 6350, 27, 44, 27, 0, -44 },
  { 6499, 27, 46, 24, -1, -45 },
  { 6655, 23, 44, 22, 4, -44 },
  { 6782, 30, 45, 30, 2, -44 },
  { 6951, 26, 44, 26, 5, -44 },
  { 7094, 42, 44, 41, 4, -44 },
  { 7325, 33, 44, 24, -4, -44 },
  { 7507, 24, 44, 23, 5, -44 },
  { 7639, 29, 44, 22, -3, -44 },
  { 7799, 24, 55, 17, -2, -45 },
  { 7964, 11, 45, 22, 6, -45 },
  { 8026, 23, 55, 17, -4, -45 },
  { 8185, 25, 24, 25, 0, -44 },
  { 8260, 20, 4, 19, -6, 5 },
  { 8270, 9, 9, 16, 9, -47 },
  { 8281, 26, 35, 27, 1, -34 },
  { 8395, 25, 48, 27, 0, -47 },
  { 8545, 21, 35, 21, 1, -34 },
  { 8637, 29, 48, 27, 1, -47 },
  { 8811, 23, 35, 24, 1, -34 },
  { 8912, 30, 62, 15, -8, -47 },
  { 9145, 28, 49, 27, -1, -34 },
  { 9317, 25, 47, 26, 0, -47 },
  { 9464, 15, 46, 13, 0, -46 },
  { 9551, 23, 61, 13, -8, -46 },
  { 9727, 26, 47, 24, 0, -47 },
  { 9880, 16, 47, 12, 0, -47 },
  { 9974, 38, 34, 39, 0, -34 },
  { 10136, 25, 34, 26, 0, -34 },
  { 10243, 23, 35, 26, 1, -34 },
  { 10344, 28, 49, 27, -3, -34 },
  { 10516, 26, 49, 27, 1, -34 },
  { 10676, 21, 34, 18, 0, -34 },
  { 10766, 22, 35, 20, -1, -34 },
  { 10863, 16, 42, 16, 2, -41 },
  { 10947, 25, 34, 26, 1, -33 },
  { 11054, 21, 33, 22, 4, -33 },
  { 11141, 35, 33, 35, 3, -33 },
  { 11286, 28, 33, 22, -3, -33 },
  { 11402, 31, 48, 22, -6, -33 },
  { 11588, 22, 33, 19, -2, -33 },
  { 11679, 24, 54, 21, 1, -44 },
  { 11841, 5, 62, 23, 9, -47 },
  { 11880, 23, 54, 20, -4, -44 },
  { 12036, 24, 8, 27, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC62PT7B_H_
