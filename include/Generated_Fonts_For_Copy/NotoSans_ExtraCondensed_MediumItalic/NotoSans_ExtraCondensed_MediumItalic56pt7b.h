#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC56PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x3E, 0x00, 0x10, 0x00, 0x1F, 0x0F, 0x9F, 0x87, 0xCF, 0xC7,
  0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x3C, 0x7C,
  0x3E, 0x3E, 0x1F, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC7, 0xC3, 0xE0,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xE0, 0x00,
  0x70, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x83, 0xC0,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x0F, 0x07, 0x00, 0x03, 0xC3,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xE3, 0x1C, 0x07, 0xC7, 0x04, 0x07, 0xC6,
  0x00, 0x07, 0xC6, 0x00, 0x07, 0xC6, 0x00, 0x07, 0xCE, 0x00, 0x07, 0xCE,
  0x00, 0x07, 0xEC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x37, 0xE0, 0x00, 0x33, 0xE0, 0x00, 0x33,
  0xF0, 0x00, 0x31, 0xF0, 0x00, 0x71, 0xF0, 0x00, 0x61, 0xF0, 0x00, 0x63,
  0xE0, 0x40, 0x63, 0xE0, 0x60, 0x67, 0xE0, 0xFC, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xE0,
  0x1F, 0xE0, 0x07, 0x80, 0x7F, 0xE0, 0x1F, 0x01, 0xF3, 0xC0, 0x3C, 0x03,
  0xC7, 0x80, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0x1E, 0x1E, 0x07, 0x80, 0x3C,
  0x3C, 0x0F, 0x00, 0xF0, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x78, 0x03, 0xC1,
  0xE1, 0xE0, 0x0F, 0x03, 0xC3, 0xC0, 0x1E, 0x0F, 0x8F, 0x00, 0x3C, 0x1E,
  0x1E, 0x00, 0x78, 0x3C, 0x78, 0x00, 0xF0, 0x78, 0xF0, 0x41, 0xE1, 0xE3,
  0xC3, 0xF3, 0xC3, 0xCF, 0x8F, 0xF7, 0x87, 0x9E, 0x3F, 0xEF, 0x1E, 0x7C,
  0xF3, 0xFE, 0x7C, 0xF1, 0xE3, 0xFF, 0xF3, 0xE7, 0x87, 0xBF, 0xC7, 0x8F,
  0x0F, 0x3F, 0x1E, 0x3C, 0x1E, 0x10, 0x3C, 0x78, 0x3C, 0x00, 0xF0, 0xF0,
  0x78, 0x01, 0xE3, 0xC1, 0xE0, 0x07, 0x87, 0x83, 0xC0, 0x0F, 0x0F, 0x07,
  0x80, 0x3C, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x78,
  0x03, 0xC1, 0xE0, 0xF0, 0x0F, 0x03, 0xC1, 0xE0, 0x1E, 0x07, 0x87, 0x80,
  0x78, 0x0F, 0x0F, 0x01, 0xF0, 0x0F, 0x3C, 0x03, 0xC0, 0x1F, 0xF0, 0x0F,
  0x80, 0x3F, 0xE0, 0x1E, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xC7, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0xF8,
  0x01, 0xF0, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xCF, 0x80, 0x03, 0xEF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x3E, 0x3F,
  0x7C, 0x3E, 0x1F, 0x3F, 0x1F, 0x1F, 0x0F, 0x9F, 0x1F, 0x87, 0xCF, 0x8F,
  0x83, 0xF7, 0xC7, 0xC0, 0xFF, 0xC7, 0xC0, 0x7F, 0xE3, 0xE0, 0x3F, 0xE1,
  0xF0, 0x0F, 0xF0, 0xF8, 0x07, 0xF0, 0x7C, 0x03, 0xF0, 0x3E, 0x03, 0xFC,
  0x1F, 0x03, 0xFE, 0x0F, 0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xF7,
  0xE0, 0x7F, 0xF1, 0xF0, 0x1F, 0xE0, 0xFC, 0x01, 0x00, 0x00, 0x00, 0x3F,
  0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF0, 0xF0,
  0xF0, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x40, 0xF0, 0x1C, 0x3C, 0x07, 0xCF, 0x05, 0xFF,
  0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0x07, 0xF0,
  0x03, 0xFE, 0x01, 0xF7, 0xC0, 0xF8, 0xF0, 0x7E, 0x3E, 0x07, 0x0F, 0xC0,
  0x81, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x1F,
  0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x00,
  0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x00, 0x1C, 0xFD, 0xFB,
  0xFF, 0xFF, 0x9F, 0x08, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xE7, 0xE0,
  0x3F, 0x0F, 0x80, 0xF8, 0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x01, 0xF0, 0xFC,
  0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F,
  0x87, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x7E, 0x7E, 0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00,
  0x7C, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3F, 0x00, 0xF8,
  0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xE0, 0xF8,
  0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x0F, 0x80, 0x7E, 0xFE,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x7E, 0xF9, 0xF9, 0xF3, 0xE7, 0xE3,
  0x8F, 0x82, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xE3,
  0xF8, 0x01, 0xC0, 0x7E, 0x00, 0xC0, 0x3F, 0x00, 0x40, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xF0, 0x7F, 0x00, 0xC0, 0x3F,
  0x00, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x80, 0x0F, 0xC0, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0xF8,
  0x00, 0x3C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF0, 0xF8, 0x00, 0xF1, 0xF0,
  0x01, 0xE1, 0xF0, 0x01, 0xE1, 0xF0, 0x03, 0xC1, 0xF0, 0x07, 0x81, 0xF0,
  0x07, 0x83, 0xE0, 0x0F, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x1E, 0x03, 0xE0,
  0x3C, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x40, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x82, 0x00,
  0x7E, 0x07, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xE0,
  0x80, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x3F, 0x80, 0x7E, 0xFF, 0x80, 0xFB,
  0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFC, 0x7E, 0x0F, 0xF0, 0x7E, 0x1F, 0xC0,
  0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x0F,
  0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF8,
  0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x3F, 0x03,
  0xE0, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x0F, 0x81,
  0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E,
  0x01, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x0F, 0x81, 0xF8, 0x3E, 0x01, 0xF0,
  0xFC, 0x03, 0xF3, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xE7, 0xE0,
  0x1F, 0x87, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x8F,
  0xC0, 0x3F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8,
  0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xE0, 0x3E, 0x0F, 0xE0,
  0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xE3, 0xF0, 0x3F, 0x07, 0xC1,
  0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x1F, 0x0F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0xFC, 0x7C, 0x03, 0xF1, 0xF0, 0x1F, 0xC7, 0xE0, 0x7F, 0x1F,
  0x83, 0xF8, 0x7F, 0x3F, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xBE, 0x07, 0xFD,
  0xF0, 0x0F, 0xE7, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x81, 0xFE, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0x80, 0x20, 0x00, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xE0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xC0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xC3, 0xF0, 0x40, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x01,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x10, 0x07,
  0x07, 0x80, 0xFF, 0x87, 0x07, 0x03, 0xFF, 0x87, 0x0F, 0x07, 0xFF, 0x87,
  0x0E, 0x07, 0x8F, 0x07, 0x1E, 0x0F, 0x0F, 0x07, 0x1E, 0x1E, 0x0F, 0x0F,
  0x1C, 0x1E, 0x0F, 0x0F, 0x3C, 0x1C, 0x1E, 0x0F, 0x3C, 0x3C, 0x1E, 0x0F,
  0x38, 0x3C, 0x1E, 0x0E, 0x78, 0x38, 0x1E, 0x0E, 0x78, 0x78, 0x3C, 0x1E,
  0x78, 0x78, 0x3C, 0x1E, 0x78, 0x78, 0x3C, 0x1C, 0x70, 0x78, 0x7C, 0x3C,
  0x70, 0x78, 0x78, 0x38, 0xF0, 0x78, 0x78, 0x78, 0xF0, 0x78, 0xF8, 0x70,
  0xF0, 0x79, 0xF8, 0xF0, 0xF0, 0x7F, 0xBF, 0xE0, 0xF0, 0x7F, 0x9F, 0xC0,
  0xF0, 0x3F, 0x1F, 0x80, 0xF0, 0x0C, 0x02, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x10, 0x00, 0x1F, 0x00, 0x70, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xDF, 0x00, 0x07, 0xDF, 0x00, 0x07,
  0xDF, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0x9F, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E,
  0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x1F, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0xC0,
  0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00,
  0x1F, 0x3F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7E, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xC0, 0xFC, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xC0,
  0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0xF8,
  0x1F, 0x80, 0xFC, 0x0F, 0x80, 0xFC, 0x07, 0xC1, 0xFC, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7C, 0x3F,
  0xC0, 0x3E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80,
  0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xF0,
  0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x3F,
  0x01, 0xF8, 0x1F, 0x01, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0x1E, 0x01, 0xFC, 0x04, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0x00, 0x7F, 0x8F, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7E, 0x0F, 0xE0, 0x1F,
  0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0,
  0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F,
  0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3F, 0x00,
  0x7E, 0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x3E,
  0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x07, 0xC1, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFE, 0x0F, 0x80, 0x7F, 0x00,
  0x60, 0x1F, 0xC0, 0x04, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xFF, 0x87, 0xC0, 0x3F, 0xF0,
  0xF8, 0x07, 0xFE, 0x3F, 0x00, 0xFF, 0xC7, 0xE0, 0x3F, 0xF8, 0xFC, 0x00,
  0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x3F,
  0x80, 0x7C, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x01, 0xF0,
  0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x07,
  0xC0, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x00,
  0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x7E, 0x01, 0xF0,
  0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x0F,
  0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x7E, 0x03, 0xF0,
  0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x0F,
  0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x00,
  0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xF0,
  0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x0F,
  0xC0, 0x7E, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x81,
  0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7C, 0xFC, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFD, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0x7C, 0x03, 0xFF, 0x00, 0x7D, 0xF0, 0x0F, 0xBC,
  0x01, 0xEF, 0xC0, 0x7C, 0xF0, 0x0F, 0xBE, 0x01, 0xF3, 0xC0, 0x3E, 0xF8,
  0x07, 0xCF, 0x01, 0xF3, 0xE0, 0x1F, 0x3C, 0x07, 0xCF, 0x80, 0xFC, 0xF0,
  0x1E, 0x7C, 0x03, 0xE3, 0xC0, 0xF9, 0xF0, 0x0F, 0x8F, 0x03, 0xC7, 0xC0,
  0x3E, 0x3C, 0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x78, 0xFC, 0x07, 0xC3, 0xC3,
  0xE3, 0xE0, 0x1F, 0x0F, 0x0F, 0x0F, 0x80, 0x7C, 0x3C, 0x7C, 0x3E, 0x01,
  0xF0, 0xF9, 0xF0, 0xF8, 0x07, 0xC3, 0xEF, 0x87, 0xE0, 0x3E, 0x0F, 0xBE,
  0x1F, 0x00, 0xF8, 0x3E, 0xF0, 0x7C, 0x03, 0xE0, 0xFF, 0xC1, 0xF0, 0x0F,
  0x83, 0xFE, 0x07, 0xC0, 0x3E, 0x0F, 0xF8, 0x3F, 0x01, 0xF0, 0x3F, 0xC0,
  0xF8, 0x07, 0xC0, 0xFF, 0x03, 0xE0, 0x1F, 0x03, 0xF8, 0x0F, 0x80, 0x7C,
  0x0F, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x81, 0xF0, 0x0F, 0x80, 0xFC, 0x07,
  0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x3E, 0x01, 0xFC,
  0x00, 0x7C, 0x03, 0xF8, 0x01, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x1F, 0xE0,
  0x07, 0xC0, 0x3F, 0xC0, 0x0F, 0x80, 0x7F, 0xC0, 0x1F, 0x00, 0xFF, 0x80,
  0x7C, 0x01, 0xFF, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x0F, 0xBC, 0x03,
  0xE0, 0x1F, 0x78, 0x0F, 0xC0, 0x3E, 0xF8, 0x1F, 0x00, 0x79, 0xF0, 0x3E,
  0x01, 0xF3, 0xE0, 0x7C, 0x03, 0xE7, 0xC0, 0xF8, 0x07, 0xC7, 0x83, 0xE0,
  0x0F, 0x8F, 0x07, 0xC0, 0x3E, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x1F, 0x00,
  0xF8, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0xF8, 0x03, 0xE0, 0xF1, 0xF0, 0x0F,
  0x81, 0xE3, 0xE0, 0x1F, 0x03, 0xE7, 0xC0, 0x3E, 0x07, 0xCF, 0x80, 0x7C,
  0x0F, 0xBE, 0x00, 0xF8, 0x1F, 0x7C, 0x03, 0xE0, 0x1E, 0xF8, 0x07, 0xC0,
  0x3D, 0xF0, 0x0F, 0x80, 0x7F, 0xC0, 0x1F, 0x00, 0xFF, 0x80, 0x3E, 0x01,
  0xFF, 0x00, 0xF8, 0x03, 0xFE, 0x01, 0xF0, 0x03, 0xFC, 0x03, 0xE0, 0x07,
  0xF0, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x3F,
  0x80, 0x7C, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x9F,
  0xE0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0xC1, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7,
  0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0xCF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x7E, 0x00,
  0x1F, 0x9F, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7C, 0xFC,
  0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xF8,
  0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0x7F, 0x1F, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7C, 0x03, 0xF0,
  0x3E, 0x01, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x7E,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x7F,
  0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x3F,
  0x81, 0xF8, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x03,
  0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0x80,
  0x03, 0xF7, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x9F,
  0x00, 0x07, 0xE7, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x1F,
  0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xF8, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0,
  0x7F, 0x1F, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0x83, 0xF8, 0x07, 0xC0, 0xFC, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x80, 0xFC,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x7F,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0xF8,
  0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F,
  0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x04, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x20, 0x01, 0xF8, 0x1C, 0x03, 0xF8, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xE0,
  0x7E, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x03, 0xE0, 0x3E, 0x00,
  0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07,
  0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x0F,
  0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0xFC,
  0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8,
  0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80,
  0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7F, 0x9F, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0x9F, 0x00, 0x3F, 0x3E, 0x00,
  0x7E, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F,
  0x87, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xE0,
  0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xF8, 0x07,
  0xC1, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xDF,
  0x80, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFD, 0xF0, 0x01, 0xF0, 0x03, 0xE7, 0xC0, 0x0F,
  0xC0, 0x0F, 0x9F, 0x00, 0x3F, 0x00, 0x7E, 0x7C, 0x01, 0xFC, 0x01, 0xF1,
  0xF0, 0x07, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0xC0, 0x3E, 0x1F, 0x00, 0xFE,
  0x00, 0xF8, 0x7C, 0x03, 0xF8, 0x07, 0xE1, 0xF0, 0x1F, 0xE0, 0x1F, 0x07,
  0xC0, 0x7F, 0x80, 0xFC, 0x1F, 0x01, 0xFE, 0x03, 0xE0, 0x7C, 0x0F, 0x78,
  0x0F, 0x81, 0xF0, 0x3D, 0xE0, 0x7E, 0x07, 0xC1, 0xF7, 0x81, 0xF0, 0x3F,
  0x07, 0x9E, 0x07, 0xC0, 0xF8, 0x1E, 0x78, 0x3E, 0x03, 0xE0, 0xF9, 0xE0,
  0xF8, 0x0F, 0x83, 0xC7, 0x87, 0xE0, 0x3E, 0x1F, 0x1E, 0x1F, 0x00, 0xF8,
  0x7C, 0x78, 0x7C, 0x03, 0xE1, 0xE1, 0xE3, 0xE0, 0x0F, 0x8F, 0x87, 0x8F,
  0x80, 0x3E, 0x3C, 0x1E, 0x7E, 0x00, 0xF9, 0xF0, 0x79, 0xF0, 0x03, 0xE7,
  0xC3, 0xE7, 0xC0, 0x0F, 0x9E, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x3E, 0xF8,
  0x00, 0xFB, 0xC0, 0xFB, 0xE0, 0x03, 0xEF, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0x7C, 0x0F,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F,
  0x8F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xFC, 0x0F,
  0x80, 0x07, 0xC0, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00,
  0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x9F, 0x80, 0x7C, 0x7E, 0x03,
  0xF1, 0xF8, 0x0F, 0x83, 0xE0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x80,
  0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE7, 0xC0, 0x07, 0x9F, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xF0, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x78, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C,
  0x1E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x79, 0xE0, 0x01,
  0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x0F, 0x00, 0x78,
  0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x78, 0x3E, 0x00,
  0xF8, 0x78, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x03, 0xDF, 0x80, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x3E, 0x1F, 0x87,
  0xC3, 0xE0, 0xF8, 0x7C, 0x1E, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xFE,
  0x3C, 0x07, 0xFE, 0xF8, 0x1F, 0xFD, 0xF0, 0x7F, 0xFB, 0xE0, 0xFC, 0x3F,
  0x83, 0xF0, 0x3F, 0x07, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF8,
  0xFC, 0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F,
  0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0,
  0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x3F, 0x01,
  0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x81, 0xF8, 0xFF,
  0x03, 0xFF, 0xBE, 0x07, 0xFF, 0x7C, 0x07, 0xFC, 0xF0, 0x07, 0xF1, 0xE0,
  0x01, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x0E, 0x00, 0x7C, 0xFF, 0x00, 0xFB, 0xFE, 0x01, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xF0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x01,
  0xF0, 0x7C, 0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F,
  0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xFC, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1,
  0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xE0,
  0x3E, 0x0F, 0xE0, 0xFC, 0x1F, 0xC3, 0xF0, 0x3D, 0xFF, 0xE0, 0xFB, 0xFF,
  0x81, 0xF7, 0xFE, 0x03, 0xC7, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xC1,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x81,
  0xF8, 0x30, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x18, 0x3E, 0x00, 0x3F, 0xCF, 0x80,
  0x1F, 0xFB, 0xE0, 0x0F, 0xFE, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xF8, 0x7F,
  0x00, 0xFC, 0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F,
  0x80, 0x3E, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0,
  0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x03,
  0xE0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xFC,
  0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xE3, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xF7, 0x80, 0x0F, 0xF9, 0xE0, 0x01, 0xFC, 0x78, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03,
  0xFB, 0xF0, 0x7E, 0x1F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x1F, 0x01, 0xF1,
  0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x07, 0xE7, 0xC3, 0xFC,
  0x7F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x47, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xE3,
  0xC0, 0x1F, 0xFB, 0xE0, 0x1F, 0xFD, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xC3,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xE0,
  0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C,
  0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F,
  0x80, 0x3E, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0x81,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF0,
  0x1F, 0x83, 0xF8, 0x07, 0xE3, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xDF, 0x00, 0x1F, 0xCF, 0x80, 0x01, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x02, 0x00, 0x7E, 0x01, 0xC0, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0xE0,
  0x0F, 0x9F, 0xE0, 0x3E, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F,
  0xE3, 0xF0, 0x7F, 0x07, 0xC1, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x3F, 0x01,
  0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE1,
  0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xC1, 0xF0,
  0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3E,
  0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x1F,
  0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x00, 0x00,
  0x30, 0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x23, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x7E, 0x03,
  0xE0, 0xFC, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xF0, 0x07,
  0xC7, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x9F, 0x80, 0x0F,
  0xBF, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x3F,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7C,
  0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C,
  0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0xF1, 0xFC, 0x1F, 0xC0,
  0x3C, 0xFF, 0x9F, 0xF8, 0x0F, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFC, 0x3F, 0xC3, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0x07, 0xC0, 0x7C, 0x07, 0xC3, 0xF0, 0x1F, 0x03, 0xF0, 0xF8, 0x0F,
  0xC0, 0xF8, 0x3E, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xE0,
  0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xC0, 0x7C, 0x1F,
  0x01, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x07, 0xC3, 0xF0, 0x1F, 0x01, 0xF0,
  0xF8, 0x0F, 0xC0, 0xF8, 0x3E, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x0F,
  0x83, 0xE0, 0x3E, 0x03, 0xE1, 0xF8, 0x0F, 0x81, 0xF8, 0x7C, 0x07, 0xC0,
  0x7C, 0x1F, 0x01, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F,
  0x01, 0xF0, 0xF8, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xE0, 0x3E, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0x1F, 0xC0, 0x3C, 0xFF, 0x80,
  0xF7, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xE3, 0xF0, 0x7F, 0x07, 0xC1, 0xF8,
  0x1F, 0x07, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x3F,
  0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F,
  0x01, 0xF8, 0x7C, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE1,
  0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xE0,
  0x1F, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xF0, 0xFC, 0x3F, 0x07, 0xE1,
  0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0x7C, 0x01,
  0xF3, 0xE0, 0x0F, 0xBF, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x3F, 0x7C,
  0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7D, 0xF8, 0x07, 0xEF, 0xC0, 0x3E,
  0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x80, 0xF8, 0xFC, 0x0F, 0xC3, 0xE0,
  0xFC, 0x1F, 0x8F, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x3F, 0xC0,
  0x07, 0x9F, 0xF0, 0x01, 0xEF, 0xFE, 0x00, 0x7B, 0xFF, 0x80, 0x3F, 0xC3,
  0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E,
  0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0xC0,
  0x7C, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F,
  0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xC0,
  0x1F, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0xFF, 0xE0,
  0x1F, 0x7F, 0xF0, 0x07, 0xCF, 0xF8, 0x01, 0xF1, 0xFC, 0x00, 0x7C, 0x10,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFE, 0x3C, 0x07, 0xFE,
  0xF8, 0x1F, 0xFD, 0xF0, 0x3F, 0xFF, 0xE0, 0xFC, 0x3F, 0x83, 0xF0, 0x3F,
  0x07, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF0, 0xFC, 0x03, 0xE1,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x7C, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xE0,
  0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3F, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x81, 0xF8, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x07, 0xFD, 0xF0, 0x07, 0xF3, 0xE0, 0x02, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x78, 0xFC, 0x0F, 0x3F, 0x01, 0xEF, 0xE0, 0x7D, 0xFC, 0x0F,
  0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0x7E, 0x04, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x08, 0x03, 0xF0, 0xF0, 0x7E, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x07, 0xFF,
  0x3F, 0xFE, 0x7F, 0xF8, 0xFF, 0xF0, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x7E,
  0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1,
  0xF0, 0x1F, 0x83, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x3E,
  0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0xFC, 0x07,
  0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8,
  0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x7F, 0x01,
  0xFF, 0xDE, 0x03, 0xFF, 0xFC, 0x07, 0xFE, 0xF8, 0x07, 0xF1, 0xE0, 0x01,
  0x80, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80,
  0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0x83, 0xE0, 0x78, 0x3E, 0x07, 0x83, 0xE0, 0x78, 0x7C, 0x07,
  0x87, 0xC0, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0x79, 0xF0, 0x07, 0x9F, 0x00,
  0x79, 0xF0, 0x07, 0xBE, 0x00, 0x7B, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x07, 0xE0, 0x3F, 0xF0, 0x1F,
  0xC0, 0x7F, 0xE0, 0x3F, 0x81, 0xF7, 0xC0, 0x7F, 0x03, 0xEF, 0x81, 0xFE,
  0x0F, 0x9F, 0x03, 0xFC, 0x1F, 0x3E, 0x0F, 0xF8, 0x3E, 0x7C, 0x1F, 0xE0,
  0xF8, 0xF8, 0x3F, 0xC1, 0xF1, 0xF0, 0xF7, 0x83, 0xC3, 0xE1, 0xEF, 0x0F,
  0x87, 0xC7, 0xDE, 0x1F, 0x0F, 0x8F, 0x3C, 0x7C, 0x1F, 0x1E, 0x78, 0xF8,
  0x3E, 0x7C, 0xF1, 0xE0, 0x7C, 0xF1, 0xE7, 0xC0, 0xF9, 0xE3, 0xCF, 0x81,
  0xF7, 0x87, 0x9E, 0x03, 0xEF, 0x0F, 0x7C, 0x07, 0xFE, 0x1E, 0xF0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8,
  0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x0F, 0x83,
  0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x07,
  0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0xF9, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x87, 0xC0,
  0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x03,
  0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07,
  0xC0, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x1F,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x87, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x04, 0x00,
  0x04, 0xFF, 0x00, 0x17, 0xFF, 0x01, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFC, 0x01, 0xFF, 0x20, 0x01, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 15, 41, 13, 0, -40 },
  { 78, 17, 14, 20, 5, -40 },
  { 108, 26, 40, 25, 0, -40 },
  { 238, 24, 46, 22, 0, -43 },
  { 376, 31, 42, 36, 3, -41 },
  { 539, 25, 42, 25, 0, -41 },
  { 671, 8, 14, 11, 6, -40 },
  { 685, 17, 49, 15, 1, -40 },
  { 790, 17, 49, 15, -4, -40 },
  { 895, 18, 20, 21, 5, -43 },
  { 940, 22, 26, 25, 2, -33 },
  { 1012, 11, 14, 12, -3, -7 },
  { 1032, 13, 5, 15, 1, -18 },
  { 1041, 7, 8, 12, 0, -7 },
  { 1048, 27, 40, 19, -3, -40 },
  { 1183, 22, 42, 22, 1, -41 },
  { 1299, 15, 40, 23, 6, -40 },
  { 1374, 25, 41, 22, -2, -41 },
  { 1503, 24, 42, 22, -1, -41 },
  { 1629, 24, 40, 23, -1, -40 },
  { 1749, 23, 41, 22, 0, -40 },
  { 1867, 23, 42, 22, 1, -41 },
  { 1988, 23, 40, 22, 2, -40 },
  { 2103, 23, 42, 22, 0, -41 },
  { 2224, 22, 42, 22, 0, -41 },
  { 2340, 12, 31, 12, 0, -30 },
  { 2387, 15, 37, 12, -3, -30 },
  { 2457, 22, 26, 25, 2, -33 },
  { 2529, 22, 16, 25, 2, -28 },
  { 2573, 22, 26, 25, 2, -33 },
  { 2645, 18, 42, 17, 1, -41 },
  { 2740, 32, 45, 34, 1, -40 },
  { 2920, 24, 40, 24, -4, -40 },
  { 3040, 25, 40, 25, 0, -40 },
  { 3165, 24, 42, 22, 2, -41 },
  { 3291, 26, 40, 27, 0, -40 },
  { 3421, 24, 40, 21, 0, -40 },
  { 3541, 24, 40, 20, 0, -40 },
  { 3661, 27, 42, 28, 2, -41 },
  { 3803, 29, 40, 28, 0, -40 },
  { 3948, 23, 40, 16, -3, -40 },
  { 4063, 22, 51, 12, -8, -40 },
  { 4204, 28, 40, 24, 0, -40 },
  { 4344, 16, 40, 20, 0, -40 },
  { 4424, 38, 40, 37, 0, -40 },
  { 4614, 31, 40, 30, 0, -40 },
  { 4769, 26, 42, 29, 2, -41 },
  { 4906, 25, 40, 24, 0, -40 },
  { 5031, 26, 51, 29, 2, -41 },
  { 5197, 25, 40, 24, 0, -40 },
  { 5322, 25, 42, 22, -1, -41 },
  { 5454, 20, 40, 20, 4, -40 },
  { 5554, 27, 41, 27, 2, -40 },
  { 5693, 23, 40, 24, 5, -40 },
  { 5808, 38, 40, 37, 4, -40 },
  { 5998, 29, 40, 22, -3, -40 },
  { 6143, 22, 40, 21, 4, -40 },
  { 6253, 25, 40, 20, -2, -40 },
  { 6378, 22, 49, 16, -2, -40 },
  { 6513, 9, 40, 20, 6, -40 },
  { 6558, 22, 49, 16, -4, -40 },
  { 6693, 23, 22, 23, 0, -40 },
  { 6757, 18, 3, 17, -5, 5 },
  { 6764, 9, 9, 15, 8, -43 },
  { 6775, 23, 32, 24, 1, -31 },
  { 6867, 23, 44, 24, 0, -43 },
  { 6994, 19, 32, 19, 1, -31 },
  { 7070, 26, 44, 24, 1, -43 },
  { 7213, 20, 32, 22, 1, -31 },
  { 7293, 27, 56, 14, -7, -43 },
  { 7482, 25, 44, 24, -1, -31 },
  { 7620, 22, 43, 24, 0, -43 },
  { 7739, 14, 42, 11, 0, -42 },
  { 7813, 21, 55, 11, -7, -42 },
  { 7958, 24, 43, 21, 0, -43 },
  { 8087, 14, 43, 11, 0, -43 },
  { 8163, 34, 31, 35, 0, -31 },
  { 8295, 22, 31, 24, 0, -31 },
  { 8381, 21, 32, 23, 1, -31 },
  { 8465, 26, 44, 24, -3, -31 },
  { 8608, 23, 44, 24, 1, -31 },
  { 8735, 19, 31, 16, 0, -31 },
  { 8809, 20, 32, 18, -1, -31 },
  { 8889, 15, 38, 14, 1, -37 },
  { 8961, 23, 31, 24, 1, -30 },
  { 9051, 20, 30, 20, 3, -30 },
  { 9126, 31, 30, 32, 3, -30 },
  { 9243, 26, 30, 20, -3, -30 },
  { 9341, 28, 44, 20, -5, -30 },
  { 9495, 20, 30, 17, -2, -30 },
  { 9570, 21, 49, 19, 1, -40 },
  { 9699, 4, 56, 21, 8, -43 },
  { 9727, 20, 49, 18, -3, -40 },
  { 9850, 22, 8, 25, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC56PT7B_H_
