#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC12PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0xA4, 0x84, 0xC0, 0x5E, 0xAA, 0x18, 0xA2, 0x9F, 0x51, 0x4F,
  0xA8, 0xA0, 0x11, 0xD4, 0xC2, 0x18, 0xDE, 0x42, 0x00, 0x46, 0xAA, 0xAC,
  0xDE, 0xD5, 0x55, 0x98, 0x11, 0x5C, 0x62, 0x36, 0x72, 0xF8, 0x5A, 0x12,
  0x24, 0x4C, 0x88, 0x88, 0x40, 0x21, 0x11, 0x11, 0x22, 0x24, 0x80, 0x2F,
  0x6A, 0x21, 0x3E, 0x42, 0x10, 0x6A, 0x00, 0xE0, 0xB0, 0x04, 0x20, 0x84,
  0x10, 0x82, 0x10, 0xC0, 0x11, 0x52, 0x95, 0xCA, 0x52, 0x60, 0x2E, 0x96,
  0x92, 0x40, 0x32, 0xC2, 0x31, 0x11, 0x10, 0xF0, 0x32, 0x42, 0x26, 0x08,
  0x42, 0xE0, 0x08, 0xCC, 0x65, 0x4B, 0xC4, 0x20, 0x39, 0x10, 0x87, 0x08,
  0x42, 0xE0, 0x19, 0x10, 0x87, 0x6A, 0x52, 0x60, 0x78, 0x42, 0x21, 0x10,
  0x88, 0xC0, 0x33, 0x52, 0xA2, 0x2A, 0x52, 0xE0, 0x33, 0xD2, 0x95, 0xB8,
  0x46, 0xE0, 0x4C, 0x01, 0x20, 0x23, 0x00, 0x02, 0x44, 0x80, 0x09, 0xB0,
  0xC1, 0x80, 0xF8, 0x01, 0xF0, 0x83, 0x06, 0x6C, 0x00, 0x25, 0x13, 0x24,
  0x40, 0xC0, 0x0C, 0x65, 0x0A, 0xF6, 0xB5, 0x6B, 0x5C, 0x80, 0xF0, 0x08,
  0xC6, 0x32, 0x9D, 0x29, 0xC8, 0x31, 0x52, 0x97, 0x2D, 0x32, 0xF0, 0x18,
  0x96, 0x10, 0x43, 0x0C, 0x10, 0x70, 0x30, 0xA6, 0xD3, 0x49, 0x24, 0xA4,
  0xE0, 0x39, 0x18, 0x87, 0x21, 0x10, 0xE0, 0x39, 0x18, 0x87, 0x21, 0x10,
  0x80, 0x1C, 0xD6, 0x10, 0x5F, 0x2C, 0x92, 0x78, 0x24, 0x96, 0x53, 0x79,
  0x24, 0xA2, 0x98, 0x38, 0x84, 0x62, 0x10, 0x84, 0xF0, 0x08, 0x46, 0x21,
  0x08, 0x44, 0x21, 0x38, 0x24, 0xA5, 0x94, 0x61, 0xC5, 0x24, 0x90, 0x25,
  0xA4, 0x94, 0xE0, 0x21, 0x23, 0x63, 0x67, 0x66, 0x5A, 0x5A, 0x92, 0x96,
  0x22, 0x49, 0x92, 0xA5, 0x4B, 0x96, 0x4C, 0x98, 0x18, 0xB6, 0x51, 0x47,
  0x3C, 0x96, 0x70, 0x31, 0xDA, 0x95, 0xB9, 0x10, 0x80, 0x18, 0xB6, 0x51,
  0x47, 0x3C, 0x96, 0x70, 0xC1, 0x00, 0x31, 0x52, 0x95, 0xB9, 0x52, 0x90,
  0x3B, 0x50, 0x82, 0x18, 0x42, 0xE0, 0xF6, 0x44, 0x44, 0x88, 0x80, 0x24,
  0x94, 0x53, 0x49, 0x2C, 0xB6, 0x70, 0x8C, 0xE5, 0x2A, 0x53, 0x18, 0xC0,
  0x89, 0x93, 0x92, 0xB2, 0xB4, 0xB4, 0xDC, 0xD8, 0x98, 0x26, 0x68, 0x60,
  0xC1, 0x06, 0x0C, 0x2C, 0xC8, 0x9C, 0xA9, 0x4C, 0x23, 0x10, 0x80, 0x78,
  0xC4, 0x62, 0x21, 0x10, 0xE0, 0x32, 0x44, 0x44, 0x48, 0x88, 0xC0, 0xA9,
  0x55, 0x40, 0x38, 0x44, 0x21, 0x08, 0x84, 0x21, 0x38, 0x11, 0x8C, 0xAC,
  0x80, 0xF0, 0x90, 0x23, 0xD3, 0x99, 0x49, 0xC0, 0x21, 0x14, 0xD4, 0xA7,
  0x7A, 0xF0, 0x17, 0x4C, 0x88, 0x60, 0x04, 0x22, 0x9E, 0x4B, 0x29, 0x24,
  0x70, 0x13, 0xD5, 0xE8, 0x41, 0xC0, 0x18, 0x8C, 0x42, 0x10, 0x88, 0x42,
  0x11, 0x00, 0x23, 0xD3, 0xB9, 0x4B, 0xC2, 0xA7, 0x00, 0x21, 0x14, 0xF4,
  0xAB, 0x52, 0x90, 0x24, 0x24, 0xB4, 0x80, 0x08, 0x40, 0x21, 0x08, 0x44,
  0x21, 0x09, 0x80, 0x21, 0x12, 0xA7, 0x31, 0x96, 0x90, 0x25, 0x24, 0x94,
  0x80, 0x16, 0xF5, 0x2A, 0x9D, 0x32, 0xE5, 0x00, 0x13, 0xD2, 0xAD, 0x4A,
  0x40, 0x33, 0xD3, 0x99, 0x49, 0x80, 0x08, 0xD2, 0x49, 0x2D, 0xA7, 0x90,
  0x43, 0x00, 0x23, 0xD3, 0x99, 0x49, 0xC2, 0x31, 0x00, 0x17, 0x44, 0xC8,
  0x80, 0x25, 0x46, 0x22, 0xE0, 0x2D, 0x24, 0xA6, 0x4A, 0x55, 0xA9, 0x78,
  0xBA, 0xEC, 0xC8, 0xB6, 0xDD, 0xB6, 0x92, 0xC0, 0x2C, 0xE1, 0x0C, 0x53,
  0x60, 0x2C, 0xA2, 0x8C, 0x30, 0x82, 0x10, 0xC0, 0x72, 0x64, 0x8E, 0x09,
  0x88, 0x42, 0x61, 0x08, 0x42, 0x18, 0xFF, 0xF0, 0x20, 0x84, 0x21, 0x0C,
  0x84, 0x23, 0x30, 0x6C, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 4, 4, 4, 1, -9 },
  { 7, 6, 9, 5, 0, -9 },
  { 14, 5, 10, 5, 0, -9 },
  { 21, 6, 9, 8, 1, -9 },
  { 28, 5, 9, 5, 0, -9 },
  { 34, 2, 4, 2, 1, -9 },
  { 35, 4, 11, 3, 0, -9 },
  { 41, 4, 11, 3, -1, -9 },
  { 47, 4, 4, 5, 1, -9 },
  { 49, 5, 6, 5, 0, -7 },
  { 53, 3, 3, 3, -1, -1 },
  { 55, 3, 1, 3, 0, -4 },
  { 56, 2, 2, 3, 0, -2 },
  { 57, 6, 9, 4, -1, -9 },
  { 64, 5, 9, 5, 0, -9 },
  { 70, 3, 9, 5, 1, -9 },
  { 74, 5, 9, 5, 0, -9 },
  { 80, 5, 9, 5, 0, -9 },
  { 86, 5, 9, 5, 0, -9 },
  { 92, 5, 9, 5, 0, -9 },
  { 98, 5, 9, 5, 0, -9 },
  { 104, 5, 9, 5, 0, -9 },
  { 110, 5, 9, 5, 0, -9 },
  { 116, 5, 9, 5, 0, -9 },
  { 122, 3, 7, 3, 0, -7 },
  { 125, 4, 9, 3, -1, -7 },
  { 130, 5, 5, 5, 0, -7 },
  { 134, 5, 4, 5, 0, -6 },
  { 137, 5, 5, 5, 0, -7 },
  { 141, 4, 9, 4, 0, -9 },
  { 146, 7, 10, 7, 0, -9 },
  { 155, 5, 9, 5, -1, -9 },
  { 161, 5, 9, 5, 0, -9 },
  { 167, 6, 9, 5, 0, -9 },
  { 174, 6, 9, 6, 0, -9 },
  { 181, 5, 9, 5, 0, -9 },
  { 187, 5, 9, 4, 0, -9 },
  { 193, 6, 9, 6, 0, -9 },
  { 200, 6, 9, 6, 0, -9 },
  { 207, 5, 9, 3, -1, -9 },
  { 213, 5, 11, 3, -2, -9 },
  { 220, 6, 9, 5, 0, -9 },
  { 227, 3, 9, 4, 0, -9 },
  { 231, 8, 9, 8, 0, -9 },
  { 240, 7, 9, 6, 0, -9 },
  { 248, 6, 9, 6, 0, -9 },
  { 255, 5, 9, 5, 0, -9 },
  { 261, 6, 11, 6, 0, -9 },
  { 270, 5, 9, 5, 0, -9 },
  { 276, 5, 9, 5, 0, -9 },
  { 282, 4, 9, 4, 1, -9 },
  { 287, 6, 9, 6, 0, -9 },
  { 294, 5, 9, 5, 1, -9 },
  { 300, 8, 9, 8, 1, -9 },
  { 309, 7, 9, 5, -1, -9 },
  { 317, 5, 9, 5, 1, -9 },
  { 323, 5, 9, 4, 0, -9 },
  { 329, 4, 11, 3, 0, -9 },
  { 335, 2, 9, 4, 1, -9 },
  { 338, 5, 11, 3, -1, -9 },
  { 345, 5, 5, 5, 0, -9 },
  { 349, 4, 1, 4, -1, 1 },
  { 350, 2, 2, 3, 2, -9 },
  { 351, 5, 7, 5, 0, -7 },
  { 356, 5, 9, 5, 0, -9 },
  { 362, 4, 7, 4, 0, -7 },
  { 366, 6, 9, 5, 0, -9 },
  { 373, 5, 7, 5, 0, -7 },
  { 378, 5, 12, 3, -1, -9 },
  { 386, 5, 10, 5, 0, -7 },
  { 393, 5, 9, 5, 0, -9 },
  { 399, 3, 9, 2, 0, -9 },
  { 403, 5, 12, 2, -2, -9 },
  { 411, 5, 9, 5, 0, -9 },
  { 417, 3, 9, 2, 0, -9 },
  { 421, 7, 7, 8, 0, -7 },
  { 428, 5, 7, 5, 0, -7 },
  { 433, 5, 7, 5, 0, -7 },
  { 438, 6, 10, 5, -1, -7 },
  { 446, 5, 10, 5, 0, -7 },
  { 453, 4, 7, 3, 0, -7 },
  { 457, 4, 7, 4, 0, -7 },
  { 461, 3, 8, 3, 0, -8 },
  { 464, 5, 6, 5, 0, -6 },
  { 468, 4, 6, 4, 1, -6 },
  { 471, 6, 6, 7, 1, -6 },
  { 476, 6, 6, 4, -1, -6 },
  { 481, 6, 9, 4, -1, -6 },
  { 488, 4, 6, 4, 0, -6 },
  { 491, 5, 11, 4, 0, -9 },
  { 498, 1, 12, 4, 2, -9 },
  { 500, 5, 11, 4, -1, -9 },
  { 507, 5, 2, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC12PT7B_H_
