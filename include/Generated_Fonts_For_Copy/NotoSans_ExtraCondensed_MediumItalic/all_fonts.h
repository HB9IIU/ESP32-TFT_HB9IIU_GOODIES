#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_ExtraCondensed_MediumItalic
// Headers: 67

#include "NotoSans_ExtraCondensed_MediumItalic6pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic7pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic8pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic9pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic10pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic11pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic12pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic13pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic14pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic15pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic16pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic17pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic18pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic19pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic20pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic21pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic22pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic23pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic24pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic25pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic26pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic27pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic28pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic29pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic30pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic31pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic32pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic33pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic34pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic35pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic36pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic37pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic38pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic39pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic40pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic41pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic42pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic43pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic44pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic45pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic46pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic47pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic48pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic49pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic50pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic51pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic52pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic53pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic54pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic55pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic56pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic57pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic58pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic59pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic60pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic61pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic62pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic63pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic64pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic65pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic66pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic67pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic68pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic69pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic70pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic71pt7b.h"
#include "NotoSans_ExtraCondensed_MediumItalic72pt7b.h"
