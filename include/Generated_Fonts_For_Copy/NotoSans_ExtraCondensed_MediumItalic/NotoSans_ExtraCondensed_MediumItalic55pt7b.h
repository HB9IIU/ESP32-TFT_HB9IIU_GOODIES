#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC55PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x07, 0x80, 0x04, 0x00, 0x3F,
  0x1F, 0x9F, 0x8F, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF0,
  0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07,
  0x87, 0x87, 0x87, 0x83, 0xC0, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xC1, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x87,
  0x80, 0x01, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x0E,
  0x0F, 0x00, 0x07, 0x83, 0xC4, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x03, 0xC3, 0xC0, 0x01, 0xE0, 0xF0,
  0x00, 0x78, 0x38, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1,
  0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x01, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x3C, 0x3C, 0x00,
  0x0E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xE0,
  0xF0, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x01,
  0xFF, 0xFC, 0x07, 0xEE, 0x78, 0x1F, 0x98, 0x20, 0x3E, 0x30, 0x00, 0x7C,
  0x60, 0x00, 0xF0, 0xC0, 0x01, 0xE3, 0x80, 0x03, 0xE6, 0x00, 0x07, 0xCC,
  0x00, 0x0F, 0xD8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x6F, 0xC0, 0x00, 0xDF, 0x80, 0x01, 0x9F, 0x00, 0x07, 0x3E, 0x00,
  0x0C, 0x3C, 0x00, 0x18, 0xF8, 0x00, 0x31, 0xF0, 0x80, 0x63, 0xE0, 0xC1,
  0xCF, 0x83, 0xE3, 0x3F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x07, 0x80, 0x7F, 0x80, 0x3C, 0x03, 0xFF, 0x00,
  0xF0, 0x1E, 0x3C, 0x07, 0x80, 0x78, 0xF0, 0x1E, 0x03, 0xC3, 0xC0, 0xF0,
  0x0F, 0x0F, 0x03, 0xC0, 0x78, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x78, 0x07,
  0x83, 0xC3, 0xC0, 0x1C, 0x0E, 0x0F, 0x00, 0xF0, 0x78, 0x78, 0x03, 0xC1,
  0xE1, 0xE0, 0x0F, 0x07, 0x8F, 0x00, 0x3C, 0x1E, 0x7C, 0x00, 0xF0, 0xF1,
  0xE1, 0xF3, 0xC3, 0xCF, 0x0F, 0xEF, 0x0F, 0x3C, 0x7F, 0xFC, 0x79, 0xE3,
  0xFF, 0xF3, 0xE7, 0x9E, 0x3F, 0xFF, 0x3C, 0x78, 0xFF, 0xF8, 0xF3, 0xC3,
  0xDF, 0xC7, 0x8F, 0x0F, 0x1C, 0x1E, 0x38, 0x3C, 0x00, 0xF1, 0xE0, 0xF0,
  0x03, 0xC7, 0x83, 0xC0, 0x1E, 0x1E, 0x0F, 0x00, 0x78, 0x78, 0x3C, 0x03,
  0xC3, 0xC1, 0xE0, 0x0F, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x1E, 0x03, 0xE0,
  0xF0, 0x70, 0x0F, 0x03, 0xC3, 0xC0, 0x7C, 0x0F, 0x0F, 0x01, 0xE0, 0x3C,
  0x78, 0x0F, 0x00, 0xF3, 0xE0, 0x3C, 0x01, 0xFF, 0x01, 0xE0, 0x07, 0xF8,
  0x07, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x01,
  0xF3, 0xE0, 0x01, 0xF3, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFE, 0x1F, 0x0F, 0xBE, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x3F, 0x3E, 0x3E,
  0x1F, 0x3E, 0x7C, 0x1F, 0x7C, 0x7C, 0x1F, 0xFC, 0xF8, 0x0F, 0xF8, 0xF8,
  0x0F, 0xF8, 0xF8, 0x0F, 0xF0, 0xF8, 0x07, 0xF0, 0xF8, 0x07, 0xE0, 0xF8,
  0x0F, 0xE0, 0xF8, 0x1F, 0xF0, 0xFC, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFD, 0xF8, 0x3F, 0xF1, 0xF8, 0x1F, 0xE0, 0xFC, 0x02, 0x00, 0x00, 0x3E,
  0x7D, 0xFB, 0xE7, 0xCF, 0x9E, 0x3C, 0xF9, 0xF3, 0xC7, 0x8F, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x40, 0xF0, 0x1C, 0x38, 0x07, 0xCE, 0x0B, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xDE, 0x03, 0xE7,
  0xC1, 0xF8, 0xF0, 0x3C, 0x3E, 0x06, 0x0F, 0x80, 0x81, 0x80, 0x00, 0x40,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0xF8,
  0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0,
  0x3C, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x00,
  0x1C, 0x7D, 0xFB, 0xFF, 0xFF, 0x9F, 0x08, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0xF8, 0xFC, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF1, 0xF8, 0x0F,
  0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE7, 0xE0, 0x1F, 0x3E, 0x01, 0xF9, 0xF0,
  0x0F, 0x8F, 0x80, 0x7C, 0xFC, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9,
  0xF0, 0x0F, 0xCF, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x3E, 0x01,
  0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F,
  0x01, 0xF0, 0xF8, 0x1F, 0x07, 0xC1, 0xF8, 0x3F, 0x0F, 0x80, 0xF9, 0xFC,
  0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0xC3,
  0xFF, 0x0F, 0xFE, 0x3F, 0x7C, 0xFC, 0xF9, 0xF3, 0xE1, 0xC7, 0xC3, 0x0F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xF8, 0x3F, 0x00, 0x60,
  0x3F, 0x00, 0x40, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xE0, 0x7E, 0x00, 0x80,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x80, 0x0F,
  0xC0, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x05, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0x7C, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1C, 0xF8, 0x00, 0x3C,
  0xF8, 0x00, 0x78, 0xF8, 0x00, 0x79, 0xF0, 0x00, 0xF1, 0xF0, 0x01, 0xE1,
  0xF0, 0x01, 0xE1, 0xF0, 0x03, 0xC1, 0xF0, 0x07, 0x83, 0xE0, 0x07, 0x83,
  0xE0, 0x0F, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x07,
  0xC0, 0x3C, 0x07, 0xC0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x30, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0x00, 0x3F, 0x03, 0x81, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x8F, 0x80,
  0x1F, 0x7F, 0x80, 0x7D, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0x7F, 0x07,
  0xF8, 0x7E, 0x0F, 0xE0, 0x7C, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x0F,
  0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x01, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xDF, 0xC0, 0x7E, 0x0F, 0xC0, 0xF8,
  0x1F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0xF8, 0x7E,
  0x01, 0xF1, 0xF8, 0x03, 0xF7, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xF3, 0xE0, 0x0F,
  0xC7, 0xE0, 0x3F, 0x07, 0xC0, 0xFC, 0x0F, 0xC1, 0xF0, 0x0F, 0x87, 0xE0,
  0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01,
  0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x07, 0xE0, 0x7E,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0xC1, 0xF0,
  0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F,
  0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F, 0x1F,
  0x00, 0xFC, 0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0x87,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0x7C, 0x07, 0xF9, 0xF0,
  0x03, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x20, 0x7F, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xE0, 0x3E, 0x07,
  0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7C, 0x07, 0xE0, 0xFE,
  0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x20, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1E, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00,
  0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x7F, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0x83,
  0xF0, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0xFE, 0x0F, 0x07, 0x81, 0xFF, 0x8F,
  0x0F, 0x03, 0xFF, 0x0F, 0x0F, 0x07, 0xCF, 0x0F, 0x1E, 0x0F, 0x0F, 0x0F,
  0x1E, 0x1E, 0x0E, 0x0F, 0x1C, 0x1E, 0x1E, 0x0E, 0x3C, 0x3C, 0x1E, 0x0E,
  0x3C, 0x3C, 0x1E, 0x0E, 0x38, 0x3C, 0x1C, 0x1E, 0x78, 0x78, 0x3C, 0x1E,
  0x78, 0x78, 0x3C, 0x1C, 0x78, 0x78, 0x3C, 0x1C, 0x78, 0x78, 0x7C, 0x3C,
  0x70, 0x70, 0x78, 0x38, 0x70, 0xF0, 0x78, 0x38, 0xF0, 0xF0, 0xF8, 0x78,
  0xF0, 0xF0, 0xF8, 0x70, 0xF0, 0x79, 0xF8, 0xE0, 0xF0, 0x7F, 0xBF, 0xE0,
  0xF0, 0x7F, 0xBF, 0xC0, 0xF0, 0x3F, 0x1F, 0x80, 0xF0, 0x1C, 0x06, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x10, 0x00,
  0x1F, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xDF, 0x00, 0x07, 0xDF, 0x00,
  0x07, 0xDF, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0x07, 0xF0, 0x0F, 0x80, 0xFC,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF0, 0x0F,
  0xC0, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x01,
  0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x81, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7C,
  0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x0F,
  0x80, 0x7E, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0x81,
  0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xF0,
  0x3E, 0x03, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFC,
  0x0C, 0x03, 0xF8, 0x04, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x01, 0x00, 0x7F, 0x07, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01,
  0xF9, 0xFF, 0x00, 0x7C, 0x0F, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80,
  0x3F, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x1F,
  0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8,
  0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xC1, 0xF8, 0x01,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0x81, 0xF0,
  0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x03,
  0xE0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0x07, 0xF8,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFC, 0x0F, 0x00,
  0xFE, 0x00, 0x60, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xFF, 0x87, 0xC0,
  0x3F, 0xF1, 0xF8, 0x0F, 0xFC, 0x3F, 0x01, 0xFF, 0x87, 0xE0, 0x01, 0xF0,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x07,
  0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0xC1, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x03, 0xF0, 0x03,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x03, 0xF0, 0x03,
  0xE0, 0x1F, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x7C, 0x03, 0xE0, 0x07,
  0xE0, 0x1F, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x7E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xE0, 0x07,
  0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80,
  0x7E, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x83, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x0F,
  0xC0, 0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x1F,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x7E, 0x7C, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x7E,
  0x00, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xF7,
  0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xDF,
  0x00, 0x7B, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0x3E,
  0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x07, 0xDF, 0x01, 0xE7, 0xC0, 0x3E, 0x7C,
  0x0F, 0x9F, 0x00, 0xF8, 0xF0, 0x3C, 0x7C, 0x03, 0xE3, 0xC1, 0xF3, 0xF0,
  0x0F, 0x8F, 0x07, 0xCF, 0x80, 0x3E, 0x3C, 0x3E, 0x3E, 0x01, 0xF0, 0xF0,
  0xF8, 0xF8, 0x07, 0xC3, 0xC3, 0xC3, 0xE0, 0x1F, 0x0F, 0x1F, 0x1F, 0x00,
  0x7C, 0x3C, 0x78, 0x7C, 0x01, 0xE0, 0xF3, 0xE1, 0xF0, 0x0F, 0x83, 0xCF,
  0x07, 0xC0, 0x3E, 0x0F, 0x7C, 0x1F, 0x00, 0xF8, 0x3D, 0xE0, 0xF8, 0x03,
  0xE0, 0xFF, 0x83, 0xE0, 0x0F, 0x03, 0xFE, 0x0F, 0x80, 0x7C, 0x0F, 0xF0,
  0x3E, 0x01, 0xF0, 0x3F, 0xC0, 0xF8, 0x07, 0xC0, 0xFE, 0x07, 0xC0, 0x1F,
  0x03, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x03,
  0xF8, 0x01, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x7F, 0x80, 0x1F, 0x01, 0xFE,
  0x00, 0xF8, 0x07, 0xF8, 0x03, 0xE0, 0x1F, 0xE0, 0x0F, 0x80, 0x7F, 0xC0,
  0x3E, 0x03, 0xFF, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x3E, 0xF0, 0x1F,
  0x00, 0xFB, 0xC0, 0x7C, 0x03, 0xCF, 0x01, 0xF0, 0x1F, 0x3E, 0x07, 0xC0,
  0x7C, 0xF8, 0x3E, 0x01, 0xF3, 0xE0, 0xF8, 0x07, 0xCF, 0x83, 0xE0, 0x3E,
  0x1E, 0x0F, 0x80, 0xF8, 0x78, 0x7C, 0x03, 0xE1, 0xF1, 0xF0, 0x0F, 0x87,
  0xC7, 0xC0, 0x3E, 0x1F, 0x1F, 0x01, 0xF0, 0x7C, 0x7C, 0x07, 0xC0, 0xF3,
  0xE0, 0x1F, 0x03, 0xCF, 0x80, 0x7C, 0x0F, 0xBE, 0x01, 0xF0, 0x3E, 0xF8,
  0x0F, 0x80, 0xFB, 0xE0, 0x3E, 0x03, 0xEF, 0x00, 0xF8, 0x07, 0xFC, 0x03,
  0xE0, 0x1F, 0xF0, 0x0F, 0x00, 0x7F, 0xC0, 0x7C, 0x01, 0xFE, 0x01, 0xF0,
  0x07, 0xF8, 0x07, 0xC0, 0x1F, 0xE0, 0x1F, 0x00, 0x3F, 0x80, 0xF8, 0x00,
  0xFE, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xE1, 0xF8, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x07,
  0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1,
  0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0x3E, 0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0x80, 0x03,
  0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x9F, 0x00,
  0x0F, 0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF8,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x0F,
  0xE3, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF9, 0xFF, 0x01, 0xF0,
  0x3F, 0x01, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x03, 0xE0,
  0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xE0,
  0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC1, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xE1, 0xF8, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3,
  0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xBF, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00,
  0x1F, 0x3F, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xC7, 0xC0,
  0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x7E,
  0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xE3, 0xF8, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x01, 0xF0, 0xFE, 0x01, 0xF0, 0x3F, 0x01, 0xF0, 0x3F, 0x01,
  0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03,
  0xE0, 0x3F, 0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x3E, 0x07,
  0xC0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x0F, 0x8F, 0xF8, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x3F,
  0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x7C,
  0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x01, 0xFC, 0x1E, 0x03, 0xF8, 0x04, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x80, 0x07, 0xE0, 0xE0, 0x1F, 0xC0, 0xFE, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x81, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7E,
  0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0,
  0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C,
  0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00,
  0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8,
  0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80,
  0xF8, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x02,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0,
  0x07, 0xCF, 0x80, 0x1F, 0x9F, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7C, 0x01,
  0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0x7E,
  0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80,
  0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F,
  0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF9,
  0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFB,
  0xE0, 0x07, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xF0,
  0x07, 0xE7, 0xC0, 0x1F, 0x80, 0x3E, 0x3E, 0x01, 0xFC, 0x01, 0xF1, 0xF0,
  0x0F, 0xE0, 0x1F, 0x0F, 0x80, 0x7F, 0x00, 0xF8, 0x7C, 0x07, 0xF8, 0x0F,
  0xC3, 0xE0, 0x3F, 0xC0, 0x7C, 0x1F, 0x03, 0xFE, 0x03, 0xE0, 0xF0, 0x1E,
  0xF0, 0x3F, 0x0F, 0x80, 0xF7, 0x81, 0xF0, 0x7C, 0x0F, 0xBC, 0x0F, 0x83,
  0xE0, 0x79, 0xE0, 0xF8, 0x1F, 0x03, 0xDF, 0x07, 0xC0, 0xF8, 0x3E, 0xF8,
  0x7E, 0x07, 0xC1, 0xE7, 0xC3, 0xE0, 0x3E, 0x1F, 0x3E, 0x1F, 0x01, 0xF0,
  0xF1, 0xF1, 0xF0, 0x0F, 0x87, 0x8F, 0x8F, 0x80, 0x7C, 0x7C, 0x7C, 0xFC,
  0x03, 0xE3, 0xC3, 0xC7, 0xC0, 0x1F, 0x3E, 0x1E, 0x3E, 0x00, 0xF9, 0xE0,
  0xF3, 0xE0, 0x07, 0xCF, 0x07, 0x9F, 0x00, 0x3E, 0xF8, 0x3C, 0xF8, 0x01,
  0xF7, 0x81, 0xEF, 0x80, 0x0F, 0xFC, 0x0F, 0x7C, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x3E,
  0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x0F, 0xBE, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x03, 0xE0,
  0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0xFD, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0xFC,
  0x7C, 0x03, 0xE1, 0xF8, 0x1F, 0x07, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E,
  0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E,
  0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xBE, 0x00, 0x1E, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x10, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1E, 0xF8, 0x00, 0xFB, 0xE0, 0x03,
  0xC7, 0x80, 0x1F, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x03,
  0xC0, 0x78, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x00, 0x78, 0x7C, 0x01, 0xE3,
  0xE0, 0x07, 0xCF, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0xFC, 0xFC, 0x7C, 0x3E, 0x3E, 0x1E,
  0x1F, 0x0F, 0x07, 0x00, 0x7E, 0x1E, 0x01, 0xFE, 0x7C, 0x0F, 0xFE, 0xF0,
  0x1F, 0xFD, 0xE0, 0x7F, 0x3F, 0xC1, 0xF8, 0x3F, 0x83, 0xE0, 0x7F, 0x0F,
  0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF0,
  0x0F, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xE0, 0x1F,
  0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0,
  0xFC, 0x1F, 0xC0, 0xF8, 0x7F, 0x81, 0xFF, 0xDE, 0x03, 0xFF, 0x3C, 0x03,
  0xFE, 0x78, 0x03, 0xF0, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x7D,
  0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xEF, 0xFE, 0x07, 0xF8, 0xFC, 0x0F, 0xE0,
  0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF0, 0x0F,
  0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0xF8,
  0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF8,
  0x0F, 0xC3, 0xF0, 0x1F, 0x07, 0xE0, 0x7E, 0x0F, 0xE1, 0xF8, 0x1F, 0xFF,
  0xE0, 0x7D, 0xFF, 0xC0, 0xF3, 0xFF, 0x01, 0xE3, 0xF8, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F,
  0x18, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x04,
  0x0F, 0xC1, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xE0,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x07, 0xE3, 0xE0, 0x07, 0xF9, 0xF0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xF3, 0xFC, 0x07, 0xE0, 0xFE, 0x03,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x3F, 0x00, 0xF8,
  0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1E, 0x03, 0xE0, 0x1F,
  0x03, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0x7C, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xE1,
  0xFE, 0x01, 0xFF, 0xDE, 0x00, 0xFF, 0xEF, 0x00, 0x3F, 0xE7, 0x80, 0x0F,
  0xC3, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xE3, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF1,
  0xF0, 0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x1E, 0x3E, 0x03, 0xE3, 0xE0, 0x7C,
  0x7C, 0x1F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xC0,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x20, 0x7F,
  0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xC8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x02, 0x3F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x1F, 0xE7,
  0xC0, 0x1F, 0xFB, 0xC0, 0x1F, 0xFD, 0xE0, 0x1F, 0xCF, 0xF0, 0x1F, 0x83,
  0xF8, 0x0F, 0x81, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0,
  0x1F, 0x03, 0xF0, 0x1F, 0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0xFC,
  0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x0F,
  0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x81,
  0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xF0,
  0x1F, 0x87, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xBE,
  0x00, 0x3F, 0x9F, 0x00, 0x04, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x04, 0x01, 0xF8, 0x03, 0xC3, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x0F, 0xBF, 0xE0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFD, 0xFC, 0x1F, 0xC3, 0xF0, 0x7E,
  0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3F, 0x03, 0xF0, 0xF8, 0x0F,
  0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x07,
  0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80,
  0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xF8,
  0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8,
  0x0F, 0x83, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xF0,
  0x1F, 0x80, 0x78, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x09, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x3F, 0x01, 0xE0,
  0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x1F, 0x80, 0x3E, 0x3E,
  0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x00,
  0x0F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1,
  0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F,
  0x81, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xC7, 0xE0, 0x7E, 0x01, 0xE7,
  0xFC, 0xFF, 0x80, 0xF7, 0xFE, 0xFF, 0xE0, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F,
  0x9F, 0xF9, 0xF8, 0x3F, 0x87, 0xF0, 0x7C, 0x1F, 0x83, 0xF8, 0x3E, 0x0F,
  0x81, 0xF8, 0x1F, 0x0F, 0xC0, 0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x07, 0xC3,
  0xE0, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xF0,
  0xF8, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0x3E,
  0x1F, 0x01, 0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x0F,
  0x87, 0xC0, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x07, 0xC1, 0xF0, 0x1F, 0x03,
  0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC0,
  0x7C, 0x3E, 0x03, 0xE0, 0x7C, 0x1F, 0x01, 0xE0, 0x3E, 0x1F, 0x01, 0xF0,
  0x1F, 0x0F, 0x80, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x0F, 0xC0, 0x03, 0xC3,
  0xE0, 0x0F, 0x3F, 0xE0, 0x3D, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFD, 0xFC,
  0x1F, 0xC3, 0xF0, 0x7E, 0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3F,
  0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x03,
  0xE1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0xFC, 0x07, 0xC3,
  0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xE0,
  0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0x83, 0xE0, 0x3E, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7E, 0x3F, 0x07, 0xE0,
  0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x3F, 0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xCF,
  0x80, 0x3E, 0x7C, 0x03, 0xF7, 0xE0, 0x1F, 0xBE, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0xBE, 0x00, 0xF9, 0xF0,
  0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x81, 0xF8,
  0x7C, 0x1F, 0x83, 0xF1, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00, 0x78, 0x7E, 0x00, 0x1E,
  0x7F, 0xC0, 0x07, 0xBF, 0xF0, 0x01, 0xEF, 0xFE, 0x00, 0xFF, 0x1F, 0x80,
  0x3F, 0x83, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0xFC,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x7E, 0x00, 0xF7, 0xFF, 0x00, 0x7D,
  0xFF, 0xC0, 0x1F, 0x3F, 0xE0, 0x07, 0xCF, 0xE0, 0x01, 0xF0, 0x40, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x1E, 0x01, 0xFE, 0x7C, 0x07, 0xFE, 0xF0,
  0x1F, 0xFD, 0xE0, 0x7F, 0x3F, 0xC1, 0xF8, 0x3F, 0x83, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0,
  0x0F, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x7C, 0x01, 0xE0, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F,
  0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x7E, 0x07, 0xE0,
  0xFC, 0x1F, 0xC1, 0xF8, 0x7F, 0x81, 0xFF, 0xDE, 0x03, 0xFF, 0xFC, 0x03,
  0xFE, 0xF8, 0x03, 0xF1, 0xF0, 0x01, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC7, 0xE0, 0x79, 0xF8,
  0x0F, 0x7F, 0x03, 0xEF, 0xE0, 0x7F, 0xF8, 0x0F, 0xF1, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFE,
  0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xE1, 0xC0, 0xFC, 0x04, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x80, 0x3F, 0x0E, 0x07, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xFF, 0x8F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x00, 0x40, 0x00, 0x07,
  0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80,
  0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x00, 0xF8,
  0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8,
  0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x0F,
  0x87, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x3F, 0x0F,
  0xC0, 0xFC, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFB, 0xE0, 0x7F, 0xCF, 0x00, 0xFE, 0x3C, 0x00, 0x40, 0x00,
  0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80,
  0xFD, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC0, 0xF0, 0xF8, 0x1E, 0x3E,
  0x03, 0xC7, 0xC0, 0x79, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0x80, 0x3D, 0xF0,
  0x07, 0xBC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x1F, 0x80, 0xFB, 0xE0, 0x3F, 0x01,
  0xF7, 0xC0, 0x7E, 0x07, 0xCF, 0x81, 0xFC, 0x0F, 0x9F, 0x03, 0xF8, 0x1F,
  0x3E, 0x0F, 0xF0, 0x7C, 0x7C, 0x1F, 0xE0, 0xF8, 0xF8, 0x3F, 0xC1, 0xE1,
  0xF0, 0xF7, 0x87, 0xC3, 0xE1, 0xEF, 0x0F, 0x87, 0xC7, 0xDE, 0x3E, 0x0F,
  0x8F, 0x3C, 0x7C, 0x1F, 0x1E, 0x78, 0xF0, 0x3E, 0x78, 0xF3, 0xE0, 0x7C,
  0xF1, 0xE7, 0xC0, 0xFB, 0xE3, 0xCF, 0x01, 0xF7, 0x87, 0xBE, 0x03, 0xEF,
  0x0F, 0x78, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x7B, 0xE0, 0x1E, 0xF0,
  0xF7, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07,
  0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x3F,
  0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x0F,
  0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x00, 0xF1, 0xF0, 0x00,
  0x7D, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x8F,
  0x80, 0x0F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC0,
  0xFC, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x78, 0x03, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0x78, 0x03, 0xE0, 0x07, 0x80, 0x7C, 0x00, 0x78,
  0x07, 0xC0, 0x07, 0x80, 0xF8, 0x00, 0x78, 0x0F, 0x80, 0x07, 0x81, 0xF0,
  0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0xF8,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x79, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x4F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x0B, 0xFF, 0x00, 0x7F, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x1F, 0xFA, 0x00, 0x3F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 14, 40, 13, 0, -39 },
  { 71, 17, 14, 20, 5, -39 },
  { 101, 26, 39, 24, 0, -39 },
  { 228, 23, 45, 22, 0, -42 },
  { 358, 30, 41, 35, 3, -40 },
  { 512, 24, 41, 25, 0, -40 },
  { 635, 7, 14, 11, 6, -39 },
  { 648, 17, 48, 14, 1, -39 },
  { 750, 17, 49, 14, -4, -40 },
  { 855, 18, 20, 21, 5, -42 },
  { 900, 21, 26, 24, 2, -32 },
  { 969, 11, 13, 12, -3, -6 },
  { 987, 13, 5, 15, 1, -17 },
  { 996, 7, 8, 12, 0, -7 },
  { 1003, 26, 39, 19, -3, -39 },
  { 1130, 21, 41, 22, 1, -40 },
  { 1238, 15, 39, 22, 6, -39 },
  { 1312, 24, 40, 22, -2, -40 },
  { 1432, 24, 41, 22, -1, -40 },
  { 1555, 24, 40, 22, -1, -40 },
  { 1675, 23, 40, 22, 0, -39 },
  { 1790, 23, 41, 22, 1, -40 },
  { 1908, 23, 39, 22, 2, -39 },
  { 2021, 23, 41, 22, 0, -40 },
  { 2139, 22, 41, 22, 0, -40 },
  { 2252, 12, 31, 12, 0, -30 },
  { 2299, 15, 37, 12, -3, -30 },
  { 2369, 21, 25, 24, 2, -32 },
  { 2435, 21, 16, 24, 2, -27 },
  { 2477, 21, 25, 24, 2, -32 },
  { 2543, 18, 41, 17, 1, -40 },
  { 2636, 32, 45, 33, 1, -40 },
  { 2816, 24, 39, 23, -4, -39 },
  { 2933, 25, 39, 24, 0, -39 },
  { 3055, 24, 41, 22, 2, -40 },
  { 3178, 26, 39, 26, 0, -39 },
  { 3305, 23, 39, 21, 0, -39 },
  { 3418, 23, 39, 20, 0, -39 },
  { 3531, 27, 41, 28, 2, -40 },
  { 3670, 29, 39, 27, 0, -39 },
  { 3812, 22, 39, 15, -3, -39 },
  { 3920, 22, 50, 12, -8, -39 },
  { 4058, 28, 39, 23, 0, -39 },
  { 4195, 16, 39, 19, 0, -39 },
  { 4273, 38, 39, 36, 0, -39 },
  { 4459, 30, 39, 29, 0, -39 },
  { 4606, 25, 41, 28, 2, -40 },
  { 4735, 24, 39, 23, 0, -39 },
  { 4852, 25, 49, 28, 2, -40 },
  { 5006, 24, 39, 24, 0, -39 },
  { 5123, 24, 41, 21, -1, -40 },
  { 5246, 20, 39, 20, 4, -39 },
  { 5344, 26, 40, 27, 2, -39 },
  { 5474, 23, 39, 23, 5, -39 },
  { 5587, 37, 39, 37, 4, -39 },
  { 5768, 28, 39, 22, -3, -39 },
  { 5905, 22, 39, 21, 4, -39 },
  { 6013, 25, 39, 19, -2, -39 },
  { 6135, 21, 49, 16, -2, -40 },
  { 6264, 10, 39, 19, 5, -39 },
  { 6313, 21, 49, 16, -4, -40 },
  { 6442, 22, 22, 23, 0, -39 },
  { 6503, 18, 3, 17, -5, 5 },
  { 6510, 8, 9, 15, 8, -42 },
  { 6519, 23, 31, 24, 1, -30 },
  { 6609, 23, 43, 24, 0, -42 },
  { 6733, 19, 31, 18, 1, -30 },
  { 6807, 25, 43, 24, 1, -42 },
  { 6942, 20, 31, 22, 1, -30 },
  { 7020, 27, 55, 13, -7, -42 },
  { 7206, 25, 43, 24, -1, -30 },
  { 7341, 22, 42, 23, 0, -42 },
  { 7457, 13, 41, 11, 0, -41 },
  { 7524, 20, 54, 11, -7, -41 },
  { 7659, 23, 42, 21, 0, -42 },
  { 7780, 14, 42, 11, 0, -42 },
  { 7854, 33, 30, 35, 0, -30 },
  { 7978, 22, 30, 23, 0, -30 },
  { 8061, 21, 31, 23, 1, -30 },
  { 8143, 26, 43, 24, -3, -30 },
  { 8283, 23, 43, 24, 1, -30 },
  { 8407, 19, 30, 16, 0, -30 },
  { 8479, 20, 31, 18, -1, -30 },
  { 8557, 15, 37, 14, 1, -36 },
  { 8627, 22, 31, 23, 1, -30 },
  { 8713, 19, 30, 20, 3, -30 },
  { 8785, 31, 30, 31, 3, -30 },
  { 8902, 25, 30, 20, -3, -30 },
  { 8996, 28, 43, 20, -5, -30 },
  { 9147, 20, 30, 16, -2, -30 },
  { 9222, 21, 48, 18, 1, -39 },
  { 9348, 4, 55, 20, 8, -42 },
  { 9376, 20, 48, 18, -3, -39 },
  { 9496, 21, 7, 24, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC55PT7B_H_
