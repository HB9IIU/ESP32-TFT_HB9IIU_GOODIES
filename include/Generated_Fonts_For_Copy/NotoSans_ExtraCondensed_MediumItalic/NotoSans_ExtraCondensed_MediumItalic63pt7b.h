#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC63PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0,
  0x00, 0x80, 0x00, 0x1F, 0x87, 0xE7, 0xF0, 0xFC, 0xFC, 0x3F, 0x1F, 0x87,
  0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x7E, 0x1F,
  0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF0, 0x3C,
  0x3E, 0x07, 0x87, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x1E, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x0F,
  0x00, 0x01, 0xE0, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0xF0, 0x00, 0x1E,
  0x0F, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x3E,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0x83, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x3E, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0x7E, 0x01, 0xFC, 0xE1, 0x80, 0x3F, 0x1C, 0x10, 0x07, 0xC3, 0x00,
  0x00, 0xF8, 0x60, 0x00, 0x3F, 0x1C, 0x00, 0x07, 0xE3, 0x80, 0x00, 0xFC,
  0x70, 0x00, 0x0F, 0x8C, 0x00, 0x01, 0xF9, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3B, 0xF8, 0x00, 0x07, 0x3F, 0x00, 0x00, 0xE7,
  0xE0, 0x00, 0x18, 0xFC, 0x00, 0x03, 0x0F, 0x80, 0x00, 0xE1, 0xF0, 0x00,
  0x1C, 0x7E, 0x00, 0x03, 0x0F, 0xC0, 0x80, 0x61, 0xF0, 0x1C, 0x0C, 0x7E,
  0x03, 0xE3, 0xBF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x0F, 0xF8, 0x00, 0xF8, 0x03, 0xFF,
  0x80, 0x1E, 0x00, 0x7F, 0xF0, 0x07, 0xC0, 0x1F, 0x1E, 0x00, 0xF0, 0x07,
  0xC3, 0xC0, 0x3E, 0x00, 0xF0, 0x78, 0x07, 0x80, 0x3E, 0x0F, 0x01, 0xF0,
  0x07, 0xC1, 0xE0, 0x3C, 0x00, 0xF0, 0x3C, 0x0F, 0x80, 0x1E, 0x07, 0x81,
  0xE0, 0x07, 0xC0, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x1F, 0x00, 0x1E, 0x07,
  0xC3, 0xE0, 0x03, 0xC0, 0xF0, 0xF8, 0x00, 0xF8, 0x1E, 0x1F, 0x00, 0x1F,
  0x07, 0xC7, 0xC0, 0x03, 0xE0, 0xF8, 0xF0, 0x10, 0x7C, 0x1E, 0x3E, 0x1F,
  0xCF, 0x87, 0xC7, 0x87, 0xFD, 0xF0, 0xF9, 0xF1, 0xFF, 0xBE, 0x3E, 0x3C,
  0x7F, 0xFF, 0xC7, 0xCF, 0x8F, 0x1F, 0xFF, 0xF1, 0xE3, 0xE1, 0xEF, 0xFC,
  0x7C, 0x78, 0x3D, 0xFF, 0x0F, 0x1F, 0x07, 0x9F, 0xC3, 0xE3, 0xC0, 0xF0,
  0x40, 0x78, 0x78, 0x3E, 0x00, 0x1F, 0x1F, 0x07, 0xC0, 0x03, 0xC3, 0xC0,
  0xF8, 0x00, 0xF8, 0x78, 0x1F, 0x00, 0x3E, 0x1F, 0x03, 0xC0, 0x07, 0xC3,
  0xE0, 0x78, 0x01, 0xF0, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x03, 0xE0, 0x0F,
  0x81, 0xE0, 0x78, 0x01, 0xF0, 0x3C, 0x1F, 0x00, 0x7C, 0x07, 0x83, 0xE0,
  0x0F, 0x00, 0xF0, 0x78, 0x03, 0xE0, 0x1E, 0x1F, 0x00, 0x78, 0x03, 0xE7,
  0xC0, 0x1F, 0x00, 0x7F, 0xF8, 0x03, 0xC0, 0x0F, 0xFE, 0x00, 0xF8, 0x00,
  0xFF, 0x80, 0x3E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x7C, 0x1F, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xF8,
  0x1F, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x83, 0xF0, 0x7F, 0xF8, 0x3F, 0x0F, 0xDF, 0x83, 0xE1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x0F, 0xC7, 0xC3, 0xF0, 0xFC, 0xFC, 0x7E, 0x07, 0xEF, 0xC7,
  0xE0, 0x7E, 0xF8, 0xFC, 0x07, 0xFF, 0x8F, 0xC0, 0x3F, 0xF0, 0xFC, 0x03,
  0xFF, 0x0F, 0xC0, 0x3F, 0xE0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0,
  0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0x7F, 0xC0, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xE7, 0xF0, 0x3F, 0xFC, 0x3F,
  0x01, 0xFF, 0x83, 0xF8, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE7,
  0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xE1, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x06, 0x0F, 0x80, 0x78, 0xF8, 0x07, 0xEF, 0x87, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xFC, 0x01, 0xFB, 0xE0, 0x3F, 0x3E, 0x07, 0xF1, 0xF0, 0x3E,
  0x1F, 0x01, 0xC1, 0xF8, 0x08, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x00, 0x7F,
  0xFE, 0xFF, 0xF9, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x80, 0x1E,
  0x3F, 0x7F, 0x7F, 0x7F, 0xFF, 0x7E, 0x7C, 0x10, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x1F,
  0x03, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x1F,
  0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3F,
  0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0,
  0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0x7C, 0x1F, 0xC0, 0x7E, 0x3F, 0x80,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC,
  0x1F, 0xFF, 0x0F, 0xEF, 0x8F, 0xE3, 0xE1, 0xF1, 0xF8, 0x38, 0x7E, 0x04,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7E, 0x0F,
  0xE0, 0x03, 0x80, 0x7E, 0x00, 0x30, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x04, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x1E, 0x07, 0xF8, 0x03, 0x00, 0x7F, 0x00, 0x40, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x04, 0x00, 0x3F, 0xC0, 0xE0, 0x0F, 0xF0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0x7E, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x79, 0xF0, 0x00, 0x1E, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0xF1, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xE1, 0xF8,
  0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0xF8,
  0x3F, 0x00, 0x1E, 0x07, 0xE0, 0x07, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x00,
  0x3C, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x78, 0x03,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xF1, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x30, 0x01, 0xFE, 0x07, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x83, 0x80,
  0x0F, 0xC7, 0xF0, 0x07, 0xEF, 0xFC, 0x03, 0xEF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x7F, 0x80,
  0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0,
  0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x7C,
  0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x07,
  0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0x8F, 0xF0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80,
  0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFE,
  0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0x7F, 0x07,
  0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x1F,
  0xE3, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x83,
  0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F,
  0x87, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x07,
  0xF8, 0xFE, 0x03, 0xF8, 0x3F, 0x03, 0xFC, 0x1F, 0x83, 0xFE, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xDF, 0x81, 0xFF, 0xEF, 0x80, 0xFF, 0xEF, 0xC0, 0x3F,
  0xC7, 0xE0, 0x03, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0,
  0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xFC, 0x07, 0xF0, 0x7F, 0x83, 0xF8,
  0x1F, 0xC0, 0xFE, 0x03, 0xE0, 0x04, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1C, 0x0F, 0xE0, 0x80, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3E, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x7F,
  0x80, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0,
  0x78, 0x03, 0xFC, 0x1E, 0x0F, 0x01, 0xFF, 0xC3, 0xC3, 0xC0, 0x7F, 0xF8,
  0x78, 0x78, 0x1F, 0xFF, 0x0F, 0x1E, 0x07, 0xC3, 0xC1, 0xE3, 0xC0, 0xF0,
  0x78, 0x3C, 0xF8, 0x3C, 0x0F, 0x07, 0x9E, 0x07, 0x83, 0xE0, 0xF3, 0xC1,
  0xE0, 0x78, 0x1E, 0xF8, 0x3C, 0x0F, 0x03, 0xDE, 0x0F, 0x83, 0xE0, 0xFB,
  0xC1, 0xE0, 0x7C, 0x1E, 0x78, 0x3C, 0x0F, 0x03, 0xDF, 0x07, 0x81, 0xE0,
  0x7B, 0xC1, 0xF0, 0x7C, 0x1F, 0x78, 0x3E, 0x0F, 0x83, 0xCF, 0x07, 0x81,
  0xE0, 0x79, 0xE0, 0xF0, 0x7C, 0x1E, 0x3C, 0x1E, 0x0F, 0x83, 0xC7, 0x83,
  0xC1, 0xF0, 0xF0, 0xF0, 0x78, 0x7E, 0x1E, 0x1E, 0x0F, 0x9D, 0xC7, 0x83,
  0xC1, 0xFF, 0xBF, 0xF0, 0x78, 0x1F, 0xE7, 0xFC, 0x0F, 0x03, 0xF8, 0x7F,
  0x01, 0xE0, 0x1C, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x40, 0x00,
  0x7E, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xDF, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF1,
  0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xF0, 0xF8, 0x00,
  0x7E, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x0F,
  0x80, 0x1F, 0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x1F,
  0x80, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x07, 0xEF, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0xBF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xC0, 0xFF, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F,
  0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x3F,
  0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x03, 0xE0, 0x3F,
  0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0xFF, 0x00, 0xFC, 0x07,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81,
  0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x00,
  0x3F, 0x83, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0,
  0x3F, 0x00, 0x7F, 0x03, 0xE0, 0x0F, 0xE0, 0x7E, 0x01, 0xFE, 0x07, 0xE0,
  0x7F, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0x81, 0x80, 0x0F, 0xE0, 0x08,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x7E, 0x3F, 0xF8, 0x03, 0xF0, 0x3F, 0xC0, 0x1F, 0x80, 0xFF, 0x00, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01,
  0xFC, 0x1F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0,
  0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x03,
  0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0,
  0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0xFF, 0x01, 0xF8,
  0x1F, 0xF0, 0x0F, 0xC7, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x1E, 0x00, 0x7F, 0x80, 0x0C,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xFC, 0x3F, 0x00,
  0x7F, 0xF0, 0x7E, 0x00, 0xFF, 0xE0, 0xFC, 0x01, 0xFF, 0xC1, 0xF8, 0x07,
  0xFF, 0x87, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x01,
  0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC,
  0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x3F, 0xC0, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x01,
  0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0,
  0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x08, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0x7C, 0x00,
  0x7D, 0xF8, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0xFD, 0xF0, 0x03, 0xEF,
  0xC0, 0x1F, 0xBE, 0x00, 0x7D, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0xBF, 0x00,
  0x7C, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0x9F, 0x00, 0xFD, 0xF8, 0x03, 0xF3,
  0xE0, 0x1F, 0x3F, 0x00, 0x7E, 0x7C, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0x80,
  0xF8, 0xFC, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x00, 0x7E, 0x3E, 0x07, 0xC7,
  0xE0, 0x0F, 0xC7, 0xC0, 0xF8, 0xFC, 0x01, 0xF8, 0xF8, 0x3E, 0x1F, 0x80,
  0x3E, 0x1F, 0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xF1, 0xF8, 0x7C, 0x01, 0xF8,
  0x7E, 0x3E, 0x1F, 0x80, 0x3F, 0x0F, 0xCF, 0xC3, 0xF0, 0x07, 0xE0, 0xF9,
  0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x3E, 0x0F, 0xC0, 0x1F, 0x03, 0xEF, 0x81,
  0xF0, 0x07, 0xE0, 0x7D, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xFC, 0x0F, 0xC0,
  0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x03, 0xE0, 0x3F, 0xE0, 0x3E, 0x00, 0x7C,
  0x07, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xFF, 0x81, 0xF8, 0x03, 0xF0, 0x1F,
  0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x7F, 0x00,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x0F,
  0xF0, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x07, 0xE0,
  0x0F, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x03,
  0xE0, 0x07, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xF8,
  0x03, 0xF0, 0x07, 0xFF, 0x00, 0x7E, 0x00, 0xFB, 0xE0, 0x0F, 0x80, 0x1F,
  0x7C, 0x01, 0xF0, 0x03, 0xEF, 0xC0, 0x7E, 0x00, 0xFC, 0xF8, 0x0F, 0xC0,
  0x1F, 0x9F, 0x01, 0xF8, 0x03, 0xF3, 0xE0, 0x3E, 0x00, 0x7C, 0x7C, 0x0F,
  0xC0, 0x0F, 0x8F, 0x81, 0xF8, 0x03, 0xF1, 0xF8, 0x3F, 0x00, 0x7E, 0x1F,
  0x07, 0xC0, 0x0F, 0xC3, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x3F, 0x00, 0x7E,
  0x0F, 0x87, 0xE0, 0x0F, 0xC1, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x1F, 0x00,
  0x3E, 0x03, 0xE3, 0xE0, 0x07, 0xC0, 0x7C, 0xFC, 0x01, 0xF8, 0x0F, 0x9F,
  0x80, 0x3F, 0x01, 0xF3, 0xF0, 0x07, 0xE0, 0x3E, 0x7C, 0x00, 0xF8, 0x07,
  0xEF, 0x80, 0x1F, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x0F, 0xFE, 0x00, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xF0, 0x03, 0xE0, 0x07, 0xFE, 0x00,
  0x7C, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0xF8, 0x03, 0xF0, 0x01, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0x80, 0x07, 0xF8, 0x03, 0xF0, 0x00,
  0xFF, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFC, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xC1,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x01,
  0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x01,
  0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0x7F, 0x83, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xC7, 0xFE, 0x00,
  0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0,
  0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xFC,
  0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x07, 0xF8, 0x07, 0xE7, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xF8, 0x03,
  0xF8, 0x1F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0,
  0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFD,
  0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x7E, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF8,
  0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xE1, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x83, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xC3, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0x7E, 0x00,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80,
  0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x80, 0x7E, 0x3F, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xE0,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F,
  0x80, 0x3F, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x00,
  0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x07, 0xC0, 0x1F, 0xE0,
  0x08, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x80, 0x03,
  0xF8, 0x0E, 0x00, 0x7F, 0x80, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x0F,
  0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xE0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F,
  0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xC7, 0xE0,
  0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x03, 0xF8,
  0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x3E, 0x00,
  0x7E, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x1F,
  0x80, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x1F,
  0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xE0,
  0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF9,
  0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7D, 0xF8, 0x00,
  0x0F, 0xBF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xEF, 0xC0,
  0x03, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x1F, 0x80, 0x1F, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0xFF, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0xF0, 0x0F, 0xC1, 0xF8,
  0x03, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0xFF, 0xC0, 0x3F, 0x07, 0xE0, 0x1F,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xDE, 0x01, 0xF8, 0x1F, 0x80, 0xFB, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x78, 0x0F, 0xC0, 0x7E, 0x07, 0xCF, 0x01, 0xF8,
  0x0F, 0xC0, 0xFB, 0xE0, 0x7E, 0x01, 0xF8, 0x3E, 0x7C, 0x0F, 0xC0, 0x3F,
  0x07, 0xCF, 0x81, 0xF0, 0x07, 0xE0, 0xF9, 0xF0, 0x7E, 0x00, 0xFC, 0x3E,
  0x3E, 0x0F, 0xC0, 0x1F, 0x87, 0xC7, 0xC3, 0xF0, 0x03, 0xF0, 0xF8, 0xF8,
  0x7E, 0x00, 0x7C, 0x3E, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xC3, 0xE3, 0xF0,
  0x01, 0xF1, 0xF0, 0x7C, 0x7E, 0x00, 0x3E, 0x3E, 0x0F, 0x9F, 0x80, 0x07,
  0xC7, 0xC1, 0xF3, 0xF0, 0x00, 0xF9, 0xF0, 0x3E, 0x7E, 0x00, 0x1F, 0x3E,
  0x07, 0xDF, 0x80, 0x03, 0xEF, 0x80, 0xFB, 0xF0, 0x00, 0x7D, 0xF0, 0x1F,
  0x7C, 0x00, 0x0F, 0xBE, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7C, 0xFC,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00,
  0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x0F,
  0xC0, 0x3E, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x20, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xF1, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x3E, 0x00,
  0x7C, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF9, 0xF8,
  0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x07,
  0xC1, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xF1,
  0xF0, 0x07, 0xFE, 0x7C, 0x03, 0xFF, 0x9F, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x83,
  0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F,
  0xE0, 0x7E, 0x07, 0xF8, 0x1F, 0x83, 0xFC, 0x07, 0xFB, 0xFF, 0x01, 0xFF,
  0xF7, 0xC0, 0x3F, 0xF9, 0xF0, 0x0F, 0xFC, 0x7C, 0x00, 0xFE, 0x1E, 0x00,
  0x0E, 0x08, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x0C,
  0x00, 0x1F, 0x9F, 0xE0, 0x07, 0xCF, 0xFC, 0x03, 0xF7, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0xC1,
  0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F,
  0xC1, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x1F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x03,
  0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x7E, 0x07, 0xF8, 0x3F, 0x81, 0xFF,
  0xBF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3E, 0x7F, 0xF8, 0x0F, 0x9F, 0xFC, 0x03,
  0xE3, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFF,
  0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xC0, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x03, 0x03, 0xFE, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x03, 0x03, 0xE0, 0x00, 0xFF, 0x1F,
  0x00, 0x0F, 0xFD, 0xF8, 0x00, 0xFF, 0xEF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7E, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7C, 0x03,
  0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0,
  0x0F, 0xC0, 0x7E, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF0,
  0x3F, 0x80, 0x1F, 0x83, 0xFC, 0x00, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0xDF,
  0x00, 0x1F, 0xFC, 0xF8, 0x00, 0xFF, 0xC7, 0x80, 0x03, 0xFC, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x1F, 0xC1, 0xFC, 0x1F,
  0x83, 0xF0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x7E, 0x01, 0xF8,
  0xFC, 0x03, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0xFE, 0x1F,
  0x1F, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0x80, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x08, 0x1F, 0xE0, 0xF0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xE1, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0x1F,
  0x00, 0x1F, 0xF9, 0xF0, 0x03, 0xFF, 0x9F, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07,
  0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81,
  0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80,
  0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x01, 0xF8,
  0x3F, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0xFC,
  0x00, 0xFF, 0xCF, 0xC0, 0x07, 0xF8, 0xF8, 0x00, 0x0C, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x08,
  0x00, 0xFE, 0x00, 0xF0, 0x3F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0x80, 0x07, 0xE7, 0xF8, 0x03,
  0xE7, 0xFE, 0x01, 0xF7, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0x87, 0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x83, 0xF0, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3E, 0x00,
  0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x1F, 0x83, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0xFC, 0x1F,
  0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x8F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03,
  0xF8, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x0F,
  0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC3, 0xF0,
  0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xC7, 0xE0, 0x00, 0xF9,
  0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFB, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFD, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3F,
  0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3E,
  0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x20, 0x01, 0x80, 0x07, 0xC7, 0xF8,
  0x3F, 0xC0, 0x1E, 0x3F, 0xF1, 0xFF, 0x80, 0x79, 0xFF, 0xCF, 0xFE, 0x03,
  0xEF, 0xFF, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC3, 0xFE,
  0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x1F,
  0xC0, 0x7E, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0,
  0x3F, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7E, 0x01,
  0xF8, 0x3E, 0x01, 0xF8, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x0F,
  0x83, 0xF0, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x3F, 0x00,
  0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x1F, 0x83, 0xE0, 0x1F, 0x80, 0x7C,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x07,
  0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0xFC, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x3E,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0xF8, 0xFF, 0x00, 0x78, 0xFF,
  0xC0, 0x3C, 0xFF, 0xE0, 0x3E, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xF0,
  0x7E, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x3F,
  0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x07,
  0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E,
  0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0x7F, 0x83, 0xF8,
  0x3F, 0x07, 0xE0, 0x7F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0xFC, 0x01,
  0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F,
  0xBF, 0x00, 0x3F, 0xFC, 0x00, 0x7D, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7,
  0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x7E, 0x7C,
  0x00, 0xFC, 0xF8, 0x03, 0xF9, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0,
  0x3F, 0x0F, 0xC0, 0xFE, 0x1F, 0x83, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xF1, 0xFE, 0x00, 0x0F, 0x9F, 0xF8,
  0x00, 0x79, 0xFF, 0xE0, 0x07, 0xDF, 0xFF, 0x00, 0x3E, 0xF3, 0xF8, 0x01,
  0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x01,
  0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0,
  0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x1F,
  0x80, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFF, 0x03, 0xF0, 0x07, 0xF8,
  0x3F, 0x80, 0x3F, 0xF7, 0xF8, 0x01, 0xF7, 0xFF, 0x80, 0x1F, 0xBF, 0xFC,
  0x00, 0xFC, 0xFF, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x06, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xF1, 0xF0, 0x07, 0xFE,
  0x7C, 0x03, 0xFF, 0x9F, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F,
  0x07, 0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xE1,
  0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F,
  0x80, 0x3F, 0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xE0, 0x7E, 0x07,
  0xF8, 0x1F, 0x83, 0xFC, 0x07, 0xFB, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFB, 0xF0, 0x0F, 0xFC, 0xF8, 0x01, 0xFE, 0x3E, 0x00, 0x0C, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x0F, 0x8F, 0xC0, 0x78, 0xFE, 0x03, 0xCF, 0xE0, 0x3E, 0xFF, 0x01,
  0xF7, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x1F, 0x01,
  0xF8, 0x06, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x08, 0x01, 0xFC, 0x1C, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE,
  0x3F, 0xFE, 0x7F, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFE, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0,
  0x7F, 0xC0, 0x0C, 0x00, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0x83, 0xF0,
  0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x3E,
  0x00, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07,
  0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC,
  0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x1F,
  0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x7C, 0x03,
  0xF0, 0x3E, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC1, 0xFE, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xEF, 0x80, 0x7F, 0xE7, 0xC0, 0x1F,
  0xE3, 0xE0, 0x01, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xEF,
  0x80, 0x1F, 0xBE, 0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xE0, 0x1F, 0x8F, 0x80,
  0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x81, 0xF8,
  0x3E, 0x07, 0xE0, 0xF8, 0x3F, 0x03, 0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x3E,
  0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E,
  0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF7, 0xC0, 0x3F, 0x80,
  0x7E, 0x7C, 0x03, 0xF8, 0x07, 0xE7, 0xC0, 0x3F, 0x80, 0x7C, 0x7C, 0x07,
  0xF8, 0x0F, 0xC7, 0xC0, 0x7F, 0x80, 0xF8, 0x7C, 0x07, 0xF8, 0x1F, 0x87,
  0xC0, 0xFF, 0x81, 0xF8, 0x7C, 0x0F, 0x78, 0x1F, 0x07, 0xC1, 0xF7, 0x83,
  0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x07, 0xC1, 0xEF, 0x83, 0xE0, 0x7C, 0x3E,
  0xF8, 0x7E, 0x07, 0xC3, 0xEF, 0x87, 0xC0, 0x7C, 0x7C, 0xF8, 0xFC, 0x07,
  0xC7, 0xCF, 0x8F, 0x80, 0x7C, 0x78, 0xF8, 0xF8, 0x07, 0xCF, 0x8F, 0x9F,
  0x80, 0x7C, 0xF8, 0xF9, 0xF0, 0x07, 0xDF, 0x0F, 0x9F, 0x00, 0x7D, 0xF0,
  0xFB, 0xE0, 0x07, 0xDE, 0x0F, 0xBE, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07,
  0xFE, 0x0F, 0x7C, 0x00, 0x7B, 0xC0, 0xF7, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0,
  0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x3E,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0xFC, 0x3F, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x01,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x43, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x8F, 0xF0, 0x00, 0x4F, 0xFF, 0x00, 0x6F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0xFF, 0xFD, 0x80, 0x0F, 0xFC, 0x80,
  0x01, 0xF8, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 17, 46, 15, 0, -45 },
  { 99, 19, 16, 22, 6, -45 },
  { 137, 29, 45, 28, 0, -45 },
  { 301, 27, 52, 25, 0, -48 },
  { 477, 35, 47, 40, 3, -46 },
  { 683, 28, 47, 29, 0, -46 },
  { 848, 9, 16, 13, 6, -45 },
  { 866, 20, 55, 16, 1, -45 },
  { 1004, 20, 55, 16, -5, -45 },
  { 1142, 20, 22, 24, 6, -48 },
  { 1197, 23, 30, 28, 3, -37 },
  { 1284, 12, 15, 13, -3, -7 },
  { 1307, 15, 6, 17, 1, -20 },
  { 1319, 8, 9, 13, 0, -8 },
  { 1328, 30, 45, 22, -3, -45 },
  { 1497, 24, 47, 25, 1, -46 },
  { 1638, 18, 45, 25, 6, -45 },
  { 1740, 28, 46, 25, -2, -46 },
  { 1901, 27, 47, 25, -1, -46 },
  { 2060, 27, 45, 25, -1, -45 },
  { 2212, 27, 46, 25, -1, -45 },
  { 2368, 25, 47, 25, 2, -46 },
  { 2515, 26, 45, 25, 2, -45 },
  { 2662, 26, 47, 25, 0, -46 },
  { 2815, 25, 47, 25, 0, -46 },
  { 2962, 13, 35, 14, 0, -34 },
  { 3019, 17, 42, 14, -3, -34 },
  { 3109, 25, 29, 28, 2, -37 },
  { 3200, 23, 18, 28, 3, -31 },
  { 3252, 24, 29, 28, 3, -37 },
  { 3339, 21, 47, 19, 1, -46 },
  { 3463, 35, 50, 38, 2, -45 },
  { 3682, 27, 45, 27, -4, -45 },
  { 3834, 28, 45, 28, 0, -45 },
  { 3992, 28, 47, 25, 2, -46 },
  { 4157, 29, 45, 30, 0, -45 },
  { 4321, 27, 45, 24, 0, -45 },
  { 4473, 27, 45, 22, 0, -45 },
  { 4625, 31, 47, 32, 2, -46 },
  { 4808, 33, 45, 31, 0, -45 },
  { 4994, 25, 45, 17, -3, -45 },
  { 5135, 25, 57, 14, -9, -45 },
  { 5314, 32, 45, 27, 0, -45 },
  { 5494, 18, 45, 22, 0, -45 },
  { 5596, 43, 45, 42, 0, -45 },
  { 5838, 35, 45, 33, 0, -45 },
  { 6035, 29, 47, 32, 2, -46 },
  { 6206, 28, 45, 27, 0, -45 },
  { 6364, 29, 57, 32, 2, -46 },
  { 6571, 28, 45, 27, 0, -45 },
  { 6729, 28, 47, 24, -1, -46 },
  { 6894, 23, 45, 23, 4, -45 },
  { 7024, 30, 46, 31, 2, -45 },
  { 7197, 27, 45, 27, 5, -45 },
  { 7349, 43, 45, 42, 4, -45 },
  { 7591, 33, 45, 25, -4, -45 },
  { 7777, 24, 45, 24, 5, -45 },
  { 7912, 29, 45, 22, -3, -45 },
  { 8076, 24, 55, 18, -2, -45 },
  { 8241, 11, 45, 22, 6, -45 },
  { 8303, 24, 55, 18, -4, -45 },
  { 8468, 26, 25, 26, 0, -45 },
  { 8550, 21, 4, 19, -6, 5 },
  { 8561, 10, 10, 17, 9, -48 },
  { 8574, 26, 36, 27, 1, -35 },
  { 8691, 26, 49, 27, 0, -48 },
  { 8851, 21, 36, 21, 2, -35 },
  { 8946, 29, 49, 27, 1, -48 },
  { 9124, 23, 36, 25, 1, -35 },
  { 9228, 31, 63, 15, -8, -48 },
  { 9473, 28, 50, 27, -1, -35 },
  { 9648, 25, 48, 27, 0, -48 },
  { 9798, 15, 47, 13, 0, -47 },
  { 9887, 23, 62, 13, -8, -47 },
  { 10066, 27, 48, 24, 0, -48 },
  { 10228, 16, 48, 13, 0, -48 },
  { 10324, 38, 35, 40, 0, -35 },
  { 10491, 25, 35, 27, 0, -35 },
  { 10601, 23, 36, 26, 2, -35 },
  { 10705, 29, 50, 27, -3, -35 },
  { 10887, 26, 50, 27, 1, -35 },
  { 11050, 21, 35, 18, 0, -35 },
  { 11142, 23, 36, 21, -1, -35 },
  { 11246, 16, 43, 16, 2, -42 },
  { 11332, 25, 35, 27, 2, -34 },
  { 11442, 22, 34, 22, 4, -34 },
  { 11536, 36, 34, 36, 3, -34 },
  { 11689, 28, 34, 23, -3, -34 },
  { 11808, 32, 49, 23, -6, -34 },
  { 12004, 23, 34, 19, -2, -34 },
  { 12102, 24, 55, 21, 1, -45 },
  { 12267, 5, 63, 23, 9, -48 },
  { 12307, 23, 55, 21, -4, -45 },
  { 12466, 25, 9, 28, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC63PT7B_H_
