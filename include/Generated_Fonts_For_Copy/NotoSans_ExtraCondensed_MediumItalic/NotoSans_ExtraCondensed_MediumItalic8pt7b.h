#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC8PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x20, 0xF0, 0x36, 0x76, 0xAC, 0x2D, 0x37, 0x80, 0x55, 0xBA,
  0xF5, 0xA8, 0x66, 0x6D, 0xAE, 0xC0, 0x29, 0x49, 0x20, 0x24, 0x92, 0xB0,
  0xFC, 0x4B, 0xA0, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x2E, 0xDB, 0x80,
  0x76, 0xA0, 0x64, 0xA5, 0x80, 0x64, 0xB3, 0x80, 0x25, 0xDE, 0x80, 0x6B,
  0x13, 0x80, 0x2B, 0xDB, 0x80, 0x72, 0x24, 0x48, 0x6D, 0xDB, 0x80, 0x6E,
  0xB3, 0x80, 0x42, 0x42, 0x80, 0x2B, 0x10, 0xFC, 0x8C, 0xE0, 0x65, 0x21,
  0x00, 0x32, 0x6F, 0xBF, 0x41, 0x80, 0x13, 0x37, 0x5D, 0x65, 0x6A, 0xAE,
  0x34, 0x88, 0x86, 0x65, 0x59, 0xAC, 0x69, 0x59, 0x80, 0x69, 0x39, 0x00,
  0x34, 0x8B, 0x96, 0x55, 0x5B, 0xAA, 0x69, 0x29, 0x80, 0x24, 0xA4, 0x94,
  0x56, 0x64, 0xAA, 0x56, 0xB0, 0x4A, 0x57, 0x7A, 0xD4, 0x55, 0x5B, 0xBA,
  0x35, 0x99, 0x9E, 0x65, 0x66, 0x88, 0x35, 0x99, 0x96, 0x20, 0x65, 0x64,
  0xAA, 0x69, 0x33, 0x80, 0xEA, 0xA0, 0x55, 0x59, 0xAE, 0xB7, 0x69, 0x00,
  0xAD, 0x7D, 0x6A, 0x50, 0x56, 0x44, 0xCA, 0xBB, 0x49, 0x00, 0x65, 0x29,
  0x80, 0x69, 0x49, 0x20, 0xFC, 0x32, 0x22, 0x22, 0xC0, 0x2E, 0x80, 0xE0,
  0x80, 0x76, 0xF0, 0x49, 0xDB, 0xC0, 0x72, 0x60, 0x11, 0x6A, 0xAE, 0x7E,
  0x60, 0x32, 0x64, 0x44, 0x48, 0x76, 0xF3, 0x80, 0x49, 0xDB, 0x40, 0x46,
  0xA0, 0x20, 0xA4, 0x94, 0x49, 0xAD, 0x40, 0x56, 0xA0, 0x7D, 0x6B, 0x60,
  0x76, 0xD0, 0x76, 0xE0, 0x76, 0xF9, 0x00, 0x76, 0xF2, 0x80, 0x72, 0x40,
  0xE9, 0x60, 0x7A, 0xC0, 0x76, 0xF0, 0xB5, 0x20, 0xAD, 0xBD, 0x40, 0x69,
  0x60, 0x55, 0x22, 0x4C, 0x6A, 0x60, 0x29, 0x65, 0x30, 0xFF, 0x55, 0x68,
  0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 3, 6, 3, 0, -6 },
  { 10, 5, 6, 5, 0, -6 },
  { 14, 4, 6, 4, 0, -6 },
  { 17, 1, 2, 2, 1, -6 },
  { 18, 3, 7, 2, 0, -6 },
  { 21, 3, 7, 2, -1, -6 },
  { 24, 2, 3, 3, 1, -6 },
  { 25, 3, 4, 4, 0, -5 },
  { 27, 1, 2, 2, 0, -1 },
  { 28, 2, 1, 2, 0, -3 },
  { 29, 1, 1, 2, 0, -1 },
  { 30, 3, 6, 3, 0, -6 },
  { 33, 3, 6, 3, 0, -6 },
  { 36, 2, 6, 3, 1, -6 },
  { 38, 3, 6, 3, 0, -6 },
  { 41, 3, 6, 3, 0, -6 },
  { 44, 3, 6, 3, 0, -6 },
  { 47, 3, 6, 3, 0, -6 },
  { 50, 3, 6, 3, 0, -6 },
  { 53, 4, 6, 3, 0, -6 },
  { 56, 3, 6, 3, 0, -6 },
  { 59, 3, 6, 3, 0, -6 },
  { 62, 2, 4, 2, 0, -4 },
  { 63, 2, 5, 2, 0, -4 },
  { 65, 3, 4, 4, 0, -5 },
  { 67, 3, 2, 4, 0, -4 },
  { 68, 3, 4, 4, 0, -5 },
  { 70, 3, 6, 2, 0, -6 },
  { 73, 5, 7, 5, 0, -6 },
  { 78, 4, 6, 3, -1, -6 },
  { 81, 4, 6, 4, 0, -6 },
  { 84, 4, 6, 3, 0, -6 },
  { 87, 4, 6, 4, 0, -6 },
  { 90, 3, 6, 3, 0, -6 },
  { 93, 3, 6, 3, 0, -6 },
  { 96, 4, 6, 4, 0, -6 },
  { 99, 4, 6, 4, 0, -6 },
  { 102, 3, 6, 2, 0, -6 },
  { 105, 3, 8, 2, -1, -6 },
  { 108, 4, 6, 3, 0, -6 },
  { 111, 2, 6, 3, 0, -6 },
  { 113, 5, 6, 5, 0, -6 },
  { 117, 4, 6, 4, 0, -6 },
  { 120, 4, 6, 4, 0, -6 },
  { 123, 4, 6, 3, 0, -6 },
  { 126, 4, 7, 4, 0, -6 },
  { 130, 4, 6, 3, 0, -6 },
  { 133, 3, 6, 3, 0, -6 },
  { 136, 2, 6, 3, 1, -6 },
  { 138, 4, 6, 4, 0, -6 },
  { 141, 3, 6, 3, 1, -6 },
  { 144, 5, 6, 5, 1, -6 },
  { 148, 4, 6, 3, 0, -6 },
  { 151, 3, 6, 3, 1, -6 },
  { 154, 3, 6, 3, 0, -6 },
  { 157, 3, 7, 2, 0, -6 },
  { 160, 1, 6, 3, 1, -6 },
  { 161, 4, 7, 2, -1, -6 },
  { 165, 3, 3, 3, 0, -6 },
  { 167, 3, 1, 2, -1, 0 },
  { 168, 1, 1, 2, 1, -6 },
  { 169, 3, 4, 3, 0, -4 },
  { 171, 3, 6, 3, 0, -6 },
  { 174, 3, 4, 3, 0, -4 },
  { 176, 4, 6, 3, 0, -6 },
  { 179, 3, 4, 3, 0, -4 },
  { 181, 4, 8, 2, -1, -6 },
  { 185, 3, 6, 3, 0, -4 },
  { 188, 3, 6, 3, 0, -6 },
  { 191, 2, 6, 2, 0, -6 },
  { 193, 3, 8, 2, -1, -6 },
  { 196, 3, 6, 3, 0, -6 },
  { 199, 2, 6, 2, 0, -6 },
  { 201, 5, 4, 5, 0, -4 },
  { 204, 3, 4, 3, 0, -4 },
  { 206, 3, 4, 3, 0, -4 },
  { 208, 3, 6, 3, 0, -4 },
  { 211, 3, 6, 3, 0, -4 },
  { 214, 3, 4, 2, 0, -4 },
  { 216, 3, 4, 3, 0, -4 },
  { 218, 2, 5, 2, 0, -5 },
  { 220, 3, 4, 3, 0, -4 },
  { 222, 3, 4, 3, 0, -4 },
  { 224, 5, 4, 5, 0, -4 },
  { 227, 3, 4, 3, 0, -4 },
  { 229, 4, 6, 3, -1, -4 },
  { 232, 3, 4, 2, 0, -4 },
  { 234, 3, 7, 3, 0, -6 },
  { 237, 1, 8, 3, 1, -6 },
  { 238, 2, 7, 3, 0, -6 },
  { 240, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC8PT7B_H_
