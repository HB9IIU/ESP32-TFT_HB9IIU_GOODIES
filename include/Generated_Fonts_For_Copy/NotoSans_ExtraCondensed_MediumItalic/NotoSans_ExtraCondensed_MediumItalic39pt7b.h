#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC39PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x78, 0x3E, 0x0F, 0x83, 0xC0,
  0x78, 0xF7, 0x9E, 0x79, 0xE7, 0x1E, 0x71, 0xC7, 0x1C, 0xF1, 0xCE, 0x3C,
  0xE3, 0x8E, 0x38, 0x00, 0x71, 0xC0, 0x18, 0x60, 0x0E, 0x38, 0x03, 0x8E,
  0x00, 0xC3, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x06, 0x18, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF1, 0xFF, 0xFC, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xE3,
  0x80, 0x38, 0xE0, 0x0E, 0x38, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x18, 0x60, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xC3, 0x00, 0x71, 0xC0, 0x1C,
  0x70, 0x06, 0x18, 0x03, 0x8E, 0x00, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0x62, 0x0E, 0x60,
  0x1E, 0x60, 0x1E, 0x40, 0x1E, 0x40, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0x3C, 0x01, 0x3C,
  0x03, 0x3C, 0x03, 0x3C, 0x83, 0x38, 0xE2, 0x78, 0xFF, 0xF0, 0xFF, 0xE0,
  0x7F, 0xC0, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0F, 0x80,
  0xE0, 0x7E, 0x03, 0x81, 0xDC, 0x1C, 0x0E, 0x70, 0x70, 0x31, 0xC3, 0x81,
  0xC7, 0x0E, 0x07, 0x1C, 0x70, 0x18, 0x71, 0xC0, 0xE1, 0xCE, 0x03, 0x86,
  0x38, 0x0E, 0x39, 0xC0, 0x38, 0xE7, 0x3C, 0xE3, 0x39, 0xFB, 0x9C, 0xCF,
  0xEE, 0xE7, 0x31, 0xFF, 0x99, 0xC7, 0x7C, 0xE7, 0x1C, 0x07, 0x38, 0x60,
  0x1C, 0xE1, 0x80, 0xE3, 0x8E, 0x03, 0x8E, 0x38, 0x1C, 0x30, 0xE0, 0x70,
  0xC3, 0x03, 0x87, 0x1C, 0x0E, 0x0C, 0x70, 0x70, 0x3B, 0x81, 0xC0, 0xFC,
  0x0E, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x71, 0xC0,
  0x78, 0xE0, 0x38, 0x70, 0x1C, 0x78, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x9C,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x0E, 0x3F,
  0xCF, 0x3D, 0xE7, 0xBC, 0x73, 0x9C, 0x3F, 0xDE, 0x1F, 0xCF, 0x07, 0xE7,
  0x03, 0xE3, 0x81, 0xF1, 0xE0, 0xF8, 0xF0, 0xFC, 0x7F, 0xFE, 0x1F, 0xE7,
  0x87, 0xE3, 0xC0, 0x7B, 0xDE, 0xF7, 0x39, 0xDC, 0xE7, 0x00, 0x00, 0xF0,
  0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x80, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03,
  0x80, 0x78, 0x0F, 0x00, 0x07, 0x80, 0x70, 0x07, 0x04, 0x70, 0xE7, 0x0F,
  0xEF, 0xFF, 0xF0, 0xFF, 0x1F, 0x03, 0xF8, 0x7B, 0x8F, 0x3C, 0x21, 0xC2,
  0x18, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x1E, 0x1E,
  0x1C, 0x3C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xBF, 0xC0, 0x33,
  0xFF, 0xF7, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF8,
  0x07, 0xF8, 0x1F, 0xF0, 0x7D, 0xE0, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x9E,
  0x0F, 0x3C, 0x1E, 0x70, 0x3D, 0xE0, 0x73, 0xC0, 0xE7, 0x81, 0xCE, 0x07,
  0x9C, 0x0F, 0x78, 0x1E, 0xF0, 0x39, 0xE0, 0xF3, 0xC1, 0xE7, 0x03, 0x8E,
  0x0F, 0x1C, 0x1E, 0x38, 0x38, 0x70, 0xF0, 0xF3, 0xC1, 0xFF, 0x81, 0xFE,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x1F, 0x07, 0xE3, 0xFC, 0xFF, 0x3C,
  0xE3, 0x3C, 0x47, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x38, 0x07, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0xF1, 0xF0, 0x20, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F,
  0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0x61, 0xF0, 0x20, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x3F, 0x80, 0x1F, 0x00,
  0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0xC0, 0xF8, 0x7F,
  0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xDC, 0x00,
  0xCE, 0x00, 0xE7, 0x00, 0xE7, 0x80, 0x73, 0xC0, 0x71, 0xC0, 0x30, 0xE0,
  0x38, 0xF0, 0x38, 0x78, 0x1C, 0x3C, 0x1C, 0x1C, 0x1C, 0x0E, 0x0F, 0xFF,
  0xE7, 0xFF, 0xE7, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF,
  0x07, 0xFE, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x10, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x81, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0xC0,
  0x7B, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0x7C, 0x78, 0xF8, 0x38, 0xF0, 0x3C,
  0xF0, 0x38, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x70,
  0xF0, 0xF0, 0xF1, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0xFF,
  0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFC,
  0x03, 0xFE, 0x07, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x07, 0x0E, 0x07,
  0x0E, 0x0F, 0x0E, 0x0F, 0x0E, 0x1E, 0x0F, 0x3C, 0x07, 0xF8, 0x07, 0xF0,
  0x03, 0xE0, 0x0F, 0xF0, 0x1E, 0xF0, 0x3C, 0x78, 0x78, 0x78, 0x70, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xE0, 0x3C, 0xE0, 0x38, 0xF0, 0x78, 0xF0, 0x78,
  0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFE,
  0x0F, 0x9E, 0x0F, 0x0E, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x3E, 0xFE,
  0x1F, 0xFE, 0x1F, 0xDC, 0x07, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0xFF, 0xC0, 0xFF, 0x80,
  0xFE, 0x00, 0x07, 0x0F, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x78, 0xF8, 0xF0, 0xF0, 0x01,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x81, 0xE0, 0x70,
  0x3C, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x38, 0x00, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x00, 0x06, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x07, 0xF0, 0x3F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0x01, 0x00, 0x00,
  0x0F, 0xE1, 0xFF, 0x3F, 0xF1, 0x8F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80,
  0x0F, 0x8F, 0x00, 0x70, 0x0E, 0x03, 0x80, 0x18, 0x1C, 0x00, 0x70, 0xE0,
  0x01, 0xC3, 0x01, 0x03, 0x1C, 0x3F, 0x8C, 0x61, 0xFE, 0x33, 0x8E, 0x38,
  0xCC, 0x30, 0xC7, 0x71, 0xC7, 0x1D, 0xC7, 0x1C, 0x76, 0x38, 0x71, 0xD8,
  0xE1, 0x86, 0xE3, 0x8E, 0x3B, 0x8E, 0x38, 0xEE, 0x30, 0xE3, 0x38, 0xC7,
  0x1C, 0xE3, 0x9E, 0x63, 0x8F, 0xFF, 0x8E, 0x3E, 0x7C, 0x38, 0x20, 0x40,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xB8, 0x01, 0xDC, 0x01, 0xEE, 0x00,
  0xE7, 0x00, 0x73, 0x80, 0x79, 0xC0, 0x38, 0xE0, 0x3C, 0xF0, 0x1E, 0x78,
  0x0E, 0x3C, 0x0F, 0x1E, 0x07, 0x0F, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xF0, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x0F, 0x3C,
  0x07, 0x9E, 0x03, 0xDE, 0x01, 0xFF, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x1E, 0x3E, 0x07, 0x87, 0x81, 0xC0, 0xF0, 0xF0, 0x3C,
  0x3C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x7C, 0x1F,
  0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x70, 0xF8, 0x3C, 0x1E, 0x0F, 0x03,
  0x83, 0xC0, 0xE0, 0xE0, 0x38, 0x38, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1,
  0xE0, 0xF0, 0x70, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFC, 0x60, 0x78, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x30, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0x87, 0xC1, 0xC0,
  0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xE0, 0x3C,
  0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x1E, 0x3C,
  0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x38, 0x0F, 0x1E, 0x07,
  0x87, 0x83, 0xE1, 0xE1, 0xF0, 0x71, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x04, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3E, 0x0C, 0x07, 0xC0, 0x40, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x83, 0xF8, 0x78, 0x3F, 0x87, 0x83, 0xF8, 0x70, 0x07,
  0x8F, 0x00, 0x70, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x07, 0x00,
  0xF0, 0x78, 0x0E, 0x07, 0x81, 0xE0, 0x7C, 0x1E, 0x03, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0xFF, 0x80, 0x03, 0xC0, 0x70, 0x38, 0x0F, 0x07, 0x80, 0xF0,
  0x78, 0x0F, 0x07, 0x80, 0xE0, 0x70, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E,
  0x0F, 0x01, 0xE0, 0xF0, 0x1C, 0x0E, 0x03, 0xC1, 0xE0, 0x3C, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xC0,
  0x78, 0x3C, 0x07, 0x03, 0x80, 0x70, 0x38, 0x0F, 0x07, 0x80, 0xF0, 0x78,
  0x0F, 0x07, 0x80, 0xE0, 0x70, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F,
  0x01, 0xE0, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0xF0, 0x38, 0x1E, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x07, 0x87, 0x80, 0x70,
  0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0x80, 0x0E,
  0x78, 0x01, 0xEF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0x87, 0x00,
  0x38, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x70, 0x78,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x70, 0x1E,
  0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0x7F,
  0x01, 0xDC, 0x0F, 0xE0, 0x3F, 0x81, 0xDC, 0x0F, 0xF0, 0x3B, 0x81, 0xDE,
  0x0F, 0x70, 0x7B, 0x81, 0xEE, 0x0E, 0x70, 0x3D, 0xC3, 0xDE, 0x07, 0x38,
  0x73, 0xC0, 0xE7, 0x0E, 0x70, 0x3C, 0xE3, 0x8E, 0x07, 0x9C, 0x73, 0xC0,
  0xE3, 0xDC, 0x78, 0x1C, 0x7B, 0x8F, 0x03, 0x8F, 0xF1, 0xC0, 0xF1, 0xFC,
  0x38, 0x1E, 0x1F, 0x8F, 0x03, 0x83, 0xE1, 0xE0, 0x70, 0x7C, 0x3C, 0x1E,
  0x0F, 0x07, 0x03, 0xC1, 0xE0, 0xE0, 0x78, 0x38, 0x3C, 0x00, 0x03, 0xC0,
  0x3C, 0x0F, 0x00, 0xE0, 0x7C, 0x03, 0x81, 0xF8, 0x1E, 0x07, 0xE0, 0x78,
  0x1F, 0x81, 0xC0, 0xFE, 0x07, 0x03, 0xF8, 0x3C, 0x0E, 0xE0, 0xF0, 0x3B,
  0xC3, 0xC0, 0xE7, 0x0E, 0x07, 0x9C, 0x38, 0x1E, 0x71, 0xE0, 0x79, 0xC7,
  0x81, 0xC7, 0x1E, 0x07, 0x1E, 0x70, 0x3C, 0x39, 0xC0, 0xF0, 0xEF, 0x03,
  0x83, 0xBC, 0x0E, 0x0E, 0xE0, 0x38, 0x3B, 0x81, 0xE0, 0xFE, 0x07, 0x81,
  0xF8, 0x1C, 0x07, 0xE0, 0x70, 0x1F, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xF0,
  0x3C, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0x1F,
  0x07, 0x83, 0xC3, 0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x07, 0x3C, 0x01, 0xCF,
  0x00, 0xF3, 0xC0, 0x3C, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x80,
  0x3D, 0xE0, 0x0E, 0x78, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x07, 0x87, 0x01, 0xE1, 0xE0, 0xF0, 0x7C, 0x7C, 0x1F,
  0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0x01, 0xFF,
  0xC0, 0xF7, 0xF0, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F,
  0x07, 0x87, 0x83, 0xC3, 0x81, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF1, 0xF0,
  0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x3F,
  0xF8, 0x1F, 0x1F, 0x07, 0x83, 0xC3, 0xC0, 0xF1, 0xE0, 0x3C, 0x78, 0x07,
  0x3C, 0x01, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xE0, 0x0F, 0x78, 0x03, 0xDE,
  0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x07, 0xBC, 0x01, 0xEF, 0x00,
  0x7B, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x87, 0x01, 0xE1, 0xE0, 0xF0,
  0x7C, 0x7C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x03, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xF3, 0xF0, 0x78, 0x78,
  0x38, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0x83,
  0xC3, 0xC1, 0xE1, 0xE1, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x1E, 0x03, 0x87, 0x03, 0xC3, 0xC1,
  0xE1, 0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x1C, 0x3C, 0x0F, 0x1E, 0x07,
  0x80, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0x9C, 0x07, 0x81,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC2, 0x01, 0xE0, 0x70, 0xF8, 0x3F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0x07, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07,
  0x87, 0x80, 0xE0, 0xF0, 0x3C, 0x1C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1C,
  0x1E, 0x03, 0x83, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x70,
  0x78, 0x1E, 0x0E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xC1,
  0xE0, 0x78, 0x38, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x38, 0x3C, 0x0F, 0x07,
  0x81, 0xE0, 0x78, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x00,
  0xF0, 0x07, 0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xCF, 0x01, 0xE7, 0x80,
  0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1C, 0x1E,
  0x1E, 0x0F, 0x0E, 0x03, 0x8F, 0x01, 0xC7, 0x80, 0xE7, 0x80, 0x73, 0xC0,
  0x39, 0xC0, 0x1D, 0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x0E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3B, 0xC0, 0xF8,
  0x1E, 0xF0, 0x3E, 0x07, 0x3C, 0x0F, 0x83, 0xCF, 0x07, 0xE0, 0xF3, 0xC1,
  0xF8, 0x38, 0xF0, 0xEE, 0x1E, 0x3C, 0x3B, 0x87, 0x8F, 0x0E, 0xE3, 0xC3,
  0xC7, 0x38, 0xF0, 0xF1, 0xDC, 0x38, 0x3C, 0xF7, 0x1E, 0x0F, 0x39, 0xC7,
  0x83, 0x8E, 0x73, 0xC0, 0xE7, 0x1C, 0xF0, 0x39, 0xC7, 0x38, 0x0E, 0xF1,
  0xDE, 0x03, 0xB8, 0x77, 0x80, 0xEE, 0x1D, 0xC0, 0x3F, 0x07, 0xF0, 0x0F,
  0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1E,
  0x01, 0xC1, 0xE0, 0x1C, 0x3C, 0x01, 0xC3, 0xC0, 0x1E, 0x78, 0x01, 0xE7,
  0x00, 0x1E, 0xF0, 0x01, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3B, 0x80, 0x07, 0xB8, 0x00, 0x73, 0x80, 0x0F, 0x38, 0x01,
  0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0x83, 0xC0,
  0x70, 0x3C, 0x0F, 0x01, 0xC0, 0xF0, 0x1E, 0xE0, 0x39, 0xC0, 0xF3, 0x81,
  0xC7, 0x07, 0x8F, 0x0E, 0x1E, 0x3C, 0x3C, 0x70, 0x79, 0xE0, 0xF3, 0x80,
  0xEF, 0x01, 0xDC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF,
  0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x00, 0xE1, 0xC3, 0x87, 0x8F, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0xC7, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xF1, 0xE3, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x78, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xBC,
  0x07, 0x1C, 0x07, 0x1C, 0x0E, 0x1C, 0x1E, 0x1E, 0x1C, 0x0E, 0x3C, 0x0E,
  0x38, 0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF3,
  0xC7, 0x1E, 0x38, 0xF0, 0x07, 0xE7, 0x0F, 0xEF, 0x1F, 0xFE, 0x1E, 0x3E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x1C, 0x70, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78,
  0xF0, 0xF0, 0xF1, 0xF0, 0xFF, 0x70, 0x7F, 0x70, 0x3E, 0x70, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x7C, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0x8F,
  0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F,
  0x3C, 0x0E, 0x38, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x3C,
  0x78, 0x3C, 0x7C, 0x78, 0xFF, 0xF0, 0xEF, 0xE0, 0xE7, 0xC0, 0x03, 0xF8,
  0x3F, 0xC3, 0xFC, 0x3C, 0x23, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x84, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x01, 0xFB, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x1E, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x1C, 0x1E,
  0x07, 0x07, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x38, 0x3C, 0x0E, 0x0F, 0x03,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x0F, 0x1F, 0x03, 0xFF, 0xC0,
  0x7F, 0x70, 0x0F, 0x9C, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0x8F,
  0x3C, 0x3C, 0xE0, 0xF7, 0x83, 0x9E, 0x1E, 0x70, 0xF3, 0xFF, 0x8F, 0xFC,
  0x3F, 0x80, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0,
  0x87, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x20, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF9, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1E, 0x3E,
  0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x1C, 0x1E, 0x07, 0x07,
  0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x0F, 0x1F, 0x03, 0xFD, 0xC0, 0x7F, 0xF0,
  0x1F, 0xBC, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x0C, 0x1F, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x7C, 0x0E, 0xFE, 0x0F, 0xFE, 0x0F,
  0x8F, 0x1F, 0x0F, 0x1E, 0x0E, 0x1E, 0x0E, 0x1C, 0x1E, 0x1C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1C, 0x3C, 0x1C, 0x38, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78,
  0x38, 0x70, 0x38, 0x70, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0xF0, 0x70, 0x03,
  0x81, 0xC1, 0xE0, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x83, 0x81,
  0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1,
  0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x87, 0xC3, 0xC3, 0x81, 0xC3, 0xC0, 0xE3, 0xC0,
  0xF3, 0xC0, 0x79, 0xC0, 0x39, 0xE0, 0x1D, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xEF, 0x00, 0xE7, 0x80, 0xF1, 0xC0, 0x78,
  0xE0, 0x38, 0x78, 0x1C, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC0,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03,
  0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0,
  0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0,
  0x3C, 0x00, 0x0E, 0x7C, 0x7C, 0x0E, 0xFE, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0x1F, 0x8F, 0x1F, 0x0F, 0x0F, 0x1E, 0x0E, 0x0E, 0x1E, 0x1E, 0x0E, 0x1C,
  0x1E, 0x0E, 0x1C, 0x1E, 0x1E, 0x3C, 0x1C, 0x1E, 0x3C, 0x1C, 0x1C, 0x38,
  0x3C, 0x1C, 0x38, 0x3C, 0x3C, 0x78, 0x38, 0x3C, 0x78, 0x38, 0x3C, 0x78,
  0x38, 0x38, 0x70, 0x78, 0x38, 0x70, 0x78, 0x78, 0xF0, 0x70, 0x78, 0xF0,
  0x70, 0x70, 0xF0, 0xF0, 0x70, 0x0E, 0x7C, 0x0E, 0xFE, 0x0F, 0xFE, 0x0F,
  0x8F, 0x1F, 0x0E, 0x1E, 0x0E, 0x1E, 0x0E, 0x1C, 0x1E, 0x1C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78,
  0x38, 0x70, 0x38, 0x70, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0x03,
  0xF0, 0x3F, 0xE0, 0xFF, 0xC7, 0x8F, 0x3C, 0x1C, 0xE0, 0x77, 0x81, 0xDE,
  0x07, 0x70, 0x1D, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xEE,
  0x07, 0xBC, 0x1E, 0xF0, 0xF3, 0xC7, 0xC7, 0xFE, 0x1F, 0xF0, 0x3F, 0x80,
  0x03, 0x9F, 0x00, 0xEF, 0xE0, 0x3F, 0xFC, 0x0F, 0x8F, 0x07, 0xC3, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0F, 0x07, 0x03, 0xC3, 0xC0, 0xF0, 0xF0,
  0x38, 0x38, 0x0E, 0x0E, 0x07, 0x83, 0x81, 0xE1, 0xE0, 0x70, 0x78, 0x3C,
  0x1E, 0x0E, 0x07, 0xC7, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3D, 0xF0, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE7, 0x0F, 0xFF,
  0x0F, 0xFE, 0x1E, 0x3E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1C,
  0x78, 0x1C, 0x70, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x38, 0xF0, 0x78,
  0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF1, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0,
  0x7E, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x0E, 0x78, 0x77, 0xC3,
  0xFC, 0x1F, 0xA1, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0xC7, 0xFE,
  0x78, 0x23, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE4, 0x1E,
  0x3F, 0xF1, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E,
  0x07, 0xF7, 0xFD, 0xFF, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03,
  0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xF8,
  0xFE, 0x1F, 0x80, 0x1E, 0x0F, 0x1C, 0x0E, 0x1C, 0x1E, 0x1C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x3C, 0x78, 0x3C, 0x78, 0x38, 0x78,
  0x38, 0x70, 0x38, 0x70, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF1, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7C, 0xE0, 0xF0, 0x3F, 0xC0,
  0xEF, 0x07, 0xBC, 0x1C, 0xF0, 0xF3, 0xC3, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xC3, 0xCF, 0x07, 0x38, 0x1D, 0xE0, 0x77, 0x01, 0xDC, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x78,
  0x3F, 0xC1, 0xE0, 0xEF, 0x0F, 0x87, 0xBC, 0x3E, 0x1E, 0xF1, 0xF8, 0x73,
  0xC7, 0xE3, 0xCF, 0x1F, 0x8E, 0x3C, 0xEE, 0x78, 0xF3, 0xB9, 0xE3, 0xDC,
  0xE7, 0x0F, 0x73, 0xBC, 0x3D, 0xCE, 0xE0, 0xEE, 0x3B, 0x83, 0xB8, 0xFE,
  0x0E, 0xC3, 0xF0, 0x3F, 0x0D, 0xC0, 0xFC, 0x3E, 0x03, 0xE0, 0xF8, 0x0F,
  0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0x87, 0xC1, 0xE1,
  0xE0, 0x78, 0xF0, 0x0E, 0x38, 0x03, 0x9E, 0x00, 0xE7, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xF7, 0x00, 0x39, 0xC0, 0x1E, 0x70, 0x0F, 0x1E,
  0x03, 0x87, 0x81, 0xE1, 0xE0, 0xF0, 0x38, 0x00, 0x07, 0x81, 0xE0, 0x70,
  0x38, 0x0E, 0x0F, 0x01, 0xC1, 0xC0, 0x38, 0x78, 0x07, 0x0F, 0x00, 0xE1,
  0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0x73, 0xC0, 0x0E, 0x70, 0x01, 0xCE,
  0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x1C, 0x01,
  0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x1F,
  0x80, 0xFC, 0x03, 0xC0, 0x0F, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x01,
  0xF0, 0x1F, 0x80, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x3F,
  0x00, 0xFC, 0x03, 0xC0, 0x00, 0x3F, 0x01, 0x7F, 0xC7, 0xFF, 0xFF, 0xC1,
  0xFE, 0x80, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 28, 9, 0, -28 },
  { 36, 12, 10, 14, 4, -28 },
  { 51, 18, 28, 17, 0, -28 },
  { 114, 16, 32, 16, 0, -30 },
  { 178, 22, 28, 25, 2, -28 },
  { 255, 17, 28, 18, 0, -28 },
  { 315, 5, 10, 8, 4, -28 },
  { 322, 12, 34, 10, 1, -28 },
  { 373, 12, 34, 10, -3, -28 },
  { 424, 12, 14, 15, 4, -30 },
  { 445, 14, 18, 17, 2, -23 },
  { 477, 8, 10, 8, -2, -5 },
  { 487, 9, 3, 10, 1, -12 },
  { 491, 5, 5, 8, 0, -5 },
  { 495, 19, 28, 13, -2, -28 },
  { 562, 15, 28, 16, 1, -28 },
  { 615, 11, 28, 16, 4, -28 },
  { 654, 17, 28, 16, -1, -28 },
  { 714, 17, 28, 16, -1, -28 },
  { 774, 17, 28, 16, -1, -28 },
  { 834, 16, 28, 16, 0, -28 },
  { 890, 16, 28, 16, 1, -28 },
  { 946, 17, 28, 16, 1, -28 },
  { 1006, 16, 28, 16, 0, -28 },
  { 1062, 16, 28, 16, 0, -28 },
  { 1118, 8, 21, 8, 0, -21 },
  { 1139, 10, 26, 8, -2, -21 },
  { 1172, 15, 18, 17, 1, -23 },
  { 1206, 14, 11, 17, 2, -19 },
  { 1226, 15, 18, 17, 2, -23 },
  { 1260, 12, 28, 12, 1, -28 },
  { 1302, 22, 31, 24, 1, -28 },
  { 1388, 17, 28, 17, -3, -28 },
  { 1448, 18, 28, 17, 0, -28 },
  { 1511, 17, 28, 16, 1, -28 },
  { 1571, 18, 28, 19, 0, -28 },
  { 1634, 16, 28, 15, 0, -28 },
  { 1690, 16, 28, 14, 0, -28 },
  { 1746, 20, 28, 20, 1, -28 },
  { 1816, 20, 28, 19, 0, -28 },
  { 1886, 16, 28, 11, -2, -28 },
  { 1942, 16, 36, 8, -6, -28 },
  { 2014, 20, 28, 16, 0, -28 },
  { 2084, 11, 28, 14, 0, -28 },
  { 2123, 27, 28, 26, 0, -28 },
  { 2218, 22, 28, 21, 0, -28 },
  { 2295, 18, 28, 20, 1, -28 },
  { 2358, 17, 28, 16, 0, -28 },
  { 2418, 18, 35, 20, 1, -28 },
  { 2497, 17, 28, 17, 0, -28 },
  { 2557, 18, 28, 15, -1, -28 },
  { 2620, 14, 28, 14, 3, -28 },
  { 2669, 19, 28, 19, 1, -28 },
  { 2736, 17, 28, 16, 3, -28 },
  { 2796, 26, 28, 26, 3, -28 },
  { 2887, 20, 28, 15, -2, -28 },
  { 2957, 15, 28, 15, 3, -28 },
  { 3010, 18, 28, 14, -2, -28 },
  { 3073, 15, 34, 11, -1, -28 },
  { 3137, 7, 28, 14, 4, -28 },
  { 3162, 15, 34, 11, -3, -28 },
  { 3226, 16, 16, 16, 0, -28 },
  { 3258, 12, 3, 12, -3, 3 },
  { 3263, 6, 6, 10, 6, -30 },
  { 3268, 16, 21, 17, 1, -21 },
  { 3310, 16, 30, 17, 0, -30 },
  { 3370, 13, 21, 13, 1, -21 },
  { 3405, 18, 30, 17, 1, -30 },
  { 3473, 14, 21, 15, 1, -21 },
  { 3510, 19, 39, 10, -5, -30 },
  { 3603, 18, 30, 17, -1, -21 },
  { 3671, 16, 30, 17, 0, -30 },
  { 3731, 9, 29, 8, 0, -29 },
  { 3764, 15, 38, 8, -5, -29 },
  { 3836, 17, 30, 15, 0, -30 },
  { 3900, 10, 30, 8, 0, -30 },
  { 3938, 24, 21, 25, 0, -21 },
  { 4001, 16, 21, 17, 0, -21 },
  { 4043, 14, 21, 16, 1, -21 },
  { 4080, 18, 30, 17, -2, -21 },
  { 4148, 16, 30, 17, 1, -21 },
  { 4208, 13, 21, 11, 0, -21 },
  { 4243, 13, 21, 13, 0, -21 },
  { 4278, 10, 26, 10, 1, -26 },
  { 4311, 16, 21, 17, 1, -21 },
  { 4353, 14, 21, 14, 2, -21 },
  { 4390, 22, 21, 22, 2, -21 },
  { 4448, 18, 21, 14, -2, -21 },
  { 4496, 19, 30, 14, -3, -21 },
  { 4568, 14, 21, 12, -1, -21 },
  { 4605, 14, 34, 13, 1, -28 },
  { 4665, 4, 39, 14, 5, -30 },
  { 4685, 14, 34, 13, -2, -28 },
  { 4745, 16, 5, 17, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC39PT7B_H_
