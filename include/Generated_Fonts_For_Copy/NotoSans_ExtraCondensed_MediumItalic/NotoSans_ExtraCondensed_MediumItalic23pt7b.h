#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC23PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0x86, 0x18, 0xE3, 0x0C, 0x30, 0xC6, 0x00, 0x01, 0x8E,
  0x38, 0x66, 0xCD, 0xB2, 0x6C, 0xD9, 0x80, 0x06, 0x40, 0x98, 0x33, 0x06,
  0x43, 0xFE, 0x7F, 0x86, 0x40, 0x98, 0x33, 0x1F, 0xF3, 0xFE, 0x13, 0x06,
  0x40, 0xD8, 0x13, 0x06, 0x40, 0x02, 0x01, 0xC1, 0xFC, 0xEA, 0x34, 0x0D,
  0x03, 0x40, 0xF0, 0x1E, 0x03, 0xC0, 0xB0, 0x2C, 0x0B, 0x25, 0xCF, 0xE1,
  0xF0, 0x10, 0x0C, 0x00, 0x18, 0x11, 0xE3, 0x1B, 0x18, 0xD9, 0x84, 0xCC,
  0x66, 0xC3, 0x36, 0x19, 0x6E, 0xDA, 0x5F, 0xB6, 0xD9, 0x26, 0x1B, 0x30,
  0x99, 0x8C, 0xC8, 0x46, 0xC6, 0x34, 0x61, 0xE0, 0x06, 0x03, 0xE1, 0x98,
  0x66, 0x19, 0x86, 0xC1, 0xB0, 0x78, 0x1C, 0x0F, 0x36, 0xEF, 0x1E, 0xC7,
  0xB1, 0xCC, 0x73, 0xFC, 0x7B, 0x80, 0x76, 0x66, 0xCC, 0x03, 0x06, 0x0C,
  0x0C, 0x18, 0x38, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0,
  0xC0, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x04, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0xE1, 0x83, 0x0C, 0x18, 0x60, 0xC3, 0x0C,
  0x00, 0x10, 0x18, 0x58, 0xFE, 0x3F, 0x38, 0xEC, 0x4C, 0x08, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x87, 0xFF, 0xFE, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x33,
  0x66, 0x4C, 0x7F, 0xE0, 0x7F, 0x80, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0xC0, 0x00, 0x02, 0x07, 0xC7, 0x63, 0x33, 0x19,
  0x8C, 0xC6, 0xC3, 0x61, 0xB1, 0xD8, 0xCC, 0x66, 0x37, 0x31, 0x98, 0xF8,
  0x78, 0x00, 0x0E, 0x79, 0xF7, 0x65, 0xC3, 0x06, 0x0C, 0x18, 0x60, 0xC1,
  0x83, 0x0E, 0x18, 0x30, 0x03, 0x03, 0xF1, 0xDC, 0x23, 0x00, 0xC0, 0x30,
  0x1C, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x03, 0xFC,
  0xFF, 0x00, 0x06, 0x1F, 0xC4, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x0E, 0x1C,
  0x07, 0x01, 0xC0, 0x60, 0x30, 0x3A, 0x19, 0xFC, 0xF8, 0x00, 0x01, 0x80,
  0xC0, 0xE0, 0xF0, 0x58, 0x78, 0x6C, 0x26, 0x33, 0x33, 0x91, 0x98, 0xDF,
  0xF0, 0x30, 0x30, 0x18, 0x0C, 0x00, 0x1F, 0xC7, 0xE1, 0x80, 0xC0, 0x30,
  0x0C, 0x03, 0xE1, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x21, 0x8F,
  0xE3, 0xE0, 0x03, 0x87, 0xC7, 0x06, 0x03, 0x03, 0x01, 0x81, 0xBC, 0xF6,
  0x63, 0xB1, 0xD8, 0xCC, 0x66, 0x33, 0x39, 0xF8, 0x78, 0x00, 0x7F, 0xBF,
  0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07,
  0x03, 0x03, 0x81, 0x80, 0x07, 0x07, 0xE1, 0x98, 0xC7, 0x31, 0x8C, 0x63,
  0xB8, 0x7C, 0x1C, 0x0F, 0x86, 0x73, 0x0C, 0xC3, 0x30, 0xCC, 0x73, 0xF8,
  0x7C, 0x00, 0x06, 0x0F, 0xC6, 0x66, 0x33, 0x1B, 0x8D, 0x86, 0xC7, 0x73,
  0x9E, 0xCE, 0xC0, 0x60, 0x70, 0x30, 0x39, 0xF8, 0xF8, 0x00, 0x11, 0xCE,
  0x20, 0x00, 0x00, 0x00, 0x19, 0xCC, 0x00, 0x08, 0x71, 0xC2, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x0C, 0x61, 0x8C, 0x30, 0x01, 0x83, 0xC7, 0x8F, 0x0E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x40, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x3C, 0x78, 0xF0, 0xE0,
  0x40, 0x00, 0x0C, 0x3F, 0x27, 0x03, 0x03, 0x06, 0x06, 0x0C, 0x18, 0x30,
  0x30, 0x20, 0x00, 0x00, 0x60, 0xE0, 0xE0, 0x01, 0x80, 0x3F, 0x03, 0x0C,
  0x20, 0x23, 0x01, 0xB1, 0xED, 0x12, 0x69, 0x93, 0xC9, 0x94, 0xCC, 0xA6,
  0x4D, 0x36, 0x49, 0xB6, 0x4E, 0xE2, 0x00, 0x10, 0x00, 0xC0, 0x03, 0xB8,
  0x0F, 0x80, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0xD8, 0x6C, 0x36, 0x33, 0x19,
  0x9F, 0xCF, 0xEE, 0x36, 0x1B, 0x0F, 0x07, 0x83, 0x1F, 0x86, 0x71, 0x8C,
  0x63, 0x38, 0xCC, 0x73, 0x38, 0xF8, 0x33, 0x9C, 0x66, 0x19, 0x86, 0x63,
  0x98, 0xCF, 0xF3, 0xF0, 0x03, 0x03, 0xF1, 0xC8, 0xE0, 0x30, 0x18, 0x06,
  0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x83, 0xF8, 0x63, 0x0C, 0x73, 0x8E, 0x61, 0xCC, 0x39,
  0x86, 0x30, 0xCE, 0x19, 0x87, 0x30, 0xC6, 0x38, 0xCE, 0x3F, 0x87, 0xE0,
  0x1F, 0xC7, 0xE1, 0x80, 0x60, 0x38, 0x0C, 0x03, 0xF0, 0xFC, 0x30, 0x1C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x0F, 0xE3, 0xF0, 0x1F, 0xC7, 0xE1, 0x80,
  0x60, 0x38, 0x0C, 0x03, 0x00, 0xFC, 0x3F, 0x1C, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x0E, 0x03, 0x00, 0x03, 0x81, 0xFC, 0x71, 0x1C, 0x03, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0xC3, 0xD8, 0xFB, 0x06, 0x60, 0xCC, 0x19, 0x83, 0x38,
  0xC3, 0xF8, 0x3F, 0x00, 0x1C, 0x31, 0x87, 0x18, 0x61, 0x86, 0x38, 0x63,
  0x06, 0x3F, 0xE3, 0xFC, 0x30, 0xC7, 0x0C, 0x61, 0xC6, 0x18, 0x61, 0x86,
  0x18, 0xC1, 0x8C, 0x38, 0x1F, 0x83, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x38, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x81, 0xE1, 0xF8, 0x03, 0x81,
  0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x2C, 0x1E, 0x0C, 0x00, 0x1C, 0x71,
  0x8C, 0x19, 0xC1, 0x98, 0x3B, 0x03, 0x70, 0x36, 0x03, 0xE0, 0x3E, 0x07,
  0x60, 0x66, 0x06, 0x60, 0x67, 0x06, 0x30, 0xC3, 0x0C, 0x30, 0x1C, 0x30,
  0x60, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xE1, 0x83, 0x06, 0x0C, 0x3F, 0xFE,
  0x1C, 0x0F, 0x1C, 0x0E, 0x1C, 0x1E, 0x1E, 0x1E, 0x36, 0x36, 0x36, 0x3E,
  0x36, 0x2C, 0x36, 0x6C, 0x36, 0x6C, 0x66, 0xCC, 0x66, 0xD8, 0x67, 0x98,
  0x67, 0x98, 0x67, 0x18, 0xC7, 0x18, 0xC6, 0x30, 0x1C, 0x38, 0xE1, 0x87,
  0x0C, 0x3C, 0x63, 0x63, 0x1B, 0x30, 0xD9, 0x86, 0xCC, 0x32, 0x63, 0x1B,
  0x18, 0xF0, 0xC7, 0x86, 0x3C, 0x31, 0xE3, 0x07, 0x18, 0x30, 0x03, 0x03,
  0xF1, 0xDC, 0xC3, 0x70, 0xD8, 0x36, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x1F,
  0x06, 0xC1, 0xB0, 0xEC, 0x73, 0xF8, 0x7C, 0x00, 0x1F, 0x87, 0xF1, 0x8C,
  0x63, 0x38, 0xCC, 0x33, 0x1C, 0xCE, 0x3F, 0x1F, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x0C, 0x03, 0x00, 0x03, 0x03, 0xF1, 0xDC, 0xC3, 0x70, 0xD8, 0x36,
  0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x1F, 0x06, 0xC1, 0xB0, 0xEC, 0x73, 0xF8,
  0x7C, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x00, 0x1F, 0x86, 0xF1, 0x8C, 0x63,
  0x38, 0xCC, 0x73, 0x18, 0xFE, 0x3E, 0x1D, 0x86, 0x61, 0x98, 0x67, 0x19,
  0xCC, 0x33, 0x0C, 0x03, 0x81, 0xFC, 0x7B, 0x0C, 0x01, 0x80, 0x30, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x10, 0xC3,
  0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60,
  0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0x38, 0xE6, 0x18, 0xC3, 0x18,
  0x67, 0x0C, 0xC3, 0x98, 0x63, 0x0C, 0xE1, 0x98, 0x73, 0x0C, 0x61, 0x8C,
  0x31, 0x8E, 0x3F, 0x83, 0xE0, 0xC1, 0xF0, 0x6C, 0x33, 0x0C, 0xC7, 0x31,
  0x8C, 0xE3, 0x30, 0xCC, 0x36, 0x0D, 0x83, 0xE0, 0xF0, 0x3C, 0x0E, 0x03,
  0x80, 0xC3, 0x87, 0x86, 0x1B, 0x0C, 0x36, 0x38, 0xEC, 0x51, 0x99, 0xA3,
  0x33, 0x4C, 0x64, 0x98, 0xDB, 0x31, 0xB6, 0xC3, 0xCD, 0x87, 0x9F, 0x0E,
  0x3C, 0x1C, 0x78, 0x38, 0xE0, 0x61, 0xC0, 0x1C, 0x70, 0xCE, 0x0C, 0xC0,
  0xD8, 0x0D, 0x80, 0xF0, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xE0, 0x1F, 0x03,
  0x30, 0x33, 0x06, 0x30, 0x63, 0x0C, 0x30, 0xC3, 0xE3, 0xB1, 0x9D, 0xC6,
  0xC3, 0xE1, 0xE0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01,
  0x80, 0x1F, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70,
  0x0C, 0x03, 0x00, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x3F, 0xC7, 0xF0, 0x07,
  0x87, 0xC3, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0x0F, 0x80, 0xCC,
  0x46, 0x66, 0x66, 0x66, 0x23, 0x33, 0x33, 0x30, 0x07, 0x87, 0xC0, 0x60,
  0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x06, 0x0F, 0x0F, 0x80, 0x06, 0x03, 0x83, 0xC3,
  0x61, 0xB1, 0x8D, 0x86, 0xC3, 0xC1, 0x80, 0xFE, 0xE6, 0x63, 0x08, 0x1E,
  0xDD, 0xEC, 0x6E, 0x36, 0x1B, 0x0D, 0x8E, 0xC6, 0x63, 0x33, 0x9F, 0xCF,
  0x40, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0xB1, 0xBC, 0xE6, 0x63, 0x31, 0x98,
  0xD8, 0x6C, 0x36, 0x3B, 0x1B, 0x8D, 0xFC, 0xDC, 0x00, 0x0C, 0x7D, 0xCB,
  0x0E, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0xC7, 0x80, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x4C, 0x3D, 0x8E, 0x71, 0x8C, 0x71, 0x8C, 0x31, 0x86,
  0x30, 0xC6, 0x31, 0xC6, 0x19, 0xC3, 0xF8, 0x7A, 0x00, 0x0C, 0x3E, 0x73,
  0x63, 0xC6, 0xCE, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0xFC, 0x7C, 0x00, 0x40,
  0x3C, 0x06, 0x81, 0x80, 0x30, 0x06, 0x83, 0xE0, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x81, 0x60, 0x3C, 0x02, 0x00, 0x02, 0x01, 0xEC, 0x77, 0x8C,
  0x63, 0x8C, 0x61, 0x8C, 0x31, 0x8E, 0x31, 0x8E, 0x30, 0xCE, 0x1F, 0xC3,
  0xF0, 0x06, 0x00, 0xC0, 0x38, 0xCE, 0x1F, 0x80, 0x40, 0x00, 0x1C, 0x0C,
  0x06, 0x03, 0x01, 0xB1, 0xBC, 0xE6, 0x63, 0x31, 0x98, 0xD8, 0xEC, 0x66,
  0x33, 0x1B, 0x8D, 0x8C, 0xC6, 0x00, 0x1C, 0x71, 0x80, 0x00, 0xE3, 0x0C,
  0x30, 0xC6, 0x18, 0x61, 0x8E, 0x30, 0xC0, 0x03, 0x81, 0xC0, 0xC0, 0x00,
  0x00, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70,
  0x30, 0x18, 0x0C, 0x06, 0x06, 0x0B, 0x07, 0x81, 0x00, 0x1C, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x4C, 0x63, 0x30, 0xDC, 0x36, 0x0F, 0x07, 0xC1, 0xF0,
  0x6E, 0x19, 0x8E, 0x63, 0x18, 0xC6, 0x00, 0x1C, 0x61, 0x86, 0x18, 0xE3,
  0x0C, 0x30, 0xC6, 0x18, 0x61, 0x8E, 0x30, 0xC0, 0x03, 0x18, 0xDF, 0xF3,
  0x9D, 0xCC, 0x63, 0x31, 0x8C, 0xC6, 0x66, 0x31, 0x98, 0xC6, 0x63, 0x19,
  0x8C, 0x6E, 0x73, 0x31, 0x8C, 0xC6, 0x30, 0x03, 0x1B, 0xCE, 0x66, 0x33,
  0x19, 0x8D, 0x8E, 0xC6, 0x63, 0x31, 0xB8, 0xD8, 0xCC, 0x60, 0x0C, 0x3E,
  0x77, 0x63, 0xE3, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6, 0xCE, 0xFC, 0x78, 0x01,
  0x86, 0xF1, 0xCC, 0x63, 0x18, 0xC6, 0x33, 0x0C, 0xC3, 0x30, 0xCC, 0x67,
  0x19, 0xFC, 0x6E, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x00, 0x04, 0x07,
  0xB3, 0xBC, 0xC6, 0x71, 0x98, 0x66, 0x19, 0x8E, 0x63, 0x38, 0xC6, 0x71,
  0xFC, 0x7E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x03, 0x36,
  0x3E, 0x38, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0x0C,
  0x3F, 0x32, 0x60, 0x70, 0x30, 0x38, 0x1C, 0x0C, 0x0C, 0x0C, 0xFC, 0xF8,
  0x10, 0xC3, 0x7E, 0x61, 0x86, 0x18, 0xC3, 0x0C, 0x30, 0xC3, 0x8E, 0x00,
  0x73, 0xB1, 0x98, 0xCC, 0x66, 0x36, 0x33, 0x19, 0x8C, 0xC6, 0x67, 0x3D,
  0x1F, 0x80, 0xC3, 0xC7, 0xC6, 0xC6, 0xCC, 0xCC, 0xD8, 0x58, 0x50, 0x70,
  0x70, 0x60, 0xC7, 0x1E, 0x39, 0xB3, 0xCD, 0x9E, 0x6C, 0xB6, 0x6D, 0xB3,
  0x6F, 0x1A, 0x78, 0xF3, 0xC7, 0x9C, 0x38, 0xE1, 0xC6, 0x00, 0x19, 0xC6,
  0x61, 0xB0, 0x7C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x36, 0x1D, 0x86, 0x63,
  0x1C, 0x1C, 0x61, 0x8C, 0x33, 0x06, 0x60, 0xD8, 0x1B, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x05, 0x80, 0xF0,
  0x08, 0x00, 0x1F, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30,
  0x30, 0x1F, 0x9F, 0x80, 0x07, 0x83, 0x83, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x30, 0x38, 0x30, 0x3C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x18,
  0x0E, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x1E, 0x06,
  0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0E, 0x03, 0x0F, 0x1C, 0x18, 0x18, 0x18,
  0x30, 0x30, 0x70, 0xE0, 0x80, 0x60, 0xFE, 0xE3, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 16, 6, 0, -16 },
  { 13, 7, 6, 8, 2, -16 },
  { 19, 11, 16, 10, 0, -16 },
  { 41, 10, 18, 9, 0, -17 },
  { 64, 13, 17, 15, 1, -17 },
  { 92, 10, 17, 10, 0, -17 },
  { 114, 4, 6, 5, 2, -16 },
  { 117, 8, 21, 6, 0, -17 },
  { 138, 7, 21, 6, -2, -17 },
  { 157, 8, 9, 9, 2, -18 },
  { 166, 9, 11, 10, 1, -14 },
  { 179, 4, 6, 5, -1, -3 },
  { 182, 6, 2, 6, 0, -7 },
  { 184, 3, 3, 5, 0, -3 },
  { 186, 11, 17, 8, -1, -17 },
  { 210, 9, 17, 9, 0, -17 },
  { 230, 7, 16, 9, 2, -16 },
  { 244, 10, 17, 9, -1, -17 },
  { 266, 9, 17, 9, 0, -17 },
  { 286, 9, 17, 9, 0, -17 },
  { 306, 10, 16, 9, 0, -16 },
  { 326, 9, 17, 9, 1, -17 },
  { 346, 9, 16, 9, 1, -16 },
  { 364, 10, 17, 9, 0, -17 },
  { 386, 9, 17, 9, 0, -17 },
  { 406, 5, 13, 5, 0, -13 },
  { 415, 6, 16, 5, -1, -13 },
  { 427, 9, 10, 10, 1, -13 },
  { 439, 9, 6, 10, 1, -11 },
  { 446, 9, 10, 10, 1, -13 },
  { 458, 8, 17, 7, 0, -17 },
  { 475, 13, 19, 14, 1, -17 },
  { 506, 9, 16, 10, -1, -16 },
  { 524, 10, 16, 10, 0, -16 },
  { 544, 10, 17, 9, 1, -17 },
  { 566, 11, 16, 11, 0, -16 },
  { 588, 10, 16, 9, 0, -16 },
  { 608, 10, 16, 8, 0, -16 },
  { 628, 11, 17, 12, 1, -17 },
  { 652, 12, 16, 11, 0, -16 },
  { 676, 9, 16, 6, -1, -16 },
  { 694, 9, 21, 5, -3, -16 },
  { 718, 12, 16, 10, 0, -16 },
  { 742, 7, 16, 8, 0, -16 },
  { 756, 16, 16, 15, 0, -16 },
  { 788, 13, 16, 12, 0, -16 },
  { 814, 10, 17, 12, 1, -17 },
  { 836, 10, 16, 10, 0, -16 },
  { 856, 10, 21, 12, 1, -17 },
  { 883, 10, 16, 10, 0, -16 },
  { 903, 11, 17, 9, -1, -17 },
  { 927, 8, 16, 8, 2, -16 },
  { 943, 11, 16, 11, 1, -16 },
  { 965, 10, 16, 10, 2, -16 },
  { 985, 15, 16, 15, 2, -16 },
  { 1015, 12, 16, 9, -1, -16 },
  { 1039, 9, 16, 9, 2, -16 },
  { 1057, 11, 16, 8, -1, -16 },
  { 1079, 9, 21, 6, -1, -17 },
  { 1103, 4, 17, 8, 2, -17 },
  { 1112, 9, 21, 6, -2, -17 },
  { 1136, 9, 9, 9, 0, -16 },
  { 1147, 7, 1, 7, -2, 2 },
  { 1148, 4, 4, 6, 3, -18 },
  { 1150, 9, 13, 10, 1, -13 },
  { 1165, 9, 17, 10, 0, -17 },
  { 1185, 7, 13, 8, 1, -13 },
  { 1197, 11, 17, 10, 0, -17 },
  { 1221, 8, 13, 9, 1, -13 },
  { 1234, 11, 24, 6, -3, -18 },
  { 1267, 11, 19, 10, -1, -13 },
  { 1294, 9, 17, 10, 0, -17 },
  { 1314, 6, 17, 5, 0, -17 },
  { 1327, 9, 23, 5, -3, -17 },
  { 1353, 10, 17, 9, 0, -17 },
  { 1375, 6, 17, 5, 0, -17 },
  { 1388, 14, 13, 14, 0, -13 },
  { 1411, 9, 13, 10, 0, -13 },
  { 1426, 8, 13, 10, 1, -13 },
  { 1439, 10, 18, 10, -1, -13 },
  { 1462, 10, 19, 10, 0, -13 },
  { 1486, 8, 13, 7, 0, -13 },
  { 1499, 8, 13, 8, 0, -13 },
  { 1512, 6, 15, 6, 1, -15 },
  { 1524, 9, 12, 10, 1, -12 },
  { 1538, 8, 12, 8, 1, -12 },
  { 1550, 13, 12, 13, 1, -12 },
  { 1570, 10, 12, 8, -1, -12 },
  { 1585, 11, 18, 8, -2, -12 },
  { 1610, 9, 12, 7, -1, -12 },
  { 1624, 9, 20, 8, 0, -16 },
  { 1647, 2, 23, 8, 3, -18 },
  { 1653, 8, 20, 8, -1, -16 },
  { 1673, 9, 3, 10, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC23PT7B_H_
