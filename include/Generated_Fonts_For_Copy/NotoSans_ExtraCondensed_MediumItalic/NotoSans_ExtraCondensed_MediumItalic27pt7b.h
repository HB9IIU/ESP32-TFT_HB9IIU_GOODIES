#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC27PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0xC1, 0x83,
  0x00, 0x00, 0x00, 0x61, 0xC3, 0x80, 0x67, 0xE6, 0xE6, 0xCE, 0xCC, 0xCC,
  0xCC, 0x03, 0x30, 0x19, 0x81, 0x98, 0x0C, 0xC0, 0x66, 0x1F, 0xFC, 0xFF,
  0xC1, 0x98, 0x18, 0xC0, 0xCC, 0x06, 0x61, 0xFF, 0xCF, 0xFE, 0x19, 0x80,
  0x8C, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x33, 0x00, 0x00, 0x80, 0x20, 0x04,
  0x07, 0xF1, 0xFE, 0x36, 0x4E, 0x81, 0xD0, 0x3A, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x0B, 0x01, 0x60, 0x4C, 0x89, 0x9F, 0xF3, 0xFC, 0x3E, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x08, 0x00, 0x3C, 0x38, 0xD8, 0x61, 0xB1, 0x86,
  0x63, 0x0C, 0xCC, 0x19, 0x98, 0x63, 0x60, 0xC6, 0xCD, 0x9B, 0x3F, 0xF6,
  0xDB, 0xDB, 0x32, 0x36, 0x60, 0xCC, 0xC1, 0x99, 0x86, 0x63, 0x0C, 0xCC,
  0x31, 0x98, 0x63, 0xE1, 0x83, 0xC0, 0x01, 0x00, 0x7C, 0x0F, 0xC0, 0xCC,
  0x1C, 0xC1, 0xCC, 0x1D, 0xC1, 0xD8, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0x67,
  0x77, 0x6E, 0x7E, 0xE3, 0xCC, 0x3C, 0xC3, 0x8E, 0x7C, 0xFF, 0xC7, 0xCE,
  0x76, 0xEE, 0xCC, 0xC0, 0x03, 0x83, 0x81, 0x81, 0x81, 0xC0, 0xC0, 0xE0,
  0x70, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0C,
  0x1C, 0x18, 0x38, 0x30, 0x70, 0xE0, 0x0E, 0x06, 0x13, 0x0D, 0x9F, 0xF8,
  0xFC, 0xF0, 0xEC, 0x67, 0x11, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x3F, 0xFF, 0xFF, 0xFF, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x39,
  0x9C, 0xC6, 0x63, 0x00, 0x7F, 0xF8, 0x7F, 0x80, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x00, 0x02, 0x03, 0xE1, 0xFC, 0xE7, 0x31, 0xCC, 0x77, 0x1D, 0x87, 0x61,
  0xF8, 0x6E, 0x1B, 0x06, 0xC3, 0xB0, 0xEC, 0x33, 0x1C, 0xC6, 0x33, 0x8F,
  0xC1, 0xE0, 0x0E, 0x3C, 0xF3, 0xEC, 0xD3, 0x87, 0x0C, 0x18, 0x70, 0xE1,
  0xC3, 0x06, 0x1C, 0x38, 0x70, 0xC3, 0x80, 0x01, 0x80, 0x7E, 0x0F, 0xF0,
  0xC7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xFF, 0x8F,
  0xF8, 0x03, 0x01, 0xF8, 0x7F, 0x88, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06,
  0x03, 0x83, 0xE0, 0x7C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x90, 0xE3, 0xFC, 0x7E, 0x00, 0x00, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x6C,
  0x0F, 0x83, 0x70, 0xCC, 0x19, 0x86, 0x31, 0x8E, 0x31, 0xCC, 0x31, 0xFF,
  0xBF, 0xF0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x00, 0x0F, 0xE1, 0xFC, 0x70,
  0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xF8, 0x3F, 0x84, 0x70, 0x06, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x87, 0x1F, 0xC3, 0xF0, 0x00, 0x00,
  0xA0, 0xF8, 0x3F, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x6F, 0x1F,
  0xF3, 0xCE, 0x71, 0xCE, 0x39, 0x87, 0x30, 0xE6, 0x18, 0xC7, 0x1C, 0xE3,
  0xF8, 0x3E, 0x00, 0x3F, 0xE7, 0xFC, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03,
  0x80, 0x70, 0x0C, 0x03, 0x80, 0x00, 0x01, 0x01, 0xF8, 0x7F, 0x8C, 0x31,
  0x86, 0x70, 0xCE, 0x38, 0xC6, 0x1F, 0x81, 0xE0, 0x7C, 0x1D, 0xC7, 0x39,
  0xC3, 0x38, 0x76, 0x0C, 0xC1, 0x9C, 0x73, 0xFC, 0x3F, 0x00, 0x01, 0x01,
  0xF8, 0x7F, 0x0E, 0x73, 0x8E, 0x61, 0xCC, 0x39, 0x87, 0x70, 0xEE, 0x38,
  0xEF, 0x1F, 0x61, 0xDC, 0x03, 0x00, 0xE0, 0x1C, 0x07, 0x01, 0xC3, 0xF8,
  0x7C, 0x00, 0x08, 0x73, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3,
  0x8E, 0x00, 0x04, 0x1C, 0x38, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x86, 0x1C, 0x30, 0xE1, 0x83, 0x00, 0x00, 0x40, 0x30, 0x3C, 0x3E,
  0x3E, 0x3E, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0x00, 0x40,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x80, 0x30, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1C, 0x1F, 0x1F, 0x1F, 0x0F, 0x03, 0x00,
  0x80, 0x00, 0x04, 0x0F, 0xCF, 0xE4, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x06,
  0x06, 0x07, 0x03, 0x03, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x3C, 0x0C,
  0x00, 0x03, 0xF8, 0x0E, 0x38, 0x30, 0x30, 0xC0, 0x33, 0x00, 0x66, 0x3E,
  0xD8, 0xD9, 0xB3, 0x33, 0x44, 0x67, 0x98, 0xCF, 0x33, 0x16, 0x66, 0x6C,
  0xCC, 0xD1, 0xBB, 0x23, 0xFE, 0x47, 0x30, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x9C, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x03,
  0xF0, 0x37, 0x07, 0x70, 0x77, 0x06, 0x70, 0xE7, 0x0C, 0x71, 0xFF, 0x1F,
  0xF1, 0x87, 0x38, 0x73, 0x07, 0x70, 0x77, 0x07, 0xE0, 0x70, 0x0F, 0xE0,
  0xFF, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0x87, 0x18, 0x73, 0x8E, 0x3F, 0x83,
  0xFC, 0x31, 0xC3, 0x0E, 0x70, 0xE7, 0x0E, 0x60, 0xC6, 0x1C, 0xE3, 0x8F,
  0xF8, 0xFE, 0x00, 0x01, 0xC0, 0x7F, 0x0F, 0xE1, 0xC2, 0x38, 0x03, 0x80,
  0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x10, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0x7F,
  0x87, 0x1C, 0x38, 0x61, 0xC3, 0x8C, 0x1C, 0x60, 0xE7, 0x07, 0x38, 0x31,
  0xC3, 0x8C, 0x1C, 0x60, 0xE7, 0x06, 0x38, 0x71, 0xC3, 0x0C, 0x38, 0xE7,
  0x87, 0xF8, 0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x70, 0x0E, 0x01, 0xC0, 0x30,
  0x06, 0x01, 0xC0, 0x3F, 0x87, 0xF0, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0xE0, 0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x70, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0xF0, 0xFE, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x3F, 0xC3, 0xFE, 0x3C, 0x23, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x7D, 0xC7, 0xCE, 0x06, 0x70, 0x73, 0x83, 0x9C, 0x18,
  0xE0, 0xC3, 0x8E, 0x1F, 0xF0, 0x7F, 0x00, 0x0E, 0x1C, 0x30, 0x71, 0xC1,
  0xC7, 0x06, 0x1C, 0x38, 0x60, 0xE1, 0x83, 0x8E, 0x0C, 0x3F, 0xF0, 0xFF,
  0xC3, 0x07, 0x0C, 0x1C, 0x70, 0x61, 0xC1, 0x87, 0x0E, 0x18, 0x38, 0xE0,
  0xE3, 0x83, 0x0E, 0x1C, 0x00, 0x0F, 0xC5, 0xE0, 0x70, 0x1C, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80,
  0xE0, 0x38, 0x3F, 0x8F, 0xC0, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x3E,
  0x07, 0x80, 0x0E, 0x3C, 0x30, 0xC1, 0xC7, 0x07, 0x38, 0x1C, 0xC0, 0x67,
  0x01, 0xB8, 0x0E, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0C, 0xC0, 0x73,
  0x01, 0xCE, 0x06, 0x38, 0x18, 0xE0, 0xE1, 0x83, 0x86, 0x0E, 0x1C, 0x00,
  0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30,
  0x70, 0x70, 0x70, 0x60, 0xE0, 0xFF, 0xFE, 0x0F, 0x03, 0xE1, 0xE0, 0x78,
  0x7C, 0x0F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x36, 0x1F, 0x06, 0xC3, 0x61,
  0xD8, 0xFC, 0x3B, 0x1B, 0x86, 0x67, 0x60, 0xCC, 0xCC, 0x19, 0x99, 0x87,
  0x36, 0x70, 0xE6, 0xCE, 0x18, 0xF1, 0x83, 0x1E, 0x30, 0xE3, 0xCE, 0x1C,
  0x71, 0xC3, 0x0E, 0x38, 0x00, 0x0E, 0x0E, 0x1C, 0x1C, 0x78, 0x30, 0xF8,
  0x61, 0xB1, 0xC3, 0x63, 0x86, 0xC7, 0x1D, 0x8C, 0x3B, 0x18, 0x67, 0x70,
  0xC6, 0xE1, 0x8D, 0x87, 0x1B, 0x0E, 0x36, 0x18, 0x7C, 0x30, 0xF8, 0xE0,
  0xE1, 0xC1, 0xC3, 0x83, 0x80, 0x01, 0x00, 0x7E, 0x0F, 0xF1, 0xC7, 0x38,
  0x33, 0x83, 0x70, 0x37, 0x03, 0x70, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0E, 0xE0, 0xEE, 0x0C, 0xE1, 0xCE, 0x38, 0x7F, 0x03, 0xE0, 0x0F,
  0xC0, 0xFE, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0x87, 0x18, 0x73, 0x86, 0x38,
  0xE3, 0xFC, 0x3F, 0x83, 0xE0, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x7E, 0x0F, 0xF1, 0xC7, 0x38, 0x33,
  0x83, 0x70, 0x37, 0x03, 0x70, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0E, 0xE0, 0xEE, 0x0C, 0xE1, 0xCE, 0x38, 0x7F, 0x03, 0xE0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x0F, 0xC0, 0xFE, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0x87, 0x18, 0x63, 0x8E, 0x39, 0xE3, 0xFC, 0x3F, 0x03, 0x30,
  0x73, 0x07, 0x38, 0x63, 0x86, 0x38, 0xE3, 0x8E, 0x18, 0xE1, 0xC0, 0x00,
  0xC0, 0x3F, 0xC3, 0xFC, 0x1C, 0x21, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC2, 0x1C, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0xFF, 0xE1, 0xC0,
  0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70,
  0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x1C, 0x38, 0xC1, 0xCE,
  0x0C, 0x70, 0xE3, 0x87, 0x18, 0x39, 0xC1, 0x8E, 0x0C, 0x70, 0xE3, 0x07,
  0x18, 0x39, 0xC1, 0x8E, 0x0C, 0x70, 0xE3, 0x87, 0x1C, 0x30, 0xE3, 0x87,
  0xF8, 0x1F, 0x80, 0xE0, 0x7E, 0x0E, 0xE0, 0xCE, 0x1C, 0xE1, 0xCE, 0x18,
  0xE3, 0x8E, 0x30, 0xE7, 0x0E, 0x60, 0xEE, 0x0E, 0xE0, 0xEC, 0x0F, 0xC0,
  0xF8, 0x0F, 0x80, 0xF0, 0x07, 0x00, 0x70, 0x00, 0xE0, 0xC1, 0xF8, 0x70,
  0x7E, 0x1C, 0x1B, 0x87, 0x0E, 0xE3, 0xC3, 0x38, 0xF1, 0xCE, 0x3C, 0x73,
  0x9B, 0x18, 0xE6, 0xCE, 0x3B, 0x33, 0x0C, 0xCD, 0xC3, 0x33, 0x70, 0xD8,
  0xD8, 0x36, 0x3E, 0x0F, 0x8F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x38, 0x38,
  0x0E, 0x0E, 0x00, 0x07, 0x1C, 0x1C, 0x60, 0x73, 0x81, 0xCC, 0x03, 0x70,
  0x0D, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xF0,
  0x0F, 0xC0, 0x37, 0x01, 0xDC, 0x0E, 0x30, 0x38, 0xC1, 0xC3, 0x0E, 0x0E,
  0x00, 0xE1, 0xEC, 0x39, 0x8E, 0x31, 0xC6, 0x70, 0xCC, 0x1B, 0x83, 0xE0,
  0x7C, 0x0F, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x60, 0x0E, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x60, 0x0F, 0xF8, 0xFF, 0x00, 0x07, 0xE0, 0xF8,
  0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xF8, 0x3F, 0x00, 0xCC, 0xCC, 0xEE, 0x66, 0x66, 0x66, 0x77,
  0x33, 0x33, 0x30, 0x07, 0xC1, 0xF0, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18,
  0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06,
  0x03, 0x80, 0xC0, 0x30, 0x0C, 0x1F, 0x0F, 0xC0, 0x03, 0x00, 0x70, 0x1E,
  0x07, 0xC0, 0xD8, 0x33, 0x86, 0x31, 0x86, 0x70, 0xFC, 0x0C, 0xFF, 0xFF,
  0xEE, 0x63, 0x30, 0x0E, 0x63, 0xFC, 0xEF, 0x38, 0xE7, 0x1C, 0xC3, 0xB8,
  0x67, 0x0C, 0xC1, 0x98, 0x73, 0x0E, 0x63, 0x8C, 0x71, 0xF6, 0x1C, 0xC0,
  0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x60, 0xDE, 0x1E,
  0xE7, 0x1C, 0xE1, 0x98, 0x73, 0x0E, 0xE1, 0xDC, 0x3B, 0x86, 0x61, 0xCC,
  0x3B, 0xCE, 0x6F, 0x8D, 0xE0, 0x0F, 0x0F, 0xCE, 0x4E, 0x07, 0x07, 0x03,
  0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x47, 0xE1, 0xF0, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x0E, 0xE1, 0xFE, 0x3B, 0xC7,
  0x1C, 0x71, 0xC6, 0x1C, 0xE1, 0x8E, 0x18, 0xC1, 0x8C, 0x38, 0xC3, 0x8C,
  0x30, 0xC7, 0x0F, 0xB0, 0x7B, 0x00, 0x0F, 0x0F, 0xCE, 0x6E, 0x36, 0x1F,
  0x1F, 0xBD, 0xFC, 0xE0, 0x60, 0x30, 0x18, 0x0E, 0x27, 0xF1, 0xF8, 0x00,
  0x30, 0x07, 0xC0, 0x7C, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0F, 0x81, 0xFC,
  0x0F, 0xC0, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x07, 0x80, 0x3C, 0x00, 0x03, 0x98, 0x3F, 0xC3, 0xBC,
  0x38, 0xE1, 0xC7, 0x0C, 0x38, 0xE1, 0x87, 0x0C, 0x30, 0x61, 0x87, 0x0C,
  0x38, 0x63, 0x83, 0x1C, 0x1F, 0x60, 0x7F, 0x00, 0x38, 0x01, 0x80, 0x1C,
  0x20, 0xE1, 0xFE, 0x0F, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01,
  0xC0, 0x38, 0x06, 0x60, 0xFE, 0x1F, 0xE7, 0x1C, 0xE3, 0x9C, 0x63, 0x0C,
  0x61, 0x9C, 0x73, 0x8E, 0x61, 0x8C, 0x33, 0x8E, 0x71, 0xCE, 0x38, 0x0C,
  0x1C, 0x30, 0x00, 0x03, 0x06, 0x0C, 0x38, 0x70, 0xC1, 0x83, 0x0E, 0x1C,
  0x30, 0x61, 0xC3, 0x87, 0x00, 0x01, 0xC0, 0x70, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0,
  0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0xF0,
  0x38, 0x00, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18,
  0x71, 0x8E, 0x19, 0xC3, 0x98, 0x3B, 0x03, 0x70, 0x3E, 0x03, 0xE0, 0x7E,
  0x07, 0x70, 0x67, 0x06, 0x70, 0xE3, 0x0E, 0x30, 0xC3, 0x80, 0x0E, 0x1C,
  0x30, 0x61, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xE1, 0x83, 0x06, 0x1C, 0x38,
  0x60, 0xC3, 0x87, 0x0E, 0x00, 0x19, 0x8E, 0x1F, 0xDF, 0x1F, 0xF7, 0x38,
  0xE3, 0x38, 0xE3, 0x30, 0xC3, 0x30, 0xC7, 0x31, 0xC7, 0x71, 0xC6, 0x71,
  0x86, 0x61, 0x8E, 0x61, 0x8E, 0xE3, 0x8E, 0xE3, 0x8C, 0xE3, 0x0C, 0x19,
  0xC3, 0xF8, 0x7F, 0x9C, 0x73, 0x8E, 0x71, 0x8C, 0x31, 0x86, 0x71, 0xCE,
  0x39, 0x86, 0x30, 0xCE, 0x19, 0xC7, 0x38, 0xE0, 0x0E, 0x07, 0xE3, 0xB9,
  0xC7, 0x61, 0xF8, 0x7E, 0x1F, 0x06, 0xC1, 0xB0, 0xEC, 0x3B, 0x0C, 0xC7,
  0x3F, 0x87, 0xC0, 0x0C, 0xC0, 0xDF, 0x0F, 0x71, 0xC7, 0x1C, 0x31, 0x87,
  0x18, 0x71, 0x87, 0x38, 0x73, 0x86, 0x38, 0xE3, 0x0E, 0x79, 0xC7, 0xF8,
  0x6F, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x00, 0x0E,
  0x63, 0xFC, 0xEF, 0x38, 0xE6, 0x1C, 0xC3, 0xB8, 0x67, 0x0C, 0xC1, 0x98,
  0x73, 0x0E, 0x61, 0x8C, 0x71, 0xF6, 0x1D, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x19, 0x8D, 0xC7, 0xE7, 0x83, 0x81, 0xC0, 0xC0,
  0x60, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x80, 0x0F, 0x0F, 0xCE,
  0x66, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0x80, 0xC8, 0xE7,
  0xF3, 0xF0, 0x18, 0x30, 0x61, 0xF7, 0xDF, 0x9C, 0x38, 0x70, 0xC1, 0x87,
  0x0E, 0x18, 0x30, 0x60, 0xF1, 0xE0, 0x30, 0xCC, 0x33, 0x0D, 0xC7, 0x71,
  0xD8, 0x66, 0x1B, 0x8E, 0xE3, 0xB8, 0xEC, 0x33, 0x1C, 0xC7, 0x3E, 0xCF,
  0x60, 0xC3, 0xE1, 0xF0, 0xD8, 0xEC, 0x66, 0x73, 0x31, 0xB8, 0xD8, 0x6C,
  0x3E, 0x1E, 0x0F, 0x07, 0x03, 0x80, 0x61, 0x87, 0x63, 0x86, 0x63, 0x8E,
  0x63, 0x8C, 0x67, 0x8C, 0x67, 0x9C, 0x6D, 0x98, 0x6D, 0xB8, 0x6D, 0xB0,
  0x79, 0xB0, 0x79, 0xF0, 0xF9, 0xE0, 0xF1, 0xE0, 0xF1, 0xC0, 0xE1, 0xC0,
  0x1C, 0x71, 0xC6, 0x1C, 0xE0, 0xDC, 0x0D, 0x80, 0xF8, 0x0F, 0x00, 0xE0,
  0x0F, 0x01, 0xF0, 0x1B, 0x03, 0x30, 0x73, 0x06, 0x38, 0xE3, 0x80, 0x0C,
  0x18, 0x61, 0xC3, 0x0C, 0x18, 0xE0, 0xC6, 0x06, 0x70, 0x33, 0x01, 0x98,
  0x0D, 0xC0, 0x6C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x0F, 0x00, 0x20, 0x00, 0x1F,
  0xC7, 0xF1, 0xF8, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x06, 0x03,
  0x81, 0xC0, 0x60, 0x3F, 0x8F, 0xE0, 0x03, 0xC1, 0xE0, 0xE0, 0x38, 0x0C,
  0x03, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x0F, 0x03, 0x00, 0xF0, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x1E, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xE0, 0x38, 0x06, 0x03,
  0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x3C, 0x03, 0x07, 0xC1, 0xC0,
  0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x3E, 0x0F, 0x00, 0x7C,
  0x7F, 0xF8, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 19, 6, 0, -19 },
  { 18, 8, 7, 10, 3, -19 },
  { 25, 13, 19, 12, 0, -19 },
  { 56, 11, 23, 11, 0, -21 },
  { 88, 15, 20, 17, 1, -20 },
  { 126, 12, 20, 12, 0, -20 },
  { 156, 4, 7, 6, 3, -19 },
  { 160, 9, 23, 7, 0, -19 },
  { 186, 8, 24, 7, -2, -20 },
  { 210, 9, 10, 10, 2, -21 },
  { 222, 10, 13, 12, 1, -16 },
  { 239, 5, 7, 6, -1, -3 },
  { 244, 7, 2, 7, 0, -8 },
  { 246, 3, 3, 6, 0, -3 },
  { 248, 12, 19, 9, -1, -19 },
  { 277, 10, 20, 11, 1, -20 },
  { 302, 7, 19, 11, 3, -19 },
  { 319, 12, 20, 11, -1, -20 },
  { 349, 11, 20, 11, 0, -20 },
  { 377, 11, 19, 11, 0, -19 },
  { 404, 11, 19, 11, 0, -19 },
  { 431, 11, 20, 11, 1, -20 },
  { 459, 11, 19, 11, 1, -19 },
  { 486, 11, 20, 11, 0, -20 },
  { 514, 11, 20, 11, 0, -20 },
  { 542, 6, 15, 6, 0, -15 },
  { 554, 7, 19, 6, -1, -15 },
  { 571, 10, 13, 12, 1, -16 },
  { 588, 10, 7, 12, 1, -13 },
  { 597, 10, 13, 12, 1, -16 },
  { 614, 9, 20, 8, 0, -20 },
  { 637, 15, 21, 16, 1, -19 },
  { 677, 12, 19, 11, -2, -19 },
  { 706, 12, 19, 12, 0, -19 },
  { 735, 12, 20, 11, 1, -20 },
  { 765, 13, 19, 13, 0, -19 },
  { 796, 11, 19, 10, 0, -19 },
  { 823, 11, 19, 10, 0, -19 },
  { 850, 13, 20, 14, 1, -20 },
  { 883, 14, 19, 13, 0, -19 },
  { 917, 10, 19, 7, -1, -19 },
  { 941, 11, 24, 6, -4, -19 },
  { 974, 14, 19, 11, 0, -19 },
  { 1008, 8, 19, 9, 0, -19 },
  { 1027, 19, 19, 18, 0, -19 },
  { 1073, 15, 19, 14, 0, -19 },
  { 1109, 12, 20, 14, 1, -20 },
  { 1139, 12, 19, 11, 0, -19 },
  { 1168, 12, 25, 14, 1, -20 },
  { 1206, 12, 19, 12, 0, -19 },
  { 1235, 13, 20, 10, -1, -20 },
  { 1268, 10, 19, 10, 2, -19 },
  { 1292, 13, 19, 13, 1, -19 },
  { 1323, 12, 19, 11, 2, -19 },
  { 1352, 18, 19, 18, 2, -19 },
  { 1395, 14, 19, 11, -2, -19 },
  { 1429, 11, 19, 10, 2, -19 },
  { 1456, 12, 19, 9, -1, -19 },
  { 1485, 11, 23, 8, -1, -19 },
  { 1517, 4, 19, 9, 3, -19 },
  { 1527, 10, 23, 8, -2, -19 },
  { 1556, 11, 10, 11, 0, -19 },
  { 1570, 8, 2, 8, -2, 2 },
  { 1572, 4, 5, 7, 4, -21 },
  { 1575, 11, 15, 12, 1, -15 },
  { 1596, 11, 21, 12, 0, -21 },
  { 1625, 9, 15, 9, 1, -15 },
  { 1642, 12, 21, 12, 1, -21 },
  { 1674, 9, 15, 11, 1, -15 },
  { 1691, 13, 27, 7, -3, -21 },
  { 1735, 13, 21, 12, -1, -15 },
  { 1770, 11, 21, 11, 0, -21 },
  { 1799, 7, 20, 5, 0, -20 },
  { 1817, 10, 26, 6, -3, -20 },
  { 1850, 12, 21, 10, 0, -21 },
  { 1882, 7, 21, 5, 0, -21 },
  { 1901, 16, 15, 17, 0, -15 },
  { 1931, 11, 15, 11, 0, -15 },
  { 1952, 10, 15, 11, 1, -15 },
  { 1971, 12, 21, 12, -1, -15 },
  { 2003, 11, 21, 12, 1, -15 },
  { 2032, 9, 15, 8, 0, -15 },
  { 2049, 9, 15, 9, 0, -15 },
  { 2066, 7, 18, 7, 1, -18 },
  { 2082, 10, 15, 11, 1, -15 },
  { 2101, 9, 15, 10, 2, -15 },
  { 2118, 16, 15, 15, 1, -15 },
  { 2148, 12, 15, 10, -1, -15 },
  { 2171, 13, 22, 10, -2, -15 },
  { 2207, 10, 15, 8, -1, -15 },
  { 2226, 10, 23, 9, 1, -19 },
  { 2255, 2, 27, 10, 4, -21 },
  { 2262, 10, 23, 9, -2, -19 },
  { 2291, 10, 3, 12, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC27PT7B_H_
