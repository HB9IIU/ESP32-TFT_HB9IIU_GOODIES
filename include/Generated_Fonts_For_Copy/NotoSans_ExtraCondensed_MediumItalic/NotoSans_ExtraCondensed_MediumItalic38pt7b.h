#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC38PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F,
  0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x01, 0xE0, 0xF8, 0x3E, 0x0F, 0x00, 0x79,
  0xEF, 0x3D, 0xC7, 0x38, 0xE7, 0x1D, 0xE7, 0xB8, 0xE7, 0x1C, 0xE3, 0x98,
  0x70, 0x00, 0x63, 0x80, 0x38, 0xE0, 0x0E, 0x30, 0x03, 0x1C, 0x01, 0xC7,
  0x00, 0x71, 0x80, 0x18, 0x60, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xE0,
  0x71, 0xC0, 0x1C, 0x70, 0x06, 0x18, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38,
  0xC0, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x63, 0x80, 0x38, 0xE0,
  0x0E, 0x30, 0x03, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x18, 0x60, 0x0E,
  0x38, 0x00, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0xF8, 0x03, 0xFF,
  0x07, 0xFF, 0x0F, 0xEE, 0x0E, 0x62, 0x1E, 0x40, 0x1E, 0x40, 0x1E, 0xC0,
  0x1E, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x01, 0x78, 0x01, 0x38, 0x03, 0x38, 0x03, 0x38, 0x82, 0x38,
  0xE2, 0x78, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x7C, 0x07, 0x07, 0xE0, 0x70,
  0x73, 0x83, 0x83, 0x1C, 0x38, 0x38, 0xE1, 0x81, 0xC7, 0x1C, 0x0C, 0x38,
  0xC0, 0xE1, 0x8E, 0x07, 0x1C, 0x60, 0x38, 0xE7, 0x01, 0xC7, 0x30, 0x8E,
  0x33, 0x9F, 0x73, 0xB9, 0xFF, 0xB9, 0xDC, 0xFF, 0xDC, 0xE7, 0x7C, 0xE6,
  0x38, 0x8E, 0x71, 0xC0, 0x73, 0x8E, 0x07, 0x18, 0x70, 0x39, 0xC3, 0x03,
  0x8E, 0x38, 0x1C, 0x71, 0xC1, 0xC3, 0x8E, 0x0E, 0x1C, 0xE0, 0xE0, 0xE7,
  0x06, 0x03, 0xF0, 0x70, 0x1F, 0x00, 0x00, 0x20, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0x73, 0xC0, 0x79, 0xE0, 0x38, 0xF0, 0x1C, 0x70, 0x0E, 0x38, 0x07,
  0x1C, 0x03, 0x9C, 0x01, 0xDE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x3F, 0x8F, 0x3D, 0xE7, 0x3C, 0xF3, 0x9C, 0x3B, 0xDE, 0x1F,
  0xCF, 0x0F, 0xE7, 0x03, 0xE3, 0x81, 0xE1, 0xC1, 0xF0, 0xF1, 0xFC, 0x7F,
  0xFE, 0x1F, 0xEF, 0x07, 0xE3, 0xC0, 0x7B, 0xDC, 0xE7, 0x7B, 0x9C, 0xE7,
  0x00, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xC6, 0x07,
  0xB1, 0xFF, 0xFC, 0x7F, 0xE1, 0xF8, 0x1F, 0x81, 0xEC, 0x1E, 0x70, 0x73,
  0xC1, 0x0C, 0x00, 0x40, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x1E, 0x3C, 0x71, 0xE3, 0x87, 0x1C, 0x38, 0xE0, 0xFF, 0xFF, 0xFF, 0x33,
  0xFF, 0xF7, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x40, 0x07, 0xE0, 0x3F, 0x81, 0xFF, 0x0F,
  0x1C, 0x38, 0x71, 0xE1, 0xC7, 0x07, 0x3C, 0x1C, 0xE0, 0x73, 0x81, 0xDE,
  0x0F, 0x78, 0x3D, 0xC0, 0xF7, 0x03, 0xFC, 0x0E, 0xF0, 0x7B, 0xC1, 0xEE,
  0x07, 0xB8, 0x1C, 0xE0, 0xF3, 0x83, 0xCE, 0x1E, 0x38, 0x78, 0xF3, 0xC3,
  0xFE, 0x07, 0xF8, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0xFC, 0x7E, 0x3F, 0x9E,
  0xEF, 0x79, 0x9E, 0x47, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0,
  0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78,
  0x1E, 0x07, 0x80, 0x00, 0x10, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x07,
  0x0F, 0x02, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0x00,
  0x10, 0x00, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x20, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0xC0, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xB8, 0x01, 0xDC, 0x01, 0xDE, 0x00, 0xCF, 0x00, 0xE7, 0x00, 0xE3,
  0x80, 0x63, 0xC0, 0x71, 0xE0, 0x70, 0xE0, 0x38, 0x70, 0x38, 0x38, 0x18,
  0x3C, 0x1F, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xE0, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x03, 0xFF, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x18,
  0xF8, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x81, 0xF0, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0x00, 0x00, 0x08, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x78,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xDF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x1E, 0x7C, 0x3C, 0xF0, 0x39, 0xE0,
  0xF3, 0xC1, 0xE7, 0x83, 0xCE, 0x07, 0x9C, 0x0E, 0x38, 0x3C, 0x78, 0x78,
  0xF1, 0xE0, 0xFF, 0x81, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0x1F, 0xFF,
  0x1F, 0xFF, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x00, 0x20, 0x01, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0x0F,
  0x0E, 0x0F, 0x0E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0E, 0x0E, 0x1E, 0x0F, 0x3C,
  0x0F, 0x78, 0x07, 0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3C, 0xF0,
  0x78, 0x78, 0x70, 0x78, 0xF0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38,
  0xF0, 0x78, 0xF0, 0x70, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x20,
  0x03, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0xF1, 0xE3, 0xC1, 0xC7, 0x83, 0x8E,
  0x07, 0x3C, 0x0E, 0x78, 0x1C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x87,
  0xCF, 0x1F, 0x0F, 0xFE, 0x1F, 0xFC, 0x1E, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC1, 0xFF, 0x83, 0xFE,
  0x07, 0xF0, 0x00, 0x02, 0x0F, 0x0F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x78, 0xF8, 0xF0, 0xF0,
  0x00, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x38, 0x00, 0x00, 0x02, 0x00,
  0x1C, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0x80, 0x07, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3C, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x0F, 0x00, 0x38, 0x00, 0x80, 0x00, 0x01, 0x00, 0xFE, 0x3F, 0xE3,
  0xFF, 0x10, 0xF0, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x1E, 0x0F, 0x00, 0xE0, 0x0E,
  0x07, 0x00, 0x38, 0x38, 0x00, 0x60, 0xE0, 0x01, 0x87, 0x07, 0xE7, 0x18,
  0x7F, 0x1C, 0xE3, 0xCC, 0x73, 0x0C, 0x71, 0xDC, 0x71, 0xC6, 0x71, 0x86,
  0x19, 0x8E, 0x18, 0x66, 0x38, 0xE3, 0xB8, 0xE3, 0x8E, 0xE3, 0x0E, 0x33,
  0x8C, 0x71, 0xCE, 0x31, 0xC6, 0x30, 0xCF, 0x38, 0xC3, 0xFF, 0xC3, 0x0F,
  0xBE, 0x0E, 0x1C, 0x20, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x06, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0xEF, 0x00, 0xEF, 0x01, 0xEF, 0x01, 0xCF, 0x03, 0xCF, 0x03, 0xCF,
  0x03, 0x8F, 0x07, 0x8F, 0x07, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0x0F, 0xFF,
  0x1F, 0xFF, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x03, 0xFC, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xF1, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0E,
  0x07, 0x87, 0x07, 0x87, 0x87, 0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC0,
  0x71, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0E, 0x07, 0x87, 0x03,
  0xC7, 0x81, 0xE3, 0xC1, 0xE1, 0xC0, 0xF0, 0xE1, 0xF0, 0xFF, 0xF8, 0x7F,
  0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x7F,
  0xE0, 0x7C, 0x10, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x20, 0x1F, 0xF0, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1E,
  0x3E, 0x07, 0x07, 0x81, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03,
  0xC3, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0x87, 0x01, 0xE1,
  0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x0F, 0x03, 0xC3, 0x80, 0xF0, 0xE0,
  0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x07, 0x87, 0xC1, 0xC7, 0xE0, 0xFF, 0xF0,
  0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0x03,
  0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0x7C, 0x0C, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x7F, 0x1E, 0x0F, 0xE3, 0x81, 0xF8, 0x70, 0x7F, 0x1E, 0x01, 0xE3,
  0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xE1, 0xE0, 0x1C, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00,
  0x03, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x01,
  0xE0, 0x70, 0x1E, 0x0F, 0x01, 0xC0, 0xF0, 0x1C, 0x0F, 0x03, 0xC0, 0xE0,
  0x3C, 0x1E, 0x03, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1C,
  0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0F, 0x03,
  0x80, 0xF0, 0x78, 0x0E, 0x07, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xE0,
  0xF0, 0x1E, 0x0F, 0x01, 0xC0, 0xF0, 0x3C, 0x00, 0x03, 0xFE, 0x0F, 0xFC,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1F, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x3F, 0x80, 0x7E,
  0x01, 0xF8, 0x00, 0x80, 0x00, 0x03, 0x81, 0xE0, 0xF0, 0x78, 0x1E, 0x0E,
  0x03, 0xC3, 0xC0, 0x70, 0xF0, 0x0E, 0x3C, 0x03, 0xC7, 0x80, 0x79, 0xE0,
  0x0E, 0x78, 0x01, 0xCF, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xF7, 0x00, 0x3C, 0xF0, 0x07, 0x9E, 0x00,
  0xE3, 0xC0, 0x1C, 0x78, 0x07, 0x87, 0x00, 0xF0, 0xF0, 0x1C, 0x1E, 0x03,
  0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xE0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80,
  0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3B,
  0x81, 0xFC, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC1, 0xEE, 0x0E, 0xF0,
  0x7B, 0x83, 0xBC, 0x1C, 0xE1, 0xCE, 0x07, 0x38, 0x73, 0x81, 0xCE, 0x3D,
  0xE0, 0xF3, 0x8E, 0x78, 0x3C, 0xE7, 0x9E, 0x0E, 0x39, 0xC7, 0x03, 0x8E,
  0x71, 0xC0, 0xE3, 0xB8, 0xF0, 0x78, 0xEE, 0x3C, 0x1E, 0x3F, 0x0E, 0x07,
  0x0F, 0xC3, 0x81, 0xC3, 0xE0, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x3E, 0x1E,
  0x0E, 0x0F, 0x07, 0x00, 0x03, 0xC0, 0x78, 0x3E, 0x03, 0xC1, 0xF0, 0x1C,
  0x0F, 0x80, 0xE0, 0x7E, 0x07, 0x03, 0xF0, 0x78, 0x3F, 0x83, 0xC1, 0xDC,
  0x1C, 0x0E, 0xE0, 0xE0, 0x77, 0x07, 0x07, 0xBC, 0x78, 0x3C, 0xE3, 0xC1,
  0xC7, 0x1C, 0x0E, 0x38, 0xE0, 0x71, 0xCF, 0x07, 0x8E, 0x78, 0x3C, 0x7B,
  0x81, 0xC1, 0xDC, 0x0E, 0x0E, 0xE0, 0x70, 0x77, 0x07, 0x83, 0xF8, 0x3C,
  0x1F, 0x81, 0xC0, 0xFC, 0x0E, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF8,
  0x38, 0x07, 0x80, 0x00, 0x10, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xFE,
  0x07, 0x87, 0x83, 0xC0, 0xF0, 0xE0, 0x3C, 0x78, 0x0F, 0x1C, 0x03, 0xCF,
  0x00, 0xF3, 0xC0, 0x3C, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xE7, 0x80,
  0x79, 0xE0, 0x1E, 0x70, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x07, 0x8F, 0x01, 0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x1F,
  0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0xF1, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F,
  0x07, 0x87, 0x03, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE1, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F,
  0xFE, 0x07, 0x87, 0x83, 0xC0, 0xF0, 0xE0, 0x3C, 0x78, 0x0F, 0x1C, 0x03,
  0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xE7,
  0x80, 0x79, 0xE0, 0x1E, 0x70, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0xF3, 0xC0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x8F, 0x01, 0xE1, 0xE0, 0xF0, 0x78, 0x78,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xF8, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0xE1, 0xE0, 0x70, 0x78, 0x38, 0x3C, 0x3C, 0x1E,
  0x1E, 0x0F, 0x0E, 0x07, 0x07, 0x07, 0x87, 0x83, 0xC3, 0xC3, 0xC1, 0xE3,
  0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3C, 0xE0, 0x1E, 0x78, 0x0E,
  0x3C, 0x07, 0x1E, 0x07, 0x87, 0x03, 0xC3, 0x81, 0xC1, 0xE0, 0xE0, 0xF0,
  0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x0F, 0x00, 0x00, 0x18, 0x00, 0x7F, 0x80,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7C, 0x30, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE1, 0x00, 0xF0, 0x60, 0xF8,
  0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0x81, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x0F, 0x01, 0xE1, 0xE0, 0x38,
  0x3C, 0x0F, 0x07, 0x01, 0xE0, 0xE0, 0x3C, 0x3C, 0x07, 0x07, 0x81, 0xE0,
  0xF0, 0x3C, 0x1C, 0x07, 0x87, 0x80, 0xE0, 0xF0, 0x1C, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x70, 0x1E, 0x1E, 0x03, 0x83, 0xC0, 0x70, 0x78, 0x1E, 0x0E,
  0x03, 0xC1, 0xC0, 0x78, 0x78, 0x0E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C,
  0x1E, 0x07, 0xC7, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x00,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xE0,
  0xF1, 0xE0, 0xF1, 0xC0, 0xF3, 0xC0, 0xF3, 0xC0, 0xF3, 0x80, 0xF7, 0x80,
  0xF7, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x1C, 0x03, 0xF8, 0x0E, 0x03,
  0xFC, 0x0F, 0x01, 0xDE, 0x07, 0x81, 0xEF, 0x07, 0xC0, 0xF7, 0x83, 0xE0,
  0x73, 0xC1, 0xF0, 0x79, 0xE1, 0xF8, 0x38, 0xF0, 0xFC, 0x3C, 0x78, 0x7E,
  0x1E, 0x38, 0x77, 0x0E, 0x1C, 0x3B, 0x8F, 0x0E, 0x39, 0xC7, 0x07, 0x1C,
  0xE7, 0x83, 0x8E, 0x73, 0xC1, 0xCE, 0x39, 0xC0, 0xE7, 0x1D, 0xE0, 0x77,
  0x0E, 0xE0, 0x3B, 0x87, 0x70, 0x1D, 0xC3, 0xF8, 0x0F, 0xC1, 0xF8, 0x07,
  0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00,
  0x78, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xF0, 0x3C, 0x1E,
  0x03, 0xC3, 0xC0, 0x1C, 0x3C, 0x01, 0xC7, 0x80, 0x1C, 0x70, 0x01, 0xCF,
  0x00, 0x1E, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0x78, 0x00, 0xF3, 0x80, 0x0E, 0x38, 0x01,
  0xE3, 0x80, 0x3C, 0x38, 0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x07, 0x03, 0xC0,
  0xF0, 0x3C, 0x00, 0xF0, 0x1F, 0xE0, 0x79, 0xC0, 0xE3, 0x83, 0xC7, 0x07,
  0x0E, 0x1E, 0x1C, 0x38, 0x3C, 0xF0, 0x79, 0xC0, 0xF7, 0x01, 0xEE, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x3F,
  0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0xE3, 0x8E, 0x38, 0xF1, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x78, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3C, 0x71, 0xC7, 0x1C,
  0x71, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFF, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xB8, 0x07, 0xB8, 0x07, 0x3C, 0x0E, 0x1C, 0x0E, 0x1C,
  0x1C, 0x1C, 0x3C, 0x1E, 0x38, 0x0E, 0x70, 0x0E, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF7, 0x9C, 0xF3, 0x8C, 0x03, 0xC1, 0x07, 0xEE, 0x0F,
  0xEE, 0x1F, 0x3E, 0x3C, 0x3E, 0x3C, 0x1C, 0x38, 0x1C, 0x78, 0x3C, 0x78,
  0x3C, 0x70, 0x3C, 0xF0, 0x38, 0xF0, 0x38, 0xF0, 0x38, 0xF0, 0x78, 0xF0,
  0x78, 0xE0, 0xF0, 0xF0, 0xF0, 0xF1, 0xF0, 0xFF, 0xF0, 0x7E, 0xF0, 0x7C,
  0xE0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x38, 0x0E, 0xFC, 0x0F, 0xFE, 0x0F,
  0x9E, 0x1F, 0x0E, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x0E, 0x3C,
  0x0E, 0x38, 0x1E, 0x38, 0x1E, 0x38, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x78, 0x78, 0x78, 0xFF, 0xF0, 0xEF, 0xE0, 0xE7, 0xC0, 0x01,
  0xE0, 0x3F, 0xC3, 0xFC, 0x3E, 0x63, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1E,
  0x00, 0xF0, 0x07, 0x84, 0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x03, 0xCF, 0x03, 0xF7, 0x03, 0xFB, 0x83, 0xC7, 0xC3,
  0xC3, 0xE1, 0xE0, 0xE0, 0xE0, 0x70, 0xF0, 0x78, 0x78, 0x3C, 0x38, 0x1E,
  0x3C, 0x0E, 0x1E, 0x07, 0x0F, 0x03, 0x87, 0x83, 0xC3, 0x81, 0xE1, 0xC0,
  0xE0, 0xE0, 0xF0, 0x78, 0xF8, 0x3F, 0xDC, 0x0F, 0xFC, 0x07, 0xCE, 0x00,
  0x01, 0xE0, 0x3F, 0x83, 0xFE, 0x3C, 0x73, 0xC3, 0x9C, 0x1D, 0xE0, 0xEF,
  0x0F, 0x70, 0xF7, 0xFF, 0x3F, 0xF1, 0xFC, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x81, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x40, 0x7E, 0xE0, 0x3F,
  0xB8, 0x1F, 0x7E, 0x0F, 0x0F, 0x83, 0xC3, 0xC0, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x03, 0xC3, 0xC0, 0xE0, 0xF0, 0x38, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0x81, 0xE0, 0xE0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1F, 0x03, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x0C, 0x1E, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F,
  0xC0, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x38, 0x1D, 0xF8, 0x3F, 0xF8, 0x7D,
  0xF1, 0xF1, 0xE3, 0xC1, 0xC7, 0x87, 0x8E, 0x0F, 0x1C, 0x1E, 0x78, 0x38,
  0xF0, 0x71, 0xC1, 0xE3, 0x83, 0xC7, 0x07, 0x1E, 0x0E, 0x3C, 0x1C, 0x70,
  0x78, 0xE0, 0xF3, 0xC1, 0xC7, 0x83, 0x8E, 0x0F, 0x00, 0x03, 0x83, 0xC1,
  0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0,
  0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0,
  0x70, 0x78, 0x3C, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x78, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x01, 0x0E, 0x0E, 0x0E, 0x1E, 0x0E, 0x3C, 0x1E, 0x38,
  0x1E, 0x70, 0x1C, 0xF0, 0x1D, 0xE0, 0x1D, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3D, 0xE0, 0x39, 0xE0, 0x79, 0xE0, 0x70, 0xE0, 0x70, 0xE0,
  0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xE0, 0xF0, 0x03, 0xC0, 0xE0, 0x38,
  0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E,
  0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07,
  0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x38, 0x38,
  0x1D, 0xF9, 0xF8, 0x3F, 0xFF, 0xF8, 0x7D, 0xFD, 0xF1, 0xF1, 0xF1, 0xE3,
  0xC3, 0xC3, 0xC7, 0x87, 0x87, 0x8E, 0x0F, 0x0F, 0x1C, 0x1C, 0x1C, 0x78,
  0x38, 0x38, 0xF0, 0xF0, 0xF1, 0xC1, 0xE1, 0xE3, 0x83, 0x83, 0x8F, 0x07,
  0x07, 0x1E, 0x0E, 0x0E, 0x3C, 0x3C, 0x3C, 0x70, 0x78, 0x78, 0xE0, 0xE0,
  0xE3, 0xC1, 0xC1, 0xC7, 0x87, 0x83, 0x8E, 0x0F, 0x0F, 0x00, 0x00, 0x38,
  0x1D, 0xF8, 0x3F, 0xF8, 0x7C, 0xF1, 0xF1, 0xE3, 0xC1, 0xC7, 0x87, 0x8E,
  0x0F, 0x1C, 0x1C, 0x78, 0x38, 0xF0, 0x71, 0xC1, 0xE3, 0x83, 0xCF, 0x07,
  0x1E, 0x0E, 0x3C, 0x1C, 0x70, 0x78, 0xE0, 0xF3, 0xC1, 0xC7, 0x83, 0x8F,
  0x0F, 0x00, 0x01, 0xE0, 0x1F, 0xC0, 0xFF, 0x87, 0x9F, 0x3C, 0x3C, 0xF0,
  0xF7, 0x83, 0xDE, 0x0F, 0x70, 0x3D, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0,
  0x3B, 0x81, 0xEE, 0x07, 0xB8, 0x1C, 0xF0, 0xF3, 0xC7, 0x87, 0xFE, 0x1F,
  0xF0, 0x3F, 0x00, 0x00, 0x0E, 0x00, 0xEF, 0xC0, 0x3B, 0xF8, 0x0F, 0x9E,
  0x07, 0xC3, 0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0F, 0x07, 0x03, 0x83,
  0xC0, 0xE0, 0xF0, 0x38, 0x38, 0x1E, 0x0E, 0x07, 0x83, 0x81, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x07, 0x87, 0x83, 0xFF, 0xC0, 0xFF, 0xE0,
  0x39, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x0F, 0xDC, 0x3F, 0xB8, 0xF3, 0xF1, 0xC3, 0xE7, 0x87, 0x8E, 0x07,
  0x3C, 0x1E, 0x78, 0x3C, 0xE0, 0x7B, 0xC0, 0xE7, 0x81, 0xCF, 0x03, 0x9E,
  0x0F, 0x38, 0x1E, 0x70, 0x78, 0xE0, 0xF1, 0xE3, 0xE3, 0xFF, 0xC3, 0xFF,
  0x07, 0xCE, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x38, 0x77, 0x83,
  0xFC, 0x1F, 0xE1, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0xC7, 0xFC,
  0x3C, 0x63, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC4, 0x1E,
  0x3F, 0xF1, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E,
  0x1F, 0xF7, 0xF8, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07,
  0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0F, 0xC3, 0xF0,
  0x7C, 0x00, 0x1E, 0x1E, 0x38, 0x3C, 0x70, 0x71, 0xE0, 0xE3, 0xC1, 0xC7,
  0x07, 0x8E, 0x0F, 0x3C, 0x1C, 0x78, 0x38, 0xF0, 0x71, 0xC1, 0xE3, 0x83,
  0xCF, 0x07, 0x1E, 0x0E, 0x3C, 0x3C, 0x70, 0x78, 0xF1, 0xE1, 0xFF, 0xC3,
  0xFB, 0x83, 0xE7, 0x00, 0xF0, 0x7F, 0x83, 0xFC, 0x1D, 0xE1, 0xEF, 0x0E,
  0x78, 0xF3, 0xC7, 0x1E, 0x38, 0xF3, 0x87, 0x9C, 0x3D, 0xE1, 0xEE, 0x0F,
  0xF0, 0x3F, 0x01, 0xB8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0,
  0x00, 0xF0, 0xF8, 0x7F, 0x87, 0xC3, 0xFC, 0x3E, 0x1D, 0xE3, 0xF1, 0xEF,
  0x1F, 0x8E, 0x78, 0xDC, 0x73, 0xCE, 0xE7, 0x9C, 0x76, 0x38, 0xE7, 0x33,
  0xC7, 0x39, 0x9C, 0x39, 0x9C, 0xE1, 0xDC, 0xEF, 0x0E, 0xE7, 0x70, 0x76,
  0x3B, 0x83, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xE0,
  0x3C, 0x1F, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x87, 0x83, 0xC7, 0x81, 0xE3,
  0x80, 0x73, 0xC0, 0x39, 0xC0, 0x1D, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x39, 0xC0, 0x3C, 0xE0, 0x3C, 0x70, 0x1C, 0x3C, 0x1E, 0x1E, 0x1E, 0x0F,
  0x00, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x0E, 0x0E, 0x01, 0xC3, 0xC0, 0x38,
  0x70, 0x07, 0x0E, 0x00, 0xE3, 0xC0, 0x1C, 0x70, 0x03, 0x9E, 0x00, 0x73,
  0x80, 0x0E, 0xF0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFC,
  0x3F, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x3C, 0x03,
  0xF0, 0x1F, 0x80, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x3F,
  0x00, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x3F, 0x00, 0x38, 0x07, 0xE0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x3E, 0x02, 0xFF, 0x0F,
  0xFF, 0xFE, 0x1F, 0xF8, 0x0F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 10, 27, 9, 0, -27 },
  { 35, 11, 10, 13, 4, -27 },
  { 49, 18, 27, 17, 0, -27 },
  { 110, 16, 31, 15, 0, -29 },
  { 172, 21, 28, 24, 2, -28 },
  { 246, 17, 28, 17, 0, -28 },
  { 306, 5, 10, 8, 4, -27 },
  { 313, 12, 33, 10, 1, -27 },
  { 363, 12, 33, 10, -3, -27 },
  { 413, 13, 14, 14, 3, -29 },
  { 436, 14, 18, 17, 2, -22 },
  { 468, 7, 9, 8, -2, -4 },
  { 476, 8, 3, 10, 1, -12 },
  { 479, 5, 5, 8, 0, -5 },
  { 483, 18, 27, 13, -2, -27 },
  { 544, 14, 28, 15, 1, -28 },
  { 593, 10, 27, 15, 4, -27 },
  { 627, 16, 28, 15, -1, -28 },
  { 683, 17, 28, 15, -1, -28 },
  { 743, 17, 27, 15, -1, -27 },
  { 801, 16, 27, 15, 0, -27 },
  { 855, 15, 28, 15, 1, -28 },
  { 908, 16, 27, 15, 1, -27 },
  { 962, 16, 28, 15, 0, -28 },
  { 1018, 15, 28, 15, 0, -28 },
  { 1071, 8, 21, 8, 0, -21 },
  { 1092, 10, 26, 8, -2, -21 },
  { 1125, 15, 17, 17, 1, -22 },
  { 1157, 14, 11, 17, 2, -19 },
  { 1177, 14, 17, 17, 2, -22 },
  { 1207, 12, 28, 11, 1, -28 },
  { 1249, 22, 30, 23, 1, -27 },
  { 1332, 16, 27, 16, -2, -27 },
  { 1386, 17, 27, 17, 0, -27 },
  { 1444, 17, 28, 15, 1, -28 },
  { 1504, 18, 27, 18, 0, -27 },
  { 1565, 16, 27, 14, 0, -27 },
  { 1619, 16, 27, 14, 0, -27 },
  { 1673, 19, 28, 19, 1, -28 },
  { 1740, 20, 27, 19, 0, -27 },
  { 1808, 15, 27, 11, -2, -27 },
  { 1859, 15, 35, 8, -6, -27 },
  { 1925, 19, 27, 16, 0, -27 },
  { 1990, 11, 27, 13, 0, -27 },
  { 2028, 26, 27, 25, 0, -27 },
  { 2116, 21, 27, 20, 0, -27 },
  { 2187, 18, 28, 19, 1, -28 },
  { 2250, 17, 27, 16, 0, -27 },
  { 2308, 18, 34, 19, 1, -28 },
  { 2385, 17, 27, 16, 0, -27 },
  { 2443, 17, 28, 15, -1, -28 },
  { 2503, 14, 27, 14, 3, -27 },
  { 2551, 19, 27, 18, 1, -27 },
  { 2616, 16, 27, 16, 3, -27 },
  { 2670, 25, 27, 25, 3, -27 },
  { 2755, 20, 27, 15, -2, -27 },
  { 2823, 15, 27, 14, 3, -27 },
  { 2874, 18, 27, 13, -2, -27 },
  { 2935, 14, 33, 11, -1, -27 },
  { 2993, 6, 27, 13, 4, -27 },
  { 3014, 15, 33, 11, -3, -27 },
  { 3076, 16, 15, 16, 0, -27 },
  { 3106, 12, 3, 12, -3, 3 },
  { 3111, 5, 6, 10, 6, -29 },
  { 3115, 16, 21, 17, 1, -21 },
  { 3157, 16, 29, 16, 0, -29 },
  { 3215, 13, 21, 13, 1, -21 },
  { 3250, 17, 29, 16, 1, -29 },
  { 3312, 13, 21, 15, 1, -21 },
  { 3347, 19, 38, 9, -5, -29 },
  { 3438, 18, 30, 17, -1, -21 },
  { 3506, 15, 29, 16, 0, -29 },
  { 3561, 9, 28, 8, 0, -28 },
  { 3593, 14, 37, 8, -5, -28 },
  { 3658, 16, 29, 14, 0, -29 },
  { 3716, 10, 29, 8, 0, -29 },
  { 3753, 23, 21, 24, 0, -21 },
  { 3814, 15, 21, 16, 0, -21 },
  { 3854, 14, 21, 16, 1, -21 },
  { 3891, 18, 30, 16, -2, -21 },
  { 3959, 15, 30, 16, 1, -21 },
  { 4016, 13, 21, 11, 0, -21 },
  { 4051, 13, 21, 13, 0, -21 },
  { 4086, 10, 25, 10, 1, -25 },
  { 4118, 15, 20, 16, 1, -20 },
  { 4156, 13, 20, 13, 2, -20 },
  { 4189, 21, 20, 21, 2, -20 },
  { 4242, 17, 20, 14, -2, -20 },
  { 4285, 19, 29, 14, -3, -20 },
  { 4354, 14, 20, 11, -1, -20 },
  { 4389, 14, 33, 13, 1, -27 },
  { 4447, 3, 38, 14, 5, -29 },
  { 4462, 14, 33, 13, -2, -27 },
  { 4520, 15, 5, 17, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC38PT7B_H_
