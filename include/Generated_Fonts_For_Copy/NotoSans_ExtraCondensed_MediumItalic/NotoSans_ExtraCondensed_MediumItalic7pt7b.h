#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC7PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0x80, 0xE0, 0x7D, 0x7C, 0x79, 0x2C, 0x5E, 0xF7, 0x70, 0x69,
  0x7E, 0xC0, 0x5A, 0xA0, 0x24, 0x95, 0x80, 0xF0, 0x5D, 0x00, 0xC0, 0xC0,
  0x80, 0x29, 0x48, 0x76, 0xDC, 0xEA, 0x80, 0x65, 0x2C, 0x65, 0x1C, 0x2E,
  0xF4, 0x71, 0x1C, 0x73, 0xDC, 0x65, 0x28, 0x75, 0x5C, 0x77, 0x9C, 0x90,
  0x42, 0x80, 0x71, 0x80, 0xFC, 0xC7, 0x00, 0x56, 0x80, 0x7B, 0xFF, 0x86,
  0x4A, 0xFA, 0x6D, 0x5C, 0x72, 0x4C, 0x6E, 0xDC, 0x69, 0x4C, 0x69, 0x48,
  0x78, 0xAA, 0xE0, 0x56, 0x6A, 0xA0, 0x56, 0x80, 0x25, 0x25, 0x80, 0x76,
  0x4C, 0xA0, 0x5A, 0xC0, 0x4A, 0x95, 0x6D, 0x00, 0x55, 0xDA, 0xA0, 0x76,
  0xDE, 0x6F, 0xC8, 0x76, 0xDE, 0x80, 0x6D, 0xEA, 0x71, 0x2C, 0x69, 0x28,
  0x56, 0xAA, 0xC0, 0xFA, 0x48, 0xAD, 0x7C, 0xAA, 0x00, 0x69, 0x6C, 0xEA,
  0x80, 0x69, 0x4C, 0x5A, 0xA0, 0xF8, 0x55, 0xA0, 0x4E, 0x80, 0xE0, 0x80,
  0x76, 0xE0, 0x4E, 0xDC, 0x72, 0x60, 0x2E, 0xDC, 0x77, 0x60, 0x36, 0x44,
  0x44, 0x80, 0x76, 0xE5, 0x00, 0x4E, 0xDC, 0x5A, 0x80, 0x25, 0x24, 0xA0,
  0x4D, 0x6C, 0x5A, 0x80, 0x7B, 0xBD, 0x76, 0xE0, 0x76, 0xE0, 0x76, 0xE9,
  0x00, 0x76, 0xE4, 0x80, 0x6A, 0x67, 0x7A, 0x80, 0x76, 0xE0, 0xBB, 0x40,
  0xBB, 0xEA, 0xA9, 0x60, 0x56, 0x24, 0x48, 0xDB, 0x69, 0x49, 0x80, 0xFE,
  0x55, 0xA0, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 2, 1, -5 },
  { 4, 3, 5, 3, 0, -5 },
  { 6, 3, 5, 3, 0, -5 },
  { 8, 4, 5, 4, 0, -5 },
  { 11, 3, 5, 3, 0, -5 },
  { 13, 1, 2, 1, 1, -5 },
  { 14, 2, 6, 2, 0, -5 },
  { 16, 3, 6, 2, -1, -5 },
  { 19, 2, 2, 3, 1, -5 },
  { 20, 3, 3, 3, 0, -4 },
  { 22, 1, 2, 1, 0, -1 },
  { 23, 2, 1, 2, 0, -2 },
  { 24, 1, 1, 1, 0, -1 },
  { 25, 3, 5, 2, 0, -5 },
  { 27, 3, 5, 3, 0, -5 },
  { 29, 2, 5, 3, 1, -5 },
  { 31, 3, 5, 3, 0, -5 },
  { 33, 3, 5, 3, 0, -5 },
  { 35, 3, 5, 3, 0, -5 },
  { 37, 3, 5, 3, 0, -5 },
  { 39, 3, 5, 3, 0, -5 },
  { 41, 3, 5, 3, 0, -5 },
  { 43, 3, 5, 3, 0, -5 },
  { 45, 3, 5, 3, 0, -5 },
  { 47, 1, 4, 2, 0, -4 },
  { 48, 2, 5, 2, 0, -4 },
  { 50, 3, 3, 3, 0, -4 },
  { 52, 3, 2, 3, 0, -3 },
  { 53, 3, 3, 3, 0, -4 },
  { 55, 2, 5, 2, 0, -5 },
  { 57, 4, 6, 4, 0, -5 },
  { 60, 3, 5, 3, 0, -5 },
  { 62, 3, 5, 3, 0, -5 },
  { 64, 3, 5, 3, 0, -5 },
  { 66, 3, 5, 3, 0, -5 },
  { 68, 3, 5, 3, 0, -5 },
  { 70, 3, 5, 2, 0, -5 },
  { 72, 4, 5, 4, 0, -5 },
  { 75, 4, 5, 3, 0, -5 },
  { 78, 2, 5, 2, 0, -5 },
  { 80, 3, 6, 2, -1, -5 },
  { 83, 4, 5, 3, 0, -5 },
  { 86, 2, 5, 2, 0, -5 },
  { 88, 5, 5, 5, 0, -5 },
  { 92, 4, 5, 4, 0, -5 },
  { 95, 3, 5, 4, 0, -5 },
  { 97, 3, 5, 3, 0, -5 },
  { 99, 3, 6, 4, 0, -5 },
  { 102, 3, 5, 3, 0, -5 },
  { 104, 3, 5, 3, 0, -5 },
  { 106, 3, 5, 3, 0, -5 },
  { 108, 4, 5, 3, 0, -5 },
  { 111, 3, 5, 3, 1, -5 },
  { 113, 5, 5, 5, 0, -5 },
  { 117, 3, 5, 3, 0, -5 },
  { 119, 2, 5, 3, 1, -5 },
  { 121, 3, 5, 2, 0, -5 },
  { 123, 2, 6, 2, 0, -5 },
  { 125, 1, 5, 2, 1, -5 },
  { 126, 2, 6, 2, 0, -5 },
  { 128, 3, 3, 3, 0, -5 },
  { 130, 3, 1, 2, -1, 0 },
  { 131, 1, 1, 2, 1, -5 },
  { 132, 3, 4, 3, 0, -4 },
  { 134, 3, 5, 3, 0, -5 },
  { 136, 3, 4, 2, 0, -4 },
  { 138, 3, 5, 3, 0, -5 },
  { 140, 3, 4, 3, 0, -4 },
  { 142, 4, 7, 2, -1, -5 },
  { 146, 3, 6, 3, 0, -4 },
  { 149, 3, 5, 3, 0, -5 },
  { 151, 2, 5, 1, 0, -5 },
  { 153, 3, 7, 1, -1, -5 },
  { 156, 3, 5, 3, 0, -5 },
  { 158, 2, 5, 1, 0, -5 },
  { 160, 4, 4, 4, 0, -4 },
  { 162, 3, 4, 3, 0, -4 },
  { 164, 3, 4, 3, 0, -4 },
  { 166, 3, 6, 3, 0, -4 },
  { 169, 3, 6, 3, 0, -4 },
  { 172, 2, 4, 2, 0, -4 },
  { 173, 2, 4, 2, 0, -4 },
  { 174, 2, 5, 2, 0, -5 },
  { 176, 3, 4, 3, 0, -4 },
  { 178, 3, 4, 2, 0, -4 },
  { 180, 4, 4, 4, 0, -4 },
  { 182, 3, 4, 3, 0, -4 },
  { 184, 4, 6, 3, -1, -4 },
  { 187, 2, 4, 2, 0, -4 },
  { 188, 3, 6, 2, 0, -5 },
  { 191, 1, 7, 3, 1, -5 },
  { 192, 2, 6, 2, 0, -5 },
  { 194, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC7PT7B_H_
