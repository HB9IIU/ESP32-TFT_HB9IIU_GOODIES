#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC42PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x7C, 0x0F, 0x80, 0xE0, 0x00, 0x3C, 0xF9, 0xE7, 0x9E, 0x3C,
  0xF1, 0xE7, 0x8F, 0x3C, 0x71, 0xC3, 0x8E, 0x3C, 0xF1, 0xC7, 0x0E, 0x38,
  0x70, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00,
  0xE1, 0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x1C, 0x38, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x38, 0x60, 0x03, 0x8E, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0x71, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03, 0x87,
  0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00, 0x71,
  0xC0, 0x0E, 0x1C, 0x00, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x3E, 0xCC, 0x0F, 0x30,
  0x03, 0x88, 0x00, 0xE2, 0x00, 0x39, 0x80, 0x0F, 0x60, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x02,
  0xF0, 0x01, 0xBE, 0x00, 0x67, 0x80, 0x19, 0xE0, 0x06, 0x78, 0x01, 0x1C,
  0x30, 0xCF, 0x0F, 0xBF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xF0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x38,
  0x1F, 0x80, 0xE0, 0x77, 0x81, 0xC1, 0xC7, 0x07, 0x03, 0x8E, 0x0E, 0x0F,
  0x1C, 0x38, 0x1C, 0x38, 0x70, 0x38, 0x71, 0xC0, 0x70, 0xE3, 0x81, 0xC3,
  0x8E, 0x03, 0x87, 0x3C, 0x07, 0x0E, 0x70, 0x0E, 0x3D, 0xE7, 0xDC, 0x73,
  0x9F, 0xF8, 0xEF, 0x7B, 0xFF, 0x9C, 0xE7, 0x7E, 0x73, 0x8E, 0xF8, 0xE7,
  0x1C, 0x03, 0x8E, 0x38, 0x07, 0x38, 0x70, 0x1C, 0x70, 0xE0, 0x38, 0xE1,
  0xC0, 0xE1, 0xC3, 0x81, 0xC3, 0x8E, 0x07, 0x06, 0x1C, 0x0E, 0x0C, 0x38,
  0x38, 0x1C, 0xE0, 0x70, 0x3B, 0xC1, 0xC0, 0x7F, 0x07, 0x80, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xE7, 0x80, 0x38, 0x70,
  0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8E, 0x00, 0xF3, 0xC0,
  0x1E, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x0F, 0x1F, 0xE1, 0xC7, 0x9E, 0x79, 0xE3, 0xCF, 0x3C, 0x7B, 0xCF,
  0x07, 0xF9, 0xE0, 0xFE, 0x3C, 0x1F, 0xC7, 0x81, 0xF0, 0xF0, 0x3C, 0x1E,
  0x0F, 0xC3, 0xE3, 0xF8, 0x7F, 0xFF, 0x87, 0xFC, 0xF0, 0x7F, 0x1F, 0x00,
  0x3C, 0xF3, 0x9E, 0x79, 0xE7, 0x1C, 0x73, 0xCE, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x87, 0x07, 0x38, 0x7F, 0xBF, 0xFF, 0xE3, 0xFF,
  0x0F, 0x80, 0xFC, 0x0F, 0x70, 0xF3, 0x87, 0x1E, 0x18, 0x70, 0x02, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x0F, 0x1F, 0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x78,
  0x70, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xF7, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0x9F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70,
  0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF1, 0xF0, 0xF3, 0xE0, 0x7F, 0xC0, 0x7F,
  0x80, 0x3F, 0x00, 0x00, 0xF0, 0x3E, 0x07, 0xE0, 0xFE, 0x1F, 0xE3, 0xFE,
  0x7F, 0xCF, 0x3C, 0x63, 0xC2, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x0F, 0x1F, 0x03, 0x03, 0xC0,
  0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xFF,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0xE0, 0x3F, 0xFC, 0x0E, 0x1F, 0x02, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x20, 0x1F, 0x0E, 0x0F, 0xC3, 0xFF, 0xE0, 0xFF,
  0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xDE, 0x00, 0x77,
  0x00, 0x3B, 0xC0, 0x1C, 0xF0, 0x07, 0x3C, 0x03, 0x8F, 0x01, 0xC3, 0x80,
  0x71, 0xE0, 0x38, 0x78, 0x1E, 0x1E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0,
  0xF0, 0x7F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xD8, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x20, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x40, 0x7C, 0x30, 0x7E, 0x1F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7C,
  0x10, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x9E, 0x03, 0xBF, 0x83, 0xFF, 0xE1, 0xFD, 0xF0,
  0xF8, 0x78, 0x78, 0x1E, 0x7C, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x8F, 0x03,
  0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x78, 0x78, 0x7C, 0x1E,
  0x7C, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xC7, 0xFF,
  0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0xF0,
  0xF0, 0xF0, 0x78, 0x78, 0x1C, 0x3C, 0x0E, 0x1E, 0x0F, 0x0F, 0x07, 0x87,
  0x83, 0x83, 0xC3, 0xC0, 0xF3, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xE0, 0x1F, 0x78, 0x1F, 0x3E, 0x1F, 0x0F, 0x0F, 0x03, 0xCF, 0x01,
  0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x3C, 0x78, 0x1E, 0x3E,
  0x1F, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0xC0, 0xF9, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x78, 0x1E, 0x3C,
  0x0F, 0x1E, 0x07, 0x8E, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xF3, 0xC0, 0xF1,
  0xE0, 0xF8, 0xF8, 0x7C, 0x3E, 0xFE, 0x1F, 0xFF, 0x0F, 0xF7, 0x01, 0xE7,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x20, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x00,
  0x03, 0x07, 0xC3, 0xE1, 0xF0, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0x0F, 0x87,
  0xC3, 0xC0, 0x00, 0xC0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78,
  0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F,
  0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x0F, 0xF0,
  0xFF, 0xC7, 0xFE, 0x30, 0xF1, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x7C, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x0E, 0x03, 0x80, 0x06, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E,
  0x0F, 0xC7, 0x1C, 0x3F, 0xC7, 0x1C, 0x39, 0xC7, 0x38, 0x71, 0xC7, 0x38,
  0xE1, 0xC7, 0x30, 0xE3, 0x87, 0x71, 0xC3, 0x86, 0x71, 0xC3, 0x86, 0x71,
  0xC3, 0x8E, 0x61, 0x87, 0x0E, 0xE3, 0x87, 0x0C, 0xE3, 0x87, 0x1C, 0xE3,
  0x8F, 0x1C, 0xE3, 0x8F, 0x38, 0xE3, 0xDF, 0x70, 0xE1, 0xF3, 0xF0, 0xE1,
  0xE3, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1D, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xEF, 0x00, 0x7B, 0xC0, 0x1E,
  0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C,
  0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F,
  0xFF, 0xC3, 0xC0, 0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xCF, 0x00,
  0xF3, 0xC0, 0x3D, 0xF0, 0x0F, 0x78, 0x03, 0xFE, 0x00, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xE7, 0xF0, 0x78, 0x3E, 0x0F, 0x03,
  0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x78, 0x3C, 0x0F,
  0x07, 0x83, 0xC0, 0xF1, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x1E, 0x1F, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x03, 0xC3, 0xC0, 0xF8,
  0x78, 0x1E, 0x0E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x07, 0xC1,
  0xE7, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0x8C, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC7, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F,
  0x0F, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x03,
  0xE1, 0xE0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0x83, 0xC0,
  0x78, 0x3C, 0x0F, 0x87, 0x81, 0xF0, 0x78, 0x3E, 0x07, 0x87, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x02, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7E, 0x1E, 0x0F,
  0xC0, 0x40, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x3F, 0xCF, 0x03, 0xF8, 0xF0, 0x3F, 0x8F, 0x00, 0x78, 0xF0, 0x07,
  0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x0F, 0x0F, 0x81, 0xE0, 0x7C, 0x1E, 0x07, 0xFF, 0xE0, 0x3F,
  0xFE, 0x01, 0xFF, 0x80, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x81,
  0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0,
  0x7C, 0x0F, 0x01, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C,
  0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x07,
  0x81, 0xE0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x03, 0xC0, 0xF0, 0x0F, 0x03,
  0xC0, 0x3C, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x07, 0xF8, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x8F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03,
  0xC0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x7C, 0x07, 0x83, 0xC0, 0x78, 0x3C,
  0x03, 0xC3, 0xE0, 0x1E, 0x3E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0x79,
  0xF0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0x78, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFB, 0xC0, 0x0F, 0x9E,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF0, 0xF0, 0x0F,
  0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x01, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFC,
  0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03,
  0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xEE, 0x01, 0xFC, 0x0F, 0x70, 0x1F, 0xE0,
  0x7B, 0x80, 0xEF, 0x03, 0xDC, 0x0F, 0x78, 0x1E, 0xE0, 0x73, 0x80, 0xE7,
  0x07, 0xBC, 0x0F, 0x38, 0x3D, 0xE0, 0x79, 0xC1, 0xCF, 0x03, 0xCE, 0x1E,
  0x78, 0x1E, 0x70, 0xE7, 0x80, 0xE3, 0x8F, 0x3C, 0x0F, 0x1C, 0x71, 0xE0,
  0x78, 0xE7, 0x8F, 0x03, 0xC7, 0x38, 0x70, 0x1E, 0x3B, 0xC7, 0x80, 0xE1,
  0xDC, 0x3C, 0x0F, 0x0F, 0xE1, 0xE0, 0x78, 0x7F, 0x0F, 0x03, 0xC3, 0xF0,
  0x70, 0x1C, 0x1F, 0x87, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xE0,
  0x78, 0x3C, 0x0F, 0x00, 0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x3C, 0x0F, 0x80,
  0x78, 0x1F, 0x00, 0xE0, 0x7F, 0x03, 0xC0, 0xFE, 0x07, 0x81, 0xFC, 0x0F,
  0x03, 0xB8, 0x1E, 0x0F, 0x70, 0x38, 0x1E, 0xE0, 0xF0, 0x3D, 0xE1, 0xE0,
  0x7B, 0xC3, 0xC0, 0xE7, 0x87, 0x83, 0xC7, 0x0E, 0x07, 0x8E, 0x3C, 0x0F,
  0x1C, 0x78, 0x1E, 0x3C, 0xF0, 0x38, 0x79, 0xE0, 0xF0, 0xF3, 0x81, 0xE0,
  0xEF, 0x03, 0xC1, 0xDE, 0x07, 0x83, 0xBC, 0x0E, 0x07, 0xF0, 0x3C, 0x0F,
  0xE0, 0x78, 0x1F, 0xC0, 0xF0, 0x1F, 0x81, 0xC0, 0x3F, 0x07, 0x80, 0x7C,
  0x0F, 0x00, 0xF8, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFC,
  0x01, 0xFF, 0xE0, 0x3E, 0x3E, 0x07, 0xC1, 0xE0, 0xF8, 0x1F, 0x0F, 0x00,
  0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0,
  0x0F, 0x3C, 0x01, 0xF7, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78,
  0x01, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xCF, 0x80, 0x3C, 0xF8, 0x07, 0xCF,
  0x80, 0x78, 0xF8, 0x07, 0x87, 0x80, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xE0,
  0x7E, 0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x78, 0x3C, 0x0F, 0x07,
  0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0x0F, 0x83, 0xE1, 0xE0, 0x78, 0x3C, 0x0F,
  0x07, 0x81, 0xE0, 0xF0, 0x7C, 0x3C, 0x1F, 0x07, 0x87, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3E, 0x3E, 0x07, 0xC1, 0xE0, 0xF8,
  0x1F, 0x0F, 0x00, 0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x3C,
  0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x01, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xE7,
  0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xCF, 0x80, 0x3C,
  0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x07, 0x87, 0x80, 0xF8, 0x78, 0x1F,
  0x07, 0x81, 0xE0, 0x7E, 0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xC0,
  0x3F, 0xF8, 0x0E, 0x7F, 0x07, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x07,
  0x87, 0x83, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x03,
  0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xC0, 0xF8, 0xF0, 0x1E,
  0x3C, 0x07, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF9,
  0xE0, 0x7C, 0x08, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3E, 0x08, 0x0F, 0x83, 0xE7, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF0, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0xF8, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0,
  0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x1E, 0x01, 0xE0,
  0xF0, 0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x83, 0xE0, 0x3C, 0x1E, 0x01,
  0xE0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x83, 0xC0, 0x3C, 0x1E,
  0x01, 0xE0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x83, 0xC0, 0x3C,
  0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC1, 0xF0, 0x1F, 0x1F, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x07, 0xF8, 0x07, 0xFC,
  0x03, 0xDE, 0x01, 0xEF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF1, 0xE0, 0x78,
  0xF0, 0x3C, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x8F,
  0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x39, 0xE0, 0x1C,
  0xF0, 0x0E, 0x70, 0x07, 0x78, 0x03, 0xBC, 0x01, 0xDC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x78,
  0x07, 0x00, 0xF7, 0x00, 0xF0, 0x0F, 0x70, 0x0F, 0x01, 0xE7, 0x01, 0xF0,
  0x1E, 0x70, 0x1F, 0x01, 0xE7, 0x01, 0xF0, 0x3C, 0x70, 0x3F, 0x03, 0xCF,
  0x03, 0xF0, 0x78, 0xF0, 0x7F, 0x07, 0x8F, 0x07, 0x70, 0x78, 0xF0, 0x77,
  0x0F, 0x0F, 0x0F, 0x70, 0xF0, 0xF0, 0xE7, 0x0F, 0x0F, 0x0E, 0x71, 0xE0,
  0xF1, 0xC7, 0x1E, 0x0F, 0x1C, 0xF3, 0xC0, 0xF3, 0xCF, 0x3C, 0x0F, 0x38,
  0xF3, 0xC0, 0xF3, 0x8F, 0x78, 0x0F, 0x78, 0xF7, 0x80, 0xF7, 0x0F, 0xF0,
  0x0F, 0xF0, 0xEF, 0x00, 0xFE, 0x0E, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0xFC,
  0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x0F,
  0x07, 0xC0, 0x78, 0x3C, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF1, 0xE0,
  0x07, 0x8F, 0x00, 0x1C, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x7B, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xC3, 0x80, 0x1E,
  0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x81, 0xE0,
  0x78, 0x0F, 0x00, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x3C, 0x78, 0x3C, 0x78, 0x78, 0x78, 0x70, 0x38, 0xF0, 0x38, 0xE0, 0x39,
  0xE0, 0x3D, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x70, 0x78,
  0x78, 0x78, 0x78, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0F, 0x00,
  0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x0F, 0x78, 0x07, 0x3C, 0x07, 0x8E, 0x03, 0x87, 0x03, 0xC3,
  0xC3, 0xC1, 0xE1, 0xC0, 0x71, 0xE0, 0x38, 0xE0, 0x1E, 0xF0, 0x0F, 0xF0,
  0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0xF9, 0xE7, 0x8F, 0x3C, 0x70, 0xC0,
  0x01, 0xE3, 0x83, 0xF9, 0xC3, 0xFF, 0xE3, 0xF7, 0xF1, 0xE1, 0xF1, 0xF0,
  0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F,
  0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C,
  0x78, 0x3E, 0x3C, 0x3E, 0x1F, 0x1F, 0x07, 0xFF, 0x83, 0xFB, 0xC0, 0xF9,
  0xE0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x8F, 0x03, 0xDF,
  0xC1, 0xFF, 0xF0, 0xFC, 0xF8, 0x7C, 0x3C, 0x3C, 0x1E, 0x3E, 0x0F, 0x1E,
  0x07, 0x8F, 0x03, 0xC7, 0x01, 0xE3, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x78,
  0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x87,
  0x87, 0xC7, 0xC7, 0xFF, 0xC3, 0xDF, 0xC1, 0xCF, 0xC0, 0x01, 0xF8, 0x0F,
  0xF0, 0xFF, 0x83, 0xE6, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x10, 0x7F, 0xC1, 0xFF, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x3C, 0xF0, 0x1F, 0xDE, 0x07, 0xFF, 0xC0, 0xFB, 0xF8, 0x3C, 0x3E, 0x0F,
  0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x0F, 0x01, 0xC1, 0xE0, 0x78, 0x3C,
  0x0F, 0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x07, 0x81, 0xE0, 0xF0,
  0x3C, 0x1E, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x0F, 0x8F, 0x81, 0xFF,
  0x70, 0x1F, 0xDE, 0x01, 0xF3, 0xC0, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xF0,
  0x78, 0xF1, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0xBC, 0x0F, 0x78, 0x3C, 0xF1,
  0xF1, 0xFF, 0xC7, 0xFF, 0x0F, 0xF0, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC1, 0x87, 0xFF, 0x07, 0xFE, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF2,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0xBE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0xE0, 0x3F, 0x9C, 0x0F, 0xFF, 0x81, 0xF7, 0xF0, 0x78, 0x7C, 0x1F,
  0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF0, 0x78,
  0x1E, 0x0F, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xC1, 0xE0,
  0x78, 0x3C, 0x0F, 0x07, 0x83, 0xE0, 0xF0, 0xF8, 0x1F, 0x3F, 0x03, 0xFF,
  0xE0, 0x3F, 0xBC, 0x03, 0xE7, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x08, 0x0F, 0x81, 0xC3, 0xE0, 0x3F, 0xFC,
  0x07, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0x9F, 0x03, 0xDF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x7C, 0x3C,
  0x3C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0x81,
  0xE3, 0xC0, 0xF1, 0xE0, 0x70, 0xF0, 0x78, 0x78, 0x3C, 0x78, 0x1E, 0x3C,
  0x0F, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0xE1,
  0xE0, 0xF0, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x17, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0xF0, 0xF0, 0x78, 0x3C,
  0x3C, 0x0F, 0x1F, 0x03, 0xC7, 0x80, 0xE3, 0xC0, 0x79, 0xE0, 0x1E, 0xF8,
  0x07, 0xBC, 0x01, 0xDE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x03,
  0xEF, 0x00, 0xF3, 0xC0, 0x38, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE1,
  0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x01, 0xE0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0x07, 0x3E, 0x1F, 0x07, 0xBF, 0x9F,
  0xC3, 0xFF, 0xDF, 0xE1, 0xF9, 0xFD, 0xF0, 0xF8, 0xFC, 0x78, 0x78, 0x3C,
  0x3C, 0x78, 0x3E, 0x1E, 0x3C, 0x1E, 0x0F, 0x1E, 0x0F, 0x07, 0x8F, 0x07,
  0x83, 0xC7, 0x03, 0x81, 0xC7, 0x83, 0xC1, 0xE3, 0xC1, 0xE0, 0xF1, 0xE0,
  0xF0, 0x78, 0xF0, 0x78, 0x3C, 0xF0, 0x38, 0x1C, 0x78, 0x3C, 0x1E, 0x3C,
  0x1E, 0x0F, 0x1E, 0x0F, 0x07, 0x8E, 0x07, 0x83, 0x8F, 0x03, 0x83, 0xC7,
  0x83, 0xC1, 0xE3, 0xC1, 0xE0, 0xF0, 0x07, 0x3E, 0x07, 0xBF, 0x83, 0xBF,
  0xC1, 0xFF, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x7C, 0x1E, 0x3C, 0x0E, 0x1E,
  0x0F, 0x0F, 0x07, 0x87, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xE1, 0xE0, 0xF0,
  0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0E, 0x07,
  0x8F, 0x03, 0xC7, 0x81, 0xC3, 0xC1, 0xE0, 0x01, 0xF0, 0x07, 0xFC, 0x0F,
  0xFE, 0x0F, 0xBE, 0x1E, 0x1E, 0x3C, 0x0E, 0x3C, 0x0F, 0x3C, 0x0F, 0x78,
  0x0F, 0x78, 0x0E, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF8, 0xF0, 0x7F,
  0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x01, 0xC7, 0x80, 0x7B, 0xF8, 0x0F, 0xFF,
  0x81, 0xD9, 0xF0, 0x3E, 0x1E, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x0F,
  0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x3C,
  0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x70, 0x1E, 0x1E, 0x07, 0x83, 0xC0, 0xF0,
  0x7C, 0x3C, 0x0F, 0x8F, 0x83, 0xFF, 0xE0, 0x7B, 0xF8, 0x0F, 0x3E, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE3, 0x83, 0xF9, 0xC3, 0xFF, 0xE1, 0xF7, 0xF1, 0xE1, 0xF0, 0xF0,
  0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x1E, 0x07, 0x8E,
  0x03, 0xCF, 0x01, 0xE7, 0x80, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C,
  0x78, 0x3E, 0x3C, 0x1E, 0x1F, 0x1F, 0x0F, 0xFF, 0x83, 0xFB, 0xC0, 0xF9,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x07,
  0x3C, 0x3D, 0xF0, 0xEF, 0xC3, 0xBE, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0xF0, 0xFF, 0xC7, 0xC6, 0x1E,
  0x08, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0x88,
  0x1E, 0x30, 0xF8, 0xFF, 0xC3, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0x80, 0x70,
  0x1C, 0x03, 0x80, 0xF0, 0x1F, 0xCF, 0xFB, 0xFF, 0x7F, 0xC3, 0xC0, 0x78,
  0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F, 0x00,
  0x0E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xE0,
  0x78, 0xF0, 0x38, 0x78, 0x3C, 0x3C, 0x1E, 0x1C, 0x0F, 0x1E, 0x07, 0x8F,
  0x03, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x78,
  0x78, 0x3C, 0x3C, 0x3E, 0x1E, 0x3F, 0x0F, 0xFF, 0x83, 0xFB, 0x81, 0xF9,
  0xC0, 0xF0, 0x1E, 0xE0, 0x3D, 0xC0, 0xF3, 0x81, 0xE7, 0x07, 0x8E, 0x0F,
  0x1C, 0x1C, 0x38, 0x78, 0x70, 0xE0, 0xE3, 0xC1, 0xC7, 0x83, 0x9E, 0x07,
  0x3C, 0x0E, 0x70, 0x1D, 0xE0, 0x3B, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x70, 0x3C, 0x0F,
  0x70, 0x3C, 0x1E, 0x70, 0x7C, 0x1E, 0x70, 0x7C, 0x1E, 0x70, 0xFC, 0x3C,
  0x70, 0xFC, 0x3C, 0x70, 0xFC, 0x38, 0xF1, 0xDC, 0x78, 0xF1, 0xDC, 0x70,
  0xF3, 0xDC, 0xF0, 0xF3, 0x9C, 0xF0, 0xF3, 0x9C, 0xE0, 0xF7, 0x1D, 0xE0,
  0xF7, 0x1D, 0xC0, 0xF7, 0x1D, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80,
  0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x3F, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x0E,
  0x1F, 0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF7, 0x80, 0x0E,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x3B, 0xC0, 0x0F, 0x78, 0x03, 0xCF,
  0x00, 0x78, 0xE0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x3C, 0x0F,
  0x00, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x3C, 0x03, 0x81, 0xE0,
  0x1C, 0x0E, 0x00, 0xE0, 0xF0, 0x07, 0x07, 0x80, 0x38, 0x78, 0x01, 0xC3,
  0xC0, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCE, 0x00, 0x1E, 0xF0, 0x00,
  0xF7, 0x00, 0x07, 0x78, 0x00, 0x3B, 0xC0, 0x01, 0xDC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x2F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0xF8,
  0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x38, 0x01,
  0x7F, 0x01, 0xFF, 0xE7, 0xFF, 0xFF, 0x81, 0xFE, 0x80, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 11, 30, 10, 0, -30 },
  { 43, 13, 11, 15, 4, -30 },
  { 61, 20, 30, 18, 0, -30 },
  { 136, 18, 34, 17, 0, -32 },
  { 213, 23, 30, 27, 2, -30 },
  { 300, 19, 30, 19, 0, -30 },
  { 372, 6, 11, 9, 4, -30 },
  { 381, 13, 37, 11, 1, -30 },
  { 442, 13, 37, 11, -3, -30 },
  { 503, 13, 15, 16, 4, -32 },
  { 528, 16, 20, 18, 2, -25 },
  { 568, 8, 11, 9, -2, -5 },
  { 579, 9, 4, 11, 1, -13 },
  { 584, 5, 5, 9, 0, -5 },
  { 588, 20, 30, 14, -2, -30 },
  { 663, 16, 30, 17, 1, -30 },
  { 723, 12, 30, 17, 4, -30 },
  { 768, 18, 30, 17, -1, -30 },
  { 836, 18, 30, 17, -1, -30 },
  { 904, 18, 30, 17, -1, -30 },
  { 972, 17, 30, 17, 0, -30 },
  { 1036, 17, 30, 17, 1, -30 },
  { 1100, 18, 30, 17, 1, -30 },
  { 1168, 17, 30, 17, 0, -30 },
  { 1232, 17, 30, 17, 0, -30 },
  { 1296, 9, 23, 9, 0, -23 },
  { 1322, 11, 29, 9, -2, -23 },
  { 1362, 16, 19, 18, 2, -24 },
  { 1400, 16, 12, 18, 2, -21 },
  { 1424, 16, 19, 18, 2, -24 },
  { 1462, 13, 30, 13, 1, -30 },
  { 1511, 24, 33, 25, 1, -30 },
  { 1610, 18, 30, 18, -3, -30 },
  { 1678, 19, 30, 19, 0, -30 },
  { 1750, 18, 30, 17, 2, -30 },
  { 1818, 20, 30, 20, 0, -30 },
  { 1893, 18, 30, 16, 0, -30 },
  { 1961, 18, 30, 15, 0, -30 },
  { 2029, 20, 30, 21, 2, -30 },
  { 2104, 22, 30, 21, 0, -30 },
  { 2187, 17, 30, 12, -2, -30 },
  { 2251, 16, 38, 9, -6, -30 },
  { 2327, 21, 30, 18, 0, -30 },
  { 2406, 12, 30, 15, 0, -30 },
  { 2451, 29, 30, 28, 0, -30 },
  { 2560, 23, 30, 22, 0, -30 },
  { 2647, 20, 30, 21, 1, -30 },
  { 2722, 19, 30, 18, 0, -30 },
  { 2794, 20, 37, 21, 1, -30 },
  { 2887, 18, 30, 18, 0, -30 },
  { 2955, 19, 30, 16, -1, -30 },
  { 3027, 15, 30, 15, 3, -30 },
  { 3084, 21, 30, 20, 1, -30 },
  { 3163, 17, 30, 18, 4, -30 },
  { 3227, 28, 30, 28, 3, -30 },
  { 3332, 21, 30, 16, -2, -30 },
  { 3411, 16, 30, 16, 3, -30 },
  { 3471, 19, 30, 15, -2, -30 },
  { 3543, 16, 37, 12, -1, -30 },
  { 3617, 8, 30, 15, 4, -30 },
  { 3647, 16, 37, 12, -3, -30 },
  { 3721, 17, 17, 17, 0, -30 },
  { 3758, 14, 2, 13, -4, 4 },
  { 3762, 6, 7, 11, 6, -32 },
  { 3768, 17, 23, 18, 1, -23 },
  { 3817, 17, 32, 18, 0, -32 },
  { 3885, 14, 23, 14, 1, -23 },
  { 3926, 19, 32, 18, 1, -32 },
  { 4002, 15, 23, 17, 1, -23 },
  { 4046, 20, 42, 10, -5, -32 },
  { 4151, 19, 33, 18, -1, -23 },
  { 4230, 17, 32, 18, 0, -32 },
  { 4298, 10, 31, 9, 0, -31 },
  { 4337, 15, 41, 9, -5, -31 },
  { 4414, 18, 32, 16, 0, -32 },
  { 4486, 11, 32, 8, 0, -32 },
  { 4530, 25, 23, 26, 0, -23 },
  { 4602, 17, 23, 18, 0, -23 },
  { 4651, 16, 23, 18, 1, -23 },
  { 4697, 19, 33, 18, -2, -23 },
  { 4776, 17, 33, 18, 1, -23 },
  { 4847, 14, 23, 12, 0, -23 },
  { 4888, 14, 23, 14, 0, -23 },
  { 4929, 11, 28, 11, 1, -28 },
  { 4968, 17, 23, 18, 1, -23 },
  { 5017, 15, 23, 15, 2, -23 },
  { 5061, 24, 23, 24, 2, -23 },
  { 5130, 19, 23, 15, -2, -23 },
  { 5185, 21, 33, 15, -4, -23 },
  { 5272, 16, 23, 13, -2, -23 },
  { 5318, 16, 37, 14, 1, -30 },
  { 5392, 3, 42, 15, 6, -32 },
  { 5408, 16, 37, 14, -3, -30 },
  { 5482, 16, 6, 18, 2, -18 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC42PT7B_H_
