#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC31PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x18, 0x38, 0x38, 0x38, 0x30, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xE0, 0x73,
  0xB9, 0xDC, 0xEC, 0x66, 0x37, 0x3B, 0x9D, 0x8C, 0x01, 0x8C, 0x06, 0x70,
  0x31, 0x80, 0xC6, 0x03, 0x38, 0x1C, 0xC3, 0xFF, 0xCF, 0xFF, 0x0E, 0x60,
  0x31, 0x80, 0xC6, 0x07, 0x30, 0x18, 0xC3, 0xFF, 0xCF, 0xFF, 0x0C, 0x60,
  0x31, 0x80, 0xCE, 0x06, 0x30, 0x18, 0xC0, 0x67, 0x03, 0x98, 0x00, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x07, 0xE0, 0xFF, 0x8F, 0xF8, 0x76, 0x43, 0x20,
  0x19, 0x00, 0xE8, 0x07, 0x40, 0x1E, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x00,
  0xDC, 0x06, 0xE0, 0x27, 0x21, 0x39, 0x8B, 0x8F, 0xFC, 0x7F, 0xC0, 0x70,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x1E, 0x0E, 0x1F, 0x06, 0x19, 0xC7,
  0x0C, 0xE3, 0x0E, 0x63, 0x86, 0x31, 0x83, 0x19, 0xC1, 0x8C, 0xC0, 0xCE,
  0xE2, 0x66, 0x67, 0xB3, 0x67, 0xFF, 0x37, 0x3F, 0x33, 0x18, 0x19, 0x9C,
  0x19, 0x8E, 0x0C, 0xC6, 0x0C, 0x63, 0x0E, 0x31, 0x86, 0x19, 0x87, 0x0C,
  0xC3, 0x07, 0xC3, 0x81, 0xE0, 0x03, 0xE0, 0x1F, 0xC0, 0xE7, 0x03, 0x9C,
  0x0E, 0x70, 0x39, 0x80, 0xEE, 0x03, 0xB0, 0x0F, 0xC0, 0x3E, 0x00, 0xF0,
  0x07, 0xC7, 0x3B, 0x99, 0xCE, 0xE6, 0x3B, 0xB8, 0x7C, 0xE1, 0xF3, 0x87,
  0x8E, 0x1E, 0x38, 0xF8, 0xFF, 0xF1, 0xF9, 0xC0, 0x77, 0x77, 0x6E, 0xEC,
  0x03, 0x83, 0x81, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x30, 0x38, 0x1C,
  0x0C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0xC0, 0xE0, 0x70, 0x18, 0x00, 0x07, 0x01, 0xC0, 0xE0, 0x70,
  0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C,
  0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x70, 0x30,
  0x30, 0x00, 0x0C, 0x03, 0x80, 0xE3, 0x30, 0xFF, 0xDF, 0xF1, 0xC0, 0xF8,
  0x76, 0x39, 0xC2, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x39, 0xCE, 0xE7, 0x33, 0x98, 0x7F, 0x7E, 0xFE, 0x7F, 0xFE, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x7B, 0x8E, 0x33, 0x86,
  0x70, 0xDC, 0x1B, 0x87, 0x70, 0xEE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3,
  0xB8, 0x76, 0x0E, 0xC3, 0x98, 0x73, 0x9C, 0x77, 0x8F, 0xE0, 0xF8, 0x00,
  0x07, 0x87, 0x87, 0xC7, 0xE7, 0x77, 0x31, 0x38, 0x1C, 0x0E, 0x07, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03,
  0x80, 0x03, 0xF0, 0x1F, 0xE0, 0xE3, 0x81, 0x0F, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1F, 0xF8,
  0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xF0, 0x3F, 0xE0, 0x63, 0xC1, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x1F, 0x80, 0x78, 0x03,
  0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x88,
  0x1E, 0x38, 0xF0, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x06, 0xE0, 0x3B, 0x00, 0xDC, 0x06, 0x70, 0x39,
  0xC0, 0xC6, 0x06, 0x38, 0x18, 0xE0, 0xC3, 0x87, 0x0E, 0x1F, 0xFE, 0x7F,
  0xF2, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x07, 0xF8,
  0x7F, 0x83, 0xFC, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x3F,
  0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0E, 0x20, 0xF1, 0x9F, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xF0,
  0x7F, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x77, 0x87,
  0xFC, 0xFF, 0xCF, 0x1C, 0xE0, 0xEE, 0x0C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE,
  0x1C, 0xE3, 0x8F, 0x78, 0x7F, 0x07, 0xE0, 0x3F, 0xF9, 0xFF, 0xCF, 0xFC,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x7F, 0x87, 0x9E,
  0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x71, 0xC3, 0x8E, 0x0E, 0xE0, 0x7E, 0x03,
  0xC0, 0x3F, 0x03, 0x9C, 0x38, 0xE3, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07,
  0x38, 0x71, 0xE7, 0x87, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFF, 0x1E, 0x71,
  0xC7, 0x38, 0x33, 0x83, 0x38, 0x73, 0x87, 0x38, 0x73, 0x87, 0x38, 0xF3,
  0xFF, 0x3F, 0x61, 0xEE, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x88,
  0xF0, 0xFE, 0x0F, 0xC0, 0x0C, 0x3C, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x3C, 0x78, 0xE0, 0x03, 0x03, 0xC1, 0xE0, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70,
  0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x00, 0x00, 0x10, 0x07, 0x01, 0xF0,
  0x7C, 0x1F, 0x07, 0xE0, 0xF8, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x80,
  0xE0, 0x08, 0x00, 0x1F, 0x8F, 0xE3, 0x3C, 0x07, 0x01, 0xC0, 0x60, 0x38,
  0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x81,
  0xC0, 0xC1, 0xC0, 0x31, 0xC0, 0x18, 0xC0, 0x0C, 0xC3, 0xE6, 0x63, 0xF3,
  0x63, 0x19, 0xB1, 0x9C, 0xD9, 0x8C, 0x78, 0xC6, 0x3C, 0x63, 0x1E, 0x73,
  0x9B, 0x31, 0x8D, 0x98, 0xCC, 0xCE, 0xBE, 0x63, 0xDE, 0x30, 0x80, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xE3, 0x80, 0x7F, 0xC0, 0x06, 0x00,
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x0E,
  0xE0, 0x77, 0x03, 0x38, 0x39, 0xC1, 0xCE, 0x1C, 0x70, 0xE3, 0x87, 0xFC,
  0x7F, 0xE3, 0x87, 0x38, 0x39, 0xC1, 0xDE, 0x0E, 0xE0, 0x77, 0x03, 0xF0,
  0x1C, 0x07, 0xF0, 0x3F, 0xE0, 0xE3, 0xC3, 0x87, 0x0E, 0x1C, 0x70, 0x71,
  0xC1, 0xC7, 0x0E, 0x1C, 0x78, 0x7F, 0xC3, 0xFC, 0x0F, 0xF8, 0x38, 0x70,
  0xE1, 0xC3, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x0E, 0x3F, 0xF8,
  0xFF, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0xF1, 0x87, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x60, 0x7F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xE0, 0xFF,
  0xC3, 0x8F, 0x0E, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x70,
  0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0xE3, 0x83, 0x9C, 0x1E, 0x70,
  0x71, 0xC3, 0xC7, 0x1E, 0x3F, 0xF0, 0xFF, 0x83, 0xF8, 0x00, 0x07, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xFF, 0x0F, 0xF8, 0x7F, 0x80, 0x07, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xFE,
  0x0F, 0xFC, 0x3E, 0x30, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC3, 0xF7, 0x87, 0xCE, 0x1F, 0x9C, 0x07,
  0x38, 0x0E, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE1, 0xC1, 0xC3, 0xE7, 0x83,
  0xFE, 0x03, 0xFC, 0x00, 0x07, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x0E,
  0x0E, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x1C, 0x1F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x70, 0x38,
  0x70, 0x38, 0x70, 0x70, 0x70, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70,
  0x07, 0xF8, 0x3F, 0x80, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x07, 0xF0, 0x7F, 0x80,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0x0F,
  0x0E, 0x1E, 0x0E, 0x1C, 0x0E, 0x38, 0x0E, 0x78, 0x1C, 0x70, 0x1C, 0xE0,
  0x1D, 0xC0, 0x1D, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3B, 0x80, 0x31, 0xC0, 0x71, 0xC0, 0x71, 0xC0, 0x71, 0xC0, 0x71, 0xC0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0,
  0x70, 0x38, 0x1C, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x78, 0x7C, 0x07,
  0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7E,
  0x0F, 0xC3, 0xF0, 0x6E, 0x1F, 0x87, 0x60, 0xDC, 0x37, 0x0E, 0xE3, 0xB8,
  0x73, 0x19, 0xC3, 0x99, 0xCE, 0x1C, 0xCE, 0x60, 0xC6, 0xE7, 0x0E, 0x37,
  0x38, 0x71, 0xB1, 0xC3, 0x8F, 0x8E, 0x18, 0x78, 0xE1, 0xC3, 0xC7, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x07, 0x03, 0x87, 0x81, 0xC3, 0xC0, 0xE1,
  0xF0, 0x60, 0xF8, 0x70, 0xFC, 0x38, 0x76, 0x1C, 0x3B, 0x0E, 0x1D, 0x86,
  0x0C, 0xE7, 0x0E, 0x73, 0x87, 0x39, 0xC3, 0x8C, 0xC1, 0xC6, 0xE0, 0xC3,
  0x70, 0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x7C, 0x18, 0x1E, 0x1C, 0x0F, 0x0E,
  0x07, 0x87, 0x03, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0xF3, 0xC7, 0x87, 0x1C,
  0x1C, 0xE0, 0x73, 0x81, 0xDE, 0x07, 0x70, 0x1D, 0xC0, 0x77, 0x01, 0xFC,
  0x07, 0xE0, 0x3F, 0x80, 0xEE, 0x03, 0xB8, 0x1E, 0xE0, 0x73, 0x83, 0xCF,
  0x0E, 0x1E, 0xF0, 0x7F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xE0, 0xFF,
  0x83, 0x8F, 0x0E, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x0E, 0x1C, 0x38, 0x71,
  0xE3, 0x8F, 0x0F, 0xF8, 0x3F, 0xC0, 0xF8, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0xF8,
  0x1F, 0xE0, 0xF3, 0xC7, 0x87, 0x1C, 0x1C, 0xE0, 0x73, 0x81, 0xDE, 0x07,
  0x70, 0x1D, 0xC0, 0x77, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xEE, 0x03,
  0xB8, 0x1E, 0xE0, 0x73, 0x83, 0xCF, 0x0E, 0x1E, 0xF8, 0x7F, 0xC0, 0xFC,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x07, 0xE0,
  0x3F, 0xE0, 0xEF, 0x83, 0x8E, 0x0E, 0x1C, 0x70, 0xF1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x71, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0xEE, 0x03, 0x1C,
  0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x38, 0x38, 0xE0, 0xE3, 0x83,
  0x80, 0x03, 0xFC, 0x1F, 0xF0, 0xF9, 0x83, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x84, 0x1E, 0x1F, 0xF0,
  0xFF, 0x81, 0xFC, 0x00, 0x7F, 0xF7, 0xFE, 0xFF, 0xE0, 0xE0, 0x0E, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E,
  0x00, 0x1E, 0x0E, 0x38, 0x1C, 0x70, 0x70, 0xE0, 0xE1, 0xC1, 0xC7, 0x03,
  0x8E, 0x07, 0x1C, 0x1C, 0x38, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x83, 0x87,
  0x07, 0x0E, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0xE1, 0xC1, 0xC3, 0x87,
  0x87, 0xBE, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0xE0, 0x7F, 0x03, 0xB8, 0x3D,
  0xC1, 0xCE, 0x0E, 0x70, 0xE3, 0x87, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x39,
  0xC1, 0xCE, 0x0E, 0xE0, 0x77, 0x03, 0xB0, 0x1B, 0x80, 0xDC, 0x06, 0xC0,
  0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x00, 0x70, 0x70, 0x3B, 0x83, 0x81,
  0xD8, 0x1C, 0x1C, 0xC1, 0xE0, 0xE6, 0x0F, 0x0E, 0x30, 0xF8, 0x71, 0x86,
  0xC3, 0x8C, 0x36, 0x38, 0xE3, 0xB1, 0xC7, 0x1B, 0x9C, 0x38, 0xDC, 0xE1,
  0xCE, 0xE7, 0x0E, 0x67, 0x70, 0x77, 0x3B, 0x83, 0xB1, 0xD8, 0x1D, 0x8F,
  0xC0, 0xFC, 0x7E, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF0, 0x0F,
  0x07, 0x80, 0x78, 0x3C, 0x00, 0x07, 0x07, 0x03, 0x0E, 0x03, 0x8E, 0x03,
  0x9C, 0x03, 0x9C, 0x03, 0xB8, 0x03, 0xB8, 0x03, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x06, 0xE0, 0x0E,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0x70, 0x70, 0x70, 0xF0,
  0x70, 0x70, 0x77, 0x0F, 0x70, 0xE7, 0x1C, 0x71, 0xC7, 0x38, 0x73, 0x83,
  0x70, 0x37, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE,
  0x00, 0x03, 0xF0, 0x7F, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06,
  0x00, 0x62, 0x0F, 0xC0, 0xFC, 0x00, 0xE3, 0x8E, 0x18, 0x61, 0x87, 0x1C,
  0x71, 0xC7, 0x0C, 0x30, 0xC3, 0x8E, 0x38, 0xE3, 0x86, 0x18, 0x70, 0x07,
  0xF0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C,
  0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x0F, 0x80, 0x6E,
  0x07, 0x70, 0x31, 0x83, 0x8C, 0x38, 0x71, 0x83, 0x9C, 0x0D, 0xC0, 0x70,
  0xFF, 0xFF, 0xF0, 0xEE, 0xE7, 0x30, 0x0F, 0x31, 0xFB, 0x3F, 0xF3, 0x8F,
  0x70, 0xF7, 0x0E, 0x70, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0x1C,
  0xE1, 0xCE, 0x3C, 0xE7, 0x8F, 0xD8, 0x79, 0x80, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x9C, 0x1F, 0xF0, 0xFF,
  0x87, 0x0E, 0x38, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xC6, 0x0E, 0x70, 0x73,
  0x83, 0x9C, 0x1C, 0xE1, 0xC7, 0x0E, 0x7C, 0xE3, 0xFE, 0x19, 0xE0, 0x07,
  0xC7, 0xF1, 0xF8, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0F, 0x23, 0xF8, 0x7E, 0x00, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x83, 0xCC, 0x1F,
  0xF0, 0xFF, 0xC3, 0x8F, 0x1C, 0x3C, 0x70, 0xE1, 0xC3, 0x8E, 0x0E, 0x38,
  0x38, 0xE0, 0xE3, 0x83, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xC3, 0x9E, 0x0F,
  0xD8, 0x1E, 0x60, 0x07, 0x83, 0xF8, 0x77, 0x9C, 0x77, 0x0E, 0xE1, 0x98,
  0x77, 0xFC, 0xFF, 0x1E, 0x03, 0x80, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x43,
  0xF8, 0x3F, 0x00, 0x00, 0x0C, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xCC, 0x1F, 0xB0, 0xFF, 0xC3, 0x8F, 0x1C, 0x3C, 0x70,
  0xE1, 0xC3, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE3, 0xC3, 0x9E, 0x0F, 0xF8, 0x1E, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x01, 0xC3, 0x0F, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xDE, 0x1F, 0xF1, 0xFF, 0x1C,
  0x71, 0xC7, 0x38, 0x73, 0x87, 0x38, 0x73, 0x87, 0x30, 0xE7, 0x0E, 0x70,
  0xE7, 0x0E, 0x70, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0x06, 0x0F, 0x0E, 0x04,
  0x00, 0x00, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x70,
  0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0x00, 0x60, 0x0F, 0x00, 0xE0,
  0x04, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0xF8, 0x0F, 0x00, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x03, 0x87, 0x1C, 0x70, 0xE3, 0x87, 0x38, 0x33, 0x83,
  0xB8, 0x1D, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x83, 0xDC, 0x1C, 0xE0, 0xE7,
  0x06, 0x38, 0x70, 0xC3, 0x87, 0x1C, 0x38, 0x07, 0x07, 0x06, 0x0E, 0x0E,
  0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30,
  0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0x1D, 0xE3, 0xC3, 0xFE, 0xF8,
  0x7F, 0xFF, 0x8E, 0x3C, 0x71, 0xC7, 0x0E, 0x70, 0xE1, 0x8E, 0x1C, 0x71,
  0xC3, 0x0E, 0x38, 0xE1, 0xCE, 0x1C, 0x39, 0xC3, 0x86, 0x38, 0x71, 0xC7,
  0x0C, 0x38, 0xE3, 0x87, 0x38, 0x70, 0xE7, 0x0E, 0x18, 0xE1, 0xC7, 0x00,
  0x1D, 0xE1, 0xFF, 0x1B, 0xF1, 0xC7, 0x1C, 0x73, 0x87, 0x38, 0x73, 0x87,
  0x38, 0x67, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0C, 0xE1, 0xCE, 0x1C,
  0xE1, 0xC0, 0x07, 0x83, 0xF8, 0xFF, 0x9C, 0x77, 0x0E, 0xE1, 0xD8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xEE, 0x1D, 0xC7, 0x39, 0xE3, 0xF8,
  0x7E, 0x00, 0x07, 0x38, 0x0F, 0xF8, 0x1F, 0x70, 0x38, 0x70, 0x70, 0xE1,
  0xC1, 0xC3, 0x83, 0x87, 0x06, 0x0C, 0x1C, 0x18, 0x38, 0x70, 0x70, 0xE0,
  0xE1, 0xC3, 0x83, 0x87, 0x0F, 0x9C, 0x1F, 0xF0, 0x3B, 0xC0, 0x70, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07,
  0x31, 0xFB, 0x3F, 0xF3, 0x8F, 0x70, 0xF7, 0x0E, 0x70, 0xEE, 0x0E, 0xE0,
  0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0xE7, 0x8F, 0xF8, 0x7B,
  0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x1D,
  0xC7, 0xF1, 0xBC, 0x78, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x0F, 0x83, 0xFC,
  0xF7, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x03, 0x80, 0x78, 0x0E, 0x33, 0xC7, 0xF0, 0xFC, 0x00, 0x0C, 0x1C, 0x1C,
  0x3F, 0x7F, 0x7E, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xF8, 0xF8, 0x38, 0x73, 0x87, 0x38, 0x73, 0x86, 0x30,
  0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x60, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE3,
  0xCE, 0x38, 0xE7, 0x8F, 0xF8, 0x7B, 0x80, 0xE0, 0xFC, 0x3B, 0x87, 0x71,
  0xCE, 0x39, 0xCE, 0x39, 0xC7, 0x30, 0xEE, 0x1D, 0xC3, 0xF0, 0x7E, 0x0D,
  0x81, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0xE1, 0xC3, 0xF1, 0xE1, 0xF8,
  0xF1, 0xDC, 0x78, 0xEE, 0x6C, 0x67, 0x36, 0x73, 0xBF, 0x39, 0x9B, 0xB8,
  0xCD, 0xDC, 0x6E, 0xEC, 0x36, 0x7E, 0x1B, 0x3F, 0x0F, 0x9F, 0x07, 0x8F,
  0x83, 0xC7, 0x81, 0xC3, 0xC0, 0xE1, 0xE0, 0x00, 0x1C, 0x38, 0x61, 0xC3,
  0x9C, 0x1C, 0xC0, 0xEE, 0x07, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0xE0, 0x3F, 0x03, 0xB8, 0x1C, 0xC1, 0xC7, 0x1C, 0x38, 0xE1, 0xC0,
  0x07, 0x07, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x18,
  0x07, 0x38, 0x07, 0x38, 0x07, 0x70, 0x07, 0x70, 0x07, 0x60, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x0F, 0xE3, 0xFC, 0x7F, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0xF8, 0xFF, 0x00,
  0x01, 0xE0, 0x7C, 0x1E, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x70, 0x1E, 0x0F, 0x81, 0xC0, 0x3C, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7C, 0x07, 0x80,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0x80, 0x7C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x01, 0xF0, 0x0E, 0x03,
  0xE0, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0xFC, 0x0F, 0x80, 0xE0, 0x00, 0x7C, 0x1F, 0xF3, 0xEF, 0xF8,
  0x3E,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 22, 7, 0, -22 },
  { 23, 9, 8, 11, 3, -22 },
  { 32, 14, 22, 14, 0, -22 },
  { 71, 13, 26, 12, 0, -24 },
  { 114, 17, 22, 20, 2, -22 },
  { 161, 14, 22, 14, 0, -22 },
  { 200, 4, 8, 6, 3, -22 },
  { 204, 9, 27, 8, 1, -22 },
  { 235, 9, 27, 8, -2, -22 },
  { 266, 10, 11, 12, 3, -24 },
  { 280, 12, 14, 14, 1, -18 },
  { 301, 5, 8, 7, -1, -4 },
  { 306, 8, 3, 8, 0, -10 },
  { 309, 4, 4, 7, 0, -4 },
  { 311, 15, 22, 11, -2, -22 },
  { 353, 11, 22, 12, 1, -22 },
  { 384, 9, 22, 13, 3, -22 },
  { 409, 14, 22, 12, -1, -22 },
  { 448, 14, 22, 12, -1, -22 },
  { 487, 14, 22, 13, -1, -22 },
  { 526, 13, 22, 12, 0, -22 },
  { 562, 12, 22, 12, 1, -22 },
  { 595, 13, 22, 12, 1, -22 },
  { 631, 13, 22, 12, 0, -22 },
  { 667, 12, 22, 12, 0, -22 },
  { 700, 7, 17, 7, 0, -17 },
  { 715, 9, 21, 7, -2, -17 },
  { 739, 12, 14, 14, 1, -18 },
  { 760, 12, 9, 14, 1, -15 },
  { 774, 12, 14, 14, 1, -18 },
  { 795, 10, 22, 9, 1, -22 },
  { 823, 17, 25, 19, 1, -22 },
  { 877, 13, 22, 13, -2, -22 },
  { 913, 14, 22, 14, 0, -22 },
  { 952, 14, 22, 12, 1, -22 },
  { 991, 14, 22, 15, 0, -22 },
  { 1030, 13, 22, 12, 0, -22 },
  { 1066, 13, 22, 11, 0, -22 },
  { 1102, 15, 22, 16, 1, -22 },
  { 1144, 16, 22, 15, 0, -22 },
  { 1188, 13, 22, 9, -2, -22 },
  { 1224, 13, 28, 7, -5, -22 },
  { 1270, 16, 22, 13, 0, -22 },
  { 1314, 9, 22, 11, 0, -22 },
  { 1339, 21, 22, 20, 0, -22 },
  { 1397, 17, 22, 16, 0, -22 },
  { 1444, 14, 22, 16, 1, -22 },
  { 1483, 14, 22, 13, 0, -22 },
  { 1522, 14, 27, 16, 1, -22 },
  { 1570, 14, 22, 13, 0, -22 },
  { 1609, 14, 22, 12, -1, -22 },
  { 1648, 12, 22, 11, 2, -22 },
  { 1681, 15, 22, 15, 1, -22 },
  { 1723, 13, 22, 13, 3, -22 },
  { 1759, 21, 22, 21, 2, -22 },
  { 1817, 16, 22, 12, -2, -22 },
  { 1861, 12, 22, 12, 2, -22 },
  { 1894, 14, 22, 11, -1, -22 },
  { 1933, 12, 27, 9, -1, -22 },
  { 1974, 6, 22, 11, 3, -22 },
  { 1991, 12, 27, 9, -2, -22 },
  { 2032, 13, 12, 13, 0, -22 },
  { 2052, 10, 2, 10, -3, 3 },
  { 2055, 4, 5, 8, 5, -24 },
  { 2058, 12, 17, 13, 1, -17 },
  { 2084, 13, 24, 13, 0, -24 },
  { 2123, 10, 17, 10, 1, -17 },
  { 2145, 14, 24, 13, 1, -24 },
  { 2187, 11, 17, 12, 1, -17 },
  { 2211, 15, 31, 8, -4, -24 },
  { 2270, 14, 24, 13, -1, -17 },
  { 2312, 12, 24, 13, 0, -24 },
  { 2348, 8, 23, 6, 0, -23 },
  { 2371, 12, 30, 6, -4, -23 },
  { 2416, 13, 24, 12, 0, -24 },
  { 2455, 8, 24, 6, 0, -24 },
  { 2479, 19, 17, 20, 0, -17 },
  { 2520, 12, 17, 13, 0, -17 },
  { 2546, 11, 17, 13, 1, -17 },
  { 2570, 15, 24, 13, -2, -17 },
  { 2615, 12, 24, 13, 1, -17 },
  { 2651, 10, 17, 9, 0, -17 },
  { 2673, 11, 17, 10, 0, -17 },
  { 2697, 8, 20, 8, 1, -20 },
  { 2717, 12, 17, 13, 1, -17 },
  { 2743, 11, 17, 11, 2, -17 },
  { 2767, 17, 17, 17, 2, -17 },
  { 2804, 13, 17, 11, -1, -17 },
  { 2832, 16, 24, 11, -3, -17 },
  { 2880, 11, 17, 9, -1, -17 },
  { 2904, 11, 27, 10, 1, -22 },
  { 2942, 3, 31, 11, 4, -24 },
  { 2954, 12, 27, 10, -2, -22 },
  { 2995, 12, 4, 14, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC31PT7B_H_
