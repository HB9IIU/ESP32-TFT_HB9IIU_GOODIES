#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC35PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x07,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x39, 0xE7, 0x3D, 0xE7, 0x38, 0xE7,
  0x1C, 0xE3, 0x1C, 0xE3, 0x1C, 0xE3, 0x80, 0x00, 0xE7, 0x00, 0xC6, 0x01,
  0xC6, 0x01, 0x8E, 0x01, 0x8C, 0x03, 0x8C, 0x03, 0x1C, 0x1F, 0xFF, 0x1F,
  0xFF, 0x27, 0x38, 0x06, 0x38, 0x0E, 0x30, 0x0E, 0x30, 0x0C, 0x70, 0x1C,
  0x60, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x38, 0xC0, 0x31, 0xC0, 0x31,
  0x80, 0x71, 0x80, 0x63, 0x80, 0x63, 0x80, 0xE3, 0x00, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x07, 0x80, 0x7F, 0xE1, 0xFF, 0x83, 0x93, 0x0E, 0x60,
  0x1C, 0xC0, 0x39, 0x00, 0x72, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x03, 0xF0, 0x06, 0xE0, 0x09, 0xC0, 0x13, 0x80, 0x27,
  0x18, 0xDE, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0x80, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x1F, 0x03, 0x83, 0xE0, 0x60, 0xCE, 0x1C, 0x39,
  0xC3, 0x06, 0x38, 0xE0, 0xC7, 0x18, 0x38, 0xE7, 0x07, 0x18, 0xC0, 0xC3,
  0x38, 0x18, 0xE6, 0x03, 0x1D, 0xCF, 0x63, 0x33, 0xFC, 0xEE, 0xE7, 0xF9,
  0x98, 0xDE, 0x77, 0x18, 0x0C, 0xC3, 0x03, 0x98, 0xE0, 0xE7, 0x1C, 0x1C,
  0xE3, 0x87, 0x1C, 0x60, 0xE3, 0x9C, 0x38, 0x73, 0x86, 0x0E, 0xE1, 0xC1,
  0xF8, 0x30, 0x1E, 0x00, 0x01, 0xF0, 0x03, 0xF8, 0x07, 0xB8, 0x07, 0x38,
  0x07, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0F, 0x70, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x81, 0x1F, 0x8E, 0x3B, 0xCE, 0x71, 0xDE,
  0x71, 0xDC, 0xE1, 0xFC, 0xE0, 0xF8, 0xE0, 0xF8, 0xE0, 0xF0, 0xE1, 0xF0,
  0xFF, 0xF8, 0x7F, 0xB8, 0x7E, 0x3C, 0x77, 0x7F, 0xEE, 0xEC, 0xC0, 0x01,
  0xE0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x3C, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x38,
  0x00, 0x06, 0x00, 0x70, 0x07, 0x04, 0x70, 0x76, 0x2F, 0xFE, 0x1F, 0xF1,
  0xF0, 0x3F, 0x07, 0xB8, 0x73, 0x83, 0x1C, 0x01, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x1E, 0x38, 0x71, 0xE3, 0x87, 0x1C, 0x38, 0xE0, 0x7F,
  0xBF, 0xBF, 0xC0, 0x7F, 0xFF, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x3F, 0x83, 0xFE, 0x1C, 0x71, 0xC3, 0x8E, 0x1C, 0xE0, 0xE7, 0x07,
  0x78, 0x3B, 0x81, 0xDC, 0x1E, 0xE0, 0xFF, 0x07, 0x78, 0x3B, 0x81, 0xDC,
  0x1E, 0xE0, 0xE7, 0x07, 0x38, 0x79, 0xC3, 0x8E, 0x1C, 0x71, 0xC3, 0xFE,
  0x0F, 0xE0, 0x7E, 0x00, 0x03, 0x87, 0xC7, 0xE7, 0xE7, 0xF7, 0xBB, 0xBC,
  0x9C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1C,
  0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x00, 0x01, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF8, 0x30, 0xF0, 0x40, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE0, 0x01, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF8, 0x30, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x10,
  0x1E, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0x80, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x37, 0x00, 0xEE, 0x03, 0xBC,
  0x06, 0x70, 0x1C, 0xE0, 0x31, 0xC0, 0xC3, 0x83, 0x8F, 0x06, 0x1C, 0x1C,
  0x38, 0x70, 0x70, 0xFF, 0xF9, 0xFF, 0xF7, 0xFF, 0xE0, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xFE, 0x0F, 0xF8, 0x19, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE2, 0x07, 0x8F, 0xFC, 0x3F, 0xE0,
  0xFF, 0x00, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xC0, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xEF, 0x07, 0x7E, 0x1F, 0xFC, 0x78,
  0xF3, 0xC1, 0xCF, 0x07, 0x3C, 0x1C, 0xE0, 0x73, 0x83, 0xCE, 0x0E, 0x38,
  0x38, 0xE1, 0xE3, 0xC7, 0x0F, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x1F, 0xFE,
  0x3F, 0xF8, 0xFF, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x0F,
  0xF8, 0x3E, 0xF0, 0x70, 0xE1, 0xE1, 0xE3, 0x83, 0x87, 0x07, 0x0E, 0x0E,
  0x1E, 0x38, 0x1C, 0xF0, 0x3F, 0xC0, 0x3E, 0x00, 0xFC, 0x03, 0xFC, 0x0F,
  0x38, 0x3C, 0x78, 0xF0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07,
  0x1E, 0x1E, 0x3E, 0x78, 0x3F, 0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0xE0,
  0xFF, 0xC3, 0x8F, 0x1E, 0x1C, 0x70, 0x73, 0xC1, 0xCE, 0x07, 0x38, 0x1C,
  0xE0, 0xF3, 0x83, 0xCE, 0x1F, 0x3C, 0xF8, 0xFF, 0xE1, 0xFB, 0x83, 0x9E,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x0F, 0xF8,
  0x3F, 0xC0, 0xFE, 0x00, 0x0E, 0x3C, 0x78, 0xF0, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xF1, 0xE3, 0x80, 0x03, 0x80, 0xF0,
  0x78, 0x1E, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0x06, 0x03, 0x80, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x3C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x03, 0xC0,
  0x0C, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0xFF, 0x90, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01,
  0xC0, 0x30, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x03, 0xC1, 0xC0, 0x70, 0x0E,
  0x06, 0x00, 0x60, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0x87, 0xE3, 0x38, 0xFE,
  0x33, 0x1C, 0xE7, 0x71, 0x8C, 0x76, 0x38, 0xC7, 0x63, 0x1C, 0x6E, 0x31,
  0xC6, 0xE7, 0x18, 0x6C, 0x71, 0x8C, 0xC6, 0x38, 0xCC, 0x63, 0x9C, 0xC7,
  0x79, 0x8C, 0x7D, 0xF0, 0xC3, 0x8E, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x83, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0x60, 0x0E, 0xC0, 0x1D, 0x80,
  0x7F, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0x38, 0x0E, 0x70, 0x3C, 0xE0, 0x71,
  0xC0, 0xE3, 0x83, 0x87, 0x87, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0xF0, 0x79,
  0xE0, 0xF3, 0x81, 0xEF, 0x03, 0xDC, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0x07,
  0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0x0F, 0x0F, 0x0F, 0x0E, 0x0F, 0x0E,
  0x0F, 0x0E, 0x0E, 0x1E, 0x0E, 0x1E, 0x1E, 0x1C, 0x7C, 0x1F, 0xF0, 0x1F,
  0xF0, 0x3C, 0x78, 0x38, 0x38, 0x38, 0x3C, 0x38, 0x3C, 0x38, 0x3C, 0x78,
  0x3C, 0x70, 0x38, 0x70, 0x78, 0x70, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF,
  0x80, 0x00, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0x84, 0x0F, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x20, 0x7F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0x1F, 0x0F,
  0x0F, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x1E, 0x07, 0x1E, 0x07, 0x1C,
  0x07, 0x1C, 0x07, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x38, 0x0E, 0x38,
  0x1E, 0x38, 0x1C, 0x78, 0x3C, 0x70, 0x38, 0x70, 0x78, 0x71, 0xF0, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0x20,
  0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x07, 0xE7, 0x83, 0xF3, 0xC0, 0x39, 0xE0,
  0x3C, 0xF0, 0x1C, 0x78, 0x0E, 0x3C, 0x07, 0x1E, 0x07, 0x87, 0x03, 0xC3,
  0xC1, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x00, 0x07, 0x81, 0xC1,
  0xC0, 0x70, 0x70, 0x3C, 0x1C, 0x0F, 0x0F, 0x03, 0x83, 0x80, 0xE0, 0xE0,
  0x38, 0x38, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x0F, 0x03, 0x83, 0xC0, 0xE0, 0xE0, 0x38, 0x38, 0x1E, 0x0E,
  0x07, 0x87, 0x81, 0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x0F, 0x0F, 0x03,
  0xC3, 0xC0, 0xE0, 0xE0, 0x38, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x1F, 0xE0,
  0xFF, 0x80, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x9E, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x07, 0x83,
  0xC1, 0xC1, 0xE0, 0x70, 0xF0, 0x1C, 0x38, 0x0F, 0x1E, 0x03, 0x8F, 0x00,
  0xE3, 0x80, 0x39, 0xE0, 0x1E, 0xF0, 0x07, 0xB8, 0x01, 0xDE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xDC, 0x00, 0xE7, 0x80, 0x39, 0xE0,
  0x0E, 0x38, 0x07, 0x8E, 0x01, 0xC3, 0x80, 0x70, 0xF0, 0x1C, 0x3C, 0x0F,
  0x07, 0x03, 0xC1, 0xC0, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xC0, 0x70, 0x1C,
  0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F,
  0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFE,
  0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xDC, 0x1D, 0xC1, 0xDC, 0x1D, 0xC1, 0x9C,
  0x1D, 0xC3, 0xBC, 0x1D, 0xC3, 0xB8, 0x3D, 0xC7, 0x38, 0x39, 0xC7, 0x38,
  0x39, 0xCE, 0x78, 0x39, 0xCE, 0x78, 0x38, 0xDC, 0x70, 0x70, 0xDC, 0x70,
  0x70, 0xD8, 0x70, 0x70, 0xF8, 0xF0, 0x70, 0xF0, 0xE0, 0xF0, 0xF0, 0xE0,
  0xE0, 0xF0, 0xE0, 0xE0, 0xE1, 0xE0, 0x07, 0x80, 0xE0, 0xF0, 0x1C, 0x1E,
  0x03, 0x83, 0xE0, 0xF0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x70, 0x7E,
  0x0E, 0x1E, 0xC3, 0xC3, 0x9C, 0x70, 0x73, 0x8E, 0x0E, 0x71, 0xC1, 0xCE,
  0x38, 0x79, 0xCE, 0x0E, 0x19, 0xC1, 0xC3, 0xB8, 0x38, 0x77, 0x07, 0x0E,
  0xE1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x03, 0xE0, 0xE0, 0x7C, 0x3C, 0x0F,
  0x87, 0x01, 0xE0, 0xE0, 0x3C, 0x00, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFF,
  0x0F, 0x0F, 0x0E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07,
  0x78, 0x07, 0x78, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x70, 0x0F, 0xF0, 0x0E,
  0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78,
  0x70, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x07, 0xF8, 0x07, 0xFC,
  0x07, 0xFE, 0x07, 0x1E, 0x0F, 0x0E, 0x0E, 0x0F, 0x0E, 0x0F, 0x0E, 0x0E,
  0x1E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1E, 0x1C, 0x3C, 0x1D, 0xF8, 0x3F, 0xF0,
  0x3F, 0xE0, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x01, 0xFC,
  0x03, 0xFE, 0x07, 0xFF, 0x0F, 0x0F, 0x0E, 0x07, 0x1E, 0x07, 0x1C, 0x07,
  0x3C, 0x07, 0x38, 0x07, 0x78, 0x07, 0x78, 0x07, 0x70, 0x07, 0x70, 0x0F,
  0x70, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x78, 0x70, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x38, 0xF0, 0xF0, 0xE1, 0xC1, 0xC3,
  0x83, 0x87, 0x07, 0x1E, 0x0E, 0x3C, 0x3C, 0x70, 0xF0, 0xE3, 0xE1, 0xFF,
  0x87, 0xFE, 0x0F, 0xF0, 0x1C, 0xF0, 0x39, 0xE0, 0x71, 0xC1, 0xE3, 0x83,
  0x87, 0x07, 0x0F, 0x0E, 0x1E, 0x3C, 0x1C, 0x78, 0x38, 0xE0, 0x78, 0x01,
  0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0x86, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x40, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F,
  0x80, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x00, 0x0E, 0x03, 0x87, 0x03, 0xC3, 0x81,
  0xC3, 0xC0, 0xE1, 0xE0, 0x70, 0xE0, 0x78, 0x70, 0x3C, 0x38, 0x1C, 0x3C,
  0x0E, 0x1C, 0x07, 0x0E, 0x07, 0x87, 0x03, 0xC7, 0x81, 0xC3, 0xC0, 0xE1,
  0xC0, 0x70, 0xE0, 0x78, 0x70, 0x38, 0x78, 0x1C, 0x3C, 0x0E, 0x1E, 0x0F,
  0x0F, 0x07, 0x07, 0x87, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x00,
  0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0xF7, 0x01, 0xCE, 0x07, 0x9C, 0x0E, 0x38,
  0x3C, 0x70, 0x70, 0xE0, 0xE1, 0xC3, 0xC3, 0x87, 0x07, 0x1E, 0x0E, 0x38,
  0x1C, 0x70, 0x39, 0xE0, 0x73, 0x80, 0xEF, 0x01, 0xDC, 0x03, 0xB8, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x70,
  0x1C, 0x07, 0x70, 0x1C, 0x0F, 0x70, 0x3C, 0x0E, 0x70, 0x3C, 0x1E, 0x70,
  0x7C, 0x1C, 0x70, 0x7C, 0x1C, 0x70, 0x7C, 0x3C, 0x70, 0xFC, 0x38, 0x70,
  0xFC, 0x38, 0x71, 0xDC, 0x70, 0x71, 0xDC, 0x70, 0x71, 0x9C, 0xF0, 0x73,
  0x9C, 0xE0, 0x73, 0x9C, 0xE0, 0x77, 0x1D, 0xC0, 0x77, 0x1D, 0xC0, 0x77,
  0x1B, 0xC0, 0x7E, 0x1B, 0x80, 0x7E, 0x1B, 0x80, 0x7C, 0x1F, 0x80, 0x7C,
  0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0xF8, 0x1E, 0x00, 0xF0,
  0x3E, 0x00, 0x03, 0x83, 0xC0, 0xE0, 0xE0, 0x38, 0x78, 0x0F, 0x1C, 0x03,
  0xCF, 0x00, 0x73, 0x80, 0x1D, 0xE0, 0x07, 0x70, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0x70, 0x03, 0xDC, 0x00, 0xE7, 0x00, 0x71, 0xC0, 0x1C,
  0x78, 0x0E, 0x1E, 0x07, 0x87, 0x81, 0xC0, 0xE0, 0xF0, 0x38, 0x00, 0xE0,
  0x7F, 0x83, 0xBC, 0x3D, 0xE1, 0xC7, 0x1E, 0x38, 0xE1, 0xCF, 0x0E, 0x70,
  0x77, 0x83, 0xB8, 0x1D, 0xC0, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x00, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x0E, 0x03, 0xF8, 0x1F, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x7C, 0x03, 0xF0, 0x1D, 0xC0, 0x77, 0x03, 0x8E, 0x1E, 0x38, 0x70,
  0xE3, 0x83, 0x8E, 0x07, 0x70, 0x1F, 0xC0, 0x70, 0xFF, 0xFF, 0xFC, 0xF3,
  0x9C, 0x73, 0x8C, 0x07, 0x9C, 0x3F, 0x71, 0xFF, 0xCF, 0x1F, 0x38, 0x39,
  0xE0, 0xE7, 0x03, 0x9C, 0x1E, 0xF0, 0x73, 0xC1, 0xCE, 0x07, 0x38, 0x1C,
  0xE0, 0xF3, 0x83, 0x8E, 0x1E, 0x38, 0x78, 0xFF, 0xE1, 0xFB, 0x87, 0xCC,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0xF8, 0x3F, 0xF1, 0xDF, 0xC7, 0xC7, 0x1E, 0x1C,
  0x70, 0x71, 0xC1, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x83, 0xDE, 0x0E,
  0x78, 0x39, 0xC1, 0xE7, 0x87, 0x1E, 0x3C, 0xFD, 0xE3, 0xBF, 0x0E, 0xF8,
  0x00, 0x07, 0xF0, 0xFE, 0x1F, 0xE3, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0x08, 0xFF, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x07, 0x9C,
  0x0F, 0xDC, 0x1F, 0xFC, 0x3C, 0x78, 0x38, 0x38, 0x78, 0x38, 0x70, 0x38,
  0x70, 0x78, 0xF0, 0x70, 0xF0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0xF0,
  0xE0, 0xE0, 0xE1, 0xE0, 0xE1, 0xE0, 0xF7, 0xE0, 0xFE, 0xE0, 0x7C, 0xC0,
  0x07, 0xE0, 0xFF, 0x1E, 0xF3, 0xC7, 0x38, 0x77, 0x87, 0x70, 0x77, 0x1E,
  0xFF, 0xCF, 0xF8, 0xF8, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xF1, 0x87, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF7, 0x03, 0xF7,
  0x07, 0xFF, 0x0F, 0x1F, 0x0E, 0x0E, 0x1E, 0x0E, 0x1C, 0x0E, 0x1C, 0x1E,
  0x3C, 0x1C, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x3C, 0x38, 0x38,
  0x38, 0x78, 0x38, 0x78, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x81, 0xE0, 0xE7, 0xC0, 0xFF, 0xC0,
  0x7F, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0xF8, 0x3F, 0xF1, 0xFF, 0xC7, 0x8F, 0x1E,
  0x1C, 0x70, 0x71, 0xC3, 0xCF, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x8E,
  0x1E, 0x78, 0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x3C, 0xF0, 0xE3, 0x83, 0x8E,
  0x0E, 0x00, 0x03, 0x03, 0xC1, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x0E,
  0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0F,
  0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x00, 0x00, 0x30, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x1F, 0x80,
  0xF8, 0x07, 0x80, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x1E, 0x1C, 0x78, 0x78,
  0xE0, 0xE3, 0x81, 0xCF, 0x03, 0x9C, 0x07, 0x70, 0x1D, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFF, 0x01, 0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x38,
  0xF0, 0xF1, 0xE1, 0xC1, 0xC3, 0x83, 0x80, 0x03, 0x83, 0xC1, 0xC0, 0xE0,
  0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70,
  0x78, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x70,
  0x38, 0x00, 0x0C, 0xF9, 0xF0, 0x6F, 0xDF, 0xC7, 0xFF, 0xFE, 0x3C, 0x7C,
  0x71, 0xE3, 0xC3, 0x8E, 0x1E, 0x1C, 0x70, 0xE0, 0xE7, 0x87, 0x0F, 0x38,
  0x38, 0x71, 0xC1, 0xC3, 0x8E, 0x1C, 0x1C, 0xF0, 0xE0, 0xE7, 0x07, 0x0E,
  0x38, 0x38, 0x71, 0xC3, 0xC3, 0x8E, 0x1C, 0x1C, 0xF0, 0xE1, 0xE7, 0x07,
  0x0E, 0x38, 0x38, 0x70, 0x0C, 0xF8, 0x37, 0xF1, 0xFF, 0xC7, 0x8F, 0x1E,
  0x1C, 0x70, 0x71, 0xC3, 0xCF, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x9E,
  0x1E, 0x78, 0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x3C, 0xF0, 0xE3, 0x83, 0x8E,
  0x0E, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0xFC, 0x78, 0xF3, 0x87, 0xBC, 0x1D,
  0xC0, 0xEE, 0x0F, 0xF0, 0x7F, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x0F, 0x70,
  0x73, 0x83, 0x9C, 0x38, 0xFF, 0xC3, 0xFC, 0x0F, 0xC0, 0x03, 0xBE, 0x03,
  0x7F, 0x07, 0x7F, 0x07, 0x87, 0x07, 0x87, 0x07, 0x07, 0x07, 0x07, 0x0F,
  0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0E, 0x0F, 0x0E, 0x0E, 0x1E, 0x0E, 0x1E,
  0x1E, 0x1E, 0x1C, 0x1E, 0x3C, 0x3F, 0x78, 0x3B, 0xF0, 0x39, 0xE0, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0x07, 0xDC, 0x3F, 0x71, 0xFF, 0xCF, 0x1E, 0x38, 0x39,
  0xE0, 0xE7, 0x03, 0x9C, 0x1E, 0xF0, 0x73, 0xC1, 0xCE, 0x07, 0x38, 0x1C,
  0xE0, 0xF3, 0x83, 0x8E, 0x1E, 0x38, 0x78, 0xFF, 0xE3, 0xFF, 0x87, 0xDC,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x00, 0x0C, 0xF0, 0xDE, 0x1D, 0xE1, 0xF0, 0x1E, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0xE1, 0xFF, 0x1E,
  0xE3, 0xC2, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC8, 0x38, 0xFF, 0x8F, 0xF0, 0xFE,
  0x00, 0x06, 0x07, 0x03, 0x81, 0x81, 0xFB, 0xFD, 0xFC, 0x78, 0x38, 0x1C,
  0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0F,
  0x47, 0xE1, 0xF0, 0x1C, 0x1C, 0x70, 0xF3, 0xC3, 0x8E, 0x0E, 0x38, 0x38,
  0xE0, 0xE3, 0x87, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x0F, 0x3C, 0x38,
  0xE0, 0xE3, 0x83, 0x8E, 0x1E, 0x38, 0xF8, 0xF7, 0xC3, 0xFF, 0x07, 0xDC,
  0x00, 0xE0, 0x7E, 0x0F, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0xE3, 0x8E,
  0x38, 0xE7, 0x8E, 0x70, 0xE7, 0x0E, 0xE0, 0xEE, 0x0F, 0xC0, 0xFC, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0xE0, 0xF0, 0xFC, 0x1E, 0x1F, 0x87,
  0xC7, 0xF0, 0xF0, 0xEE, 0x3E, 0x1D, 0xC7, 0xC7, 0x38, 0xD8, 0xE7, 0x3B,
  0x3C, 0xE6, 0x67, 0x1D, 0xCC, 0xE3, 0xB9, 0xB8, 0x76, 0x37, 0x0F, 0xCE,
  0xE1, 0xF9, 0xF8, 0x3E, 0x3F, 0x07, 0xC7, 0xC0, 0xF0, 0xF8, 0x1E, 0x1F,
  0x03, 0xC3, 0xC0, 0x00, 0x07, 0x0F, 0x07, 0x0E, 0x07, 0x1E, 0x07, 0x1C,
  0x07, 0xB8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xF0,
  0x38, 0xF0, 0x78, 0x70, 0xF0, 0x70, 0x07, 0x03, 0x83, 0x81, 0xC1, 0xC1,
  0xC0, 0xE0, 0xE0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x78, 0x0E, 0x38, 0x07,
  0x1C, 0x01, 0x9C, 0x00, 0xCE, 0x00, 0x6E, 0x00, 0x37, 0x00, 0x1B, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xBC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0x87, 0xFC, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0x00,
  0x78, 0x0F, 0xC0, 0xFC, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x1E, 0x03, 0xE0, 0x1C,
  0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0xE0, 0x0E, 0x01, 0xF0, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x78, 0x0F, 0xC0, 0x7C, 0x02, 0x00, 0x00, 0x3C, 0x05, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0x80, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 25, 8, 0, -25 },
  { 30, 11, 9, 12, 3, -25 },
  { 43, 16, 25, 15, 0, -25 },
  { 93, 15, 29, 14, 0, -27 },
  { 148, 19, 25, 22, 2, -25 },
  { 208, 16, 25, 16, 0, -25 },
  { 258, 4, 9, 7, 4, -25 },
  { 263, 11, 31, 9, 1, -25 },
  { 306, 11, 31, 9, -3, -25 },
  { 349, 12, 13, 13, 3, -27 },
  { 369, 14, 17, 15, 1, -21 },
  { 399, 7, 9, 7, -2, -4 },
  { 407, 9, 3, 9, 0, -11 },
  { 411, 4, 4, 7, 0, -4 },
  { 413, 17, 25, 12, -2, -25 },
  { 467, 13, 25, 14, 1, -25 },
  { 508, 9, 25, 14, 4, -25 },
  { 537, 15, 25, 14, -1, -25 },
  { 584, 15, 25, 14, -1, -25 },
  { 631, 15, 25, 14, -1, -25 },
  { 678, 14, 25, 14, 0, -25 },
  { 722, 14, 25, 14, 1, -25 },
  { 766, 15, 25, 14, 1, -25 },
  { 813, 15, 25, 14, 0, -25 },
  { 860, 14, 25, 14, 0, -25 },
  { 904, 7, 19, 8, 0, -19 },
  { 921, 10, 24, 8, -2, -19 },
  { 951, 14, 15, 15, 1, -20 },
  { 978, 14, 10, 15, 1, -17 },
  { 996, 14, 15, 15, 1, -20 },
  { 1023, 11, 25, 11, 1, -25 },
  { 1058, 20, 28, 21, 1, -25 },
  { 1128, 15, 25, 15, -2, -25 },
  { 1175, 16, 25, 16, 0, -25 },
  { 1225, 16, 25, 14, 1, -25 },
  { 1275, 16, 25, 17, 0, -25 },
  { 1325, 15, 25, 13, 0, -25 },
  { 1372, 15, 25, 12, 0, -25 },
  { 1419, 17, 25, 18, 1, -25 },
  { 1473, 18, 25, 17, 0, -25 },
  { 1530, 14, 25, 10, -2, -25 },
  { 1574, 14, 32, 8, -5, -25 },
  { 1630, 18, 25, 15, 0, -25 },
  { 1687, 10, 25, 12, 0, -25 },
  { 1719, 24, 25, 23, 0, -25 },
  { 1794, 19, 25, 18, 0, -25 },
  { 1854, 16, 25, 18, 1, -25 },
  { 1904, 16, 25, 15, 0, -25 },
  { 1954, 16, 31, 18, 1, -25 },
  { 2016, 15, 25, 15, 0, -25 },
  { 2063, 16, 25, 14, -1, -25 },
  { 2113, 13, 25, 13, 2, -25 },
  { 2154, 17, 25, 17, 1, -25 },
  { 2208, 15, 25, 15, 3, -25 },
  { 2255, 24, 25, 23, 2, -25 },
  { 2330, 18, 25, 14, -2, -25 },
  { 2387, 13, 25, 13, 3, -25 },
  { 2428, 15, 25, 12, -1, -25 },
  { 2475, 13, 31, 10, -1, -25 },
  { 2526, 7, 25, 12, 3, -25 },
  { 2548, 13, 31, 10, -2, -25 },
  { 2599, 14, 14, 14, 0, -25 },
  { 2624, 11, 2, 11, -3, 3 },
  { 2627, 5, 6, 9, 5, -27 },
  { 2631, 14, 19, 15, 1, -19 },
  { 2665, 14, 27, 15, 0, -27 },
  { 2713, 12, 19, 12, 1, -19 },
  { 2742, 16, 27, 15, 1, -27 },
  { 2796, 12, 19, 14, 1, -19 },
  { 2825, 17, 35, 9, -4, -27 },
  { 2900, 16, 27, 15, -1, -19 },
  { 2954, 14, 27, 15, 0, -27 },
  { 3002, 9, 26, 7, 0, -26 },
  { 3032, 13, 34, 7, -4, -26 },
  { 3088, 15, 27, 13, 0, -27 },
  { 3139, 9, 27, 7, 0, -27 },
  { 3170, 21, 19, 22, 0, -19 },
  { 3220, 14, 19, 15, 0, -19 },
  { 3254, 13, 19, 15, 1, -19 },
  { 3285, 16, 27, 15, -2, -19 },
  { 3339, 14, 27, 15, 1, -19 },
  { 3387, 12, 19, 10, 0, -19 },
  { 3416, 12, 19, 12, 0, -19 },
  { 3445, 9, 23, 9, 1, -23 },
  { 3471, 14, 19, 15, 1, -19 },
  { 3505, 12, 19, 12, 2, -19 },
  { 3534, 19, 19, 20, 2, -19 },
  { 3580, 16, 19, 13, -2, -19 },
  { 3618, 17, 27, 13, -3, -19 },
  { 3676, 13, 19, 10, -1, -19 },
  { 3707, 13, 31, 12, 1, -25 },
  { 3758, 3, 35, 13, 5, -27 },
  { 3772, 13, 31, 12, -2, -25 },
  { 3823, 14, 5, 15, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC35PT7B_H_
