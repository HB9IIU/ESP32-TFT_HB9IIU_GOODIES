#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC72PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8,
  0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F,
  0x0F, 0xC1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xC0, 0xFC, 0x3F, 0x03,
  0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07,
  0xC0, 0xF8, 0x20, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0x31, 0xF0, 0x07, 0xF1, 0xC1, 0xC0, 0x1F, 0x87, 0x01, 0x00, 0x7E,
  0x1C, 0x00, 0x03, 0xF8, 0x70, 0x00, 0x0F, 0xC1, 0x80, 0x00, 0x3F, 0x0E,
  0x00, 0x00, 0xFC, 0x38, 0x00, 0x03, 0xF8, 0xE0, 0x00, 0x0F, 0xE3, 0x80,
  0x00, 0x1F, 0xDC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1D, 0xFE, 0x00, 0x00, 0x77,
  0xF8, 0x00, 0x01, 0xCF, 0xE0, 0x00, 0x06, 0x1F, 0x80, 0x00, 0x38, 0x7E,
  0x00, 0x00, 0xE1, 0xF8, 0x00, 0x03, 0x87, 0xE0, 0x00, 0x0E, 0x1F, 0x80,
  0x00, 0x70, 0x7E, 0x04, 0x01, 0xC3, 0xF8, 0x18, 0x07, 0x0F, 0xC0, 0x78,
  0x1C, 0x7F, 0x01, 0xFC, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x10, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xE0, 0x07,
  0xFF, 0x80, 0x07, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xC7, 0xC0,
  0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x00,
  0x1F, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x07,
  0xC0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0xF8,
  0x00, 0x7C, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0xC1, 0xF0, 0x00, 0xFC,
  0x0F, 0x83, 0xF0, 0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x0F, 0x87,
  0xE0, 0x00, 0xF8, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x1F, 0x8F, 0xC0, 0x00,
  0xF8, 0x1F, 0x0F, 0x80, 0x40, 0xF8, 0x1F, 0x1F, 0x83, 0xF8, 0xF8, 0x3F,
  0x1F, 0x0F, 0xFC, 0xF8, 0x3E, 0x3F, 0x1F, 0xFC, 0xF8, 0x7E, 0x3E, 0x3F,
  0xFE, 0xF8, 0x7C, 0x7E, 0x3F, 0x7E, 0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0xFF,
  0xF8, 0xF8, 0x7C, 0x3E, 0xFF, 0xF0, 0xF8, 0xF8, 0x3F, 0x7F, 0xE1, 0xF0,
  0xF8, 0x3F, 0x3F, 0xC1, 0xF1, 0xF0, 0x3F, 0x1F, 0x83, 0xE1, 0xF0, 0x3E,
  0x00, 0x03, 0xE1, 0xF0, 0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x3E, 0x00, 0x0F,
  0xC3, 0xE0, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x3E, 0x00, 0x1F, 0x83, 0xE0,
  0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x7C, 0x00,
  0x3E, 0x07, 0xC0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07,
  0xC0, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0xF8,
  0x01, 0xF8, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xF0,
  0x07, 0xC3, 0xE0, 0x03, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xC0, 0x07, 0xFF,
  0xC0, 0x07, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0x80, 0x03, 0xFF, 0x00, 0x1F,
  0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x7F, 0x3F,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x7F, 0x07, 0xFF, 0xE0, 0x7F, 0x07, 0xF7, 0xF0, 0x7E, 0x0F, 0xE7, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF0, 0xFC, 0x3F, 0x83, 0xF8, 0xFC, 0x3F, 0x03, 0xF9,
  0xFC, 0x7F, 0x01, 0xF9, 0xF8, 0x7E, 0x01, 0xFF, 0xF8, 0x7E, 0x01, 0xFF,
  0xF0, 0xFE, 0x00, 0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0xFF,
  0xE0, 0xFC, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x7F,
  0x80, 0xFC, 0x00, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0x80, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0x8F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xCF,
  0xE0, 0x3F, 0xFF, 0x8F, 0xE0, 0x1F, 0xFF, 0x0F, 0xF0, 0x0F, 0xFC, 0x07,
  0xF0, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1,
  0xF0, 0x7C, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x08, 0x07, 0xC0, 0x1C, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x7F,
  0x7C, 0x0D, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xBE, 0x00, 0x7F, 0x7E, 0x01, 0xFC, 0x7E, 0x07, 0xF0, 0xFC,
  0x07, 0xE1, 0xFC, 0x07, 0x81, 0xFC, 0x06, 0x03, 0xE0, 0x04, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0xC0, 0x3E, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0x3E, 0x7F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xC7, 0xF0, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x0F,
  0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x03, 0xF0, 0x7F,
  0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F,
  0x0F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xC0,
  0x07, 0xF3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xF1,
  0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00,
  0x7E, 0x3F, 0x80, 0x1F, 0xC7, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F,
  0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F,
  0xE3, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8,
  0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8,
  0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0,
  0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xDF, 0xCF, 0xF1, 0xF8, 0x7E,
  0x3F, 0x83, 0xC3, 0xF8, 0x38, 0x3F, 0x81, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xE0, 0xFF, 0x80, 0x1F, 0x00, 0xFF, 0x00, 0x1C, 0x00, 0xFE,
  0x00, 0x30, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0x81, 0xFF, 0x00, 0x1C, 0x01, 0xFE, 0x00, 0x30, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x08, 0x00, 0x1F, 0xF0, 0x1C, 0x00, 0x7F, 0xC0, 0x3F, 0x07, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3E, 0xFE, 0x00, 0x00, 0xF9, 0xFC, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x0F, 0x9F, 0xC0, 0x00,
  0x3E, 0x3F, 0x80, 0x00, 0xF8, 0x7F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x3E, 0x0F, 0xE0, 0x00, 0xF8,
  0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x01,
  0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x0F,
  0xC0, 0x07, 0xC0, 0x3F, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0x81, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x04, 0x00, 0x0F,
  0xF8, 0x0E, 0x00, 0x3F, 0xE0, 0x1F, 0xC3, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x40, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x83, 0xC0, 0x01, 0xF8, 0xFF,
  0x80, 0x0F, 0xCF, 0xFE, 0x00, 0xFE, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0x87, 0xF8, 0x1F, 0xF8, 0x1F, 0xC0, 0xFF,
  0x80, 0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x00,
  0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC,
  0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7E,
  0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0,
  0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFC, 0x0F,
  0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x81, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x0F,
  0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x0F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xFC,
  0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0,
  0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x03, 0xFE, 0x0F, 0xE0, 0x1F, 0xF0,
  0x7F, 0x01, 0xFF, 0x83, 0xFC, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xF7, 0xF0, 0x0F, 0xFF, 0x3F, 0x00, 0x3F, 0xF3,
  0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x03, 0x81, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0x80, 0x08, 0x00, 0x00, 0x03, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xC0, 0xFF, 0x03, 0x00,
  0x7F, 0x02, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0xE0, 0x3E, 0x07, 0xC0, 0x3F,
  0xFC, 0x1F, 0x07, 0xC0, 0x3F, 0xFE, 0x0F, 0x83, 0xE0, 0x3F, 0xFF, 0x07,
  0xC3, 0xE0, 0x3F, 0x9F, 0x83, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF1, 0xF0,
  0x1F, 0x07, 0xC0, 0xF8, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x7C, 0x0F, 0x81,
  0xF0, 0x3C, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x1F, 0x07, 0xC0, 0x7C, 0x0F, 0x8F, 0x03, 0xE0, 0x3E, 0x07, 0xCF, 0x81,
  0xF0, 0x3E, 0x03, 0xE7, 0xC1, 0xF0, 0x1F, 0x01, 0xE3, 0xE0, 0xF8, 0x0F,
  0x81, 0xF1, 0xE0, 0x7C, 0x07, 0xC0, 0xF9, 0xF0, 0x3E, 0x07, 0xE0, 0x78,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x7C, 0x0F, 0x01, 0xF0, 0x3E, 0x3E, 0x0F,
  0x81, 0xF8, 0x1E, 0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0x0F, 0x83, 0xE0, 0xFE,
  0x0F, 0x07, 0xC1, 0xF8, 0x7F, 0x0F, 0x83, 0xE0, 0x7C, 0x77, 0x8F, 0x81,
  0xE0, 0x3F, 0xFB, 0xFF, 0x80, 0xF0, 0x1F, 0xF9, 0xFF, 0xC0, 0x7C, 0x0F,
  0xF8, 0xFF, 0xC0, 0x3E, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0x00, 0x78, 0x07,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x10, 0x00, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x00,
  0x7F, 0xE3, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF1, 0xFC,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x03,
  0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE,
  0xFF, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0x07, 0xFF,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xF0, 0x3F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0,
  0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0,
  0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x07, 0xF0,
  0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0,
  0x3F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0x01, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xF8, 0x1E, 0x00, 0x7F, 0xC0, 0x08, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x06, 0x00, 0x1F, 0xFC,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x1F, 0xF0, 0x01, 0xFC, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0, 0x1F,
  0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x03, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xE0, 0x03, 0xFE,
  0x00, 0x38, 0x00, 0xFF, 0x80, 0x01, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xFE, 0x0F, 0xE0, 0x07, 0xFF, 0xC3, 0xFC, 0x00, 0xFF,
  0xF0, 0x7F, 0x80, 0x3F, 0xFE, 0x0F, 0xE0, 0x07, 0xFF, 0xC1, 0xFC, 0x00,
  0xFF, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x07, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0x80,
  0x0F, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x08, 0x7F, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF0,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x01,
  0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x00, 0x1F, 0x9F, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x9F,
  0xC0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0x03, 0xFF, 0xE0, 0x07,
  0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x03,
  0xFB, 0xF0, 0x01, 0xFB, 0xF8, 0x01, 0xFD, 0xF8, 0x00, 0xFD, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x3F, 0x3F, 0x80,
  0x1F, 0xCF, 0xC0, 0x1F, 0x9F, 0xC0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xE0,
  0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xF0,
  0x03, 0xF8, 0xFC, 0x07, 0xE3, 0xF8, 0x01, 0xFC, 0x7E, 0x03, 0xF1, 0xFC,
  0x00, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x81, 0xF8, 0x7E,
  0x00, 0x7F, 0x0F, 0xC1, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xE0, 0xFC, 0x3F,
  0x80, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x3F, 0x07,
  0xF0, 0x03, 0xF8, 0x3F, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0x9F, 0x81,
  0xFC, 0x00, 0xFC, 0x07, 0xCF, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xEF, 0xC0,
  0x7E, 0x00, 0x7F, 0x01, 0xF7, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFF, 0xE0,
  0x3F, 0x80, 0x1F, 0x80, 0x7F, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0xF0,
  0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF8,
  0x07, 0xF0, 0x03, 0xF8, 0x07, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x03, 0xFC,
  0x01, 0xF8, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xE0,
  0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x00, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFC, 0x00,
  0xFD, 0xF8, 0x01, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xF8, 0x00, 0xFD, 0xF8,
  0x03, 0xF8, 0x00, 0xFD, 0xF8, 0x03, 0xF8, 0x01, 0xFD, 0xF8, 0x03, 0xF0,
  0x01, 0xFC, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x01, 0xF8,
  0xFC, 0x07, 0xF0, 0x01, 0xF8, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0xFC, 0x07,
  0xE0, 0x03, 0xF8, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x0F, 0xE0, 0x03,
  0xF0, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0x7E,
  0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x1F, 0xC0,
  0x07, 0xE0, 0x3E, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x1F, 0x80, 0x0F, 0xE0,
  0x3F, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x3F,
  0x80, 0x0F, 0xC0, 0x3F, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x3F, 0x00, 0x1F,
  0xC0, 0x1F, 0xBF, 0x00, 0x1F, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0x80, 0x1F,
  0xBF, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xFE, 0x00,
  0x3F, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0x7E,
  0x00, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x07, 0xFC,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x07, 0xF9, 0xFC, 0x00,
  0x03, 0xF9, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0,
  0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0x03, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0xFE, 0x01, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8,
  0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x03, 0xF0,
  0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x07,
  0xF9, 0xFC, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x03, 0xFC, 0xFE, 0x00,
  0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x1F, 0xC0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0x03, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xF8,
  0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x1F, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xE3, 0xF8, 0x00, 0xFF, 0x80, 0x38, 0x00, 0x7F, 0x80, 0x04, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x08, 0x00, 0x0F, 0xF0, 0x07,
  0x00, 0x0F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F,
  0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83,
  0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE,
  0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F,
  0x80, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x01,
  0xF8, 0x7F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E,
  0x3F, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x9F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF1,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xF8,
  0x7F, 0x00, 0x1F, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xF8, 0x01, 0xFC,
  0x1F, 0xC0, 0x0F, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xFE, 0x00, 0xFE,
  0x07, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x3F,
  0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0x80, 0xFC, 0x01, 0xF7, 0xE0, 0x1F,
  0xC0, 0x7E, 0x01, 0xFB, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFD, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x7C, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x7C, 0x07,
  0xF0, 0x07, 0xE0, 0x3F, 0x3E, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x1F, 0x03,
  0xF8, 0x01, 0xF8, 0x1F, 0x8F, 0x81, 0xFC, 0x00, 0xFC, 0x0F, 0x87, 0xC0,
  0xFC, 0x00, 0x7E, 0x0F, 0xC3, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xE1, 0xF0,
  0x7F, 0x00, 0x1F, 0x83, 0xE0, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x7C,
  0x3F, 0x80, 0x07, 0xE1, 0xF8, 0x7E, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x3F,
  0x1F, 0xC0, 0x01, 0xF8, 0xFC, 0x1F, 0x8F, 0xE0, 0x01, 0xFC, 0x7C, 0x0F,
  0xC7, 0xE0, 0x00, 0xFE, 0x7E, 0x07, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x03,
  0xF3, 0xF8, 0x00, 0x3F, 0xBF, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0x80,
  0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0x80, 0x7E, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x1F, 0xFF, 0x00, 0x01, 0xFB, 0xE0,
  0x0F, 0xBF, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xC7, 0xF0, 0x03,
  0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0x81, 0xFC,
  0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8,
  0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7E, 0x00,
  0x1F, 0xDF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x3F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x01,
  0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF1,
  0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xC0, 0xFE, 0x3F, 0x8F, 0xF1, 0xFC, 0x7F, 0x0F, 0xE1, 0xF8, 0x7E,
  0x0F, 0xC3, 0xF0, 0x7C, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x07, 0xC0,
  0x1F, 0xFC, 0x7E, 0x01, 0xFF, 0xF3, 0xF0, 0x1F, 0xFF, 0xBF, 0x81, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFD, 0xFF, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF0, 0x1F,
  0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1,
  0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0,
  0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07,
  0xF0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x07, 0xF0,
  0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0,
  0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x3F, 0xF0, 0x3F, 0xC3, 0xFF, 0x01, 0xFF,
  0xFD, 0xF8, 0x07, 0xFF, 0xEF, 0xC0, 0x3F, 0xFE, 0x7E, 0x00, 0xFF, 0xE3,
  0xE0, 0x03, 0xFC, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x81, 0x00, 0x00, 0xFC, 0x3F,
  0xC0, 0x03, 0xF3, 0xFF, 0x80, 0x0F, 0xDF, 0xFF, 0x00, 0x7F, 0x7F, 0xFC,
  0x01, 0xFB, 0xFF, 0xF8, 0x07, 0xFF, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0x80,
  0xFF, 0x80, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xC0,
  0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x03,
  0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE,
  0x0F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07,
  0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00,
  0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x7F, 0xC0, 0xFF,
  0x01, 0xFF, 0x87, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0x7F, 0xFF, 0x00,
  0xFC, 0xFF, 0xF8, 0x03, 0xF1, 0xFF, 0xC0, 0x0F, 0x83, 0xFC, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFE, 0x3C,
  0x07, 0xF8, 0x04, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x80, 0xFF, 0x87, 0x80,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x04, 0x03, 0xF0,
  0x00, 0x1F, 0xE1, 0xF8, 0x00, 0x3F, 0xF9, 0xFC, 0x00, 0x3F, 0xFE, 0xFE,
  0x00, 0x3F, 0xFF, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xF3, 0xFF,
  0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0,
  0x01, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xFC, 0x00,
  0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x87, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xDF, 0x80, 0x07, 0xFF, 0xCF, 0xC0, 0x01, 0xFF, 0xC7, 0xC0,
  0x00, 0x7F, 0x83, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xE1, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0,
  0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF8,
  0x03, 0xF9, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0x7F,
  0x0F, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x10, 0x3F, 0xC0, 0x78, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF,
  0x0F, 0xC0, 0x00, 0xFF, 0xC7, 0xE0, 0x01, 0xFF, 0xF3, 0xF0, 0x01, 0xFF,
  0xF9, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0x07, 0xF0, 0x3F,
  0xF0, 0x03, 0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0xFD, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0xFE, 0x00, 0x0F, 0xFE, 0x7E, 0x00, 0x03, 0xFE,
  0x3F, 0x00, 0x00, 0x78, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x60, 0x00, 0xFE, 0x00, 0x3C, 0x01, 0xFF, 0x00, 0x1F,
  0xE7, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0xC0, 0x00,
  0xFC, 0x3F, 0xC0, 0x07, 0xE7, 0xFF, 0x00, 0x3F, 0x7F, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xBF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0,
  0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07,
  0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x07,
  0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC0,
  0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8,
  0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x02, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFD, 0xFC, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8,
  0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x08, 0x00, 0x0F, 0x87, 0xFC, 0x07, 0xF8,
  0x00, 0xF8, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0x9F, 0xFE, 0x3F, 0xFE, 0x01,
  0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xDF, 0xFF, 0x9F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0,
  0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x7E,
  0x00, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00,
  0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xFC,
  0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x3F,
  0x80, 0x3F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00,
  0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7F,
  0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x00,
  0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFE, 0x01, 0xFC,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x04, 0x00, 0x07, 0xC1, 0xFE,
  0x00, 0x3E, 0x3F, 0xF8, 0x01, 0xF3, 0xFF, 0xE0, 0x1F, 0xBF, 0xFF, 0x00,
  0xFD, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0x03, 0xFE,
  0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x07,
  0xE0, 0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x03, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07,
  0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x3F, 0xE7, 0xF8, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0xC3,
  0xF8, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0xC0, 0x0F,
  0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7F, 0x00,
  0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0xFE,
  0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x07, 0xF3, 0xF0, 0x01,
  0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF8,
  0x07, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x03, 0xE0, 0xFF, 0x00, 0x00, 0xF8, 0x7F, 0xE0, 0x00, 0x3E, 0x7F,
  0xFC, 0x00, 0x1F, 0x9F, 0xFF, 0x00, 0x07, 0xEF, 0xFF, 0xE0, 0x01, 0xFF,
  0xC7, 0xF8, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x0F,
  0xF0, 0x07, 0xE0, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F,
  0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xF0,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xE1, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xEF, 0xFF, 0xC0, 0x03, 0xFB, 0xFF,
  0xE0, 0x00, 0xFE, 0x7F, 0xF0, 0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x0F, 0xC0,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xFF, 0x07, 0xC0, 0x0F, 0xFC, 0x7E, 0x01, 0xFF,
  0xF3, 0xF0, 0x0F, 0xFF, 0x9F, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xF9, 0xFF,
  0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0x00, 0x7F, 0x83,
  0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xC0,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0x03,
  0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x03, 0xFE, 0x07, 0xF0,
  0x3F, 0xE0, 0x3F, 0xC3, 0xFF, 0x01, 0xFF, 0xFD, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFE, 0xFE, 0x00, 0xFF, 0xE7, 0xE0, 0x03, 0xFC, 0x3F, 0x00,
  0x07, 0x83, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0xF8, 0x7F, 0x00, 0xF8, 0xFF, 0x00,
  0xF9, 0xFF, 0x01, 0xFB, 0xFE, 0x01, 0xFB, 0xFE, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xC1,
  0xF0, 0x0F, 0xE0, 0x08, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x80, 0x07,
  0xF0, 0x38, 0x03, 0xFC, 0x0F, 0x83, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC2, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x38, 0x00, 0x03, 0xF0,
  0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F,
  0x07, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F,
  0xC0, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F,
  0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x83, 0xF8, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0xC0, 0xFE, 0x07, 0xFC, 0x0F, 0xF1, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xDF, 0x80, 0x7F, 0xFD, 0xF8, 0x07, 0xFF, 0x9F, 0x80, 0x3F,
  0xE1, 0xF0, 0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xE7, 0xF0, 0x07,
  0xF3, 0xF8, 0x03, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x7F, 0x03, 0xF0,
  0x3F, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F,
  0x0F, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03,
  0xF1, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFE, 0x00,
  0x3F, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x80,
  0x03, 0xEF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x00, 0x7E, 0xFE,
  0x01, 0xFF, 0x00, 0xFE, 0xFE, 0x01, 0xFF, 0x00, 0xFC, 0xFE, 0x01, 0xFF,
  0x00, 0xFC, 0xFE, 0x03, 0xFF, 0x01, 0xFC, 0xFE, 0x03, 0xFF, 0x01, 0xF8,
  0xFE, 0x07, 0xFF, 0x03, 0xF8, 0xFE, 0x07, 0xFF, 0x03, 0xF0, 0xFE, 0x07,
  0xFF, 0x03, 0xF0, 0xFE, 0x0F, 0xFF, 0x07, 0xF0, 0xFC, 0x0F, 0xBF, 0x07,
  0xE0, 0xFC, 0x1F, 0xBE, 0x07, 0xE0, 0xFC, 0x1F, 0x3E, 0x0F, 0xC0, 0xFC,
  0x1F, 0x3E, 0x0F, 0xC0, 0xFC, 0x3F, 0x3E, 0x1F, 0xC0, 0xFC, 0x3E, 0x3E,
  0x1F, 0x80, 0xFC, 0x7E, 0x3E, 0x1F, 0x80, 0xFC, 0x7E, 0x3E, 0x3F, 0x00,
  0xFC, 0x7C, 0x3E, 0x3F, 0x00, 0xFC, 0xFC, 0x3E, 0x7F, 0x00, 0xFC, 0xF8,
  0x3E, 0x7E, 0x00, 0xFC, 0xF8, 0x3E, 0x7E, 0x00, 0xFD, 0xF8, 0x3E, 0xFC,
  0x00, 0xFD, 0xF0, 0x3E, 0xFC, 0x00, 0xFD, 0xF0, 0x3E, 0xFC, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x01,
  0xF9, 0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x7F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8,
  0x1F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x13, 0xFF, 0xC0, 0x03, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xEC, 0x00, 0x7F, 0xFC, 0x80, 0x01, 0xFF, 0x08,
  0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 19, 52, 17, 0, -51 },
  { 125, 22, 18, 26, 7, -51 },
  { 175, 33, 51, 32, 0, -51 },
  { 386, 30, 59, 29, 0, -55 },
  { 608, 40, 53, 46, 4, -52 },
  { 873, 32, 53, 33, 0, -52 },
  { 1085, 10, 18, 15, 7, -51 },
  { 1108, 23, 63, 19, 1, -52 },
  { 1290, 22, 63, 19, -5, -52 },
  { 1464, 23, 26, 27, 7, -55 },
  { 1539, 27, 34, 32, 3, -42 },
  { 1654, 13, 19, 15, -3, -9 },
  { 1685, 17, 7, 19, 1, -23 },
  { 1700, 8, 10, 15, 1, -9 },
  { 1710, 35, 52, 25, -4, -52 },
  { 1938, 27, 53, 29, 2, -52 },
  { 2117, 20, 51, 29, 7, -51 },
  { 2245, 31, 52, 29, -2, -52 },
  { 2447, 31, 53, 29, -1, -52 },
  { 2653, 31, 52, 29, -1, -52 },
  { 2855, 31, 52, 29, -1, -51 },
  { 3057, 29, 53, 29, 2, -52 },
  { 3250, 30, 51, 29, 2, -51 },
  { 3442, 30, 53, 29, 0, -52 },
  { 3641, 29, 53, 29, 0, -52 },
  { 3834, 15, 40, 15, 0, -39 },
  { 3909, 19, 49, 15, -4, -39 },
  { 4026, 27, 33, 32, 3, -42 },
  { 4138, 27, 21, 32, 3, -36 },
  { 4209, 27, 33, 32, 3, -42 },
  { 4321, 24, 53, 22, 1, -52 },
  { 4480, 41, 58, 43, 2, -52 },
  { 4778, 31, 52, 30, -5, -52 },
  { 4980, 32, 51, 32, 0, -51 },
  { 5184, 31, 53, 29, 3, -52 },
  { 5390, 34, 51, 34, 0, -51 },
  { 5607, 30, 51, 27, 0, -51 },
  { 5799, 30, 51, 26, 0, -51 },
  { 5991, 35, 53, 36, 3, -52 },
  { 6223, 38, 51, 36, 0, -51 },
  { 6466, 29, 51, 20, -4, -51 },
  { 6651, 29, 65, 15, -11, -51 },
  { 6887, 36, 51, 30, 0, -51 },
  { 7117, 21, 51, 25, 0, -51 },
  { 7251, 49, 51, 48, 0, -51 },
  { 7564, 40, 51, 38, 0, -51 },
  { 7819, 33, 53, 37, 3, -52 },
  { 8038, 32, 51, 30, 0, -51 },
  { 8242, 33, 64, 37, 3, -52 },
  { 8506, 32, 51, 31, 0, -51 },
  { 8710, 33, 53, 28, -2, -52 },
  { 8929, 26, 51, 26, 5, -51 },
  { 9095, 35, 52, 35, 2, -51 },
  { 9323, 30, 51, 30, 6, -51 },
  { 9515, 49, 51, 48, 5, -51 },
  { 9828, 37, 51, 28, -4, -51 },
  { 10064, 27, 51, 27, 6, -51 },
  { 10237, 33, 51, 25, -3, -51 },
  { 10448, 27, 64, 20, -2, -52 },
  { 10664, 13, 52, 25, 7, -52 },
  { 10749, 28, 64, 20, -5, -52 },
  { 10973, 29, 28, 29, 0, -51 },
  { 11075, 23, 5, 22, -6, 6 },
  { 11090, 10, 11, 19, 11, -55 },
  { 11104, 29, 41, 31, 2, -40 },
  { 11253, 30, 56, 31, 0, -55 },
  { 11463, 24, 41, 24, 2, -40 },
  { 11586, 33, 56, 31, 2, -55 },
  { 11817, 25, 40, 28, 2, -39 },
  { 11942, 35, 72, 18, -9, -55 },
  { 12257, 33, 57, 31, -2, -40 },
  { 12493, 29, 55, 31, 0, -55 },
  { 12693, 18, 54, 15, 0, -54 },
  { 12815, 27, 71, 15, -9, -54 },
  { 13055, 31, 55, 27, 0, -55 },
  { 13269, 18, 55, 14, 0, -55 },
  { 13393, 44, 40, 45, 0, -40 },
  { 13613, 29, 40, 31, 0, -40 },
  { 13758, 26, 41, 30, 2, -40 },
  { 13892, 34, 57, 31, -4, -40 },
  { 14135, 29, 57, 31, 2, -40 },
  { 14342, 24, 40, 21, 0, -40 },
  { 14462, 26, 41, 24, -1, -40 },
  { 14596, 19, 48, 18, 2, -47 },
  { 14710, 28, 40, 31, 2, -39 },
  { 14850, 25, 39, 26, 4, -39 },
  { 14972, 40, 39, 41, 4, -39 },
  { 15167, 32, 39, 26, -3, -39 },
  { 15323, 36, 56, 26, -6, -39 },
  { 15575, 27, 39, 22, -3, -39 },
  { 15707, 28, 62, 24, 1, -51 },
  { 15924, 6, 72, 27, 10, -55 },
  { 15978, 26, 62, 24, -4, -51 },
  { 16180, 28, 10, 32, 3, -30 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC72PT7B_H_
