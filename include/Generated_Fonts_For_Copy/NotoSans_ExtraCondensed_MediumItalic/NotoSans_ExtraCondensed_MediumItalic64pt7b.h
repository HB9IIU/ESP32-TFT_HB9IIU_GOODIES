#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC64PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0,
  0x03, 0xE0, 0x00, 0x40, 0x00, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0xFE, 0x1F,
  0x9F, 0x83, 0xF3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF0, 0x7E,
  0x3E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0x87, 0xC1, 0xF0,
  0xF8, 0x3E, 0x1E, 0x07, 0xC7, 0xC0, 0xF0, 0xF8, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x78, 0x1E,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0x81,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFE, 0x63, 0xC0, 0x3F, 0x1C, 0x18, 0x07,
  0xE3, 0x80, 0x00, 0xF8, 0x70, 0x00, 0x1F, 0x0C, 0x00, 0x03, 0xE1, 0x80,
  0x00, 0xFC, 0x70, 0x00, 0x0F, 0x8E, 0x00, 0x01, 0xF9, 0x80, 0x00, 0x3F,
  0xB0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0x7F, 0x00,
  0x00, 0xE7, 0xE0, 0x00, 0x1C, 0xFC, 0x00, 0x03, 0x8F, 0x80, 0x00, 0x61,
  0xF0, 0x00, 0x0C, 0x3E, 0x00, 0x03, 0x87, 0xC0, 0x00, 0x71, 0xF8, 0x10,
  0x0C, 0x3F, 0x03, 0x81, 0x8F, 0xC0, 0xFE, 0x77, 0xF8, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x01, 0xF0, 0x03,
  0xFF, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x03, 0xE0, 0x0F, 0x8F, 0x00, 0x7C,
  0x00, 0xF0, 0xF8, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0xF8,
  0x0F, 0x00, 0x3E, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xF8, 0x1E, 0x00, 0x3C,
  0x0F, 0x83, 0xE0, 0x07, 0xC0, 0xF0, 0x3C, 0x00, 0x7C, 0x0F, 0x07, 0xC0,
  0x07, 0xC1, 0xF0, 0x78, 0x00, 0x78, 0x1F, 0x0F, 0x80, 0x07, 0x81, 0xF0,
  0xF0, 0x00, 0xF8, 0x1E, 0x1F, 0x00, 0x0F, 0x83, 0xE3, 0xE0, 0x00, 0xF8,
  0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xC7, 0xC3, 0xFC, 0xF8, 0x7C, 0x7C, 0x7F,
  0xEF, 0x87, 0xCF, 0x8F, 0xFE, 0xF8, 0xF8, 0xF9, 0xFB, 0xEF, 0x8F, 0x9F,
  0x1E, 0x1F, 0x7F, 0xF1, 0xF3, 0xE1, 0xF7, 0xFE, 0x3E, 0x3C, 0x1F, 0x3F,
  0xC3, 0xC3, 0xC1, 0xF1, 0xF8, 0x7C, 0x7C, 0x1F, 0x00, 0x07, 0x87, 0x81,
  0xF0, 0x00, 0xF8, 0x78, 0x1E, 0x00, 0x0F, 0x0F, 0x81, 0xE0, 0x01, 0xF0,
  0xF8, 0x3E, 0x00, 0x1E, 0x0F, 0x03, 0xE0, 0x03, 0xE0, 0xF0, 0x3E, 0x00,
  0x3C, 0x1F, 0x03, 0xC0, 0x07, 0xC1, 0xF0, 0x3C, 0x00, 0xF8, 0x1F, 0x07,
  0xC0, 0x0F, 0x81, 0xF0, 0x7C, 0x01, 0xF0, 0x1F, 0x07, 0x80, 0x1F, 0x01,
  0xF0, 0xF8, 0x03, 0xE0, 0x1F, 0x0F, 0x00, 0x3E, 0x01, 0xF1, 0xF0, 0x07,
  0xC0, 0x0F, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x0F, 0xF8,
  0x01, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x07,
  0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x1F,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0xFC, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x83, 0xF0, 0xFF, 0xF8, 0x3F, 0x0F, 0xCF, 0xC3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x0F, 0xC7, 0xE3, 0xF0, 0x7E, 0x7C, 0x7E, 0x07, 0xEF, 0xC7, 0xE0,
  0x7E, 0xF8, 0xFC, 0x03, 0xFF, 0x8F, 0xC0, 0x3F, 0xF0, 0xFC, 0x03, 0xFF,
  0x0F, 0xC0, 0x1F, 0xE0, 0xFC, 0x01, 0xFE, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC,
  0x03, 0xFC, 0x0F, 0xC0, 0x7F, 0xE0, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xF3, 0xF0, 0x3F, 0xFC, 0x3F, 0x81,
  0xFF, 0x83, 0xF8, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF0, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7A, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x10, 0x3C, 0x01, 0xE1,
  0xE0, 0x0F, 0xCF, 0x02, 0xFF, 0xF9, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xC0, 0x1F, 0xBE, 0x01, 0xF8, 0xF8, 0x1F, 0x87, 0xC0, 0x7C, 0x3F, 0x01,
  0xC0, 0xFC, 0x04, 0x07, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C,
  0x0F, 0x80, 0xF8, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF7, 0xFF, 0xEF,
  0xFF, 0xDF, 0xFF, 0x80, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x20,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xF1, 0xF8,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3,
  0xF0, 0x07, 0xE1, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFE, 0x3F, 0xBF, 0x3F, 0x9F, 0x9F, 0x8F, 0xC7, 0x8F, 0xC3,
  0x87, 0xE0, 0x83, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7C, 0x07, 0xF0, 0x03,
  0x00, 0x7F, 0x00, 0x20, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xF8, 0x3F, 0xC0,
  0x1C, 0x03, 0xF8, 0x02, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x04, 0x00, 0x3F, 0xC0, 0xE0, 0x0F, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xEF, 0xC0, 0x00,
  0x79, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF9, 0xF8,
  0x00, 0x1E, 0x3F, 0x00, 0x07, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3C,
  0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x78, 0x1F, 0x80,
  0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xF0, 0x1F, 0x80, 0x3E, 0x03,
  0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F,
  0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x10, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x0C, 0x00,
  0x7F, 0x80, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xE0, 0x20, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC3,
  0xF0, 0x03, 0xF3, 0xFE, 0x00, 0xFD, 0xFF, 0xC0, 0x3E, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x07, 0xFE, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFC,
  0x3F, 0xC0, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC,
  0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x0F, 0xC0,
  0xF8, 0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0,
  0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00,
  0x3E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07,
  0xE0, 0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0x8F, 0xE0, 0x1F,
  0x81, 0xF8, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0,
  0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0,
  0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x83,
  0xF0, 0x1F, 0xE0, 0xFC, 0x0F, 0xF0, 0x3F, 0x87, 0xFC, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xEF, 0xC0, 0x7F, 0xFB, 0xF0, 0x0F, 0xF9, 0xF8, 0x01, 0xFC,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x80, 0x7F, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0x3F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x1F, 0x00, 0x20, 0x00, 0x00,
  0x0E, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xC1, 0xFC, 0x18, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x1F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x0F, 0x07, 0xC0, 0x1F, 0x80, 0xF0, 0x78, 0x07, 0xFF, 0x0F, 0x0F,
  0x80, 0xFF, 0xE0, 0xF0, 0xF0, 0x1F, 0xFE, 0x0F, 0x1F, 0x03, 0xE1, 0xE0,
  0xF1, 0xE0, 0x7C, 0x3E, 0x0F, 0x1E, 0x07, 0x83, 0xE0, 0xF3, 0xE0, 0xF8,
  0x3C, 0x0F, 0x3C, 0x0F, 0x03, 0xC1, 0xF3, 0xC1, 0xF0, 0x7C, 0x1E, 0x7C,
  0x1E, 0x07, 0xC1, 0xE7, 0x83, 0xE0, 0x78, 0x1E, 0x78, 0x3E, 0x0F, 0x81,
  0xE7, 0x83, 0xC0, 0xF8, 0x3E, 0xF8, 0x3C, 0x0F, 0x83, 0xCF, 0x07, 0xC0,
  0xF0, 0x3C, 0xF0, 0x7C, 0x1F, 0x03, 0xCF, 0x07, 0xC1, 0xF0, 0x78, 0xF0,
  0x78, 0x1F, 0x07, 0x8F, 0x07, 0x83, 0xE0, 0xF0, 0xF0, 0x78, 0x3E, 0x0F,
  0x0F, 0x07, 0xC7, 0xE1, 0xE0, 0xF0, 0x7C, 0xFF, 0x3E, 0x0F, 0x07, 0xFE,
  0xFF, 0xC0, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0x01, 0xF8, 0x7F, 0x00, 0xF0,
  0x06, 0x00, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x40, 0x00, 0x3F,
  0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xDF, 0x80,
  0x01, 0xFB, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9,
  0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x1F,
  0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xF0,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0x3F, 0x3F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0x1F, 0xF8, 0x03, 0xF0, 0x1F, 0xE0,
  0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7E,
  0x00, 0x7E, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE1, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E,
  0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00,
  0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF0,
  0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0xC0, 0x7E,
  0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFC, 0x3C, 0x00, 0xFF, 0x00, 0xC0, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x02, 0x00, 0x3F, 0xC0, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0x00, 0x3F, 0x01, 0xFE,
  0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x1F,
  0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xC0,
  0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x01,
  0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x03,
  0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00,
  0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x7F,
  0x00, 0xFC, 0x03, 0xFC, 0x03, 0xF0, 0x1F, 0xE0, 0x1F, 0x81, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0xFC, 0x00,
  0xFF, 0x80, 0x18, 0x01, 0xFE, 0x00, 0x08, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0xF0, 0x7F, 0x00, 0xFF, 0xF0, 0x7E, 0x00, 0xFF, 0xF0, 0x7E,
  0x00, 0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0xE0, 0xFE,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0,
  0x07, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07,
  0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x0F,
  0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x41, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x03, 0xF3, 0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0x7F, 0xF8, 0x01, 0xF7,
  0xC0, 0x07, 0xDF, 0x80, 0x3F, 0x7C, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xC0,
  0x0F, 0x9F, 0x00, 0x3F, 0x7C, 0x01, 0xFB, 0xF0, 0x03, 0xE7, 0xC0, 0x1F,
  0x3F, 0x00, 0x3E, 0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x3E, 0x3F,
  0x00, 0x7E, 0x7E, 0x03, 0xE3, 0xE0, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x00,
  0x7C, 0x7E, 0x07, 0xC7, 0xE0, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x00, 0xFC,
  0x3E, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xE1, 0xF8, 0xFC, 0x00, 0xFC, 0x3E,
  0x1F, 0x0F, 0xC0, 0x0F, 0x83, 0xE1, 0xF0, 0xFC, 0x01, 0xF8, 0x3E, 0x3E,
  0x0F, 0xC0, 0x1F, 0x83, 0xE3, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x7C, 0x1F,
  0x80, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x01, 0xF0, 0x3E, 0xFC, 0x1F, 0x80,
  0x3F, 0x03, 0xEF, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0xF8, 0x1F, 0x00, 0x3F,
  0x03, 0xFF, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0xF0, 0x3F, 0x00, 0x3E, 0x03,
  0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xFC,
  0x03, 0xE0, 0x07, 0xE0, 0x3F, 0xC0, 0x7E, 0x00, 0x7C, 0x03, 0xFC, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x0F,
  0xF0, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x03, 0xF0,
  0x07, 0xF8, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x0F, 0x80, 0x3F, 0xF0, 0x03,
  0xF0, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x1F, 0xF8,
  0x01, 0xF0, 0x07, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F,
  0x7E, 0x01, 0xF8, 0x03, 0xEF, 0xC0, 0x3F, 0x00, 0x7C, 0xF8, 0x07, 0xC0,
  0x1F, 0x9F, 0x01, 0xF8, 0x03, 0xF3, 0xE0, 0x3F, 0x00, 0x7E, 0x7C, 0x07,
  0xE0, 0x0F, 0x8F, 0xC0, 0xFC, 0x01, 0xF1, 0xF8, 0x1F, 0x00, 0x7E, 0x1F,
  0x07, 0xE0, 0x0F, 0xC3, 0xE0, 0xFC, 0x01, 0xF8, 0x7C, 0x1F, 0x80, 0x3E,
  0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF8, 0x7C, 0x01, 0xF8, 0x3F, 0x1F, 0x80,
  0x3F, 0x03, 0xE3, 0xF0, 0x07, 0xE0, 0x7C, 0x7E, 0x00, 0xF8, 0x0F, 0x8F,
  0x80, 0x3F, 0x01, 0xF1, 0xF0, 0x07, 0xE0, 0x3F, 0x7E, 0x00, 0xFC, 0x07,
  0xEF, 0xC0, 0x1F, 0x80, 0x7D, 0xF8, 0x03, 0xE0, 0x0F, 0xBE, 0x00, 0xFC,
  0x01, 0xF7, 0xC0, 0x1F, 0x80, 0x3F, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0x00,
  0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x0F, 0xF8, 0x03, 0xF0, 0x01, 0xFF,
  0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0xC0, 0x07, 0xFC, 0x01, 0xF0, 0x00,
  0xFF, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x01, 0xFC, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x03, 0xF8,
  0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF9, 0xFC,
  0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFE, 0x7E, 0x00,
  0x03, 0xF9, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x01,
  0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFE,
  0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F,
  0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x01, 0xF8,
  0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x83,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFC,
  0x0F, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x01, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F,
  0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xF0, 0x07,
  0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x07,
  0xE0, 0x1F, 0xC0, 0x7E, 0x03, 0xFC, 0x07, 0xE0, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x7E,
  0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xFC, 0x7E, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01,
  0xF9, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFE,
  0x7E, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F,
  0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x7F, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0x81, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80,
  0x7F, 0x83, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7E,
  0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x07, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01,
  0xF8, 0x3F, 0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0,
  0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0,
  0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFE, 0xFE, 0x01, 0xFE, 0x01, 0xC0, 0x1F, 0xC0,
  0x04, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x80, 0x03,
  0xF8, 0x0E, 0x00, 0x7F, 0x80, 0xFC, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0,
  0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x0F,
  0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0,
  0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x01,
  0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC,
  0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xC0,
  0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xCF, 0xC0,
  0x07, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFE,
  0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x3E,
  0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3F, 0x00,
  0x3E, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0xFC,
  0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE7, 0xE0, 0x00, 0xF9,
  0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xF3, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE3, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x80, 0x0F,
  0xC7, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0x87,
  0xE0, 0x07, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x80, 0x1F, 0x87, 0xE0,
  0x0F, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFF, 0x80, 0x3F, 0x07, 0xE0, 0x0F,
  0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xFF, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0xF8,
  0x07, 0xE0, 0x7E, 0x01, 0xEF, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xEF, 0x81, 0xFC, 0x07, 0xE0, 0x7C, 0xF8, 0x1F, 0x80,
  0x7E, 0x07, 0xCF, 0x81, 0xF8, 0x07, 0xE0, 0x7C, 0xF8, 0x3F, 0x00, 0x7E,
  0x0F, 0x8F, 0x83, 0xF0, 0x07, 0xE0, 0xF8, 0xF8, 0x3F, 0x00, 0x7E, 0x1F,
  0x0F, 0x87, 0xE0, 0x07, 0xE1, 0xF0, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x0F,
  0x8F, 0xC0, 0x07, 0xE3, 0xE0, 0xF8, 0xFC, 0x00, 0x7E, 0x3E, 0x0F, 0x8F,
  0xC0, 0x07, 0xE7, 0xE1, 0xF1, 0xF8, 0x00, 0x7E, 0x7C, 0x1F, 0x1F, 0x80,
  0x07, 0xC7, 0xC1, 0xF3, 0xF0, 0x00, 0x7C, 0xF8, 0x1F, 0x3F, 0x00, 0x07,
  0xCF, 0x81, 0xF3, 0xF0, 0x00, 0x7D, 0xF8, 0x1F, 0x7E, 0x00, 0x07, 0xDF,
  0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF0, 0x1F, 0x7C, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x1F,
  0x80, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xF9,
  0xF0, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xCF,
  0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x81, 0xF8,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xDF,
  0x80, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F,
  0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE7, 0xC0, 0x01,
  0xF1, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x83, 0xE0,
  0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x7C, 0x01,
  0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xE3, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xF0,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE,
  0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3E, 0x07, 0xC1, 0xF0,
  0x00, 0x1F, 0x83, 0xE0, 0x0F, 0xF8, 0xFC, 0x03, 0xFF, 0x9F, 0x00, 0xFF,
  0xFB, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xF8, 0xFF, 0x81, 0xFC, 0x0F, 0xF0,
  0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x7F, 0x00,
  0xFE, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F,
  0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC,
  0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFE, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0,
  0x7F, 0x80, 0xFC, 0x1F, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xEF, 0x80,
  0x3F, 0xF9, 0xF0, 0x03, 0xFE, 0x3E, 0x00, 0x3F, 0x87, 0xC0, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xE7, 0xFC, 0x01, 0xF3, 0xFF, 0x80, 0xFD, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF8, 0x7F, 0x03, 0xFC, 0x0F, 0xC0, 0xFE,
  0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC1,
  0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x07, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F,
  0xE0, 0x7F, 0xEF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0x9F, 0xFE, 0x03, 0xE7,
  0xFF, 0x00, 0xF8, 0x7F, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFC,
  0x30, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x20, 0x7F, 0x03, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xF1, 0xF8, 0x00, 0xFF, 0xE7, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFE, 0x1F, 0xF0, 0x07,
  0xF0, 0x3F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC,
  0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0x7E, 0x01,
  0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x7F,
  0x80, 0x1F, 0x83, 0xFE, 0x00, 0x7F, 0xBF, 0xF0, 0x01, 0xFF, 0xF7, 0xC0,
  0x03, 0xFF, 0x9F, 0x00, 0x07, 0xFC, 0x7C, 0x00, 0x0F, 0xE1, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0x0F, 0xC1, 0xFC, 0x0F,
  0x83, 0xF0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x7E, 0x01, 0xF8,
  0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC1, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x08, 0x1F, 0xE0, 0xF0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xF1, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0xFF, 0xCF, 0xC0, 0x0F, 0xFE, 0x7C, 0x00, 0xFF, 0xFB, 0xE0, 0x07,
  0xFF, 0xDF, 0x00, 0x7F, 0x0F, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F,
  0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00,
  0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8,
  0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F,
  0x80, 0x7F, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01,
  0xFC, 0x01, 0xF8, 0x1F, 0xE0, 0x0F, 0xC1, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xEF, 0x80, 0x0F, 0xFE, 0xFC, 0x00, 0x7F, 0xE7, 0xE0, 0x01,
  0xFE, 0x3F, 0x00, 0x01, 0x81, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x01, 0x00, 0x1F, 0xC0, 0x0E,
  0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xE7, 0xFC, 0x01, 0xF7, 0xFF, 0x00, 0x7D, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xF8, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x01,
  0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E,
  0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0,
  0xFC, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F,
  0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8,
  0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x03,
  0xF0, 0x00, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0x3E, 0x03, 0xF0,
  0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xC1,
  0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00,
  0xFC, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFD, 0xF8,
  0x00, 0x1F, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0x00, 0x0F, 0xE7, 0xE0,
  0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80,
  0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0xFC, 0x03, 0xF0, 0x03, 0xE7, 0xFE, 0x1F, 0xF0, 0x07, 0xDF, 0xFC,
  0x7F, 0xF0, 0x0F, 0x7F, 0xFD, 0xFF, 0xE0, 0x3E, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xC7, 0xFE, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x00, 0xF8,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x7C, 0x01,
  0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0x3E,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x0F,
  0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0xC0,
  0x7E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0xFF, 0x80, 0x7D, 0xFF, 0xC0,
  0x3C, 0xFF, 0xF0, 0x3E, 0xFF, 0xF8, 0x1F, 0xF1, 0xFC, 0x0F, 0xF0, 0x7E,
  0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xC1, 0xF8, 0x07,
  0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x87, 0xE0,
  0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0xC1,
  0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xF8,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0x83, 0xF8, 0x1F,
  0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0xFC, 0x01, 0xF9,
  0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBE, 0x00, 0x7F, 0x7C, 0x00,
  0xFC, 0xF8, 0x01, 0xF9, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xC7, 0xE0, 0x3F,
  0x8F, 0xC0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF1, 0xFF, 0x00, 0x0F, 0x9F, 0xFC, 0x00,
  0x7D, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xE1, 0xFC, 0x01, 0xFE,
  0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF0,
  0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x3F,
  0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xF7, 0xFF, 0xC0, 0x1F, 0xBF, 0xFC, 0x00,
  0xFC, 0xFF, 0xC0, 0x07, 0xE3, 0xFC, 0x00, 0x3F, 0x06, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x07, 0xFC, 0xFC, 0x03, 0xFF, 0x9F,
  0x00, 0xFF, 0xFB, 0xE0, 0x1F, 0xFF, 0x7C, 0x07, 0xF0, 0xFF, 0x81, 0xFC,
  0x0F, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x07, 0xF0,
  0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7E, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x0F,
  0xC0, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC,
  0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x01, 0xFC,
  0x07, 0xE0, 0x7F, 0x80, 0xFC, 0x1F, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xEF, 0x80, 0x3F, 0xFB, 0xF0, 0x07, 0xFE, 0x7E, 0x00, 0x7F, 0x8F, 0xC0,
  0x01, 0x81, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0xFC, 0x07, 0xCF, 0xE0, 0x1F, 0x7F, 0x80,
  0x79, 0xFE, 0x03, 0xEF, 0xF0, 0x0F, 0xBF, 0xC0, 0x3F, 0xF1, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0x07, 0x01, 0xF8, 0x02,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x08, 0x01, 0xFC, 0x1C, 0x03, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xFF, 0x0F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE,
  0x4F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0,
  0x0C, 0x00, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xE1,
  0xF8, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC,
  0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F,
  0x83, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0xFC, 0x03,
  0xF0, 0x7E, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x1F, 0x80,
  0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x3F,
  0x01, 0xFC, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0xFF, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xF7, 0xC0, 0x3F, 0xF3, 0xE0,
  0x0F, 0xF1, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0x80,
  0xFC, 0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xF0,
  0x3E, 0x0F, 0x80, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E,
  0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0xFC,
  0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x03,
  0xF7, 0xE0, 0x1F, 0xC0, 0x3F, 0x7E, 0x01, 0xFC, 0x03, 0xE7, 0xE0, 0x3F,
  0xC0, 0x7E, 0x7E, 0x03, 0xFC, 0x07, 0xE7, 0xE0, 0x7F, 0xC0, 0xFC, 0x7C,
  0x07, 0xFC, 0x0F, 0xC7, 0xC0, 0x7F, 0xC0, 0xF8, 0x7C, 0x0F, 0xFC, 0x1F,
  0x87, 0xC0, 0xF7, 0xC1, 0xF8, 0x7C, 0x1F, 0x78, 0x1F, 0x07, 0xC1, 0xF7,
  0x83, 0xF0, 0x7C, 0x1E, 0x78, 0x3E, 0x07, 0xC3, 0xE7, 0x87, 0xE0, 0x7C,
  0x3E, 0x78, 0x7E, 0x07, 0xC7, 0xC7, 0x87, 0xC0, 0x7C, 0x7C, 0xF8, 0xFC,
  0x07, 0xC7, 0xCF, 0x8F, 0x80, 0x7C, 0xF8, 0xF8, 0xF8, 0x07, 0xCF, 0x8F,
  0x9F, 0x80, 0x7C, 0xF0, 0xF9, 0xF0, 0x07, 0xDF, 0x0F, 0xBF, 0x00, 0x7D,
  0xF0, 0xFB, 0xE0, 0x07, 0xFE, 0x0F, 0xBE, 0x00, 0x7F, 0xE0, 0xFF, 0xE0,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F,
  0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0x7C,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF8, 0xFC, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x9F, 0xFC, 0x00, 0x5F, 0xFF, 0x80, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x80, 0x7F, 0xFD, 0x80, 0x0F, 0xFC, 0x80,
  0x00, 0xF8, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 17, 47, 15, 0, -46 },
  { 101, 19, 17, 23, 6, -46 },
  { 142, 30, 46, 28, 0, -46 },
  { 315, 27, 53, 26, 0, -49 },
  { 494, 36, 47, 41, 3, -46 },
  { 706, 28, 47, 29, 0, -46 },
  { 871, 9, 17, 13, 6, -46 },
  { 891, 20, 56, 17, 1, -46 },
  { 1031, 20, 56, 17, -5, -46 },
  { 1171, 21, 23, 24, 6, -49 },
  { 1232, 24, 30, 28, 3, -38 },
  { 1322, 12, 17, 14, -3, -8 },
  { 1348, 15, 6, 17, 1, -20 },
  { 1360, 7, 9, 14, 1, -8 },
  { 1368, 30, 46, 22, -3, -46 },
  { 1541, 25, 47, 26, 1, -46 },
  { 1688, 17, 46, 26, 7, -46 },
  { 1786, 28, 46, 26, -2, -46 },
  { 1947, 27, 47, 26, -1, -46 },
  { 2106, 27, 46, 26, -1, -46 },
  { 2262, 28, 47, 26, -1, -46 },
  { 2427, 26, 47, 26, 2, -46 },
  { 2580, 27, 46, 26, 2, -46 },
  { 2736, 27, 47, 26, 0, -46 },
  { 2895, 26, 47, 26, 0, -46 },
  { 3048, 13, 36, 14, 0, -35 },
  { 3107, 17, 44, 14, -3, -35 },
  { 3201, 25, 29, 28, 2, -37 },
  { 3292, 24, 19, 28, 3, -32 },
  { 3349, 24, 29, 28, 3, -37 },
  { 3436, 21, 47, 19, 1, -46 },
  { 3560, 36, 51, 39, 2, -46 },
  { 3790, 27, 46, 27, -4, -46 },
  { 3946, 29, 46, 28, 0, -46 },
  { 4113, 28, 47, 26, 2, -46 },
  { 4278, 30, 46, 31, 0, -46 },
  { 4451, 27, 46, 24, 0, -46 },
  { 4607, 27, 46, 23, 0, -46 },
  { 4763, 32, 47, 32, 2, -46 },
  { 4951, 33, 46, 32, 0, -46 },
  { 5141, 25, 46, 18, -3, -46 },
  { 5285, 26, 59, 14, -10, -46 },
  { 5477, 32, 46, 27, 0, -46 },
  { 5661, 18, 46, 22, 0, -46 },
  { 5765, 44, 46, 42, 0, -46 },
  { 6018, 35, 46, 34, 0, -46 },
  { 6220, 30, 47, 33, 2, -46 },
  { 6397, 28, 46, 27, 0, -46 },
  { 6558, 30, 57, 33, 2, -46 },
  { 6772, 28, 46, 28, 0, -46 },
  { 6933, 28, 47, 25, -1, -46 },
  { 7098, 24, 46, 23, 4, -46 },
  { 7236, 31, 47, 31, 2, -46 },
  { 7419, 26, 46, 27, 6, -46 },
  { 7569, 44, 46, 43, 4, -46 },
  { 7822, 34, 46, 25, -4, -46 },
  { 8018, 25, 46, 24, 5, -46 },
  { 8162, 30, 46, 22, -3, -46 },
  { 8335, 25, 56, 18, -2, -46 },
  { 8510, 12, 46, 22, 6, -46 },
  { 8579, 24, 56, 18, -4, -46 },
  { 8747, 26, 26, 26, 0, -46 },
  { 8832, 21, 4, 20, -6, 5 },
  { 8843, 10, 10, 17, 9, -49 },
  { 8856, 27, 36, 28, 1, -35 },
  { 8978, 26, 50, 27, 0, -49 },
  { 9141, 21, 36, 21, 2, -35 },
  { 9236, 30, 50, 28, 1, -49 },
  { 9424, 23, 36, 25, 1, -35 },
  { 9528, 31, 64, 16, -8, -49 },
  { 9776, 29, 50, 28, -1, -35 },
  { 9958, 26, 49, 27, 0, -49 },
  { 10118, 16, 48, 13, 0, -48 },
  { 10214, 24, 63, 13, -8, -48 },
  { 10403, 27, 49, 24, 0, -49 },
  { 10569, 16, 49, 13, 0, -49 },
  { 10667, 39, 35, 40, 0, -35 },
  { 10838, 25, 35, 27, 0, -35 },
  { 10948, 23, 36, 27, 2, -35 },
  { 11052, 29, 50, 27, -3, -35 },
  { 11234, 27, 50, 28, 1, -35 },
  { 11403, 22, 35, 19, 0, -35 },
  { 11500, 23, 36, 21, -1, -35 },
  { 11604, 16, 43, 16, 2, -42 },
  { 11690, 25, 36, 27, 2, -35 },
  { 11803, 22, 35, 23, 4, -35 },
  { 11900, 36, 35, 36, 3, -35 },
  { 12058, 29, 35, 23, -3, -35 },
  { 12185, 32, 50, 23, -6, -35 },
  { 12385, 23, 35, 19, -2, -35 },
  { 12486, 24, 56, 21, 1, -46 },
  { 12654, 5, 64, 24, 9, -49 },
  { 12694, 24, 56, 21, -4, -46 },
  { 12862, 25, 9, 28, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC64PT7B_H_
