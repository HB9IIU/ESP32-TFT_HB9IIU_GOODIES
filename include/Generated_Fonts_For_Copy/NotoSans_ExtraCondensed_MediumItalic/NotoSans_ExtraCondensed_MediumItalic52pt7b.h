#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC52PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x0F, 0x00, 0x7E, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0x3E, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3C, 0x3E, 0x7C, 0x3C, 0x7C, 0x3C, 0x7C, 0x7C, 0x78, 0x7C, 0x78, 0x78,
  0x78, 0x78, 0x70, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x01, 0xE1, 0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xC1, 0xC0, 0x03,
  0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x83, 0x80, 0x07,
  0x87, 0x80, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x0E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1C,
  0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x78, 0x00, 0x70, 0x70, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x1F, 0x99, 0xC0, 0x7C, 0xE1, 0x01, 0xE3, 0x00, 0x07, 0x8C, 0x00, 0x3E,
  0x30, 0x00, 0xF8, 0xC0, 0x01, 0xE6, 0x00, 0x07, 0xD8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0x9F, 0x00, 0x06,
  0x7C, 0x00, 0x18, 0xF0, 0x00, 0x63, 0xC0, 0x03, 0x8F, 0x00, 0x0C, 0x7C,
  0x10, 0x31, 0xF0, 0xF0, 0xCF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x7E, 0x00, 0x78, 0x0F, 0xF0, 0x07, 0x81, 0xFF, 0x80, 0xF0,
  0x1E, 0x78, 0x0F, 0x03, 0xC7, 0x81, 0xE0, 0x3C, 0x78, 0x1E, 0x07, 0x87,
  0x83, 0xC0, 0x78, 0x78, 0x3C, 0x07, 0x07, 0x87, 0x80, 0xF0, 0x78, 0x78,
  0x0F, 0x07, 0x8F, 0x00, 0xF0, 0x70, 0xF0, 0x0F, 0x0F, 0x1E, 0x00, 0xE0,
  0xF1, 0xC0, 0x0E, 0x0F, 0x3C, 0x38, 0xE1, 0xE3, 0x87, 0xEE, 0x1E, 0x78,
  0xFF, 0xE1, 0xC7, 0x1F, 0xFF, 0x3C, 0xF3, 0xC7, 0xFF, 0x9E, 0x38, 0x7F,
  0xF1, 0xE7, 0x87, 0x7E, 0x3C, 0x70, 0x71, 0x83, 0xCF, 0x07, 0x00, 0x78,
  0xF0, 0x70, 0x07, 0x8F, 0x0F, 0x00, 0xF0, 0xE0, 0xF0, 0x0F, 0x1E, 0x0F,
  0x01, 0xE1, 0xE0, 0xE0, 0x1E, 0x1E, 0x1E, 0x03, 0xC1, 0xE1, 0xE0, 0x3C,
  0x1E, 0x1E, 0x07, 0x81, 0xE3, 0xC0, 0x70, 0x1E, 0x3C, 0x0F, 0x01, 0xE7,
  0x80, 0xE0, 0x1F, 0xF8, 0x1E, 0x00, 0xFF, 0x03, 0xC0, 0x07, 0xE0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x0F, 0x9F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3C, 0x00,
  0xF0, 0xF8, 0x01, 0xE1, 0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1F,
  0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC3, 0xE3, 0xFF, 0x87, 0xC7, 0xCF, 0x8F, 0x1F, 0x1F, 0x3E,
  0x7C, 0x3E, 0x78, 0xF8, 0x3F, 0xF3, 0xE0, 0x7F, 0xE7, 0xC0, 0xFF, 0x8F,
  0x80, 0xFE, 0x1F, 0x01, 0xFC, 0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0xF8,
  0x1F, 0xC1, 0xF0, 0x7F, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xDF, 0x87, 0xFF,
  0x1F, 0x03, 0xFC, 0x3E, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E,
  0x3C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x70, 0xF0, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01,
  0x80, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x04, 0x1E, 0x03, 0x8F, 0x03,
  0xF7, 0x0D, 0xFF, 0xFE, 0xFF, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xE1, 0xFC,
  0x01, 0xFF, 0x01, 0xF7, 0x81, 0xF1, 0xE0, 0xF8, 0xF0, 0x38, 0x7C, 0x08,
  0x1C, 0x00, 0x08, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3E,
  0x0F, 0x87, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x08, 0x79, 0xFB, 0xFF, 0xDF, 0x9E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0x1F,
  0x03, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0,
  0x1E, 0x3E, 0x03, 0xE3, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0xCF,
  0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xF0,
  0xF8, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x0F, 0xCF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x8F,
  0xBE, 0xFC, 0xF9, 0xE3, 0xC3, 0x1F, 0x08, 0x7C, 0x01, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1E, 0x0F, 0xC0, 0x38, 0x0F,
  0x80, 0x20, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0x03, 0xF0, 0x08,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x80, 0x1F,
  0x83, 0x80, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01,
  0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0E, 0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDF,
  0x00, 0x0E, 0x7C, 0x00, 0x79, 0xF0, 0x03, 0xC7, 0x80, 0x0E, 0x1E, 0x00,
  0x78, 0xF8, 0x01, 0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x78, 0x3C, 0x01, 0xC1,
  0xF0, 0x0F, 0x07, 0xC0, 0x78, 0x1F, 0x01, 0xC0, 0x7C, 0x0F, 0x01, 0xE0,
  0x78, 0x0F, 0x81, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0xE3, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x20, 0x0F, 0xC0, 0xC0, 0x7F, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x30,
  0x07, 0xCF, 0xE0, 0x3E, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFE,
  0x0F, 0x87, 0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80,
  0x78, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x03,
  0xE1, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0x83, 0xE0, 0x7C,
  0x07, 0xC1, 0xF0, 0x1F, 0x07, 0x80, 0x7C, 0x1E, 0x01, 0xE0, 0x78, 0x07,
  0x81, 0xE0, 0x3E, 0x07, 0xC0, 0xF0, 0x1F, 0x07, 0xC0, 0x7E, 0x3E, 0x00,
  0xF9, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x3F, 0x7E, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xF0,
  0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8,
  0x03, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F,
  0x83, 0xF0, 0x7E, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xF0, 0xF8, 0x1F, 0x03,
  0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3E,
  0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xE3, 0xE0, 0x3E,
  0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xC1, 0xFC, 0x3F, 0x1F, 0xE1, 0xFF,
  0xFF, 0x07, 0xFE, 0xF0, 0x3F, 0xEF, 0x80, 0xFE, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x3F,
  0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x80, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x1F, 0x03, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF8, 0x60, 0x7C, 0x20, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0,
  0x1E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0xF0, 0x70, 0x1F, 0xE3, 0xC3, 0xC1, 0xFF, 0x87, 0x0E, 0x0F,
  0xFE, 0x1C, 0x78, 0x3C, 0x70, 0xF1, 0xC1, 0xE1, 0xC3, 0xCF, 0x0F, 0x0F,
  0x0F, 0x3C, 0x3C, 0x3C, 0x3C, 0xE0, 0xE0, 0xE0, 0xE3, 0x87, 0x83, 0x83,
  0x9E, 0x1C, 0x1E, 0x0E, 0x78, 0x70, 0x78, 0x79, 0xC3, 0xC1, 0xE1, 0xC7,
  0x0F, 0x0F, 0x07, 0x1C, 0x3C, 0x3C, 0x3C, 0xF0, 0xF0, 0xF0, 0xE3, 0xC3,
  0xC7, 0xC3, 0x8F, 0x0F, 0x1F, 0x1C, 0x3C, 0x3C, 0xFC, 0xF0, 0xF0, 0xFF,
  0x7F, 0x83, 0xC1, 0xF9, 0xFC, 0x0F, 0x03, 0xC3, 0xE0, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x20, 0x00, 0x7C, 0x03, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x7C,
  0x00, 0x7D, 0xF0, 0x01, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x01,
  0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1,
  0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xF0, 0x07,
  0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0xF8,
  0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x7E,
  0x07, 0xC3, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFF, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0xF8, 0x1E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0,
  0x0F, 0x83, 0xE0, 0x1F, 0x07, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x3E, 0x03,
  0xF0, 0x7C, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x03, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x0C, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xF1, 0xFE,
  0x01, 0xF0, 0x7E, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x1F,
  0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x03, 0xF0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x1F, 0xC0, 0x7C, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xE0, 0x78, 0x0F, 0xC0, 0x08, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xFF, 0x1F,
  0x80, 0xFF, 0x8F, 0xC0, 0x7F, 0xC7, 0xC0, 0x7F, 0xE3, 0xE0, 0x01, 0xF1,
  0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xF0, 0x07,
  0xC1, 0xF8, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0x81, 0xF0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F,
  0x80, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0xF8,
  0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xF8, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xF0, 0x03,
  0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0,
  0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x11,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x07,
  0xC0, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0xC0,
  0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x3C, 0x3E,
  0x00, 0x1F, 0x1F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7D,
  0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xE7, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x07, 0xC0,
  0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3D, 0xE0, 0x0F, 0xFC, 0x03, 0xDE, 0x00,
  0xF7, 0x80, 0x7D, 0xE0, 0x1F, 0xF8, 0x07, 0xDE, 0x01, 0xEF, 0x80, 0x7D,
  0xE0, 0x3E, 0xF8, 0x07, 0x9E, 0x03, 0xCF, 0x80, 0xF9, 0xE0, 0x3C, 0xF0,
  0x0F, 0x9E, 0x07, 0x9F, 0x00, 0xF9, 0xE0, 0x79, 0xF0, 0x0F, 0x9E, 0x0F,
  0x9F, 0x00, 0xF1, 0xE0, 0xF1, 0xF0, 0x1F, 0x1E, 0x1F, 0x1E, 0x01, 0xF1,
  0xE1, 0xE3, 0xE0, 0x1F, 0x1E, 0x3E, 0x3E, 0x01, 0xE1, 0xE3, 0xC3, 0xE0,
  0x1E, 0x1E, 0x3C, 0x3C, 0x03, 0xE1, 0xE7, 0x87, 0xC0, 0x3E, 0x1E, 0x78,
  0x7C, 0x03, 0xE1, 0xEF, 0x87, 0xC0, 0x3C, 0x1E, 0xF0, 0x7C, 0x03, 0xC1,
  0xFF, 0x07, 0x80, 0x7C, 0x1F, 0xE0, 0xF8, 0x07, 0xC1, 0xFE, 0x0F, 0x80,
  0x7C, 0x1F, 0xC0, 0xF8, 0x07, 0x81, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0xF8, 0x0F, 0xE0, 0x07, 0x80, 0x7F, 0x00, 0x3C, 0x03, 0xF8,
  0x03, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0xFE, 0x00, 0xF8, 0x0F, 0xF8, 0x07,
  0x80, 0x7F, 0xC0, 0x7C, 0x03, 0xDE, 0x03, 0xE0, 0x1E, 0xF0, 0x1F, 0x00,
  0xF7, 0x80, 0xF0, 0x0F, 0xBC, 0x07, 0x80, 0x7D, 0xF0, 0x7C, 0x03, 0xEF,
  0x83, 0xE0, 0x1E, 0x3C, 0x1F, 0x01, 0xF1, 0xE0, 0xF0, 0x0F, 0x8F, 0x07,
  0x80, 0x7C, 0x78, 0x7C, 0x03, 0xE3, 0xE3, 0xE0, 0x1E, 0x1F, 0x1F, 0x01,
  0xF0, 0x78, 0xF0, 0x0F, 0x83, 0xC7, 0x80, 0x7C, 0x1E, 0x7C, 0x03, 0xC0,
  0xF3, 0xE0, 0x1E, 0x07, 0xDF, 0x01, 0xF0, 0x3E, 0xF0, 0x0F, 0x80, 0xF7,
  0x80, 0x7C, 0x07, 0xFC, 0x03, 0xC0, 0x3F, 0xE0, 0x1E, 0x01, 0xFE, 0x01,
  0xF0, 0x0F, 0xF0, 0x0F, 0x80, 0x7F, 0x80, 0x7C, 0x01, 0xFC, 0x03, 0xC0,
  0x0F, 0xE0, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x3E, 0x07,
  0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F,
  0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0xFC,
  0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F,
  0x1F, 0xC0, 0x3E, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x07, 0xC0, 0x7E, 0x0F, 0x81, 0xF8,
  0x1F, 0x07, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x3F, 0x0F, 0xC0,
  0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00,
  0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01,
  0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F,
  0xC0, 0x7E, 0x1F, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0x1F, 0xC0, 0x3C, 0x0F,
  0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C,
  0x0F, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81,
  0xF0, 0x3F, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x1F, 0xE0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xC7,
  0xC0, 0x0F, 0x8F, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0x81, 0xF0, 0x1F, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0x07, 0x80,
  0xFC, 0x02, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0xC0, 0x1F, 0x81, 0xF0, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0x83,
  0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0,
  0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07,
  0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8,
  0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x00,
  0xFC, 0x3F, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7D, 0xE0, 0x03, 0xEF, 0x00, 0x3E, 0x78, 0x01, 0xF3, 0xC0,
  0x1F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x7C, 0x3C, 0x03, 0xE1,
  0xE0, 0x3E, 0x0F, 0x01, 0xF0, 0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07,
  0xC0, 0xF0, 0x7C, 0x07, 0x83, 0xE0, 0x3C, 0x3E, 0x01, 0xE1, 0xF0, 0x0F,
  0x0F, 0x00, 0x78, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x7C, 0x00, 0xF3, 0xE0,
  0x07, 0x9E, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xEF, 0x00, 0x3E, 0x00, 0xFB, 0xE0, 0x07, 0xC0, 0x1F, 0x7C, 0x01,
  0xF8, 0x03, 0xCF, 0x80, 0x3F, 0x00, 0xF9, 0xF0, 0x0F, 0xE0, 0x1F, 0x3E,
  0x01, 0xFC, 0x07, 0xC7, 0xC0, 0x3F, 0x80, 0xF8, 0xF8, 0x0F, 0xF0, 0x1F,
  0x1F, 0x01, 0xFE, 0x07, 0xC3, 0xE0, 0x7B, 0xC0, 0xF8, 0x7C, 0x0F, 0x70,
  0x3E, 0x0F, 0x81, 0xFE, 0x07, 0xC1, 0xF0, 0x7B, 0xC0, 0xF8, 0x3E, 0x0F,
  0x78, 0x3E, 0x07, 0xC3, 0xEF, 0x07, 0xC0, 0xF8, 0x79, 0xE1, 0xF0, 0x1F,
  0x0F, 0x3C, 0x3E, 0x03, 0xE3, 0xC7, 0x87, 0xC0, 0x7C, 0x78, 0xF1, 0xF0,
  0x0F, 0x9F, 0x1E, 0x3E, 0x01, 0xF3, 0xC3, 0xC7, 0x80, 0x3E, 0x78, 0x79,
  0xF0, 0x07, 0xDE, 0x0F, 0x3E, 0x00, 0xF3, 0xC1, 0xEF, 0x80, 0x1E, 0x78,
  0x3D, 0xF0, 0x03, 0xDE, 0x07, 0xBC, 0x00, 0x7B, 0xC0, 0xFF, 0x80, 0x0F,
  0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xF0,
  0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00,
  0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xF8, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF7, 0xC0,
  0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0x7C,
  0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xC3, 0xE0, 0x3C, 0x3C, 0x03,
  0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xEF, 0x80, 0x3E, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x00, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xF3, 0xC0,
  0x0F, 0x1E, 0x00, 0xF8, 0xF8, 0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xC0,
  0xF0, 0x3C, 0x07, 0xC3, 0xE0, 0x1E, 0x1E, 0x00, 0xF1, 0xF0, 0x07, 0x8F,
  0x00, 0x3E, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0x80, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF9, 0xF3, 0xF3, 0xE3, 0xC7, 0xC7, 0x8F,
  0x00, 0x10, 0x00, 0x03, 0xF1, 0xF0, 0x1F, 0xE7, 0x80, 0xFF, 0xDE, 0x07,
  0xFF, 0xF8, 0x3F, 0x0F, 0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0x7C, 0x1F, 0x01,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x78, 0x7C, 0x03, 0xE1,
  0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xC3, 0xE0,
  0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3E,
  0x0F, 0x81, 0xF8, 0x3E, 0x07, 0xE0, 0xFC, 0x3F, 0x81, 0xFF, 0xFC, 0x07,
  0xFE, 0xF0, 0x0F, 0xF3, 0xC0, 0x1F, 0x8F, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC2, 0x00, 0x3C, 0xFE, 0x03, 0xEF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xF0, 0xF8, 0x3F, 0x07, 0xC3, 0xF0,
  0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3C, 0x03, 0xE3,
  0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x7E,
  0x03, 0xE3, 0xF0, 0x3E, 0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0x83, 0xCF, 0xF8, 0x1E, 0x3F, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xF0,
  0x40, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x18, 0x1F, 0xFE, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x10, 0x7C, 0x00, 0xFE, 0x78, 0x01, 0xFE,
  0x78, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x01,
  0xF0, 0x3E, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03,
  0xE0, 0x7C, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07,
  0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xEF,
  0x00, 0x3F, 0xCF, 0x00, 0x1F, 0x8F, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x0F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7E, 0x7C, 0x1F, 0x87,
  0xC3, 0xE0, 0xF8, 0xF8, 0x1F, 0x1E, 0x03, 0xE7, 0xC0, 0x78, 0xF8, 0x1F,
  0x1E, 0x07, 0xC7, 0xC3, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80,
  0xFE, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x06, 0x0F, 0xE7, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0x20, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0x9F, 0x00,
  0x7F, 0x9E, 0x00, 0xFF, 0xDE, 0x01, 0xFF, 0xFE, 0x03, 0xF0, 0xFE, 0x03,
  0xE0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x0F,
  0x80, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F,
  0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x3E, 0x01, 0xF0, 0x3E,
  0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFB, 0xC0, 0x0F, 0xF7, 0xC0, 0x0F, 0xE7, 0xC0, 0x01, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x80, 0x3F, 0x00, 0xC0, 0x7E, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC3, 0x00, 0x3C, 0xFE, 0x03, 0xEF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x07, 0xF1, 0xF8, 0x3F, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x01,
  0xF0, 0xF8, 0x0F, 0x07, 0xC0, 0xF8, 0x3C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F,
  0x01, 0xF0, 0xF8, 0x0F, 0x07, 0xC0, 0xF8, 0x3C, 0x07, 0xC3, 0xE0, 0x3E,
  0x1F, 0x01, 0xE0, 0xF8, 0x1F, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0,
  0x3E, 0x1F, 0x01, 0xE0, 0xF8, 0x1F, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0xC3,
  0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0x00, 0x60, 0x07, 0x80, 0x7E, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x1F, 0x01, 0xF0,
  0xFC, 0x07, 0xC3, 0xE0, 0x1E, 0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xE7, 0xE0,
  0x0F, 0x9F, 0x00, 0x3C, 0xF8, 0x00, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xEF, 0x00, 0x3F, 0x3E,
  0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x0F, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0x78, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x78, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x01, 0x00, 0x20, 0x07, 0x9F, 0xC3, 0xF8, 0x1E, 0x7F, 0xCF, 0xF8,
  0x3D, 0xFF, 0xBF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFC, 0x3F, 0x87, 0xC1,
  0xF0, 0x7F, 0x0F, 0x87, 0xE0, 0x7C, 0x0F, 0x0F, 0x81, 0xF0, 0x3E, 0x1F,
  0x03, 0xE0, 0x7C, 0x3E, 0x07, 0xC0, 0xF8, 0x78, 0x0F, 0x81, 0xF1, 0xF0,
  0x1E, 0x03, 0xC3, 0xE0, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x1F, 0x0F, 0x01,
  0xF0, 0x3E, 0x3E, 0x03, 0xE0, 0x7C, 0x7C, 0x07, 0x80, 0xF0, 0xF8, 0x1F,
  0x03, 0xE1, 0xF0, 0x3E, 0x07, 0xC3, 0xC0, 0x7C, 0x0F, 0x8F, 0x80, 0xF0,
  0x1E, 0x1F, 0x01, 0xE0, 0x3C, 0x3E, 0x07, 0xC0, 0xF8, 0x7C, 0x0F, 0x81,
  0xF0, 0xF0, 0x1F, 0x03, 0xE3, 0xE0, 0x3C, 0x07, 0x87, 0xC0, 0xF8, 0x0F,
  0x0F, 0x81, 0xF0, 0x3E, 0x00, 0x00, 0x01, 0x00, 0x1E, 0x7F, 0x01, 0xE7,
  0xFC, 0x0F, 0x7F, 0xE0, 0x7F, 0xFF, 0x83, 0xF8, 0xFC, 0x1F, 0x83, 0xE1,
  0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0x7C, 0x07, 0x83, 0xE0, 0x7C, 0x1E, 0x03,
  0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0x83, 0xE0, 0x7C, 0x3E,
  0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF0, 0x7C, 0x07, 0x83, 0xC0, 0x7C,
  0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF0, 0x7C, 0x0F, 0x83, 0xC0,
  0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x08,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFC,
  0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x1E, 0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E,
  0x01, 0xF3, 0xC0, 0x1E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7,
  0xC0, 0x3E, 0x78, 0x03, 0xEF, 0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x80, 0x7C,
  0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0x7C, 0x3F,
  0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x78, 0xFC, 0x00, 0x7B, 0xFE, 0x00, 0xF7,
  0xFE, 0x00, 0xF7, 0xFF, 0x00, 0xFE, 0x1F, 0x00, 0xFC, 0x1F, 0x01, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0,
  0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xC0,
  0x1E, 0x03, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0xC1,
  0xF8, 0x0F, 0xE3, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0x7F, 0xE0, 0x1F, 0x7F,
  0xC0, 0x1F, 0x3F, 0x80, 0x1F, 0x04, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xF9, 0xF0, 0x1F, 0xF7,
  0x80, 0xFF, 0xDE, 0x07, 0xFF, 0xF8, 0x3F, 0x0F, 0xE0, 0xF8, 0x1F, 0x07,
  0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80,
  0x78, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8,
  0x78, 0x03, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8,
  0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x81, 0xF8, 0x3E, 0x07, 0xE0, 0xFC, 0x3F,
  0x81, 0xFF, 0xFC, 0x07, 0xFE, 0xF0, 0x0F, 0xF7, 0xC0, 0x3F, 0x9F, 0x00,
  0x10, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0x40,
  0xF3, 0xE0, 0x79, 0xF8, 0x1E, 0xFE, 0x07, 0xBF, 0x01, 0xFF, 0xC0, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xC0, 0x7F, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0x87, 0xE0, 0x41, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC2, 0x01, 0xF0, 0xC0, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0xFF, 0xCF,
  0xFE, 0x3F, 0xF8, 0xFF, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0xC0,
  0x00, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x1F, 0x01, 0xE0,
  0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x1F, 0x03,
  0xE0, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x1F,
  0x03, 0xE0, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C,
  0x1F, 0x03, 0xE0, 0xF0, 0x1F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0x83, 0xE0,
  0xFC, 0x1F, 0x8F, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0x78, 0x1F, 0xF7, 0x80,
  0x7F, 0x3C, 0x00, 0x40, 0x00, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xEF, 0x80,
  0xFB, 0xE0, 0x3E, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0xF8,
  0xF8, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x3C, 0x0F, 0x9F, 0x03, 0xE7, 0x80, 0xFB, 0xE0, 0x3E, 0xF0, 0x0F, 0xBC,
  0x03, 0xFF, 0x00, 0xF7, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80,
  0xFF, 0xC0, 0xFC, 0x07, 0xBE, 0x07, 0xE0, 0x7D, 0xF0, 0x3F, 0x03, 0xCF,
  0x83, 0xF8, 0x3E, 0x7C, 0x1F, 0xC1, 0xF3, 0xE1, 0xFE, 0x0F, 0x1F, 0x0F,
  0xF0, 0xF8, 0xF8, 0x77, 0x87, 0x87, 0xC7, 0xBC, 0x3C, 0x3E, 0x3D, 0xE3,
  0xE1, 0xF3, 0xCF, 0x1E, 0x0F, 0x1E, 0x79, 0xF0, 0x78, 0xF3, 0xCF, 0x03,
  0xCF, 0x1E, 0x78, 0x1E, 0x78, 0xF7, 0xC0, 0xF7, 0x87, 0xBC, 0x07, 0xBC,
  0x3B, 0xE0, 0x3D, 0xE1, 0xDE, 0x01, 0xFE, 0x0E, 0xF0, 0x0F, 0xF0, 0xFF,
  0x80, 0x7F, 0x87, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00,
  0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF0,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0,
  0x0F, 0x07, 0xC0, 0x1E, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0xF8, 0x00,
  0xFB, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0,
  0x00, 0xF9, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x07, 0x80,
  0x3E, 0x0F, 0x00, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xE0,
  0x3E, 0x00, 0xF8, 0x0F, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0x81, 0xE0, 0x01,
  0xE0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0x87, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x9F,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07,
  0xBC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7F,
  0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7F,
  0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x17, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFC, 0x07, 0xFE, 0x80, 0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 14, 37, 12, 0, -37 },
  { 66, 16, 13, 18, 5, -37 },
  { 92, 24, 37, 23, 0, -37 },
  { 203, 22, 43, 21, 0, -40 },
  { 322, 28, 39, 33, 3, -38 },
  { 459, 23, 39, 24, 0, -38 },
  { 572, 8, 13, 11, 5, -37 },
  { 585, 16, 45, 14, 1, -37 },
  { 675, 16, 46, 14, -4, -38 },
  { 767, 17, 19, 20, 5, -40 },
  { 808, 20, 25, 23, 2, -31 },
  { 871, 10, 13, 11, -3, -6 },
  { 888, 12, 4, 14, 1, -16 },
  { 894, 7, 7, 11, 0, -7 },
  { 901, 25, 37, 18, -3, -37 },
  { 1017, 20, 39, 21, 1, -38 },
  { 1115, 14, 37, 21, 5, -37 },
  { 1180, 23, 38, 21, -2, -38 },
  { 1290, 22, 39, 21, -1, -38 },
  { 1398, 22, 37, 21, -1, -37 },
  { 1500, 22, 38, 21, 0, -37 },
  { 1605, 21, 39, 21, 1, -38 },
  { 1708, 21, 37, 21, 2, -37 },
  { 1806, 22, 39, 21, 0, -38 },
  { 1914, 21, 39, 21, 0, -38 },
  { 2017, 11, 28, 11, 0, -28 },
  { 2056, 14, 35, 11, -3, -28 },
  { 2118, 20, 23, 23, 2, -30 },
  { 2176, 20, 15, 23, 2, -26 },
  { 2214, 20, 23, 23, 2, -30 },
  { 2272, 17, 38, 16, 1, -38 },
  { 2353, 30, 41, 31, 1, -37 },
  { 2507, 22, 37, 22, -3, -37 },
  { 2609, 23, 37, 23, 0, -37 },
  { 2716, 23, 39, 21, 2, -38 },
  { 2829, 24, 37, 25, 0, -37 },
  { 2940, 22, 37, 20, 0, -37 },
  { 3042, 22, 37, 19, 0, -37 },
  { 3144, 25, 39, 26, 2, -38 },
  { 3266, 27, 37, 26, 0, -37 },
  { 3391, 21, 37, 14, -3, -37 },
  { 3489, 21, 47, 11, -8, -37 },
  { 3613, 26, 37, 22, 0, -37 },
  { 3734, 15, 37, 18, 0, -37 },
  { 3804, 36, 37, 34, 0, -37 },
  { 3971, 29, 37, 27, 0, -37 },
  { 4106, 24, 39, 27, 2, -38 },
  { 4223, 23, 37, 22, 0, -37 },
  { 4330, 24, 47, 27, 2, -38 },
  { 4471, 23, 37, 22, 0, -37 },
  { 4578, 23, 39, 20, -1, -38 },
  { 4691, 20, 37, 19, 3, -37 },
  { 4784, 25, 38, 25, 2, -37 },
  { 4903, 21, 37, 22, 5, -37 },
  { 5001, 35, 37, 35, 4, -37 },
  { 5163, 27, 37, 20, -3, -37 },
  { 5288, 20, 37, 20, 4, -37 },
  { 5381, 24, 37, 18, -2, -37 },
  { 5492, 20, 45, 15, -2, -37 },
  { 5605, 9, 37, 18, 5, -37 },
  { 5647, 20, 45, 15, -4, -37 },
  { 5760, 21, 21, 21, 0, -37 },
  { 5816, 17, 4, 16, -5, 4 },
  { 5825, 7, 8, 14, 8, -40 },
  { 5832, 22, 30, 23, 1, -29 },
  { 5915, 21, 41, 22, 0, -40 },
  { 6023, 18, 30, 17, 1, -29 },
  { 6091, 24, 41, 23, 1, -40 },
  { 6214, 19, 30, 20, 1, -29 },
  { 6286, 25, 52, 13, -6, -40 },
  { 6449, 24, 41, 23, -1, -29 },
  { 6572, 21, 40, 22, 0, -40 },
  { 6677, 13, 39, 11, 0, -39 },
  { 6741, 20, 51, 11, -7, -39 },
  { 6869, 22, 40, 20, 0, -40 },
  { 6979, 13, 40, 10, 0, -40 },
  { 7044, 31, 29, 33, 0, -29 },
  { 7157, 21, 29, 22, 0, -29 },
  { 7234, 20, 30, 22, 1, -29 },
  { 7309, 24, 41, 22, -3, -29 },
  { 7432, 22, 41, 23, 1, -29 },
  { 7545, 18, 29, 15, 0, -29 },
  { 7611, 18, 30, 17, 0, -29 },
  { 7679, 14, 35, 13, 1, -34 },
  { 7741, 21, 29, 22, 1, -28 },
  { 7818, 18, 28, 18, 3, -28 },
  { 7881, 29, 28, 29, 3, -28 },
  { 7983, 23, 28, 19, -2, -28 },
  { 8064, 26, 41, 19, -5, -28 },
  { 8198, 19, 28, 16, -2, -28 },
  { 8265, 20, 45, 17, 1, -37 },
  { 8378, 4, 52, 19, 7, -40 },
  { 8404, 19, 45, 17, -3, -37 },
  { 8511, 20, 7, 23, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC52PT7B_H_
