#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC20PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x63, 0x18, 0xC4, 0x63, 0x00, 0x8E, 0x60, 0x6F, 0x2C,
  0xB6, 0x98, 0x0D, 0x84, 0xC2, 0x43, 0x27, 0xF8, 0x90, 0xC8, 0x6C, 0xFF,
  0x7F, 0x9B, 0x09, 0x04, 0x86, 0xC0, 0x04, 0x06, 0x1F, 0x35, 0x24, 0x38,
  0x38, 0x1C, 0x0E, 0x16, 0x16, 0x96, 0xFC, 0xF8, 0x20, 0x20, 0x38, 0xC9,
  0x11, 0x26, 0x64, 0x8D, 0xA1, 0x3D, 0xA5, 0x7F, 0xE9, 0x0B, 0x23, 0x6C,
  0x49, 0x99, 0x22, 0x2C, 0xC7, 0x00, 0x1E, 0x0D, 0x84, 0xC6, 0x41, 0x60,
  0xE0, 0x60, 0xD3, 0x6D, 0x67, 0xB1, 0x98, 0xCD, 0xE3, 0x98, 0x6B, 0x6C,
  0x0E, 0x10, 0x61, 0x83, 0x04, 0x18, 0x30, 0x40, 0x83, 0x06, 0x0C, 0x18,
  0x10, 0x20, 0x60, 0x18, 0x20, 0xC3, 0x0C, 0x30, 0xC3, 0x08, 0x61, 0x84,
  0x30, 0xC6, 0x10, 0xC0, 0x12, 0x4F, 0xCF, 0x73, 0x64, 0x80, 0x10, 0x20,
  0x40, 0x8F, 0xFF, 0xC4, 0x08, 0x10, 0x20, 0x36, 0x64, 0xC0, 0xFF, 0xC0,
  0x5F, 0x00, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18,
  0x18, 0x0C, 0x0C, 0x06, 0x06, 0x00, 0x0F, 0x1B, 0x33, 0x33, 0x63, 0x63,
  0x63, 0x63, 0x46, 0xC6, 0xC6, 0xCC, 0x7C, 0x78, 0x19, 0xDF, 0xB1, 0x18,
  0xC6, 0x31, 0x18, 0xC6, 0x30, 0x0F, 0x8C, 0xC0, 0x60, 0x30, 0x18, 0x18,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x07, 0xE7, 0xF0, 0x3F, 0x33, 0x03,
  0x03, 0x03, 0x06, 0x38, 0x0C, 0x06, 0x06, 0x06, 0x0C, 0xDC, 0xF8, 0x03,
  0x07, 0x0F, 0x0A, 0x1E, 0x16, 0x26, 0x66, 0x44, 0xFE, 0xFE, 0x0C, 0x08,
  0x18, 0x1F, 0x10, 0x30, 0x30, 0x30, 0x3C, 0x7E, 0x06, 0x06, 0x06, 0x06,
  0x0C, 0xDC, 0xF8, 0x0F, 0x8E, 0x04, 0x06, 0x02, 0x03, 0x71, 0xF8, 0xCC,
  0x62, 0x23, 0x31, 0x88, 0xC7, 0xC3, 0xC0, 0x7F, 0x03, 0x06, 0x06, 0x0C,
  0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0xC0, 0x1F, 0x33, 0x33,
  0x33, 0x33, 0x36, 0x1C, 0x3C, 0x66, 0xC6, 0xC6, 0xC6, 0xEC, 0x78, 0x1E,
  0x33, 0x33, 0x63, 0x63, 0x63, 0x67, 0x7E, 0x36, 0x06, 0x04, 0x0C, 0xB8,
  0xF0, 0x33, 0x30, 0x00, 0x00, 0x4C, 0xC0, 0x18, 0xC6, 0x00, 0x00, 0x00,
  0x01, 0x98, 0xCC, 0x60, 0x02, 0x0C, 0x7B, 0xCE, 0x1C, 0x0E, 0x07, 0x02,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x81, 0x81, 0xC0, 0xE0, 0x61, 0xCE,
  0x70, 0xC0, 0x3E, 0x4C, 0x18, 0x30, 0xC3, 0x06, 0x18, 0x20, 0xC0, 0x00,
  0x0E, 0x18, 0x00, 0x07, 0xE0, 0xC2, 0x18, 0x33, 0x11, 0x27, 0x96, 0x59,
  0x49, 0xB4, 0x92, 0x49, 0x25, 0xB6, 0xCF, 0xC4, 0xD8, 0x40, 0x06, 0x00,
  0x3F, 0x01, 0xC0, 0x07, 0x05, 0x07, 0x0F, 0x0B, 0x1B, 0x1B, 0x33, 0x3F,
  0x3F, 0x63, 0x63, 0xC3, 0xC3, 0x1F, 0x0D, 0xCC, 0x66, 0x33, 0x19, 0x98,
  0xF0, 0xCC, 0x63, 0x31, 0x98, 0xC8, 0xCF, 0xE7, 0xE0, 0x04, 0x1F, 0x39,
  0x30, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xF8, 0x78,
  0x1F, 0x0D, 0xCC, 0x66, 0x33, 0x19, 0x8C, 0x86, 0xC3, 0x61, 0xB1, 0x98,
  0xC8, 0xCF, 0xC7, 0xC0, 0x1F, 0x18, 0x30, 0x30, 0x30, 0x30, 0x3E, 0x60,
  0x60, 0x60, 0x60, 0x40, 0xFC, 0xFC, 0x1F, 0x18, 0x30, 0x30, 0x30, 0x30,
  0x3E, 0x7E, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0x02, 0x07, 0xF3, 0x88,
  0xC0, 0x60, 0x18, 0x0C, 0x03, 0x1C, 0xCF, 0x30, 0xCC, 0x33, 0x0C, 0xC6,
  0x3F, 0x87, 0xE0, 0x18, 0xC6, 0x33, 0x0C, 0xC3, 0x30, 0x8C, 0x63, 0xF9,
  0x86, 0x61, 0x98, 0xC6, 0x31, 0x0C, 0xC3, 0x31, 0xC0, 0x1F, 0x0C, 0x0C,
  0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0xF8, 0x03,
  0x03, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18,
  0x18, 0x18, 0x38, 0xF0, 0xE0, 0x18, 0xC6, 0x63, 0x30, 0xDC, 0x36, 0x0F,
  0x03, 0xC1, 0xF0, 0x6C, 0x1B, 0x06, 0x41, 0x18, 0xC6, 0x31, 0x80, 0x18,
  0x63, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x86, 0x10, 0xFF, 0xE0, 0x1C, 0x1C,
  0x70, 0xE3, 0xC3, 0x8F, 0x1E, 0x3C, 0x78, 0xF3, 0x42, 0xCF, 0x1B, 0x2C,
  0x6D, 0xB1, 0xB4, 0xC6, 0xF2, 0x13, 0x98, 0xCE, 0x63, 0x31, 0x80, 0x18,
  0x63, 0x0C, 0xF1, 0x1E, 0x63, 0xCC, 0x79, 0x89, 0x33, 0x24, 0x67, 0x8C,
  0xF1, 0x9E, 0x23, 0xCC, 0x31, 0x86, 0x00, 0x1F, 0x1D, 0xDC, 0x6C, 0x36,
  0x1E, 0x0F, 0x07, 0x82, 0xC3, 0x61, 0xB1, 0xD8, 0xCF, 0xC3, 0xC0, 0x1F,
  0x0D, 0xCC, 0x66, 0x33, 0x19, 0x98, 0x9C, 0xFC, 0x78, 0x30, 0x18, 0x08,
  0x0C, 0x06, 0x00, 0x1F, 0x1D, 0xDC, 0x6C, 0x36, 0x1E, 0x0F, 0x07, 0x83,
  0xC3, 0x61, 0xB1, 0xD8, 0xCF, 0xC3, 0xC0, 0x60, 0x30, 0x0C, 0x00, 0x1F,
  0x09, 0xCC, 0x66, 0x33, 0x19, 0x98, 0x9C, 0xF8, 0x6C, 0x36, 0x19, 0x08,
  0xCC, 0x66, 0x30, 0x1F, 0x9C, 0x8C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x38,
  0x0E, 0x03, 0x01, 0x81, 0x8F, 0xC7, 0xC0, 0x7F, 0x18, 0x18, 0x10, 0x30,
  0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0xC0, 0x31, 0x90, 0xD8,
  0x6C, 0x26, 0x33, 0x1B, 0x0D, 0x86, 0xC6, 0x63, 0x31, 0x98, 0xCF, 0xC3,
  0xC0, 0xC3, 0xC6, 0xC6, 0xC4, 0xCC, 0xCC, 0xD8, 0xD8, 0xF0, 0xF0, 0xE0,
  0xE0, 0xE0, 0xC0, 0x63, 0x0D, 0x8C, 0x64, 0x71, 0x91, 0xC4, 0x45, 0x31,
  0x3C, 0xC4, 0xB6, 0x16, 0xD8, 0x5B, 0x63, 0x4F, 0x0F, 0x3C, 0x3C, 0xE0,
  0xE3, 0x83, 0x8E, 0x00, 0x18, 0xC6, 0x60, 0x98, 0x2C, 0x0F, 0x03, 0x80,
  0xC0, 0x30, 0x1E, 0x0D, 0x83, 0x61, 0x98, 0x66, 0x31, 0x80, 0xC7, 0x9B,
  0x36, 0xCD, 0x9E, 0x3C, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x18, 0x00, 0x1F,
  0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C,
  0x07, 0xE7, 0xE0, 0x0F, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30,
  0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x48, 0xF0, 0xCC, 0xCC, 0x44, 0x66,
  0x66, 0x66, 0x23, 0x1E, 0x0C, 0x18, 0x20, 0x41, 0x83, 0x06, 0x08, 0x30,
  0x60, 0xC1, 0x82, 0x0C, 0x18, 0xF0, 0x0C, 0x0E, 0x1E, 0x16, 0x32, 0x63,
  0x63, 0xC3, 0xFE, 0xCD, 0x80, 0x1D, 0x9F, 0x8C, 0xCC, 0x66, 0x33, 0x19,
  0x09, 0x8C, 0xC6, 0x37, 0x1D, 0x80, 0x18, 0x18, 0x10, 0x30, 0x36, 0x3F,
  0x33, 0x23, 0x63, 0x63, 0x63, 0x66, 0xE6, 0xEC, 0xFC, 0x1E, 0x7C, 0xC3,
  0x06, 0x0C, 0x10, 0x60, 0x40, 0xD1, 0xE0, 0x00, 0xC0, 0x60, 0x18, 0x06,
  0x1D, 0x8F, 0xC3, 0x31, 0x8C, 0x63, 0x18, 0xC4, 0x23, 0x18, 0xC6, 0x1B,
  0x87, 0x40, 0x0E, 0x3E, 0x33, 0x62, 0x66, 0x7C, 0x40, 0xC0, 0xC0, 0x64,
  0x7C, 0x03, 0x83, 0x41, 0x80, 0x80, 0xF0, 0xF0, 0x30, 0x18, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x38, 0x18, 0x00,
  0x1D, 0x9F, 0x8C, 0xCC, 0x66, 0x33, 0x19, 0x09, 0x8C, 0xC6, 0x37, 0x1D,
  0x81, 0x80, 0xC4, 0x63, 0xE1, 0xE0, 0x18, 0x18, 0x10, 0x30, 0x36, 0x3F,
  0x33, 0x23, 0x63, 0x62, 0x66, 0x66, 0xC6, 0xC6, 0xCC, 0x18, 0xC4, 0x03,
  0x18, 0xC4, 0x63, 0x18, 0xCC, 0x63, 0x00, 0x03, 0x03, 0x02, 0x00, 0x06,
  0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x10,
  0x30, 0xF0, 0xE0, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x39, 0x98, 0xD8, 0x58,
  0x78, 0x3C, 0x1B, 0x09, 0x8C, 0xC6, 0x63, 0x30, 0x18, 0xC4, 0x63, 0x18,
  0xC4, 0x63, 0x18, 0xCC, 0x63, 0x00, 0x36, 0x73, 0xFF, 0x33, 0x32, 0x33,
  0x62, 0x36, 0x63, 0x66, 0x26, 0x66, 0xC6, 0x6C, 0x46, 0xCC, 0x40, 0x36,
  0x3F, 0x33, 0x23, 0x63, 0x62, 0x66, 0x66, 0xC6, 0xC6, 0xCC, 0x1E, 0x3F,
  0x33, 0x63, 0x63, 0x63, 0x43, 0xC6, 0x46, 0x6C, 0x78, 0x1B, 0x0F, 0xC6,
  0x62, 0x33, 0x19, 0x8C, 0xC6, 0x62, 0x33, 0x3B, 0x1F, 0x8C, 0x04, 0x06,
  0x03, 0x01, 0x80, 0x1D, 0x9F, 0x8C, 0xCC, 0x66, 0x33, 0x19, 0x09, 0x8C,
  0xC6, 0x37, 0x1D, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x36, 0x78, 0xC1,
  0x86, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x00, 0x3E, 0x79, 0x83, 0x07, 0x07,
  0x06, 0x0C, 0x19, 0x73, 0xC0, 0x31, 0x1F, 0xE6, 0x23, 0x18, 0xC6, 0x21,
  0xCE, 0x00, 0x31, 0x33, 0x33, 0x23, 0x63, 0x62, 0x66, 0x46, 0xC6, 0x6E,
  0x74, 0xC7, 0x8F, 0x36, 0x6D, 0x9B, 0x34, 0x78, 0xE1, 0xC3, 0x80, 0xC6,
  0x79, 0xCF, 0x39, 0x6F, 0x6D, 0xED, 0xAF, 0x3D, 0xE7, 0x28, 0xE7, 0x1C,
  0xE3, 0x18, 0x00, 0x31, 0x8D, 0x86, 0xC3, 0xC1, 0xC0, 0xE0, 0x70, 0x78,
  0x24, 0x33, 0x31, 0x80, 0x18, 0xC6, 0x31, 0x98, 0x66, 0x19, 0x06, 0xC1,
  0xA0, 0x78, 0x0E, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x0F, 0x03, 0x80,
  0x1F, 0x3E, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x30, 0x60, 0x7C, 0xFC, 0x07,
  0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x30, 0xC0, 0x30, 0x30, 0x30, 0x20,
  0x60, 0x60, 0x70, 0x30, 0xFF, 0xFF, 0xF0, 0x1C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x06, 0x38, 0x60, 0x83, 0x06, 0x0C, 0x30, 0xE0, 0xFB, 0x3C,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 6, 5, 7, 2, -14 },
  { 14, 9, 14, 9, 0, -14 },
  { 30, 8, 16, 8, 0, -15 },
  { 46, 11, 14, 13, 1, -14 },
  { 66, 9, 14, 9, 0, -14 },
  { 82, 3, 5, 4, 2, -14 },
  { 84, 7, 17, 5, 0, -14 },
  { 99, 6, 17, 5, -1, -14 },
  { 112, 6, 7, 8, 2, -15 },
  { 118, 7, 10, 9, 1, -12 },
  { 127, 4, 5, 4, -1, -2 },
  { 130, 5, 2, 5, 0, -6 },
  { 132, 3, 3, 4, 0, -3 },
  { 134, 9, 14, 7, -1, -14 },
  { 150, 8, 14, 8, 0, -14 },
  { 164, 5, 14, 8, 2, -14 },
  { 173, 9, 14, 8, -1, -14 },
  { 189, 8, 14, 8, 0, -14 },
  { 203, 8, 14, 8, 0, -14 },
  { 217, 8, 14, 8, 0, -14 },
  { 231, 9, 14, 8, 0, -14 },
  { 247, 8, 14, 8, 1, -14 },
  { 261, 8, 14, 8, 0, -14 },
  { 275, 8, 14, 8, 0, -14 },
  { 289, 4, 11, 4, 0, -11 },
  { 295, 5, 14, 4, -1, -11 },
  { 304, 7, 9, 9, 1, -12 },
  { 312, 7, 6, 9, 1, -10 },
  { 318, 7, 9, 9, 1, -12 },
  { 326, 7, 14, 6, 0, -14 },
  { 339, 12, 16, 12, 0, -14 },
  { 363, 8, 14, 8, -1, -14 },
  { 377, 9, 14, 9, 0, -14 },
  { 393, 8, 15, 8, 1, -15 },
  { 408, 9, 14, 10, 0, -14 },
  { 424, 8, 14, 8, 0, -14 },
  { 438, 8, 14, 7, 0, -14 },
  { 452, 10, 15, 10, 1, -15 },
  { 471, 10, 14, 10, 0, -14 },
  { 489, 8, 14, 6, -1, -14 },
  { 503, 8, 18, 4, -3, -14 },
  { 521, 10, 14, 8, 0, -14 },
  { 539, 6, 14, 7, 0, -14 },
  { 550, 14, 14, 13, 0, -14 },
  { 575, 11, 14, 11, 0, -14 },
  { 595, 9, 14, 10, 1, -14 },
  { 611, 9, 14, 8, 0, -14 },
  { 627, 9, 17, 10, 1, -14 },
  { 647, 9, 14, 9, 0, -14 },
  { 663, 9, 14, 8, 0, -14 },
  { 679, 8, 14, 7, 1, -14 },
  { 693, 9, 14, 10, 1, -14 },
  { 709, 8, 14, 8, 2, -14 },
  { 723, 14, 14, 13, 1, -14 },
  { 748, 10, 14, 8, -1, -14 },
  { 766, 7, 14, 8, 2, -14 },
  { 779, 9, 14, 7, -1, -14 },
  { 795, 8, 17, 6, -1, -14 },
  { 812, 4, 14, 7, 2, -14 },
  { 819, 7, 17, 6, -1, -14 },
  { 834, 8, 8, 8, 0, -14 },
  { 842, 7, 1, 6, -2, 2 },
  { 843, 3, 3, 5, 3, -15 },
  { 845, 9, 11, 9, 0, -11 },
  { 858, 8, 15, 9, 0, -15 },
  { 873, 7, 11, 7, 0, -11 },
  { 883, 10, 15, 9, 0, -15 },
  { 902, 8, 11, 8, 0, -11 },
  { 913, 9, 20, 5, -2, -15 },
  { 936, 9, 16, 9, 0, -11 },
  { 954, 8, 15, 9, 0, -15 },
  { 969, 5, 15, 4, 0, -15 },
  { 979, 8, 20, 4, -3, -15 },
  { 999, 9, 15, 8, 0, -15 },
  { 1016, 5, 15, 4, 0, -15 },
  { 1026, 12, 11, 13, 0, -11 },
  { 1043, 8, 11, 9, 0, -11 },
  { 1054, 8, 11, 8, 0, -11 },
  { 1065, 9, 16, 9, -1, -11 },
  { 1083, 9, 16, 9, 0, -11 },
  { 1101, 7, 11, 6, 0, -11 },
  { 1111, 7, 11, 7, 0, -11 },
  { 1121, 5, 13, 5, 1, -13 },
  { 1130, 8, 11, 9, 0, -11 },
  { 1141, 7, 11, 7, 1, -11 },
  { 1151, 11, 11, 11, 1, -11 },
  { 1167, 9, 11, 7, -1, -11 },
  { 1180, 10, 16, 7, -2, -11 },
  { 1200, 8, 11, 6, -1, -11 },
  { 1211, 8, 17, 7, 0, -14 },
  { 1228, 1, 20, 7, 3, -15 },
  { 1231, 7, 17, 7, -1, -14 },
  { 1246, 7, 2, 9, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC20PT7B_H_
