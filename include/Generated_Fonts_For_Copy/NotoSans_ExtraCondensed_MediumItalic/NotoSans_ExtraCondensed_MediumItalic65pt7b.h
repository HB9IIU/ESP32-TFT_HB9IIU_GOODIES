#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC65PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0,
  0x03, 0xE0, 0x00, 0x40, 0x00, 0x1F, 0x87, 0xF1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0,
  0xFC, 0x3E, 0x0F, 0x87, 0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1F, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x1F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0x81, 0xE0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC1,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFB, 0x9F, 0x00, 0xFC, 0x60, 0xC0, 0x3F, 0x1C, 0x08, 0x07, 0xE3,
  0x80, 0x00, 0xF8, 0x70, 0x00, 0x1F, 0x0C, 0x00, 0x03, 0xE1, 0x80, 0x00,
  0x7C, 0x70, 0x00, 0x0F, 0xCE, 0x00, 0x01, 0xF9, 0xC0, 0x00, 0x3F, 0xB0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0x3F, 0x00, 0x00,
  0xE7, 0xF0, 0x00, 0x1C, 0x7E, 0x00, 0x03, 0x8F, 0xC0, 0x00, 0x61, 0xF8,
  0x00, 0x0C, 0x3F, 0x00, 0x03, 0x87, 0xE1, 0x00, 0x70, 0xF8, 0x10, 0x0E,
  0x3F, 0x03, 0x81, 0x8F, 0xE0, 0xFF, 0x3F, 0xF8, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x80, 0x1F, 0xE0, 0x00, 0xF0, 0x03, 0xFF,
  0x00, 0x1F, 0x00, 0x7F, 0xF0, 0x03, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x00,
  0xF8, 0xF8, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0xF8, 0x0F,
  0x80, 0x1E, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x3E, 0x0F,
  0x81, 0xF0, 0x03, 0xC0, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x83, 0xE0, 0x07,
  0xC0, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x07, 0x80, 0x07, 0x81, 0xF0, 0xF8,
  0x00, 0x78, 0x1F, 0x0F, 0x00, 0x0F, 0x81, 0xF1, 0xF0, 0x00, 0xF8, 0x1E,
  0x1E, 0x00, 0x0F, 0x83, 0xE3, 0xE1, 0xFC, 0xF8, 0x3E, 0x3C, 0x3F, 0xEF,
  0x83, 0xC7, 0xC7, 0xFE, 0xF8, 0x7C, 0xF8, 0xFF, 0xFF, 0x8F, 0x8F, 0x8F,
  0x9F, 0x7D, 0xF9, 0xF1, 0xF0, 0xF7, 0xFF, 0x1F, 0x1E, 0x0F, 0x7F, 0xE3,
  0xE3, 0xE0, 0xF3, 0xFC, 0x3E, 0x3C, 0x0F, 0x1F, 0x07, 0xC7, 0xC0, 0xF0,
  0x00, 0x7C, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0x81, 0xF0, 0x00, 0xF8, 0x78,
  0x1F, 0x00, 0x1F, 0x0F, 0x81, 0xF0, 0x01, 0xE0, 0xF8, 0x1E, 0x00, 0x3E,
  0x0F, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x03, 0xE0,
  0x07, 0x80, 0xF0, 0x3C, 0x00, 0xF8, 0x1F, 0x07, 0xC0, 0x1F, 0x01, 0xF0,
  0x7C, 0x01, 0xF0, 0x1F, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0xF8, 0x03, 0xE0,
  0x0F, 0x1F, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x07, 0xC0, 0x0F, 0xFE, 0x00,
  0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x01,
  0xF8, 0x7E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xE0,
  0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x81, 0xF8, 0x3F, 0xFC, 0x0F, 0xC3,
  0xFB, 0xF0, 0xFC, 0x3F, 0x9F, 0x87, 0xE1, 0xF8, 0xFC, 0x3E, 0x1F, 0x83,
  0xF3, 0xF0, 0xF8, 0x1F, 0x9F, 0x8F, 0xC0, 0xFD, 0xF8, 0x7E, 0x03, 0xFF,
  0xC7, 0xE0, 0x1F, 0xFC, 0x3F, 0x00, 0xFF, 0xE1, 0xF8, 0x03, 0xFE, 0x0F,
  0xC0, 0x1F, 0xF0, 0x7E, 0x00, 0xFF, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x80,
  0x7F, 0xC0, 0xFC, 0x07, 0xFE, 0x07, 0xF0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x7E, 0x07, 0xFF, 0xF3, 0xF8, 0x1F, 0xFE, 0x1F, 0xC0,
  0x7F, 0xE0, 0x7F, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x3F, 0x1F, 0x8F, 0x87, 0xC3, 0xE1,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x10, 0x3E, 0x01, 0xC1, 0xF0, 0x0F, 0x8F, 0x00, 0x7F, 0x78, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFC, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xBE, 0x01, 0xFC, 0xF8, 0x1F, 0xC7,
  0xE0, 0x7C, 0x1F, 0x01, 0xE0, 0xFC, 0x06, 0x07, 0xC0, 0x10, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x7F, 0x07,
  0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x3F,
  0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x00, 0x7F, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xC0, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7C, 0x30, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x81,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xF3, 0xF8, 0x03,
  0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00,
  0x3F, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x07, 0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x7F, 0x0F,
  0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0xF8, 0x1F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xBF, 0x3F, 0x9F,
  0x9F, 0x8F, 0xC7, 0x8F, 0xE1, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFB, 0xFF,
  0x00, 0x7C, 0x07, 0xF0, 0x03, 0x80, 0x7F, 0x00, 0x30, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xE3, 0xFE, 0x00, 0x78, 0x0F,
  0xE0, 0x06, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x80, 0x03, 0xF8, 0x0F,
  0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xEF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xDF, 0x80, 0x00, 0x79,
  0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xF1, 0xF8, 0x00, 0x1F, 0x3F, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x3C, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x0F, 0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x1E, 0x07, 0xE0,
  0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0x80, 0xFC, 0x00, 0xF8,
  0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x01, 0xE0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x78, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x10, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x0C, 0x00, 0x7F, 0x80, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xF8, 0x60, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0xC0, 0x03, 0xF1, 0xFE, 0x00, 0xFC, 0xFF, 0xC0, 0x3F,
  0x7F, 0xF8, 0x0F, 0xBF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0x07, 0xF0,
  0x7F, 0x81, 0xFC, 0x1F, 0xC0, 0x3F, 0x0F, 0xF0, 0x0F, 0xC3, 0xF8, 0x03,
  0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x03, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83,
  0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F,
  0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFC, 0x3F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F,
  0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xCF,
  0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F,
  0xC0, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F,
  0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8,
  0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFE, 0x01, 0xF8,
  0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0xC1, 0xF8, 0x0F,
  0xE0, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC,
  0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x1F, 0xE0,
  0xFC, 0x07, 0xF8, 0x3F, 0x83, 0xFE, 0x0F, 0xF3, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFB, 0xF0, 0x1F, 0xFC, 0xFC, 0x03, 0xFE, 0x3F, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x20, 0x1F, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x07,
  0xC0, 0x04, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xE3, 0xFC, 0x1C, 0x07, 0xE0, 0x80, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x3C,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x1F,
  0xF0, 0x7C, 0x1E, 0x01, 0xFF, 0xC3, 0xE1, 0xF0, 0x1F, 0xFE, 0x1F, 0x0F,
  0x01, 0xFF, 0xF0, 0xF8, 0xF8, 0x1F, 0x0F, 0x07, 0xC7, 0x81, 0xF0, 0x78,
  0x3E, 0x3C, 0x0F, 0x07, 0xC1, 0xE3, 0xE0, 0xF8, 0x3E, 0x0F, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0xF0, 0x7C, 0x0F, 0x03, 0xCF, 0x83, 0xC0, 0xF8, 0x1E,
  0x78, 0x1E, 0x07, 0xC1, 0xF3, 0xC1, 0xF0, 0x3C, 0x0F, 0x1E, 0x0F, 0x03,
  0xE0, 0x79, 0xF0, 0x78, 0x1F, 0x03, 0xCF, 0x83, 0xC0, 0xF8, 0x3C, 0x78,
  0x3E, 0x07, 0x81, 0xE3, 0xC1, 0xF0, 0x7C, 0x0F, 0x1E, 0x0F, 0x83, 0xE0,
  0xF0, 0xF0, 0x7C, 0x3F, 0x07, 0x87, 0x83, 0xE1, 0xF8, 0x78, 0x3C, 0x1F,
  0x1F, 0xC7, 0xC1, 0xE0, 0xFD, 0xFF, 0x7C, 0x0F, 0x03, 0xFE, 0x7F, 0xC0,
  0x78, 0x1F, 0xE3, 0xFC, 0x03, 0xC0, 0x7E, 0x0F, 0xC0, 0x1E, 0x00, 0xC0,
  0x18, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x08, 0x00, 0x07, 0xF0,
  0x03, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0xF9, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF8,
  0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00,
  0x3F, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F,
  0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF0,
  0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFE, 0x00,
  0x3F, 0x1F, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xBF,
  0x80, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F,
  0x80, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x0F, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xE1, 0xFF, 0x00, 0x7E, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xE0,
  0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x1F,
  0x80, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x03,
  0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x03, 0xFC, 0x0F, 0xC0,
  0x3F, 0xC0, 0x7E, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFB, 0xF0, 0x03, 0xFE,
  0x03, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x20, 0x01, 0xFE, 0x07, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xF8, 0x7F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x00, 0xFF,
  0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0,
  0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01,
  0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7E,
  0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x7E, 0x00,
  0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x7F,
  0x00, 0xFC, 0x03, 0xFC, 0x03, 0xF0, 0x1F, 0xE0, 0x1F, 0xC1, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFB, 0xFE, 0x00,
  0x7F, 0x80, 0x3C, 0x00, 0xFF, 0x00, 0x0C, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x7F, 0x00, 0x7F, 0xF0, 0x7F,
  0x00, 0xFF, 0xF0, 0x7E, 0x00, 0xFF, 0xF0, 0x7E, 0x00, 0xFF, 0xF0, 0x7E,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0xE0, 0x3F, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x0F,
  0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xE0,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x03, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x01,
  0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x41, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xC0,
  0x1F, 0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF0,
  0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00,
  0xFD, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFD, 0xF8, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0x80,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0xFE, 0x00, 0x7E, 0xFC,
  0x00, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00,
  0x7C, 0xFC, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x07, 0xC7, 0xC0, 0x3E,
  0x7E, 0x00, 0x7E, 0x3E, 0x03, 0xF3, 0xF0, 0x03, 0xF1, 0xF0, 0x1F, 0x1F,
  0x80, 0x1F, 0x8F, 0x81, 0xF8, 0xFC, 0x00, 0xFC, 0x7C, 0x0F, 0x87, 0xE0,
  0x0F, 0xC3, 0xE0, 0x7C, 0x7E, 0x00, 0x7E, 0x1F, 0x07, 0xE3, 0xF0, 0x03,
  0xF0, 0xF8, 0x3E, 0x1F, 0x80, 0x1F, 0x87, 0xC3, 0xF0, 0xFC, 0x00, 0xF8,
  0x3E, 0x1F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF1, 0xF8, 0x7E, 0x00, 0x7E, 0x0F,
  0x8F, 0x83, 0xF0, 0x03, 0xF0, 0x7C, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xE7,
  0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x3E, 0x0F, 0xC0, 0x0F, 0xC0, 0xFB, 0xE0,
  0x7E, 0x00, 0x7E, 0x07, 0xDF, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0xF8, 0x1F,
  0x80, 0x1F, 0x81, 0xFF, 0x80, 0xFC, 0x00, 0xF8, 0x0F, 0xFC, 0x0F, 0xC0,
  0x0F, 0xC0, 0x7F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xFE, 0x03, 0xF0, 0x03,
  0xF0, 0x1F, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0xFF, 0x00, 0xF8, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x7E, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x07, 0xF8, 0x00,
  0x3F, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x7F,
  0xC0, 0x07, 0xE0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x07, 0xC0,
  0x0F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFC, 0x00,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0xFE, 0x00, 0xF8, 0x01, 0xFB,
  0xE0, 0x1F, 0x80, 0x1F, 0x3E, 0x01, 0xF8, 0x01, 0xF3, 0xE0, 0x1F, 0x80,
  0x3F, 0x3E, 0x01, 0xF8, 0x03, 0xF3, 0xF0, 0x3F, 0x00, 0x3F, 0x3F, 0x03,
  0xF0, 0x03, 0xF1, 0xF0, 0x3F, 0x00, 0x3E, 0x1F, 0x03, 0xF0, 0x07, 0xE1,
  0xF0, 0x3F, 0x00, 0x7E, 0x1F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x7E, 0x00,
  0x7E, 0x1F, 0x87, 0xE0, 0x0F, 0xC0, 0xF8, 0x7E, 0x00, 0xFC, 0x0F, 0x87,
  0xC0, 0x0F, 0xC0, 0xF8, 0xFC, 0x00, 0xFC, 0x0F, 0x8F, 0xC0, 0x0F, 0x80,
  0xFC, 0xFC, 0x01, 0xF8, 0x0F, 0xCF, 0xC0, 0x1F, 0x80, 0x7C, 0xF8, 0x01,
  0xF8, 0x07, 0xDF, 0x80, 0x1F, 0x80, 0x7D, 0xF8, 0x01, 0xF0, 0x07, 0xDF,
  0x80, 0x3F, 0x00, 0x7F, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0x00,
  0x3F, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x07,
  0xE0, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x07, 0xE0, 0x03, 0xFE,
  0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x80,
  0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0xFC, 0x7E,
  0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x3F, 0x80,
  0x01, 0xFC, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x7E, 0x7F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x7F, 0x01, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0x0F, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0x7F,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03,
  0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x07, 0xE0,
  0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x3F,
  0x80, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03,
  0xF0, 0x1F, 0xE0, 0x1F, 0x83, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x80, 0x7F,
  0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFC,
  0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0xFC, 0x7E, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x01,
  0xFC, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7E,
  0x7F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0x9F,
  0x80, 0x00, 0xFE, 0x7E, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x7F, 0x3F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x7F, 0x01, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xE1, 0xFF, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x7F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x1F,
  0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03,
  0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03,
  0xF0, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0xC0, 0x7E, 0x0F,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC3,
  0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00,
  0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x01, 0xFC,
  0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFC, 0x07, 0x80, 0x3F, 0xC0, 0x08, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x10, 0x00,
  0x7F, 0x80, 0xE0, 0x07, 0xF8, 0x07, 0xE0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8,
  0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFC, 0x07,
  0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x7F,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0,
  0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07,
  0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7E,
  0x03, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3A, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFB, 0xF0,
  0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x81,
  0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07,
  0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x0F,
  0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF9, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0xE0,
  0x07, 0xE0, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xF8, 0x03,
  0xF8, 0x7E, 0x00, 0x7F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xFE, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xFF, 0x00, 0x7E, 0x07,
  0xE0, 0x1F, 0x78, 0x07, 0xF0, 0x3F, 0x00, 0xFF, 0xC0, 0x3F, 0x01, 0xF8,
  0x07, 0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0x7D, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xEF, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x7C, 0x0F, 0xE0, 0x1F, 0x81, 0xF3,
  0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0x9F, 0x03, 0xF0, 0x07, 0xE0, 0xF8, 0xF8,
  0x3F, 0x00, 0x3F, 0x07, 0xC7, 0xC1, 0xF8, 0x01, 0xF8, 0x7E, 0x3E, 0x0F,
  0xC0, 0x0F, 0xC3, 0xE1, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x0F, 0x87, 0xE0,
  0x03, 0xF1, 0xF8, 0x7C, 0x7E, 0x00, 0x1F, 0x8F, 0x83, 0xE3, 0xF0, 0x00,
  0xFC, 0x7C, 0x1F, 0x1F, 0x80, 0x07, 0xE7, 0xC0, 0xF9, 0xF8, 0x00, 0x3F,
  0x3E, 0x07, 0xCF, 0xC0, 0x01, 0xFB, 0xF0, 0x3E, 0xFC, 0x00, 0x0F, 0xDF,
  0x01, 0xF7, 0xE0, 0x00, 0x7C, 0xF8, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0x80,
  0x7F, 0xF0, 0x00, 0x1F, 0x7C, 0x03, 0xDF, 0x80, 0x00, 0xFB, 0xE0, 0x1E,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x1F,
  0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x07,
  0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC1,
  0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x07,
  0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x04,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x3E,
  0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF1, 0xF0, 0x00, 0x3E, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFE, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3E, 0x07, 0xC1,
  0xF0, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x07, 0xF8, 0x7C, 0x01, 0xFF, 0x8F,
  0x80, 0x7F, 0xFB, 0xF0, 0x1F, 0xFF, 0x7E, 0x07, 0xFF, 0xFF, 0x80, 0xFE,
  0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF0,
  0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00,
  0x3F, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07,
  0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x7E,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE,
  0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x0F, 0xF0, 0x1F, 0xC3, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFD, 0xF8, 0x07, 0xFF, 0x3E, 0x00, 0x7F, 0xC7, 0xC0,
  0x07, 0xF0, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x70, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xDF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7E, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0x07, 0xE0, 0x3F, 0xC0, 0xFC, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x83, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC3, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00,
  0x7E, 0x0F, 0xF0, 0x1F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFB, 0xFF, 0xE0, 0x3F, 0x7F, 0xF8, 0x07, 0xC7, 0xFE,
  0x00, 0xF8, 0x7F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0x02, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x04, 0x0F, 0xE0, 0x60, 0x3F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x1C, 0x1F, 0x80, 0x03, 0xFC, 0x7E, 0x00, 0x1F,
  0xF9, 0xF8, 0x00, 0xFF, 0xF7, 0xE0, 0x07, 0xFF, 0xDF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0x80, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0x80,
  0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0x80,
  0x0F, 0x80, 0x7E, 0x00, 0x3E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7C, 0x03, 0xF8, 0x03, 0xF0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x80, 0x1F, 0xC3, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xF7, 0xE0, 0x03, 0xFF, 0xDF, 0x00, 0x07, 0xFE,
  0x7C, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xFC, 0x7E, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80,
  0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x07, 0xF8, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x40, 0x3F, 0xC7, 0xC0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFB,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xE1,
  0xF0, 0x00, 0xFF, 0xC7, 0xC0, 0x07, 0xFF, 0xBF, 0x00, 0x3F, 0xFE, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE,
  0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00,
  0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F,
  0x80, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0xFE, 0x1F,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xBF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xF7, 0xE0, 0x00, 0xFF, 0x1F, 0x80, 0x00, 0x70, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x80, 0x07, 0xF0, 0x03, 0xC0, 0x3F, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x0E, 0x00, 0x1F, 0x9F, 0xF0, 0x07, 0xEF, 0xFE,
  0x01, 0xF7, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF8,
  0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F,
  0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83,
  0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80,
  0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x1F, 0xC0,
  0x1F, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0,
  0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x80,
  0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xFD,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xEF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03,
  0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x03,
  0xE3, 0xFC, 0x0F, 0xF0, 0x07, 0xCF, 0xFC, 0x3F, 0xF0, 0x0F, 0xBF, 0xFD,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFB, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x07, 0xFC, 0x1F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x03, 0xF8, 0x1F,
  0xE0, 0x7E, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x7F, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0xFC, 0x03,
  0xF0, 0x0F, 0x83, 0xF0, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x3E, 0x00,
  0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x1F,
  0x83, 0xF0, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x1F, 0x80,
  0x3E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0xFC, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x1F, 0x07, 0xE0,
  0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7C, 0x7F, 0x80, 0x1F, 0x3F, 0xF0,
  0x07, 0xDF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFB, 0xFF, 0xF0, 0x3F, 0xE1,
  0xFC, 0x0F, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7F,
  0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x0F,
  0xC0, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0,
  0x1F, 0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0x7E, 0x1F,
  0xC0, 0x7E, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC,
  0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x7F, 0x80, 0x03, 0xE3,
  0xFF, 0x00, 0x0F, 0x9F, 0xFC, 0x00, 0x3E, 0xFF, 0xF8, 0x01, 0xFF, 0xDF,
  0xE0, 0x07, 0xFC, 0x1F, 0x80, 0x1F, 0xE0, 0x7E, 0x00, 0x7F, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00,
  0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E,
  0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xF0, 0x1F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xBF, 0xFE, 0x00, 0x7E, 0xFF, 0xF0, 0x01, 0xF9, 0xFF,
  0x80, 0x07, 0xE3, 0xFC, 0x00, 0x1F, 0x83, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFC, 0x7C, 0x01, 0xFF, 0x8F,
  0x80, 0x7F, 0xFB, 0xF0, 0x1F, 0xFF, 0x7C, 0x07, 0xFF, 0xFF, 0x80, 0xFE,
  0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07,
  0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE,
  0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x0F, 0xF0, 0x1F, 0xC3, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFD, 0xF8, 0x07, 0xFF, 0x3E, 0x00, 0xFF, 0xEF, 0xC0,
  0x0F, 0xF1, 0xF8, 0x00, 0x38, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x07, 0xC7, 0xF0, 0x1F, 0x3F, 0x80, 0x7D, 0xFE, 0x01, 0xF7, 0xF8,
  0x0F, 0xBF, 0xE0, 0x3E, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0x8F, 0x81, 0xFC, 0x06, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x10, 0x01, 0xF8, 0x38, 0x07, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xFF, 0x8F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xE7, 0xFF, 0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xC0, 0x00, 0x07, 0xE0,
  0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01,
  0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xC0, 0xFC,
  0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1,
  0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0,
  0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F, 0x07, 0xF8, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xEF, 0x80, 0xFF, 0xF3, 0xE0, 0x1F, 0xF8, 0xF0,
  0x03, 0xFC, 0x7C, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xC0,
  0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0xC3, 0xF0,
  0x3F, 0x0F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F,
  0x3F, 0x00, 0xFC, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0xFC,
  0x00, 0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x01,
  0xFB, 0xF0, 0x0F, 0xE0, 0x1F, 0x9F, 0x80, 0x7F, 0x00, 0xFC, 0xFC, 0x07,
  0xF8, 0x07, 0xC7, 0xE0, 0x3F, 0xC0, 0x7E, 0x3F, 0x03, 0xFE, 0x03, 0xF1,
  0xF8, 0x1F, 0xF0, 0x3F, 0x0F, 0xC0, 0xFF, 0x81, 0xF8, 0x7E, 0x0F, 0xFC,
  0x0F, 0x83, 0xF0, 0x7F, 0xE0, 0xFC, 0x1F, 0x83, 0xDF, 0x07, 0xE0, 0xF8,
  0x3E, 0xF8, 0x3E, 0x07, 0xC1, 0xF7, 0xC3, 0xF0, 0x3E, 0x1F, 0x3E, 0x1F,
  0x01, 0xF0, 0xF9, 0xF1, 0xF8, 0x0F, 0x87, 0x8F, 0x8F, 0xC0, 0x7C, 0x7C,
  0x7C, 0x7C, 0x03, 0xE3, 0xE3, 0xE7, 0xE0, 0x1F, 0x3E, 0x1F, 0x3E, 0x00,
  0xF9, 0xF0, 0xF9, 0xF0, 0x07, 0xCF, 0x87, 0x9F, 0x80, 0x3E, 0xF8, 0x3C,
  0xF8, 0x01, 0xF7, 0xC1, 0xEF, 0xC0, 0x0F, 0xBC, 0x1F, 0x7C, 0x00, 0x7F,
  0xE0, 0xFB, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xF0,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x01,
  0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0,
  0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80,
  0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x0F,
  0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x4F, 0xFF, 0x00, 0x37, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xEE, 0x00, 0xFF, 0xF2, 0x00, 0x0F, 0xF8, 0x80,
  0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 17, 47, 16, 0, -46 },
  { 101, 20, 16, 23, 6, -46 },
  { 141, 30, 46, 29, 0, -46 },
  { 314, 27, 53, 26, 0, -49 },
  { 493, 36, 48, 41, 3, -47 },
  { 709, 29, 48, 30, 0, -47 },
  { 883, 9, 16, 13, 7, -46 },
  { 901, 20, 57, 17, 1, -47 },
  { 1044, 20, 57, 17, -5, -47 },
  { 1187, 21, 24, 24, 6, -50 },
  { 1250, 24, 30, 29, 3, -38 },
  { 1340, 12, 17, 14, -3, -8 },
  { 1366, 15, 5, 17, 1, -20 },
  { 1376, 7, 9, 14, 1, -8 },
  { 1384, 31, 47, 22, -3, -47 },
  { 1567, 25, 48, 26, 1, -47 },
  { 1717, 17, 46, 26, 7, -46 },
  { 1815, 28, 47, 26, -2, -47 },
  { 1980, 28, 48, 26, -1, -47 },
  { 2148, 28, 47, 26, -1, -47 },
  { 2313, 28, 47, 26, -1, -46 },
  { 2478, 26, 48, 26, 2, -47 },
  { 2634, 27, 46, 26, 2, -46 },
  { 2790, 27, 48, 26, 0, -47 },
  { 2952, 26, 48, 26, 0, -47 },
  { 3108, 14, 36, 14, 0, -35 },
  { 3171, 17, 44, 14, -3, -35 },
  { 3265, 25, 30, 29, 2, -38 },
  { 3359, 24, 18, 29, 3, -32 },
  { 3413, 25, 30, 29, 3, -38 },
  { 3507, 21, 48, 20, 1, -47 },
  { 3633, 37, 52, 39, 2, -47 },
  { 3874, 27, 47, 28, -4, -47 },
  { 4033, 29, 46, 29, 0, -46 },
  { 4200, 29, 48, 26, 2, -47 },
  { 4374, 30, 46, 31, 0, -46 },
  { 4547, 27, 46, 24, 0, -46 },
  { 4703, 27, 46, 23, 0, -46 },
  { 4859, 32, 48, 33, 2, -47 },
  { 5051, 34, 46, 32, 0, -46 },
  { 5247, 26, 46, 18, -3, -46 },
  { 5397, 26, 59, 14, -10, -46 },
  { 5589, 33, 46, 27, 0, -46 },
  { 5779, 19, 46, 23, 0, -46 },
  { 5889, 45, 46, 43, 0, -46 },
  { 6148, 36, 46, 34, 0, -46 },
  { 6355, 30, 48, 33, 2, -47 },
  { 6535, 29, 46, 27, 0, -46 },
  { 6702, 30, 58, 33, 2, -47 },
  { 6920, 28, 46, 28, 0, -46 },
  { 7081, 29, 48, 25, -1, -47 },
  { 7255, 24, 46, 23, 4, -46 },
  { 7393, 31, 47, 32, 2, -46 },
  { 7576, 27, 46, 27, 6, -46 },
  { 7732, 45, 46, 43, 4, -46 },
  { 7991, 34, 46, 25, -4, -46 },
  { 8187, 25, 46, 24, 5, -46 },
  { 8331, 30, 46, 23, -3, -46 },
  { 8504, 25, 57, 18, -2, -47 },
  { 8683, 12, 47, 23, 6, -47 },
  { 8754, 24, 57, 18, -4, -47 },
  { 8925, 27, 25, 27, 0, -46 },
  { 9010, 21, 5, 20, -6, 5 },
  { 9024, 10, 11, 17, 9, -50 },
  { 9038, 27, 37, 28, 1, -36 },
  { 9163, 27, 50, 28, 0, -49 },
  { 9332, 22, 37, 22, 2, -36 },
  { 9434, 30, 50, 28, 1, -49 },
  { 9622, 24, 37, 26, 1, -36 },
  { 9733, 31, 66, 16, -8, -50 },
  { 9989, 30, 52, 28, -2, -36 },
  { 10184, 26, 49, 28, 0, -49 },
  { 10344, 16, 48, 13, 0, -48 },
  { 10440, 24, 64, 13, -8, -48 },
  { 10632, 28, 49, 25, 0, -49 },
  { 10804, 16, 49, 13, 0, -49 },
  { 10902, 39, 36, 41, 0, -36 },
  { 11078, 26, 36, 28, 0, -36 },
  { 11195, 24, 37, 27, 2, -36 },
  { 11306, 30, 51, 28, -3, -36 },
  { 11498, 27, 52, 28, 1, -36 },
  { 11674, 22, 36, 19, 0, -36 },
  { 11773, 23, 37, 21, -1, -36 },
  { 11880, 17, 44, 17, 2, -43 },
  { 11974, 26, 36, 28, 2, -35 },
  { 12091, 22, 35, 23, 4, -35 },
  { 12188, 37, 35, 37, 3, -35 },
  { 12350, 29, 35, 24, -3, -35 },
  { 12477, 33, 51, 23, -6, -35 },
  { 12688, 23, 35, 19, -2, -35 },
  { 12789, 25, 56, 22, 1, -46 },
  { 12964, 5, 65, 24, 9, -50 },
  { 13005, 24, 56, 21, -4, -46 },
  { 13173, 26, 9, 29, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic65pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC65PT7B_H_
