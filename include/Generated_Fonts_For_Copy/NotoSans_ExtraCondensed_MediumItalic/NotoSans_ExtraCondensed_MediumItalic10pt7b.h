#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC10PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x24, 0x20, 0xB4, 0x39, 0x9E, 0xAF, 0x52, 0x80, 0x23, 0x66,
  0x25, 0xA4, 0x40, 0x6D, 0xAB, 0x3F, 0x34, 0xD4, 0x80, 0x35, 0x66, 0xBB,
  0xF0, 0xC0, 0x29, 0x49, 0x24, 0x80, 0x24, 0x92, 0x52, 0x80, 0x5D, 0x50,
  0x22, 0xF2, 0x20, 0xC0, 0xC0, 0x80, 0x08, 0x84, 0x42, 0x23, 0x00, 0x35,
  0x59, 0x9A, 0xE0, 0x79, 0x24, 0xA0, 0x71, 0x12, 0x48, 0xE0, 0x71, 0x16,
  0x22, 0xE0, 0x13, 0x56, 0xA7, 0x20, 0x74, 0x4A, 0x12, 0xE0, 0x34, 0x6D,
  0x9A, 0x60, 0x71, 0x22, 0x44, 0xC0, 0x75, 0x56, 0xA9, 0xE0, 0x75, 0x57,
  0x12, 0xC0, 0x40, 0x80, 0x20, 0x05, 0x80, 0x12, 0xC3, 0x10, 0xF0, 0xF0,
  0x86, 0x16, 0x80, 0x64, 0xA4, 0x20, 0x39, 0x17, 0xED, 0xB6, 0xA8, 0x1C,
  0x18, 0xCA, 0x57, 0xA7, 0x20, 0x72, 0x54, 0xE9, 0x4B, 0x80, 0x3A, 0x11,
  0x08, 0x41, 0x80, 0x72, 0x52, 0x99, 0x4B, 0x80, 0x74, 0x46, 0x88, 0xE0,
  0x74, 0x46, 0x88, 0x80, 0x3A, 0x11, 0x39, 0x49, 0xC0, 0x4A, 0x52, 0xE9,
  0x4A, 0x40, 0x69, 0x24, 0xB0, 0x24, 0x92, 0x92, 0x80, 0x4A, 0x98, 0xCA,
  0x52, 0x80, 0x49, 0x29, 0x38, 0x66, 0xCD, 0xB3, 0x6B, 0x56, 0xAA, 0x00,
  0x6D, 0xA6, 0x9A, 0xAA, 0x49, 0x00, 0x3A, 0x53, 0x18, 0xC9, 0x80, 0x75,
  0x57, 0x88, 0x80, 0x3A, 0x53, 0x18, 0xC9, 0x84, 0x20, 0x75, 0x57, 0xAA,
  0xB0, 0x74, 0x42, 0x22, 0xE0, 0xE9, 0x49, 0x20, 0x4A, 0x52, 0xA9, 0x49,
  0x80, 0x9A, 0xAA, 0xCC, 0x80, 0x96, 0xDB, 0xB6, 0xDA, 0x49, 0x00, 0x2C,
  0xA3, 0x0C, 0x31, 0x4D, 0x00, 0xBA, 0xCC, 0x88, 0x80, 0x72, 0x24, 0x48,
  0xE0, 0x74, 0x44, 0x88, 0x88, 0xC0, 0xAA, 0x54, 0x31, 0x12, 0x22, 0x22,
  0xC0, 0x25, 0x59, 0xE0, 0xD0, 0x75, 0x99, 0xE0, 0x24, 0x47, 0x59, 0x9E,
  0x74, 0x88, 0xE0, 0x08, 0x4C, 0xA5, 0x4A, 0x5C, 0x79, 0xE8, 0xE0, 0x19,
  0x08, 0xE2, 0x11, 0x08, 0x46, 0x00, 0x75, 0x9B, 0xE2, 0xE0, 0x24, 0x65,
  0x59, 0xAA, 0x45, 0xA8, 0x20, 0x94, 0x92, 0xC0, 0x24, 0x45, 0x66, 0xAA,
  0x29, 0x25, 0x24, 0x7D, 0x59, 0x69, 0xA8, 0x75, 0x9A, 0xA0, 0x75, 0x99,
  0xE0, 0x39, 0x52, 0x97, 0x23, 0x00, 0x75, 0x99, 0xE2, 0x20, 0x6A, 0x48,
  0x69, 0x9C, 0x4D, 0x29, 0x30, 0x55, 0x9A, 0xE0, 0xBB, 0x48, 0xAF, 0xAD,
  0x6A, 0x00, 0x76, 0x4A, 0xA0, 0x29, 0x8C, 0x42, 0x13, 0x00, 0x69, 0x4C,
  0x32, 0x24, 0xC4, 0x44, 0x40, 0xFF, 0xC0, 0x31, 0x22, 0x32, 0x24, 0x80,
  0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 2, 0, -7 },
  { 4, 3, 2, 4, 1, -7 },
  { 5, 5, 7, 4, 0, -7 },
  { 10, 4, 9, 4, 0, -8 },
  { 15, 6, 7, 6, 0, -7 },
  { 21, 4, 7, 5, 0, -7 },
  { 25, 1, 2, 2, 1, -7 },
  { 26, 3, 9, 3, 0, -7 },
  { 30, 3, 9, 3, -1, -7 },
  { 34, 3, 4, 4, 1, -8 },
  { 36, 4, 5, 4, 0, -6 },
  { 39, 1, 2, 2, 0, -1 },
  { 40, 2, 1, 3, 0, -3 },
  { 41, 1, 1, 2, 0, -1 },
  { 42, 5, 7, 3, -1, -7 },
  { 47, 4, 7, 4, 0, -7 },
  { 51, 3, 7, 4, 1, -7 },
  { 54, 4, 7, 4, 0, -7 },
  { 58, 4, 7, 4, 0, -7 },
  { 62, 4, 7, 4, 0, -7 },
  { 66, 4, 7, 4, 0, -7 },
  { 70, 4, 7, 4, 0, -7 },
  { 74, 4, 7, 4, 0, -7 },
  { 78, 4, 7, 4, 0, -7 },
  { 82, 4, 7, 4, 0, -7 },
  { 86, 2, 5, 2, 0, -5 },
  { 88, 3, 6, 2, -1, -5 },
  { 91, 4, 5, 4, 0, -6 },
  { 94, 4, 3, 4, 0, -5 },
  { 96, 4, 5, 4, 0, -6 },
  { 99, 3, 7, 3, 0, -7 },
  { 102, 6, 8, 6, 0, -7 },
  { 108, 5, 7, 4, -1, -7 },
  { 113, 5, 7, 4, 0, -7 },
  { 118, 5, 7, 4, 0, -7 },
  { 123, 5, 7, 5, 0, -7 },
  { 128, 4, 7, 4, 0, -7 },
  { 132, 4, 7, 4, 0, -7 },
  { 136, 5, 7, 5, 0, -7 },
  { 141, 5, 7, 5, 0, -7 },
  { 146, 3, 7, 3, 0, -7 },
  { 149, 3, 9, 2, -1, -7 },
  { 153, 5, 7, 4, 0, -7 },
  { 158, 3, 7, 4, 0, -7 },
  { 161, 7, 7, 7, 0, -7 },
  { 168, 6, 7, 5, 0, -7 },
  { 174, 5, 7, 5, 0, -7 },
  { 179, 4, 7, 4, 0, -7 },
  { 183, 5, 9, 5, 0, -7 },
  { 189, 4, 7, 4, 0, -7 },
  { 193, 4, 7, 4, 0, -7 },
  { 197, 3, 7, 4, 1, -7 },
  { 200, 5, 7, 5, 0, -7 },
  { 205, 4, 7, 4, 1, -7 },
  { 209, 6, 7, 7, 1, -7 },
  { 215, 6, 7, 4, -1, -7 },
  { 221, 4, 7, 4, 1, -7 },
  { 225, 4, 7, 4, 0, -7 },
  { 229, 4, 9, 3, 0, -7 },
  { 234, 2, 7, 4, 1, -7 },
  { 236, 4, 9, 3, -1, -7 },
  { 241, 4, 4, 4, 0, -7 },
  { 243, 3, 1, 3, -1, 1 },
  { 244, 2, 2, 3, 1, -8 },
  { 245, 4, 5, 4, 0, -5 },
  { 248, 4, 8, 4, 0, -8 },
  { 252, 4, 5, 3, 0, -5 },
  { 255, 5, 8, 4, 0, -8 },
  { 260, 4, 5, 4, 0, -5 },
  { 263, 5, 10, 2, -1, -8 },
  { 270, 4, 7, 4, 0, -5 },
  { 274, 4, 8, 4, 0, -8 },
  { 278, 2, 7, 2, 0, -7 },
  { 280, 3, 9, 2, -1, -7 },
  { 284, 4, 8, 4, 0, -8 },
  { 288, 3, 8, 2, 0, -8 },
  { 291, 6, 5, 6, 0, -5 },
  { 295, 4, 5, 4, 0, -5 },
  { 298, 4, 5, 4, 0, -5 },
  { 301, 5, 7, 4, -1, -5 },
  { 306, 4, 7, 4, 0, -5 },
  { 310, 3, 5, 3, 0, -5 },
  { 312, 3, 5, 3, 0, -5 },
  { 314, 3, 7, 3, 0, -7 },
  { 317, 4, 5, 4, 0, -5 },
  { 320, 3, 5, 4, 1, -5 },
  { 322, 5, 5, 6, 1, -5 },
  { 326, 4, 5, 4, 0, -5 },
  { 329, 5, 7, 4, -1, -5 },
  { 334, 3, 5, 3, 0, -5 },
  { 336, 4, 9, 3, 0, -7 },
  { 341, 1, 10, 4, 1, -8 },
  { 343, 4, 9, 3, -1, -7 },
  { 348, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC10PT7B_H_
