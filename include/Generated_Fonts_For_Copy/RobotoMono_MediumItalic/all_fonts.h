#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/RobotoMono_MediumItalic
// Headers: 67

#include "RobotoMono_MediumItalic6pt7b.h"
#include "RobotoMono_MediumItalic7pt7b.h"
#include "RobotoMono_MediumItalic8pt7b.h"
#include "RobotoMono_MediumItalic9pt7b.h"
#include "RobotoMono_MediumItalic10pt7b.h"
#include "RobotoMono_MediumItalic11pt7b.h"
#include "RobotoMono_MediumItalic12pt7b.h"
#include "RobotoMono_MediumItalic13pt7b.h"
#include "RobotoMono_MediumItalic14pt7b.h"
#include "RobotoMono_MediumItalic15pt7b.h"
#include "RobotoMono_MediumItalic16pt7b.h"
#include "RobotoMono_MediumItalic17pt7b.h"
#include "RobotoMono_MediumItalic18pt7b.h"
#include "RobotoMono_MediumItalic19pt7b.h"
#include "RobotoMono_MediumItalic20pt7b.h"
#include "RobotoMono_MediumItalic21pt7b.h"
#include "RobotoMono_MediumItalic22pt7b.h"
#include "RobotoMono_MediumItalic23pt7b.h"
#include "RobotoMono_MediumItalic24pt7b.h"
#include "RobotoMono_MediumItalic25pt7b.h"
#include "RobotoMono_MediumItalic26pt7b.h"
#include "RobotoMono_MediumItalic27pt7b.h"
#include "RobotoMono_MediumItalic28pt7b.h"
#include "RobotoMono_MediumItalic29pt7b.h"
#include "RobotoMono_MediumItalic30pt7b.h"
#include "RobotoMono_MediumItalic31pt7b.h"
#include "RobotoMono_MediumItalic32pt7b.h"
#include "RobotoMono_MediumItalic33pt7b.h"
#include "RobotoMono_MediumItalic34pt7b.h"
#include "RobotoMono_MediumItalic35pt7b.h"
#include "RobotoMono_MediumItalic36pt7b.h"
#include "RobotoMono_MediumItalic37pt7b.h"
#include "RobotoMono_MediumItalic38pt7b.h"
#include "RobotoMono_MediumItalic39pt7b.h"
#include "RobotoMono_MediumItalic40pt7b.h"
#include "RobotoMono_MediumItalic41pt7b.h"
#include "RobotoMono_MediumItalic42pt7b.h"
#include "RobotoMono_MediumItalic43pt7b.h"
#include "RobotoMono_MediumItalic44pt7b.h"
#include "RobotoMono_MediumItalic45pt7b.h"
#include "RobotoMono_MediumItalic46pt7b.h"
#include "RobotoMono_MediumItalic47pt7b.h"
#include "RobotoMono_MediumItalic48pt7b.h"
#include "RobotoMono_MediumItalic49pt7b.h"
#include "RobotoMono_MediumItalic50pt7b.h"
#include "RobotoMono_MediumItalic51pt7b.h"
#include "RobotoMono_MediumItalic52pt7b.h"
#include "RobotoMono_MediumItalic53pt7b.h"
#include "RobotoMono_MediumItalic54pt7b.h"
#include "RobotoMono_MediumItalic55pt7b.h"
#include "RobotoMono_MediumItalic56pt7b.h"
#include "RobotoMono_MediumItalic57pt7b.h"
#include "RobotoMono_MediumItalic58pt7b.h"
#include "RobotoMono_MediumItalic59pt7b.h"
#include "RobotoMono_MediumItalic60pt7b.h"
#include "RobotoMono_MediumItalic61pt7b.h"
#include "RobotoMono_MediumItalic62pt7b.h"
#include "RobotoMono_MediumItalic63pt7b.h"
#include "RobotoMono_MediumItalic64pt7b.h"
#include "RobotoMono_MediumItalic65pt7b.h"
#include "RobotoMono_MediumItalic66pt7b.h"
#include "RobotoMono_MediumItalic67pt7b.h"
#include "RobotoMono_MediumItalic68pt7b.h"
#include "RobotoMono_MediumItalic69pt7b.h"
#include "RobotoMono_MediumItalic70pt7b.h"
#include "RobotoMono_MediumItalic71pt7b.h"
#include "RobotoMono_MediumItalic72pt7b.h"
