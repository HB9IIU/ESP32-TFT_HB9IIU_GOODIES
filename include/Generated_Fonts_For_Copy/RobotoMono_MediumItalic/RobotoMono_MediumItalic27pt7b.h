#ifndef _ROBOTOMONO_MEDIUMITALIC27PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC7, 0x38, 0xE3, 0x8E, 0x38, 0xC7, 0x1C, 0x70, 0x00,
  0x00, 0xE3, 0x8E, 0x00, 0x63, 0x63, 0xE7, 0xE7, 0xC6, 0xC6, 0x00, 0xC6,
  0x01, 0xCE, 0x01, 0x8C, 0x01, 0x8C, 0x03, 0x9C, 0x1F, 0xFF, 0x3F, 0xFF,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x60, 0x0C, 0x60, 0xFF, 0xFC,
  0xFF, 0xFC, 0x18, 0xC0, 0x39, 0xC0, 0x31, 0x80, 0x31, 0x80, 0x73, 0x80,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x01, 0xFC, 0x0F, 0xF8, 0x78, 0xF1, 0xC1,
  0xC7, 0x07, 0x3C, 0x1C, 0x70, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0x00, 0x0E, 0xF0, 0x3B, 0xC0, 0xE7, 0x07, 0x9E, 0x3C, 0x3F,
  0xE0, 0x7F, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x00, 0x03, 0xE0, 0x3B,
  0x81, 0x8C, 0x4C, 0x67, 0x63, 0x33, 0x3B, 0x1F, 0xB0, 0x7B, 0x80, 0x18,
  0x01, 0x80, 0x1C, 0x00, 0xDE, 0x0D, 0xF8, 0xCC, 0xE6, 0xE7, 0x67, 0x30,
  0x39, 0x80, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x79,
  0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x9C, 0x07, 0x78, 0x0F, 0xE0, 0x0F, 0x00,
  0x3E, 0x00, 0xFC, 0x73, 0x9C, 0xEE, 0x39, 0xDC, 0x3F, 0x38, 0x7E, 0x70,
  0x78, 0xF3, 0xF0, 0xFF, 0xE0, 0xFC, 0xE0, 0x6D, 0xFF, 0xB0, 0x00, 0x80,
  0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07,
  0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0x80,
  0xE0, 0x30, 0x1C, 0x07, 0x01, 0x00, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x30,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x86, 0x17, 0x33, 0xFF, 0xFC, 0x7F,
  0x80, 0xE0, 0x0D, 0x80, 0xEC, 0x0E, 0x70, 0xE1, 0xC2, 0x08, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x81, 0xFF, 0xF7, 0xFF, 0xBF,
  0xFE, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0x39, 0xDC, 0xE7, 0x73, 0x98, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x07, 0xFC, 0x78, 0xE3, 0x87, 0x38, 0x1D, 0xC0,
  0xEE, 0x0F, 0xF1, 0xFF, 0x1F, 0xBB, 0xDD, 0xF8, 0xEF, 0x87, 0x70, 0x3B,
  0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x9E, 0x1F, 0xE0, 0x7E, 0x00, 0x01, 0x87,
  0xDF, 0xEF, 0xF6, 0x74, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x07, 0xF0, 0x3F, 0xE1,
  0xE3, 0xCF, 0x07, 0x38, 0x1C, 0xE0, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0x7F, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x0F, 0xE0, 0xFF, 0xCF, 0x1E, 0x70,
  0x73, 0x83, 0x80, 0x1C, 0x00, 0xE0, 0x1E, 0x07, 0xE0, 0x7E, 0x00, 0xF8,
  0x00, 0xE0, 0x07, 0x00, 0x3B, 0x81, 0xDC, 0x1E, 0xF1, 0xE3, 0xFE, 0x0F,
  0xE0, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0E, 0xE0,
  0x73, 0x81, 0xCE, 0x0E, 0x70, 0x71, 0xC3, 0x87, 0x1C, 0x1C, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x98, 0x0F,
  0xF8, 0x3F, 0xF0, 0xE1, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xEE,
  0x07, 0x1C, 0x1C, 0x79, 0xE0, 0xFF, 0x81, 0xF8, 0x00, 0x01, 0xF0, 0x1F,
  0x83, 0xF0, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xE6, 0x0E, 0xFC, 0x7F, 0xF3,
  0xC3, 0x9C, 0x1F, 0xE0, 0x7E, 0x03, 0xF0, 0x39, 0xC1, 0xCE, 0x1E, 0x79,
  0xE1, 0xFE, 0x07, 0xE0, 0x7F, 0xFD, 0xFF, 0xF8, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0x00, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xE3, 0x87, 0x0F, 0x38, 0x1C, 0xE0,
  0xF3, 0x83, 0x87, 0x1E, 0x0F, 0xE0, 0x7F, 0x83, 0xDF, 0x1C, 0x1C, 0x70,
  0x73, 0x81, 0xEE, 0x07, 0x3C, 0x1C, 0x79, 0xF1, 0xFF, 0x81, 0xF8, 0x00,
  0x0F, 0xC3, 0xFE, 0x38, 0xF7, 0x07, 0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xF0, 0x77, 0x0F, 0x7F, 0xF3, 0xF6, 0x1C, 0xE0, 0x0E, 0x01, 0xC0, 0x78,
  0x7F, 0x07, 0xE0, 0x78, 0x00, 0x1C, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0xFB, 0xE7, 0x00, 0x0E, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0xE0,
  0x40, 0x00, 0x10, 0x03, 0x01, 0xF0, 0x7F, 0x3F, 0xCF, 0xE0, 0xF0, 0x0F,
  0x80, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x0C, 0x00, 0x40, 0x3F, 0xFD, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0xBF, 0xFC, 0x30,
  0x01, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3C, 0x07, 0xE1, 0xFC,
  0x7F, 0x83, 0xE0, 0x3C, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0xE7,
  0x8F, 0x70, 0x7E, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x3C, 0x03,
  0x80, 0x03, 0xF0, 0x0F, 0xF0, 0x70, 0x70, 0xC0, 0x63, 0x1E, 0x4C, 0xFC,
  0x99, 0x99, 0xA6, 0x32, 0xCC, 0x45, 0x99, 0x9B, 0x63, 0x36, 0xC6, 0x6D,
  0xDD, 0x99, 0xFF, 0x33, 0x98, 0x60, 0x00, 0x60, 0x80, 0xFF, 0x00, 0x7C,
  0x00, 0x00, 0x70, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xE6, 0x01, 0xCC, 0x07, 0x1C, 0x0E, 0x38, 0x38, 0x70, 0x70, 0xE1,
  0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x1C, 0x0F, 0x78, 0x0E, 0xE0, 0x1F, 0xC0,
  0x38, 0x0F, 0xF8, 0x1F, 0xF8, 0x70, 0xF8, 0xE0, 0x71, 0xC0, 0xE3, 0x81,
  0xC7, 0x03, 0x9E, 0x1E, 0x3F, 0xF8, 0x7F, 0xF0, 0xE0, 0xF1, 0xC0, 0xE3,
  0x81, 0xCF, 0x03, 0x9C, 0x07, 0x38, 0x1E, 0x7F, 0xF8, 0xFF, 0xE3, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x87, 0x8F, 0x3C, 0x1C, 0xE0, 0x77,
  0x01, 0xDC, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x03, 0xB8, 0x1E, 0x70, 0x71, 0xE7, 0xC3, 0xFE, 0x07, 0xE0,
  0x0F, 0xE0, 0x3F, 0xF0, 0x73, 0xF0, 0xE0, 0xE1, 0xC1, 0xE3, 0x81, 0xC7,
  0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0xE7, 0x81,
  0xCE, 0x07, 0x9C, 0x0E, 0x38, 0x3C, 0x7F, 0xF0, 0xFF, 0x83, 0xFC, 0x00,
  0x1F, 0xFE, 0x3F, 0xFC, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3F, 0xF0, 0xFF, 0xE1, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC0,
  0x1F, 0xFE, 0x3F, 0xFC, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0xC3, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x07, 0xF0, 0x3F, 0xE1, 0xE3, 0xCF, 0x07, 0x38, 0x1D, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC7, 0xFE, 0x1F, 0xF8, 0x7E, 0xE0, 0x3B, 0x80,
  0xEF, 0x03, 0x9C, 0x0E, 0x7C, 0xF8, 0xFF, 0xC1, 0xFC, 0x00, 0x1E, 0x07,
  0x1C, 0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x38, 0x0E,
  0x38, 0x0E, 0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x1C, 0x38, 0x1C, 0x70, 0x1C,
  0x70, 0x1C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x38,
  0x1F, 0xFC, 0x7F, 0xF0, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x9C, 0x0E,
  0x38, 0x1C, 0x70, 0x78, 0x79, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0x0E, 0x07,
  0x87, 0x07, 0x87, 0x07, 0x83, 0x87, 0x81, 0xC7, 0x80, 0xE7, 0x80, 0x77,
  0x80, 0x7F, 0x80, 0x3B, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0x9C, 0x03,
  0x8E, 0x03, 0xC7, 0x81, 0xC1, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x38, 0x1E,
  0x3C, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x0F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x3F, 0x1F, 0x3E, 0x1B, 0x3E, 0x1B, 0x7E, 0x3B, 0x6E,
  0x3B, 0xEE, 0x3B, 0xCE, 0x3B, 0xDC, 0x39, 0x9C, 0x71, 0x9C, 0x70, 0x1C,
  0x70, 0x1C, 0x70, 0x18, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x38, 0x1E, 0x07,
  0x1E, 0x0F, 0x1E, 0x0E, 0x1F, 0x0E, 0x1F, 0x0E, 0x1F, 0x0E, 0x3F, 0x8E,
  0x3B, 0x9E, 0x39, 0x9C, 0x39, 0x9C, 0x39, 0xDC, 0x39, 0xDC, 0x78, 0xDC,
  0x70, 0xFC, 0x70, 0xF8, 0x70, 0x78, 0x70, 0x78, 0x70, 0x78, 0xF0, 0x78,
  0x07, 0xF0, 0x3F, 0xE1, 0xE7, 0x8F, 0x0F, 0x38, 0x1D, 0xC0, 0x77, 0x01,
  0xDC, 0x07, 0x70, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0E, 0xE0, 0x3B, 0x80,
  0xEE, 0x07, 0x1C, 0x3C, 0x79, 0xE0, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0xF0,
  0x3F, 0xF0, 0x71, 0xF1, 0xE0, 0xF3, 0x80, 0xE7, 0x01, 0xCE, 0x07, 0x9C,
  0x0E, 0x38, 0x3C, 0xFF, 0xF1, 0xFF, 0xC3, 0xFC, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x07, 0xF0,
  0x3F, 0xE1, 0xE7, 0x8F, 0x07, 0x38, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x07,
  0x70, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3B, 0x80, 0xEE, 0x07,
  0x9C, 0x1C, 0x79, 0xE0, 0xFF, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0xF1, 0xF1, 0xC0, 0xE3, 0x81, 0xC7, 0x03,
  0x8E, 0x07, 0x1C, 0x1E, 0x70, 0x78, 0xFF, 0xE1, 0xFF, 0x83, 0xFE, 0x07,
  0x1E, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0x78, 0xE0, 0x71, 0xC0, 0xE3, 0x81,
  0xE0, 0x07, 0xF0, 0x3F, 0xF0, 0x78, 0xF1, 0xE0, 0xE3, 0x81, 0xE7, 0x00,
  0x0E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0x9C, 0x07, 0x38, 0x0E, 0x78, 0x3C, 0x78, 0xF0, 0x7F, 0xC0, 0x7F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x1C, 0x0E, 0x70, 0x1C, 0xE0, 0x79, 0xC0, 0xE3, 0x81, 0xC7, 0x03,
  0x8E, 0x07, 0x38, 0x0E, 0x70, 0x3C, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xCF,
  0x03, 0x9C, 0x07, 0x3C, 0x1C, 0x38, 0x78, 0x79, 0xE0, 0x7F, 0x80, 0x7E,
  0x00, 0xF0, 0x1E, 0xE0, 0x39, 0xC0, 0xF3, 0x81, 0xC7, 0x07, 0x8E, 0x0E,
  0x1C, 0x1C, 0x3C, 0x70, 0x38, 0xE0, 0x73, 0x80, 0xE7, 0x01, 0xDE, 0x03,
  0xB8, 0x07, 0x70, 0x0F, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE3, 0x8F, 0xC7, 0x1F, 0x8E, 0x77, 0x3C, 0xEE, 0x79, 0xDC, 0xF3,
  0x3B, 0xEE, 0x76, 0xDC, 0xED, 0xB9, 0xFB, 0x63, 0xE7, 0xC7, 0xCF, 0x8F,
  0x9E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xC1, 0xC3, 0x83, 0x87,
  0x00, 0x0E, 0x03, 0xC3, 0xC1, 0xE0, 0x70, 0xF0, 0x1C, 0x38, 0x03, 0x9E,
  0x00, 0xE7, 0x00, 0x3B, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xCE, 0x00, 0xE3, 0x80, 0x78,
  0xF0, 0x3C, 0x1C, 0x1E, 0x07, 0x0F, 0x81, 0xE0, 0xE0, 0x3F, 0x80, 0xEF,
  0x07, 0x9C, 0x3C, 0x70, 0xE1, 0xC7, 0x83, 0x9C, 0x0E, 0xE0, 0x3F, 0x80,
  0xFC, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xC3, 0xF0, 0xE0,
  0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x7C, 0x3F, 0x00, 0xE3, 0x8E, 0x18, 0x71, 0xC7, 0x1C, 0x30,
  0xC3, 0x8E, 0x38, 0xE1, 0x87, 0x1C, 0x71, 0xC3, 0x0C, 0x0F, 0xC3, 0xF0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07,
  0x01, 0xC0, 0x70, 0x7C, 0x3F, 0x00, 0x07, 0x01, 0xC0, 0xF8, 0x3E, 0x1D,
  0x86, 0x63, 0x9D, 0xC7, 0x71, 0xF8, 0x30, 0xFF, 0xFF, 0xFF, 0xF3, 0x8C,
  0x70, 0x01, 0x00, 0x7F, 0x0F, 0xFC, 0x70, 0xF7, 0x83, 0x80, 0x1C, 0x1F,
  0xC7, 0xFE, 0x7C, 0x77, 0x83, 0xB8, 0x1D, 0xC1, 0xEF, 0x1F, 0x3F, 0xF0,
  0xFB, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x40,
  0xEF, 0x87, 0xFE, 0x3C, 0x7B, 0xC1, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0xB8,
  0x1D, 0xC0, 0xFE, 0x0E, 0xF0, 0x77, 0xCF, 0x3F, 0xF9, 0xDF, 0x80, 0x01,
  0x00, 0x7F, 0x07, 0xFC, 0x78, 0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x1C, 0x1C, 0xE0, 0xE7, 0x9E, 0x1F, 0xF0, 0x7E, 0x00,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x43, 0x83,
  0xFF, 0x0F, 0xFC, 0x3C, 0x78, 0xF0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03,
  0x9C, 0x0E, 0x38, 0x1C, 0x78, 0x38, 0x70, 0xF0, 0xF3, 0xE1, 0xFF, 0xC1,
  0xFB, 0x00, 0x01, 0x00, 0x7F, 0x07, 0xFC, 0x78, 0xF7, 0x83, 0xB8, 0x1D,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xE0, 0x47, 0xCF, 0x1F,
  0xF0, 0x7F, 0x00, 0x00, 0x7C, 0x03, 0xFC, 0x0F, 0xF0, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x3F, 0xFC, 0xFF, 0xF0, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x01, 0x00, 0x0F, 0xDC, 0x3F,
  0xF8, 0xF1, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x70, 0x3C,
  0xE0, 0x71, 0xE0, 0xE1, 0xC1, 0xC3, 0xCF, 0x83, 0xFF, 0x03, 0xEE, 0x00,
  0x38, 0x20, 0x70, 0xC1, 0xE3, 0xFF, 0x81, 0xFE, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x40, 0xEF, 0xC7, 0xFF,
  0x3C, 0x7B, 0xC1, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC1, 0xFC,
  0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xE0, 0x00, 0xC0, 0x1E, 0x01,
  0xE0, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x07, 0xFF, 0x7F,
  0xFF, 0xFF, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0xFE, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x0F,
  0x0F, 0xE0, 0xFC, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x83, 0xCE, 0x1E, 0x39, 0xE1, 0xEF, 0x07, 0x78,
  0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xB8, 0x3C, 0xF0, 0xE1, 0xE3, 0x83,
  0x8E, 0x0F, 0x38, 0x1C, 0x0F, 0xE1, 0xFE, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x08,
  0x7F, 0x78, 0xFF, 0xF9, 0xCE, 0x73, 0x1C, 0xEE, 0x39, 0xDC, 0x63, 0xB9,
  0xC6, 0x73, 0x9C, 0xC7, 0x3B, 0x8E, 0x77, 0x18, 0xEE, 0x71, 0xDC, 0xE3,
  0x39, 0xCE, 0x00, 0x00, 0x81, 0xDF, 0x8F, 0xFE, 0x78, 0xF7, 0x83, 0xB8,
  0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x83, 0xB8, 0x1D, 0xC0, 0xEE, 0x07,
  0x70, 0x3B, 0x83, 0xC0, 0x01, 0x00, 0x7F, 0x07, 0xFC, 0x78, 0xF7, 0x83,
  0xB8, 0x1D, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1C, 0xE0, 0xE7,
  0x9E, 0x1F, 0xE0, 0x7E, 0x00, 0x00, 0x40, 0x7F, 0xC1, 0xFF, 0x87, 0x8F,
  0x3C, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0xF7, 0x03,
  0x9E, 0x1E, 0x7C, 0xF1, 0xFF, 0xC7, 0x7C, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x02, 0x00, 0x3F, 0x71, 0xFF, 0x8F, 0x1E, 0x78,
  0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0xE0, 0x73, 0x81, 0xCF, 0x07, 0x1C,
  0x1C, 0x79, 0xF1, 0xFF, 0xC3, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x00, 0x43, 0xBF, 0x3F, 0xF3, 0xFE, 0x7C, 0x07, 0x80,
  0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x00, 0x01, 0x00, 0x7F, 0x07, 0xFE, 0x70, 0x73, 0x83, 0x9C, 0x00,
  0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0x80, 0x1D, 0xC0, 0xE7, 0x0F, 0x3F,
  0xF0, 0x7F, 0x00, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x7F, 0xFF, 0xFF,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xE6, 0x1F, 0xE0, 0xFE, 0x70, 0x3B, 0x81, 0xDC, 0x1C, 0xE0,
  0xEE, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x1E, 0xE0, 0xE7, 0x07, 0x38, 0x39,
  0xE7, 0xCF, 0xFE, 0x3E, 0x70, 0xE0, 0x3F, 0x80, 0xE7, 0x07, 0x1C, 0x1C,
  0x70, 0xE1, 0xC3, 0x83, 0x1C, 0x0E, 0x70, 0x3B, 0x80, 0xEC, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x00, 0xC3, 0x1F, 0x1C, 0x7C, 0x71, 0xB3,
  0xCE, 0xCF, 0x3B, 0x3C, 0xCD, 0xB7, 0x36, 0xDC, 0xDB, 0x63, 0xCF, 0x8F,
  0x3C, 0x38, 0xF0, 0xE3, 0xC3, 0x86, 0x00, 0x3C, 0x0F, 0x1E, 0x1C, 0x0E,
  0x3C, 0x0F, 0x78, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x0E, 0xE0, 0x1C, 0xF0, 0x3C, 0x70, 0x78, 0x38, 0xF0, 0x3C, 0x38,
  0x07, 0x9E, 0x07, 0x07, 0x07, 0x83, 0x83, 0x81, 0xC3, 0xC0, 0xE1, 0xC0,
  0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x80, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x00, 0x00, 0xC0, 0xF0,
  0x38, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0xF0,
  0xF0, 0x3C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0x00, 0x1C, 0x61, 0x86, 0x18, 0x61, 0x8E,
  0x30, 0xC3, 0x0C, 0x31, 0xC6, 0x18, 0x61, 0x86, 0x18, 0xC3, 0x0C, 0x30,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x07, 0xC1, 0xE0, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0xF0, 0x08, 0x00,
  0x1C, 0x00, 0x7E, 0x0D, 0xFE, 0x3F, 0x1F, 0xEC, 0x1F, 0xC0, 0x0E, 0x00,
};

const GFXglyph RobotoMono_MediumItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 19, 16, 5, -19 },
  { 16, 8, 6, 16, 5, -20 },
  { 22, 16, 19, 16, 0, -19 },
  { 60, 14, 25, 16, 1, -22 },
  { 104, 13, 20, 16, 2, -20 },
  { 137, 15, 20, 16, 0, -20 },
  { 175, 3, 7, 16, 7, -20 },
  { 178, 9, 28, 16, 4, -22 },
  { 210, 9, 27, 16, 2, -21 },
  { 241, 13, 13, 16, 2, -19 },
  { 263, 14, 14, 16, 1, -16 },
  { 288, 5, 8, 16, 3, -3 },
  { 293, 11, 3, 16, 3, -10 },
  { 298, 4, 4, 16, 5, -4 },
  { 300, 14, 21, 16, 1, -19 },
  { 337, 13, 20, 16, 2, -20 },
  { 370, 9, 19, 16, 3, -19 },
  { 392, 14, 19, 16, 0, -19 },
  { 426, 13, 19, 16, 1, -19 },
  { 457, 14, 19, 16, 0, -19 },
  { 491, 14, 19, 16, 1, -19 },
  { 525, 13, 19, 16, 1, -19 },
  { 556, 14, 19, 16, 2, -19 },
  { 590, 14, 19, 16, 1, -19 },
  { 624, 12, 19, 16, 2, -19 },
  { 653, 6, 15, 16, 5, -15 },
  { 665, 8, 20, 16, 4, -15 },
  { 685, 12, 13, 16, 2, -15 },
  { 705, 14, 8, 16, 1, -12 },
  { 719, 13, 12, 16, 1, -14 },
  { 739, 12, 20, 16, 3, -20 },
  { 769, 15, 19, 16, 1, -19 },
  { 805, 15, 19, 16, -1, -19 },
  { 841, 15, 19, 16, 0, -19 },
  { 877, 14, 20, 16, 1, -20 },
  { 912, 15, 19, 16, 0, -19 },
  { 948, 15, 19, 16, 1, -19 },
  { 984, 15, 19, 16, 1, -19 },
  { 1020, 14, 19, 16, 1, -19 },
  { 1054, 16, 19, 16, 0, -19 },
  { 1092, 14, 19, 16, 1, -19 },
  { 1126, 15, 19, 16, 1, -19 },
  { 1162, 17, 19, 16, 0, -19 },
  { 1203, 12, 19, 16, 1, -19 },
  { 1232, 16, 19, 16, 0, -19 },
  { 1270, 16, 19, 16, 0, -19 },
  { 1308, 14, 19, 16, 1, -19 },
  { 1342, 15, 19, 16, 1, -19 },
  { 1378, 14, 22, 16, 1, -19 },
  { 1417, 15, 19, 16, 1, -19 },
  { 1453, 15, 19, 16, 1, -19 },
  { 1489, 15, 19, 16, 2, -19 },
  { 1525, 15, 19, 16, 1, -19 },
  { 1561, 15, 19, 16, 2, -19 },
  { 1597, 15, 19, 16, 2, -19 },
  { 1633, 18, 19, 16, -1, -19 },
  { 1676, 14, 19, 16, 3, -19 },
  { 1710, 16, 19, 16, 0, -19 },
  { 1748, 10, 26, 16, 3, -22 },
  { 1781, 6, 21, 16, 5, -19 },
  { 1797, 10, 26, 16, 3, -22 },
  { 1830, 10, 10, 16, 3, -19 },
  { 1843, 12, 2, 16, 0, 0 },
  { 1846, 5, 4, 16, 7, -20 },
  { 1849, 13, 15, 16, 1, -15 },
  { 1874, 13, 20, 16, 1, -20 },
  { 1907, 13, 15, 16, 1, -15 },
  { 1932, 15, 20, 16, 1, -20 },
  { 1970, 13, 15, 16, 1, -15 },
  { 1995, 15, 21, 16, 2, -21 },
  { 2035, 15, 21, 16, 0, -15 },
  { 2075, 13, 20, 16, 1, -20 },
  { 2108, 12, 20, 16, 1, -20 },
  { 2138, 12, 26, 16, 1, -20 },
  { 2177, 14, 20, 16, 1, -20 },
  { 2212, 12, 20, 16, 1, -20 },
  { 2242, 15, 15, 16, 0, -15 },
  { 2271, 13, 15, 16, 1, -15 },
  { 2296, 13, 15, 16, 1, -15 },
  { 2321, 14, 20, 16, 0, -15 },
  { 2356, 14, 20, 16, 1, -15 },
  { 2391, 12, 15, 16, 3, -15 },
  { 2414, 13, 15, 16, 1, -15 },
  { 2439, 12, 18, 16, 2, -18 },
  { 2466, 13, 14, 16, 2, -14 },
  { 2489, 14, 14, 16, 2, -14 },
  { 2514, 14, 14, 16, 2, -14 },
  { 2539, 16, 14, 16, 0, -14 },
  { 2567, 17, 20, 16, 0, -14 },
  { 2610, 15, 14, 16, 0, -14 },
  { 2637, 10, 26, 16, 4, -21 },
  { 2670, 6, 24, 16, 5, -19 },
  { 2688, 11, 26, 16, 2, -21 },
  { 2724, 15, 6, 16, 0, -11 },
};

const GFXfont RobotoMono_MediumItalic27pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic27pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOMONO_MEDIUMITALIC27PT7B_H_
