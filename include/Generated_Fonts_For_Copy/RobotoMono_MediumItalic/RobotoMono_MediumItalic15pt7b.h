#ifndef _ROBOTOMONO_MEDIUMITALIC15PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB4, 0xB0, 0x1B, 0x00, 0xD9, 0xB0, 0x0D, 0x04, 0x82, 0xCF,
  0xF7, 0xF8, 0xB0, 0x91, 0xFE, 0x2C, 0x24, 0x16, 0x00, 0x0C, 0x38, 0xFB,
  0x16, 0x2C, 0x0E, 0x06, 0x07, 0x8F, 0x33, 0xC2, 0x04, 0x00, 0x61, 0xA2,
  0x5D, 0xE6, 0x82, 0x0D, 0x1F, 0x52, 0xA4, 0x70, 0x0C, 0x1E, 0x32, 0x36,
  0x3C, 0x38, 0x79, 0x4F, 0xC7, 0x6E, 0x7B, 0xEA, 0x08, 0xCC, 0x46, 0x31,
  0x18, 0xC6, 0x30, 0x84, 0x30, 0x80, 0x20, 0x86, 0x10, 0x84, 0x21, 0x18,
  0xC4, 0x63, 0x33, 0x00, 0x08, 0x11, 0x2F, 0xF1, 0x85, 0x1B, 0x24, 0x18,
  0x30, 0x67, 0xFF, 0xE6, 0x0C, 0x18, 0x2D, 0xAC, 0xFC, 0xF0, 0x02, 0x0C,
  0x10, 0x60, 0x83, 0x04, 0x18, 0x60, 0xC3, 0x06, 0x00, 0x1C, 0x7D, 0x9A,
  0x3C, 0xFB, 0xF9, 0xE3, 0xC5, 0x99, 0xE0, 0x0B, 0xFD, 0x23, 0x18, 0xC6,
  0x23, 0x18, 0x1C, 0x3E, 0x63, 0x63, 0x02, 0x06, 0x0C, 0x18, 0x30, 0xE0,
  0xFE, 0x1E, 0x3F, 0x63, 0x03, 0x06, 0x1C, 0x06, 0x02, 0xC6, 0x66, 0x7C,
  0x03, 0x07, 0x0E, 0x1A, 0x16, 0x36, 0x66, 0xFF, 0xFF, 0x0C, 0x0C, 0x3F,
  0x3E, 0x60, 0x60, 0x7C, 0xEC, 0x06, 0x06, 0x84, 0xCC, 0x78, 0x0C, 0x79,
  0x82, 0x0F, 0xDD, 0xB1, 0xC3, 0xC5, 0x99, 0xE0, 0x7F, 0xFF, 0x06, 0x04,
  0x0C, 0x18, 0x18, 0x30, 0x20, 0x60, 0xC0, 0x1C, 0xFD, 0x9B, 0x36, 0x67,
  0x33, 0x63, 0x85, 0x99, 0xE0, 0x18, 0xF9, 0x1E, 0x3C, 0x78, 0xDF, 0x82,
  0x0C, 0x71, 0xC0, 0x6C, 0x00, 0x36, 0x39, 0x80, 0x00, 0x01, 0x8C, 0x62,
  0x20, 0x06, 0x3D, 0xC6, 0x07, 0x83, 0x81, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x40, 0xE0, 0x70, 0x77, 0x9C, 0x20, 0x00, 0x3B, 0xFC, 0x43, 0x0C,
  0x63, 0x18, 0x01, 0x86, 0x00, 0x04, 0x0D, 0x88, 0x49, 0xD5, 0x2A, 0xAA,
  0xD5, 0x7A, 0x56, 0x20, 0x0F, 0x00, 0x04, 0x0C, 0x0E, 0x1E, 0x16, 0x36,
  0x22, 0x7E, 0x7E, 0xC3, 0xC3, 0x3C, 0x1F, 0x88, 0x64, 0x26, 0x33, 0xF1,
  0x8C, 0xC6, 0x43, 0x23, 0x3F, 0x00, 0x1C, 0x7E, 0x62, 0xC3, 0xC0, 0xC0,
  0x80, 0x80, 0x86, 0xCC, 0x78, 0x3C, 0x3E, 0x23, 0x21, 0x61, 0x61, 0x63,
  0x63, 0x46, 0xCE, 0xF8, 0x3F, 0x9F, 0xCC, 0x04, 0x02, 0x03, 0xF1, 0x80,
  0xC0, 0x60, 0x20, 0x3F, 0x80, 0x3F, 0x9F, 0xCC, 0x04, 0x02, 0x03, 0xF9,
  0x80, 0xC0, 0x60, 0x20, 0x30, 0x00, 0x1C, 0x7E, 0x62, 0xC3, 0xC0, 0xC0,
  0x9E, 0x86, 0xC6, 0xCE, 0x7C, 0x31, 0x90, 0xC8, 0x4C, 0x26, 0x33, 0xF9,
  0x8C, 0x86, 0x42, 0x61, 0x31, 0x80, 0x7F, 0x7E, 0x18, 0x18, 0x18, 0x10,
  0x30, 0x30, 0x30, 0x30, 0xFC, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18,
  0x0D, 0x06, 0x46, 0x33, 0x0F, 0x00, 0x31, 0xCC, 0xE2, 0x30, 0x98, 0x6C,
  0x1E, 0x07, 0xC1, 0xB0, 0x46, 0x11, 0x8C, 0x30, 0x30, 0x60, 0xC1, 0x02,
  0x0C, 0x18, 0x30, 0x60, 0x83, 0xF8, 0x31, 0x99, 0xCC, 0xEE, 0xE7, 0xD3,
  0xE9, 0xAC, 0x96, 0x43, 0x61, 0x30, 0x80, 0x31, 0x98, 0xCC, 0x4F, 0x27,
  0xB3, 0x59, 0xAC, 0xDE, 0x46, 0x63, 0x31, 0x80, 0x1C, 0xFD, 0x9E, 0x1C,
  0x38, 0x61, 0xC3, 0x85, 0x99, 0xE0, 0x3E, 0x1F, 0x8C, 0x64, 0x32, 0x1B,
  0x39, 0xF8, 0xC0, 0x60, 0x20, 0x30, 0x00, 0x1C, 0xFD, 0x8E, 0x1C, 0x38,
  0x61, 0xC3, 0x87, 0x99, 0xE0, 0x70, 0x40, 0x3C, 0x1F, 0x8C, 0x64, 0x36,
  0x33, 0xF9, 0xF0, 0xCC, 0x46, 0x23, 0x30, 0xC0, 0x0E, 0x1F, 0x8C, 0x64,
  0x03, 0x00, 0xE0, 0x18, 0x06, 0x43, 0x33, 0x0F, 0x00, 0xFF, 0xFF, 0x86,
  0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x63, 0x63,
  0x43, 0xC2, 0xC6, 0xC6, 0xC6, 0xC6, 0xC4, 0xCC, 0x78, 0xC3, 0x43, 0x42,
  0x66, 0x64, 0x6C, 0x6C, 0x78, 0x38, 0x30, 0x30, 0xC9, 0xEC, 0xB6, 0xDB,
  0x6F, 0xA7, 0x53, 0xB9, 0xD8, 0xCC, 0x66, 0x33, 0x00, 0x61, 0x98, 0xCC,
  0xC2, 0xC1, 0xE0, 0x60, 0x70, 0x68, 0x66, 0x33, 0x30, 0xC0, 0xC1, 0xB1,
  0x99, 0x8C, 0xC2, 0xC1, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x3F,
  0xBF, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x60, 0xBF, 0x80,
  0x39, 0x88, 0x46, 0x31, 0x8C, 0x42, 0x31, 0x8C, 0x70, 0x9B, 0x64, 0x93,
  0x6C, 0x90, 0x38, 0xC6, 0x31, 0x08, 0xC6, 0x31, 0x88, 0x46, 0x70, 0x11,
  0x8E, 0xFC, 0xC4, 0xFE, 0xCC, 0x3C, 0xDA, 0x1B, 0xEC, 0x51, 0xB7, 0x7E,
  0x30, 0x30, 0x30, 0x2E, 0x77, 0x63, 0x63, 0x63, 0x62, 0x66, 0xDC, 0x3C,
  0xDF, 0x1E, 0x0C, 0x18, 0xB3, 0x3C, 0x03, 0x02, 0x02, 0x3E, 0x6E, 0xC6,
  0xC6, 0x84, 0xC4, 0xCC, 0x7C, 0x3C, 0xCF, 0x1F, 0xFF, 0xF8, 0x33, 0x3C,
  0x02, 0x0F, 0x18, 0x10, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60,
  0x1D, 0x37, 0x63, 0x63, 0x43, 0x62, 0x66, 0x3E, 0x06, 0xCC, 0x78, 0x30,
  0x30, 0x20, 0x2E, 0x77, 0x63, 0x63, 0x63, 0x42, 0x42, 0xC6, 0x0C, 0x30,
  0x1E, 0x78, 0x61, 0x84, 0x10, 0xCF, 0xC0, 0x06, 0x0C, 0x00, 0xF1, 0xC0,
  0x83, 0x06, 0x0C, 0x18, 0x20, 0x41, 0x9E, 0x00, 0x30, 0x18, 0x0C, 0x04,
  0x76, 0x63, 0x61, 0xE0, 0xF8, 0x6C, 0x23, 0x31, 0xC0, 0x7C, 0x20, 0x86,
  0x18, 0x61, 0x84, 0x10, 0xCF, 0xC0, 0x7B, 0x6D, 0x49, 0x49, 0xDB, 0xDB,
  0xDB, 0x92, 0x2E, 0x73, 0x63, 0x63, 0x63, 0x42, 0x42, 0xC6, 0x3C, 0xDB,
  0x1E, 0x38, 0x70, 0xB3, 0x3C, 0x2E, 0x77, 0x63, 0x63, 0x63, 0x42, 0x66,
  0xFC, 0xC0, 0xC0, 0xC0, 0x3A, 0xDF, 0x1E, 0x38, 0x58, 0xB3, 0x3E, 0x0C,
  0x18, 0x20, 0x2E, 0x7D, 0x83, 0x06, 0x0C, 0x10, 0x60, 0x3C, 0xCF, 0x03,
  0x83, 0xC0, 0xB3, 0x3C, 0x10, 0x23, 0xF9, 0x83, 0x06, 0x08, 0x10, 0x34,
  0x78, 0x42, 0x8F, 0x1E, 0x3C, 0x78, 0xB3, 0x3E, 0xC3, 0xC6, 0x44, 0x4C,
  0x68, 0x78, 0x30, 0x30, 0x9B, 0x9B, 0xBA, 0xAE, 0xAC, 0xCC, 0xCC, 0xC8,
  0x63, 0x99, 0x85, 0x83, 0x81, 0xC1, 0xE1, 0x99, 0x8E, 0x61, 0xB1, 0x88,
  0xC6, 0xC3, 0x61, 0xE0, 0x60, 0x30, 0x30, 0x18, 0x38, 0x00, 0x3F, 0x7F,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xFE, 0x04, 0x21, 0x84, 0x10, 0xC3, 0x30,
  0x60, 0x82, 0x08, 0x20, 0xC1, 0x00, 0x25, 0xA4, 0x92, 0x5A, 0x49, 0x00,
  0x20, 0x41, 0x86, 0x18, 0x61, 0x83, 0x18, 0xC3, 0x0C, 0x21, 0x88, 0x00,
  0x71, 0xD9, 0x8F,
};

const GFXglyph RobotoMono_MediumItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 4, 3, 9, 3, -11 },
  { 8, 9, 11, 9, 0, -11 },
  { 21, 7, 14, 9, 1, -12 },
  { 34, 7, 11, 9, 1, -11 },
  { 44, 8, 11, 9, 0, -11 },
  { 55, 2, 4, 9, 4, -11 },
  { 56, 5, 15, 9, 2, -12 },
  { 66, 5, 15, 9, 1, -12 },
  { 76, 7, 8, 9, 1, -11 },
  { 83, 7, 8, 9, 1, -9 },
  { 90, 3, 5, 9, 1, -2 },
  { 92, 6, 1, 9, 2, -5 },
  { 93, 2, 2, 9, 3, -2 },
  { 94, 7, 12, 9, 1, -11 },
  { 105, 7, 11, 9, 1, -11 },
  { 115, 5, 11, 9, 2, -11 },
  { 122, 8, 11, 9, 0, -11 },
  { 133, 8, 11, 9, 0, -11 },
  { 144, 8, 11, 9, 0, -11 },
  { 155, 8, 11, 9, 1, -11 },
  { 166, 7, 11, 9, 1, -11 },
  { 176, 8, 11, 9, 1, -11 },
  { 187, 7, 11, 9, 1, -11 },
  { 197, 7, 11, 9, 1, -11 },
  { 207, 3, 8, 9, 3, -8 },
  { 210, 5, 11, 9, 2, -8 },
  { 217, 7, 7, 9, 1, -8 },
  { 224, 7, 5, 9, 1, -7 },
  { 229, 7, 7, 9, 1, -8 },
  { 236, 6, 11, 9, 2, -11 },
  { 245, 9, 11, 9, 0, -11 },
  { 258, 8, 11, 9, 0, -11 },
  { 269, 9, 11, 9, 0, -11 },
  { 282, 8, 11, 9, 1, -11 },
  { 293, 8, 11, 9, 0, -11 },
  { 304, 9, 11, 9, 0, -11 },
  { 317, 9, 11, 9, 0, -11 },
  { 330, 8, 11, 9, 1, -11 },
  { 341, 9, 11, 9, 0, -11 },
  { 354, 8, 11, 9, 1, -11 },
  { 365, 9, 11, 9, 0, -11 },
  { 378, 10, 11, 9, 0, -11 },
  { 392, 7, 11, 9, 0, -11 },
  { 402, 9, 11, 9, 0, -11 },
  { 415, 9, 11, 9, 0, -11 },
  { 428, 7, 11, 9, 1, -11 },
  { 438, 9, 11, 9, 0, -11 },
  { 451, 7, 13, 9, 1, -11 },
  { 463, 9, 11, 9, 0, -11 },
  { 476, 9, 11, 9, 0, -11 },
  { 489, 9, 11, 9, 1, -11 },
  { 502, 8, 11, 9, 1, -11 },
  { 513, 8, 11, 9, 1, -11 },
  { 524, 9, 11, 9, 1, -11 },
  { 537, 9, 11, 9, 0, -11 },
  { 550, 9, 11, 9, 1, -11 },
  { 563, 9, 11, 9, 0, -11 },
  { 576, 5, 14, 9, 2, -12 },
  { 585, 3, 12, 9, 3, -11 },
  { 590, 5, 14, 9, 2, -12 },
  { 599, 5, 6, 9, 2, -11 },
  { 603, 7, 1, 9, 0, 0 },
  { 604, 3, 2, 9, 4, -11 },
  { 605, 7, 8, 9, 1, -8 },
  { 612, 8, 11, 9, 0, -11 },
  { 623, 7, 8, 9, 1, -8 },
  { 630, 8, 11, 9, 1, -11 },
  { 641, 7, 8, 9, 1, -8 },
  { 648, 8, 12, 9, 1, -12 },
  { 660, 8, 11, 9, 0, -8 },
  { 671, 8, 11, 9, 0, -11 },
  { 682, 6, 11, 9, 1, -11 },
  { 691, 7, 14, 9, 0, -11 },
  { 704, 9, 11, 9, 0, -11 },
  { 717, 6, 11, 9, 1, -11 },
  { 726, 8, 8, 9, 0, -8 },
  { 734, 8, 8, 9, 0, -8 },
  { 742, 7, 8, 9, 1, -8 },
  { 749, 8, 11, 9, 0, -8 },
  { 760, 7, 11, 9, 1, -8 },
  { 770, 7, 8, 9, 1, -8 },
  { 777, 7, 8, 9, 1, -8 },
  { 784, 7, 10, 9, 1, -10 },
  { 793, 7, 8, 9, 1, -8 },
  { 800, 8, 8, 9, 1, -8 },
  { 808, 8, 8, 9, 1, -8 },
  { 816, 9, 8, 9, 0, -8 },
  { 825, 9, 11, 9, 0, -8 },
  { 838, 8, 8, 9, 0, -8 },
  { 846, 6, 15, 9, 2, -12 },
  { 858, 3, 14, 9, 3, -11 },
  { 864, 6, 15, 9, 1, -12 },
  { 876, 8, 3, 9, 0, -6 },
};

const GFXfont RobotoMono_MediumItalic15pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic15pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOMONO_MEDIUMITALIC15PT7B_H_
