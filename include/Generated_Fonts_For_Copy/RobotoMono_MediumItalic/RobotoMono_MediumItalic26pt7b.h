#ifndef _ROBOTOMONO_MEDIUMITALIC26PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x63, 0x8E, 0x38, 0xE3, 0x8C, 0x71, 0xC7, 0x1C, 0x00, 0x00,
  0x38, 0xE3, 0x80, 0x67, 0x67, 0xE6, 0xC6, 0xC6, 0xC6, 0xCE, 0x01, 0xCE,
  0x03, 0x18, 0x06, 0x70, 0x18, 0xC0, 0x31, 0x87, 0xFF, 0xCF, 0xFF, 0x83,
  0x18, 0x06, 0x60, 0x18, 0xC0, 0x31, 0x87, 0xFF, 0xCF, 0xFF, 0x83, 0x18,
  0x0E, 0x60, 0x18, 0xC0, 0x31, 0x80, 0xC6, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x01, 0xFC, 0x1F, 0xF8, 0x70, 0xE3, 0xC3, 0x8E, 0x07, 0x38, 0x00,
  0x70, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x38, 0x1C,
  0xE0, 0x71, 0xC1, 0xC7, 0x8F, 0x0F, 0xF8, 0x1F, 0x80, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x38, 0x07, 0xC0, 0xCE, 0x0C, 0xE6, 0xCE, 0x6C, 0xCC, 0xFD,
  0x87, 0xB8, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xDC, 0x1B, 0xF3, 0x73, 0x36,
  0x36, 0x63, 0x26, 0x30, 0x7E, 0x03, 0xC0, 0x01, 0xC0, 0x0F, 0xE0, 0x3F,
  0xC0, 0x71, 0x80, 0xC3, 0x01, 0x8E, 0x03, 0xBC, 0x07, 0xF0, 0x0F, 0x80,
  0x1E, 0x00, 0x7E, 0x39, 0xDC, 0x67, 0x1D, 0xCE, 0x3B, 0x9C, 0x3E, 0x38,
  0x78, 0x79, 0xF0, 0xFF, 0xF0, 0x7E, 0xF0, 0x6F, 0xFD, 0xB0, 0x00, 0x81,
  0xC1, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0x80,
  0xE0, 0x30, 0x0C, 0x02, 0x00, 0x08, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18,
  0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07,
  0x03, 0x81, 0x81, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x70, 0x20, 0x00,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0xC6, 0x27, 0xBF, 0x7F, 0xFC, 0x1E, 0x01,
  0xE0, 0x1F, 0x81, 0xCC, 0x1C, 0x70, 0x41, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0xE3, 0x8E, 0x39, 0xCE, 0x10,
  0xFF, 0xFF, 0xF0, 0xEF, 0xFE, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0x07, 0x01, 0xFC, 0x3F, 0xE3, 0x87, 0x70, 0x77,
  0x07, 0x70, 0x7E, 0x0F, 0xE3, 0xFE, 0x77, 0xFE, 0x7F, 0x8E, 0xF0, 0xEC,
  0x0E, 0xE0, 0xEE, 0x1C, 0xF3, 0xC7, 0xF8, 0x3F, 0x00, 0x03, 0x8F, 0x9F,
  0xDF, 0xEC, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0x3F, 0xC1, 0xFF, 0x87,
  0x0E, 0x38, 0x3C, 0xE0, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x0B,
  0xFF, 0xCF, 0xFF, 0x00, 0x03, 0x80, 0x7F, 0x07, 0xFC, 0x70, 0xF3, 0x83,
  0xA0, 0x1C, 0x00, 0xE0, 0x0E, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x01, 0xC0,
  0x07, 0x00, 0x3B, 0x81, 0xDC, 0x1C, 0xF1, 0xE3, 0xFE, 0x0F, 0xC0, 0x00,
  0x38, 0x01, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xB8, 0x0C, 0xC0, 0x77, 0x03,
  0x9C, 0x1C, 0x70, 0xE1, 0xC3, 0x07, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x0F, 0xFC, 0x3F, 0xF1, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0xFC, 0x0F, 0xF8, 0x3D, 0xF0, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x73, 0x81, 0xCF, 0x0F, 0x1E, 0x78, 0x3F,
  0xC0, 0x7E, 0x00, 0x00, 0x20, 0x3E, 0x07, 0xE0, 0xF0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x7C, 0x7F, 0xE7, 0xCF, 0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x77, 0x0E, 0x79, 0xE3, 0xFC, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFE, 0x38, 0x73, 0x83, 0x9C, 0x1C,
  0xE0, 0xE7, 0x8E, 0x1F, 0xE0, 0x7E, 0x0F, 0xF8, 0xF1, 0xE7, 0x07, 0x70,
  0x3B, 0x81, 0xDC, 0x1E, 0x71, 0xE3, 0xFE, 0x0F, 0xE0, 0x07, 0x01, 0xFC,
  0x3F, 0xE7, 0x8E, 0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0E,
  0x7B, 0xE7, 0xFE, 0x1E, 0xE0, 0x1C, 0x01, 0xC0, 0x78, 0x7F, 0x07, 0xE0,
  0x78, 0x00, 0x18, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0xF3,
  0xCF, 0x00, 0x0E, 0x3C, 0x78, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x87, 0x0C, 0x38, 0x71, 0xC3, 0x82, 0x00, 0x00, 0x30, 0x0F, 0x03,
  0xE1, 0xFC, 0x7E, 0x0F, 0x80, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01,
  0xC0, 0x04, 0x3F, 0xF9, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF9,
  0xFF, 0xDF, 0xFE, 0x20, 0x03, 0x80, 0x3E, 0x01, 0xFC, 0x03, 0xF0, 0x0F,
  0x01, 0xF0, 0xFE, 0x3F, 0x87, 0xC0, 0xF0, 0x08, 0x00, 0x0F, 0x07, 0xF9,
  0xFF, 0xB8, 0x7E, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x38,
  0x0E, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x38, 0x07, 0x00, 0xE0, 0x00,
  0x07, 0xF0, 0x3D, 0xE1, 0x81, 0x8C, 0x23, 0x33, 0xED, 0x99, 0xB6, 0xC4,
  0xF3, 0x33, 0xC8, 0xCF, 0x63, 0x2D, 0x88, 0xB6, 0x66, 0xDF, 0xF3, 0x3B,
  0x8C, 0x00, 0x18, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x7E, 0x01, 0xF8, 0x0E, 0xE0, 0x3B, 0x81, 0xCE, 0x07, 0x38,
  0x38, 0x60, 0xE1, 0x87, 0xFF, 0x1F, 0xFC, 0xFF, 0xF3, 0x81, 0xDE, 0x07,
  0x70, 0x1F, 0xC0, 0x70, 0x0F, 0xF8, 0x3F, 0xF8, 0x70, 0x78, 0xE0, 0x71,
  0xC0, 0xE3, 0x83, 0xCE, 0x07, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF0, 0xE0,
  0xF1, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x3C, 0xFC, 0x7F, 0xF1,
  0xFF, 0x80, 0x03, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0x0E, 0x38, 0x1D, 0xC0,
  0x77, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0xEE, 0x07, 0x1C, 0x1C, 0x79, 0xE0, 0xFF, 0x01, 0xF8, 0x00,
  0x1F, 0xE0, 0x3F, 0xF0, 0x70, 0xE0, 0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x8E,
  0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x73, 0xC0, 0xE7, 0x03,
  0x8E, 0x0F, 0x1C, 0x3C, 0x39, 0xF0, 0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xFC,
  0x7F, 0xF3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1F, 0xFC,
  0x7F, 0xF1, 0xFF, 0xC7, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xF8, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x7F, 0xF0, 0xFF,
  0xE1, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x3F, 0xC1, 0xFF, 0x87, 0x0E, 0x38,
  0x1D, 0xE0, 0x77, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x1F, 0xB8,
  0x7E, 0xE0, 0x3B, 0x80, 0xEE, 0x07, 0x1C, 0x1C, 0x78, 0xF0, 0xFF, 0x81,
  0xFC, 0x00, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xC7,
  0x03, 0x8E, 0x07, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xE0, 0x63, 0x81,
  0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x60, 0x71, 0xC0, 0xE0,
  0x1F, 0xFC, 0x7F, 0xE0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x73, 0x81, 0xCE, 0x0E, 0x3C, 0x78,
  0x7F, 0xC0, 0xFC, 0x00, 0x0E, 0x0F, 0x8E, 0x0F, 0x07, 0x0F, 0x03, 0x8F,
  0x01, 0xCF, 0x00, 0xE7, 0x00, 0xE7, 0x00, 0x77, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x0F, 0x70, 0x07, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x81, 0xC1, 0xC0,
  0xE0, 0xF0, 0x70, 0x38, 0x78, 0x1E, 0x00, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x1F,
  0x1E, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1B, 0x7E, 0x1B, 0x6E, 0x3B, 0xEC,
  0x3B, 0xDC, 0x3B, 0xDC, 0x3B, 0x9C, 0x33, 0x9C, 0x73, 0x1C, 0x70, 0x18,
  0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0x60, 0x38, 0xE0, 0x30, 0x1E, 0x0E,
  0x3C, 0x1C, 0x78, 0x38, 0xF8, 0x71, 0xF1, 0xC7, 0x63, 0x8E, 0xC7, 0x1D,
  0xCE, 0x3B, 0x9C, 0x73, 0x38, 0xE7, 0xE3, 0x8F, 0xC7, 0x0F, 0x8E, 0x1F,
  0x1C, 0x3E, 0x38, 0x7C, 0x70, 0x71, 0xC0, 0xE0, 0x03, 0x80, 0x3F, 0xC1,
  0xFF, 0x0F, 0x0E, 0x38, 0x39, 0xC0, 0xE7, 0x01, 0xDC, 0x07, 0x70, 0x3B,
  0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x81, 0xCE, 0x07, 0x1C, 0x3C,
  0x79, 0xE0, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xE3, 0x83, 0xCE,
  0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0E, 0x7F, 0xF9, 0xFF, 0xC7,
  0xFC, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x3F, 0xC1, 0xFF, 0x0F, 0x0E, 0x38, 0x39, 0xC0,
  0x77, 0x01, 0xDC, 0x07, 0x70, 0x1F, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0,
  0x3B, 0x80, 0xEE, 0x07, 0x1C, 0x3C, 0x79, 0xE0, 0xFF, 0x01, 0xFC, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0x80, 0x1F, 0xF0, 0xFF, 0xE3, 0x83, 0x8E, 0x07,
  0x38, 0x1C, 0xE0, 0x73, 0x83, 0xDC, 0x1E, 0x7F, 0xF1, 0xFF, 0x87, 0xFC,
  0x1C, 0x70, 0x61, 0xC3, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0x73, 0x81,
  0xC0, 0x03, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0x0F, 0x38, 0x1C, 0xE0, 0x73,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x7B,
  0x80, 0xEE, 0x03, 0xB8, 0x1C, 0x78, 0xF1, 0xFF, 0x81, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x1C, 0xE0, 0x73, 0x81,
  0xCE, 0x07, 0x38, 0x1D, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0,
  0xE7, 0x03, 0xB8, 0x1C, 0xE0, 0x73, 0x81, 0xC7, 0x0E, 0x1E, 0x78, 0x3F,
  0xC0, 0x7E, 0x00, 0xF0, 0x3D, 0xC0, 0xE7, 0x03, 0x9C, 0x1C, 0x70, 0x71,
  0xC3, 0xC7, 0x0E, 0x1C, 0x38, 0x31, 0xC0, 0xE7, 0x03, 0xB8, 0x0E, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x00, 0xE3,
  0x1F, 0x8C, 0x7E, 0x71, 0xF9, 0xC6, 0xE7, 0x3B, 0xBC, 0xEE, 0xF3, 0x3B,
  0xCC, 0xFF, 0x73, 0xED, 0xCD, 0xB6, 0x3E, 0xF8, 0xF3, 0xE3, 0xCF, 0x8F,
  0x3C, 0x38, 0xF0, 0xE3, 0xC3, 0x8E, 0x00, 0x0E, 0x07, 0x87, 0x87, 0x81,
  0xC3, 0x80, 0xE3, 0xC0, 0x3B, 0xC0, 0x1D, 0xC0, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xEE, 0x00, 0xF7, 0x00, 0x71,
  0xC0, 0x70, 0xE0, 0x78, 0x78, 0x78, 0x1C, 0x78, 0x0F, 0x00, 0xF0, 0x1E,
  0xE0, 0x71, 0xC1, 0xE1, 0xC3, 0x83, 0x8E, 0x07, 0x1C, 0x06, 0x70, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1F, 0xFE, 0x3F, 0xFC,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x0F, 0x87, 0xC3, 0x81, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xF8, 0xFC, 0x00, 0xE3,
  0x8E, 0x18, 0x61, 0xC7, 0x1C, 0x70, 0xC3, 0x0E, 0x38, 0xE3, 0x86, 0x18,
  0x71, 0xC7, 0x0F, 0x87, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x03,
  0x81, 0xC0, 0xE0, 0x71, 0xF8, 0xF8, 0x00, 0x07, 0x03, 0xC0, 0xF0, 0x7C,
  0x1B, 0x8E, 0x67, 0x19, 0x86, 0xE1, 0xC0, 0xFF, 0xFF, 0xFF, 0xE3, 0x8C,
  0x70, 0x0F, 0xC1, 0xFE, 0x3C, 0xF7, 0x87, 0x00, 0x70, 0x07, 0x3F, 0xF7,
  0xFF, 0xF0, 0x7E, 0x0E, 0xE0, 0xEF, 0x3E, 0x7F, 0xE3, 0xEE, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xEF, 0x07, 0xFC, 0x3F,
  0xF3, 0xC3, 0x9C, 0x1E, 0xE0, 0x77, 0x03, 0xB8, 0x39, 0xC1, 0xDC, 0x0E,
  0xF0, 0xF7, 0xCF, 0x3F, 0xF1, 0xDF, 0x00, 0x07, 0xC0, 0xFF, 0x0F, 0xBC,
  0x70, 0xE7, 0x03, 0xB8, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x03, 0x9C,
  0x3C, 0xF3, 0xC3, 0xFC, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0xFB, 0x87, 0xFE, 0x3F, 0xF9, 0xE1, 0xE7,
  0x03, 0x9C, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0x70, 0xE1,
  0xE7, 0x87, 0xFE, 0x0F, 0xB8, 0x07, 0xC0, 0xFF, 0x0F, 0xBC, 0x70, 0xE7,
  0x03, 0xB8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x1C, 0x08, 0xF1,
  0xE3, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xF0, 0x3C, 0xC1, 0xC0, 0x07,
  0x00, 0x38, 0x07, 0xFF, 0x1F, 0xFC, 0xFF, 0xF0, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x07, 0xCC, 0x3F, 0xF1, 0xFF, 0xCF, 0x0F, 0x38, 0x1C,
  0xE0, 0xE3, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE3, 0x87, 0x8F, 0x3C,
  0x3F, 0xF0, 0x7D, 0xC0, 0x07, 0x10, 0x3C, 0x61, 0xE3, 0xFF, 0x03, 0xF8,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE7,
  0x87, 0xFE, 0x3F, 0xF3, 0xC3, 0xDC, 0x0E, 0xE0, 0x77, 0x07, 0x38, 0x39,
  0xC1, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x39, 0xC1, 0xC0, 0x00, 0xC0,
  0x1E, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0xC3, 0xF8, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x7F, 0xF7,
  0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xC3,
  0xF0, 0xFE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x3F, 0x87, 0xE0,
  0x60, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x83, 0xCE, 0x1E, 0x38, 0xE1, 0xCF, 0x07, 0x78, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xB8, 0x3C, 0xE0, 0xE1, 0xC3, 0x87, 0x8E, 0x0E, 0x38,
  0x3C, 0x0F, 0xE1, 0xFE, 0x1F, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x3B, 0xB8, 0xDF, 0xF3, 0xFF,
  0xDC, 0x63, 0x73, 0x8D, 0xCE, 0x77, 0x39, 0xDC, 0xE7, 0x63, 0x9F, 0x8C,
  0x7E, 0x71, 0xB9, 0xCE, 0xE7, 0x3B, 0x9C, 0xE0, 0x3B, 0xE1, 0xBF, 0x8F,
  0xFC, 0xF0, 0xF7, 0x03, 0xB8, 0x1D, 0xC1, 0xCE, 0x0E, 0x70, 0x77, 0x03,
  0xB8, 0x1D, 0xC0, 0xEE, 0x0E, 0x70, 0x70, 0x07, 0xC0, 0xFF, 0x0F, 0xFC,
  0xF0, 0xE7, 0x03, 0xB8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x77, 0x03, 0xBC,
  0x3C, 0xF3, 0xC3, 0xFC, 0x0F, 0xC0, 0x1D, 0xE0, 0x6F, 0xC1, 0xFF, 0x8F,
  0x0E, 0x38, 0x38, 0xE0, 0x73, 0x81, 0x8E, 0x0E, 0x38, 0x39, 0xC0, 0xE7,
  0x07, 0x9E, 0x3C, 0x7F, 0xE1, 0xDF, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x0F, 0xB8, 0xFF, 0xCF, 0xBE, 0xF0, 0xF7, 0x03,
  0xB8, 0x39, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0x9C, 0x38, 0xF3, 0xC7,
  0xFE, 0x1F, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x1C,
  0xF8, 0xDF, 0x8F, 0xFC, 0x7C, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0x07, 0xC0,
  0xFF, 0x8F, 0x3C, 0x70, 0x73, 0x00, 0x1C, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xF0, 0x03, 0xB8, 0x1C, 0xE1, 0xE7, 0xFE, 0x0F, 0xC0, 0x0E, 0x00, 0xE0,
  0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x1C, 0x41, 0xFC, 0x0F, 0xC0, 0x70,
  0x77, 0x07, 0x70, 0x76, 0x07, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0,
  0xEE, 0x0E, 0xE1, 0xEF, 0x3C, 0xFE, 0xC7, 0xDC, 0xE0, 0x3F, 0x03, 0xB8,
  0x1C, 0xE1, 0xC7, 0x0E, 0x38, 0xE1, 0xC7, 0x06, 0x70, 0x33, 0x81, 0xF8,
  0x0F, 0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xC7, 0x1F, 0x1C, 0x6C, 0x73,
  0xB3, 0xCE, 0xCF, 0x33, 0x3D, 0xCD, 0xB6, 0x36, 0xD8, 0xF3, 0xE3, 0xCF,
  0x0F, 0x3C, 0x38, 0xF0, 0xE3, 0x83, 0x0E, 0x00, 0x3C, 0x0E, 0x38, 0x38,
  0x38, 0xE0, 0x73, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1D, 0xC0, 0x73, 0x81, 0xE3, 0x87, 0x87, 0x1E, 0x07, 0x00, 0x38,
  0x0F, 0x38, 0x0E, 0x38, 0x1E, 0x1C, 0x1C, 0x1C, 0x38, 0x1C, 0x38, 0x1C,
  0x70, 0x0E, 0xF0, 0x0E, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x60, 0x00, 0x1F, 0xFC, 0x7F, 0xF3, 0xFF, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0x7F, 0xFB, 0xFF, 0xE0, 0x01, 0xC0, 0xF0, 0x70, 0x18, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x07, 0x03, 0xC3, 0xC0, 0xE0, 0x1C, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x30, 0x04, 0x00,
  0x18, 0xC6, 0x31, 0x98, 0xC6, 0x31, 0x8C, 0xC6, 0x31, 0x8C, 0x67, 0x31,
  0x8C, 0x63, 0x00, 0x0C, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0F, 0x03, 0xC1, 0xE0, 0xE0, 0x38, 0x0C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x07, 0x83, 0xC0, 0x40, 0x00, 0x3E,
  0x0D, 0xFC, 0x36, 0x7D, 0xF0, 0x7E, 0x00, 0xF0,
};

const GFXglyph RobotoMono_MediumItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 6, 18, 15, 5, -18 },
  { 15, 8, 7, 15, 5, -20 },
  { 22, 15, 18, 15, 0, -18 },
  { 56, 14, 24, 15, 1, -21 },
  { 98, 12, 19, 15, 2, -19 },
  { 127, 15, 19, 15, 0, -19 },
  { 163, 3, 7, 15, 7, -20 },
  { 166, 9, 27, 15, 4, -21 },
  { 197, 9, 27, 15, 2, -21 },
  { 228, 13, 12, 15, 2, -18 },
  { 248, 13, 13, 15, 1, -15 },
  { 270, 6, 8, 15, 2, -3 },
  { 276, 10, 2, 15, 3, -9 },
  { 279, 4, 4, 15, 5, -4 },
  { 281, 14, 20, 15, 1, -18 },
  { 316, 12, 19, 15, 2, -19 },
  { 345, 9, 18, 15, 3, -18 },
  { 366, 14, 19, 15, 0, -19 },
  { 400, 13, 19, 15, 1, -19 },
  { 431, 14, 18, 15, 0, -18 },
  { 463, 14, 18, 15, 1, -18 },
  { 495, 12, 19, 15, 1, -19 },
  { 524, 13, 18, 15, 2, -18 },
  { 554, 13, 19, 15, 1, -19 },
  { 585, 12, 19, 15, 2, -19 },
  { 614, 6, 15, 15, 5, -15 },
  { 626, 7, 20, 15, 4, -15 },
  { 644, 12, 12, 15, 2, -14 },
  { 662, 13, 8, 15, 1, -12 },
  { 675, 12, 12, 15, 1, -14 },
  { 693, 11, 19, 15, 3, -19 },
  { 720, 14, 18, 15, 1, -18 },
  { 752, 14, 18, 15, -1, -18 },
  { 784, 15, 18, 15, 0, -18 },
  { 818, 14, 19, 15, 1, -19 },
  { 852, 15, 18, 15, 0, -18 },
  { 886, 14, 18, 15, 1, -18 },
  { 918, 15, 18, 15, 1, -18 },
  { 952, 14, 19, 15, 1, -19 },
  { 986, 15, 18, 15, 0, -18 },
  { 1020, 14, 18, 15, 1, -18 },
  { 1052, 14, 18, 15, 1, -18 },
  { 1084, 17, 18, 15, 0, -18 },
  { 1123, 12, 18, 15, 1, -18 },
  { 1150, 16, 18, 15, 0, -18 },
  { 1186, 15, 18, 15, 0, -18 },
  { 1220, 14, 19, 15, 1, -19 },
  { 1254, 14, 18, 15, 1, -18 },
  { 1286, 14, 22, 15, 1, -19 },
  { 1325, 14, 18, 15, 1, -18 },
  { 1357, 14, 19, 15, 1, -19 },
  { 1391, 14, 18, 15, 2, -18 },
  { 1423, 14, 18, 15, 1, -18 },
  { 1455, 14, 18, 15, 2, -18 },
  { 1487, 14, 18, 15, 2, -18 },
  { 1519, 17, 18, 15, -1, -18 },
  { 1558, 15, 18, 15, 2, -18 },
  { 1592, 15, 18, 15, 0, -18 },
  { 1626, 9, 25, 15, 3, -21 },
  { 1655, 6, 20, 15, 5, -18 },
  { 1670, 9, 25, 15, 3, -21 },
  { 1699, 10, 9, 15, 3, -18 },
  { 1711, 12, 2, 15, 0, 0 },
  { 1714, 5, 4, 15, 7, -19 },
  { 1717, 12, 14, 15, 1, -14 },
  { 1738, 13, 20, 15, 1, -20 },
  { 1771, 13, 14, 15, 1, -14 },
  { 1794, 14, 20, 15, 1, -20 },
  { 1829, 13, 14, 15, 1, -14 },
  { 1852, 14, 20, 15, 2, -20 },
  { 1887, 14, 19, 15, 0, -14 },
  { 1921, 13, 20, 15, 1, -20 },
  { 1954, 12, 19, 15, 1, -19 },
  { 1983, 11, 25, 15, 1, -19 },
  { 2018, 14, 20, 15, 1, -20 },
  { 2053, 12, 20, 15, 1, -20 },
  { 2083, 14, 14, 15, 0, -14 },
  { 2108, 13, 14, 15, 1, -14 },
  { 2131, 13, 14, 15, 1, -14 },
  { 2154, 14, 19, 15, 0, -14 },
  { 2188, 13, 19, 15, 1, -14 },
  { 2219, 13, 14, 15, 2, -14 },
  { 2242, 13, 14, 15, 1, -14 },
  { 2265, 12, 17, 15, 2, -17 },
  { 2291, 12, 14, 15, 2, -14 },
  { 2312, 13, 14, 15, 2, -14 },
  { 2335, 14, 14, 15, 2, -14 },
  { 2360, 15, 14, 15, 0, -14 },
  { 2387, 16, 20, 15, 0, -14 },
  { 2427, 14, 14, 15, 0, -14 },
  { 2452, 10, 25, 15, 4, -20 },
  { 2484, 5, 23, 15, 5, -18 },
  { 2499, 10, 25, 15, 2, -20 },
  { 2531, 14, 5, 15, 0, -10 },
};

const GFXfont RobotoMono_MediumItalic26pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic26pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOMONO_MEDIUMITALIC26PT7B_H_
