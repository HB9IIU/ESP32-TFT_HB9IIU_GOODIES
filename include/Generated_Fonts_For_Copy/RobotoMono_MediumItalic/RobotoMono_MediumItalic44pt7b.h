#ifndef _ROBOTOMONO_MEDIUMITALIC44PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x07, 0x83, 0xF0,
  0xFC, 0x3F, 0x07, 0x80, 0x38, 0x3D, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x78,
  0x79, 0xC1, 0xE7, 0x07, 0x3C, 0x1C, 0xF0, 0xF3, 0xC3, 0xCE, 0x0E, 0x00,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x38,
  0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x38, 0x3C, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x0F,
  0x00, 0x07, 0x83, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x3C,
  0x1C, 0x01, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x00,
  0x78, 0x78, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0xE0, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x07,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x01,
  0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x03, 0xE7, 0xC0,
  0x07, 0xCF, 0x80, 0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x3F, 0x03,
  0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xF3,
  0xC0, 0x0F, 0x0E, 0x04, 0x78, 0x78, 0x7B, 0x83, 0xC3, 0x9C, 0x1C, 0x38,
  0xE0, 0xE3, 0xC7, 0x0F, 0x3C, 0x3C, 0x79, 0xC1, 0xFF, 0x9E, 0x07, 0xF9,
  0xE0, 0x0F, 0x8E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x9F, 0x80, 0x39, 0xFF, 0x03, 0xDF,
  0xF8, 0x3C, 0xF1, 0xE1, 0xCF, 0x0F, 0x1C, 0x78, 0x79, 0xE3, 0xC3, 0xCE,
  0x1E, 0x1E, 0x20, 0xF0, 0xE0, 0x07, 0x8F, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x03, 0xFB, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xC1, 0xF0,
  0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xE0, 0x07, 0xC3, 0xE0,
  0x03, 0xCF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0x1F, 0xFC, 0x1F,
  0x3F, 0x7E, 0x1E, 0x7E, 0x3E, 0x1E, 0x7C, 0x1F, 0x3E, 0xFC, 0x1F, 0xFC,
  0xF8, 0x0F, 0xFC, 0xF8, 0x0F, 0xF8, 0xF8, 0x07, 0xF8, 0xFC, 0x07, 0xF0,
  0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFE, 0xF8,
  0x0F, 0xF8, 0xFC, 0x3C, 0xF3, 0xDE, 0x79, 0xE7, 0x9E, 0x73, 0xCF, 0x00,
  0x00, 0x04, 0x00, 0x38, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0x80, 0x04,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xC1, 0xE0, 0xCF, 0x8E, 0x3E, 0xFF,
  0x77, 0xF7, 0xFF, 0xFF, 0xC3, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x1E, 0xF0, 0x01, 0xE3, 0x80, 0x1F, 0x1E, 0x01, 0xF0,
  0xF8, 0x1F, 0x03, 0xE0, 0x70, 0x1E, 0x01, 0x80, 0x40, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xE0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E,
  0x3E, 0x1E, 0x1F, 0x03, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFE, 0x7F,
  0x07, 0xC0, 0xF8, 0x7C, 0x03, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0,
  0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x03, 0xF7, 0xC0, 0x7F, 0xBE, 0x07, 0xFD,
  0xF0, 0xFF, 0xCF, 0x8F, 0xBE, 0xF9, 0xF9, 0xF7, 0xDF, 0x8F, 0xBF, 0xF0,
  0x7D, 0xFF, 0x03, 0xEF, 0xE0, 0x3F, 0x7E, 0x01, 0xF3, 0xE0, 0x0F, 0x9F,
  0x00, 0x7C, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xF0, 0xF8, 0x3F,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0xF8, 0x07, 0xF0, 0x7F, 0xE7, 0xFF, 0xCF,
  0xFF, 0x9F, 0xDF, 0x3C, 0x3C, 0xC0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x1F,
  0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0x00,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xBF, 0xC1,
  0xF8, 0x1F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3,
  0xF0, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x0F, 0xBC, 0x00, 0x1E, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF3,
  0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x3C, 0x3E, 0x00, 0xF8, 0x7C,
  0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x78, 0x07, 0xC1,
  0xF0, 0x1F, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF0, 0xF8,
  0x0F, 0xC1, 0xF8, 0x3F, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x1E, 0x03, 0xEF,
  0xF8, 0x3D, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xCF, 0xE7, 0xF0, 0x3F, 0x7E,
  0x01, 0xF7, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x7E,
  0x7E, 0x0F, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFB, 0xF8, 0x3F,
  0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01,
  0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3E, 0x0F, 0x81, 0xF8, 0x3F, 0x0F, 0xC0,
  0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x03, 0xF8,
  0x7E, 0x0F, 0x80, 0xF8, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x1F,
  0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0xC0, 0x3E, 0x1F,
  0x83, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFD,
  0xFC, 0x7E, 0x0F, 0x9F, 0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xEF, 0xC7, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE1, 0xFF, 0x7C, 0x07, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0x01, 0xF8, 0x3F, 0x87, 0xF1, 0xFE,
  0x1F, 0x83, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x3F, 0x07, 0xE1, 0xFE, 0x3F,
  0xC3, 0xF0, 0x7C, 0x00, 0x00, 0xE0, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x1F,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xF0, 0x00, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x18,
  0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0,
  0x10, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x01, 0xFF,
  0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x3E,
  0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFD, 0xF8, 0x1F, 0xBE, 0x01,
  0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x0F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x07,
  0xC0, 0x3C, 0x00, 0xE0, 0x3C, 0x00, 0x70, 0x3C, 0x1C, 0x1C, 0x1C, 0x3F,
  0x8E, 0x1C, 0x3F, 0xE7, 0x0E, 0x3E, 0x73, 0x8E, 0x3C, 0x39, 0xC7, 0x1C,
  0x38, 0xE7, 0x9E, 0x1C, 0x73, 0x8E, 0x0E, 0x39, 0xC7, 0x07, 0x1C, 0xE3,
  0x87, 0x0E, 0xF3, 0xC3, 0x87, 0x71, 0xC1, 0xC3, 0x38, 0xE0, 0xE3, 0x9C,
  0x70, 0xE1, 0xCE, 0x3C, 0xF1, 0xC7, 0x1F, 0xFF, 0xC3, 0x87, 0xEF, 0xE1,
  0xE1, 0xE7, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C,
  0x78, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7E, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0x80,
  0x7F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x01,
  0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0xFC, 0x7C, 0x01, 0xF8, 0x7C, 0x07, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xF8, 0x1F,
  0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7C,
  0xF8, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE1, 0xF0, 0x0F,
  0x83, 0xF0, 0x3F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x80, 0xFC,
  0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3E,
  0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0xFC,
  0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x7C, 0x07, 0xE0,
  0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xF8, 0x1F, 0x87, 0xE0,
  0x1F, 0x8F, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x1F, 0xFD, 0xF0, 0x3F, 0xFB, 0xE0, 0x7F, 0xF7,
  0xC0, 0xFF, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xF0,
  0x1F, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0x78, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0,
  0x7C, 0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07,
  0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x1E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C,
  0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC3,
  0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF8,
  0x1F, 0x81, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0xE0, 0xF8, 0x03, 0xF8, 0x1F,
  0x00, 0xFE, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x01, 0xF8,
  0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x01, 0xF1,
  0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x9F, 0xC0, 0x01, 0xF7, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x7E, 0x00, 0x1F, 0xC7, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3F,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x7E,
  0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x02,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x07,
  0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0,
  0xFF, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE3, 0xDE,
  0x1F, 0xF1, 0xFF, 0x0F, 0xB9, 0xEF, 0x87, 0xDC, 0xF7, 0xC3, 0xEE, 0xF3,
  0xC1, 0xE7, 0xF9, 0xE0, 0xF3, 0xF9, 0xF0, 0xF9, 0xFC, 0xF8, 0x7C, 0xFC,
  0x7C, 0x3E, 0x7E, 0x3C, 0x1F, 0x1F, 0x1E, 0x0F, 0x0F, 0x1F, 0x07, 0x87,
  0x8F, 0x87, 0xC3, 0x87, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xE0, 0xF8,
  0x00, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7F, 0x00, 0xF8, 0x1F, 0xC0,
  0x3E, 0x07, 0xF0, 0x0F, 0x81, 0xFE, 0x03, 0xE0, 0x7F, 0x80, 0xF8, 0x1F,
  0xE0, 0x7E, 0x0F, 0xF8, 0x1F, 0x03, 0xFF, 0x07, 0xC0, 0xFB, 0xC1, 0xF0,
  0x3E, 0xF0, 0x7C, 0x0F, 0xBE, 0x1F, 0x03, 0xE7, 0x8F, 0xC1, 0xF1, 0xE3,
  0xE0, 0x7C, 0x78, 0xF8, 0x1F, 0x1F, 0x3E, 0x07, 0xC3, 0xCF, 0x81, 0xF0,
  0xF3, 0xE0, 0xFC, 0x3D, 0xF0, 0x3E, 0x07, 0xFC, 0x0F, 0x81, 0xFF, 0x03,
  0xE0, 0x7F, 0xC0, 0xF8, 0x1F, 0xF0, 0x3E, 0x03, 0xFC, 0x1F, 0x80, 0xFE,
  0x07, 0xC0, 0x3F, 0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x1F, 0x00,
  0x7E, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xF8, 0x1F, 0x07, 0xE0,
  0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0xF8, 0x00,
  0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x1F,
  0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7,
  0xC0, 0x03, 0xEF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF8, 0x07, 0xE1, 0xF0, 0x1F, 0x83, 0xF0,
  0x7E, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x7C, 0x07, 0xF0, 0x3E, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F,
  0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC1,
  0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x7C, 0x07, 0xF8,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x0F, 0x80,
  0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xE0, 0x01,
  0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF,
  0x80, 0x07, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8,
  0x01, 0xF1, 0xF0, 0x07, 0xE1, 0xF0, 0x1F, 0x83, 0xF0, 0x7E, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0C,
  0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00,
  0x3F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0xFE, 0x1F, 0x07, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3E, 0x0F,
  0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7C, 0x03,
  0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x3F, 0x03, 0xF8, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xF8,
  0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xFC,
  0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0x7C,
  0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C,
  0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x3E,
  0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x7E, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x1E, 0x0F, 0xBC,
  0x1F, 0x07, 0x9E, 0x0F, 0x87, 0xCF, 0x07, 0xC3, 0xE7, 0x87, 0xE1, 0xF3,
  0xC3, 0xF0, 0xF1, 0xE1, 0xF8, 0xF8, 0xF1, 0xFC, 0x7C, 0x78, 0xFE, 0x3C,
  0x3C, 0x7F, 0x3E, 0x1E, 0x7F, 0x9F, 0x0F, 0x3F, 0xCF, 0x8F, 0x9F, 0xE7,
  0x87, 0xCE, 0xF7, 0xC3, 0xEF, 0x7B, 0xE1, 0xF7, 0xBD, 0xE0, 0xFB, 0x9E,
  0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xE7, 0xFC, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1,
  0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE,
  0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC1, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x03,
  0xF8, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x1F, 0x81, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC, 0x1F, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x7F,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7E,
  0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x1F,
  0x03, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x0F,
  0x9F, 0x80, 0x0F, 0x9F, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07,
  0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F,
  0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0x70, 0x0F, 0x3C,
  0x0F, 0x9E, 0x07, 0x8F, 0x07, 0x87, 0x83, 0xC1, 0xE3, 0xC0, 0xF3, 0xE0,
  0x79, 0xE0, 0x3D, 0xF0, 0x1F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF8, 0x7C, 0x7C, 0x3E, 0x1E, 0x0F, 0x00, 0x3C, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xC7, 0xF3, 0xF0, 0x1F,
  0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x03, 0xFF,
  0xF0, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xF0, 0x3E, 0xFC, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0xC1, 0xFC, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xF7, 0xC1, 0xFE, 0x7E, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x1C,
  0x00, 0xFB, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1,
  0xFC, 0x0F, 0x87, 0xE0, 0x3F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0,
  0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x9F,
  0x80, 0xFC, 0x7F, 0x07, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3E, 0xFF,
  0xE0, 0xF8, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xC0, 0xF8, 0xFC, 0x03, 0xE7, 0xC0,
  0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x01,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xFC, 0x0F, 0xC3, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x78, 0x7C, 0x03, 0xFE, 0x7C, 0x07, 0xFF, 0x7C, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x01, 0xF8, 0x3E, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xFC, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03,
  0xF0, 0xF8, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F,
  0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFB, 0xC0, 0x0F, 0xE3,
  0xC0, 0x00, 0x1C, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x0F, 0xC0, 0xF8, 0xFC, 0x03, 0xE7, 0xC0, 0x1F, 0x7E, 0x00,
  0xFB, 0xE0, 0x07, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x04,
  0x1F, 0x00, 0x30, 0xFE, 0x07, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xF0, 0x60, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x07,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xFE, 0x7C,
  0x0F, 0xFE, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xF8, 0x1F, 0x87,
  0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8,
  0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x0F,
  0xC1, 0xF8, 0x3F, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0x7C,
  0x03, 0xFD, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x80, 0x1F, 0x83,
  0x80, 0x7E, 0x0F, 0x81, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x0E, 0x00, 0xF9, 0xFE, 0x03,
  0xEF, 0xFC, 0x0F, 0x7F, 0xF8, 0x7F, 0xFF, 0xE1, 0xFC, 0x0F, 0xC7, 0xE0,
  0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x1F,
  0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x7C,
  0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0x7C, 0x01,
  0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x81, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7F,
  0x0F, 0x80, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x1F, 0x0F, 0xE0,
  0x1F, 0x1F, 0xC0, 0x1F, 0x3F, 0x80, 0x1F, 0x7F, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xBF, 0x00, 0x3F, 0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x7C, 0x0F, 0x80,
  0x7C, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x0C, 0x03, 0xEF, 0xCF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xE3, 0xE1,
  0xE0, 0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x07, 0x87, 0xC3,
  0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x0F,
  0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x1E, 0x1F,
  0x0F, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x78, 0x7C, 0x3C,
  0x1E, 0x1F, 0x0F, 0x0F, 0x87, 0x83, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0x00,
  0x83, 0x80, 0x3C, 0x7F, 0x80, 0xF3, 0xFF, 0x03, 0xDF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x7F, 0x03, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0xFC, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0xF8,
  0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03,
  0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xCF,
  0x80, 0x1F, 0x3E, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xC0, 0xF8, 0xF8, 0x07, 0xEF,
  0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3E, 0xF8,
  0x01, 0xF7, 0xC0, 0x1F, 0x9F, 0x01, 0xF8, 0xFC, 0x1F, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x03, 0xEF, 0xF8, 0x03, 0xDF, 0xFC, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x07,
  0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3E, 0xFF, 0xE0, 0x3E, 0x3F, 0x80, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xF9, 0xF0, 0x7F, 0xF7, 0xC3, 0xFF,
  0xFF, 0x1F, 0xEF, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x3E,
  0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8,
  0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xFC, 0xF8, 0x03,
  0xE3, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x83, 0xF8, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFD, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xE0,
  0x7C, 0x7F, 0xC3, 0xEF, 0xFC, 0x1E, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFE,
  0x70, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFC,
  0x3F, 0x8F, 0x80, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF7, 0xC0, 0x0F, 0xBE,
  0x00, 0x7C, 0xF8, 0x07, 0xC7, 0xF9, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x00, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F,
  0xF8, 0x03, 0xFF, 0x00, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80,
  0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0xBE, 0x00, 0xF9, 0xF0, 0x07, 0xCF,
  0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x07,
  0xC7, 0xC0, 0x7E, 0x3F, 0x07, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F,
  0xFB, 0xE0, 0x7F, 0x1E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0xF8, 0x01,
  0xF9, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x07, 0x80, 0x7C,
  0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x3C, 0x1F, 0x00,
  0x78, 0x3E, 0x00, 0xF8, 0x78, 0x01, 0xF1, 0xF0, 0x01, 0xE3, 0xC0, 0x03,
  0xCF, 0x80, 0x07, 0x9E, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x38, 0x1F, 0xF0, 0x78, 0x3E, 0xF0, 0x78, 0x3E, 0xF0,
  0xF8, 0x3C, 0xF0, 0xF8, 0x7C, 0xF0, 0xF8, 0x7C, 0xF1, 0xF8, 0x78, 0xF1,
  0xF8, 0xF8, 0xF3, 0xF8, 0xF0, 0xF3, 0xB8, 0xF0, 0xF3, 0xB8, 0xF0, 0xF7,
  0xBD, 0xE0, 0xF7, 0x3D, 0xE0, 0xF7, 0x3D, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC,
  0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x1E, 0x00, 0x0F,
  0xC0, 0x1F, 0xC1, 0xF0, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x0F, 0x81, 0xF8,
  0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xDF, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x0F, 0xC0,
  0x07, 0xC0, 0x1F, 0x80, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3E,
  0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x1F, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xE0,
  0x00, 0x10, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E,
  0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07,
  0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x83,
  0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC0,
  0x03, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x03,
  0xFE, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x47, 0xFE, 0x01, 0xC7, 0xFF, 0x81, 0xE7, 0xFF, 0xE0, 0xF3, 0xC1, 0xFF,
  0xF9, 0xC0, 0x7F, 0xF9, 0xE0, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x70, 0x00,
};

const GFXglyph RobotoMono_MediumItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 10, 31, 26, 8, -31 },
  { 40, 14, 11, 26, 8, -33 },
  { 60, 26, 31, 26, 0, -31 },
  { 161, 23, 41, 26, 2, -36 },
  { 279, 21, 32, 26, 3, -32 },
  { 363, 24, 32, 26, 1, -32 },
  { 459, 6, 11, 26, 11, -33 },
  { 468, 15, 45, 26, 7, -35 },
  { 553, 15, 45, 26, 3, -35 },
  { 638, 21, 21, 26, 4, -31 },
  { 694, 22, 23, 26, 2, -26 },
  { 758, 9, 13, 26, 4, -5 },
  { 773, 18, 4, 26, 5, -16 },
  { 782, 7, 7, 26, 8, -7 },
  { 789, 23, 34, 26, 2, -31 },
  { 887, 21, 33, 26, 3, -32 },
  { 974, 15, 31, 26, 5, -31 },
  { 1033, 23, 32, 26, 0, -32 },
  { 1125, 23, 32, 26, 1, -32 },
  { 1217, 23, 31, 26, 0, -31 },
  { 1307, 23, 32, 26, 2, -31 },
  { 1399, 20, 32, 26, 2, -31 },
  { 1479, 23, 31, 26, 3, -31 },
  { 1569, 22, 32, 26, 2, -32 },
  { 1657, 19, 32, 26, 4, -32 },
  { 1733, 11, 25, 26, 8, -25 },
  { 1768, 13, 33, 26, 6, -25 },
  { 1822, 20, 20, 26, 3, -24 },
  { 1872, 22, 13, 26, 2, -20 },
  { 1908, 21, 21, 26, 2, -24 },
  { 1964, 19, 32, 26, 6, -32 },
  { 2040, 25, 31, 26, 1, -31 },
  { 2137, 24, 31, 26, -1, -31 },
  { 2230, 24, 31, 26, 1, -31 },
  { 2323, 23, 33, 26, 2, -32 },
  { 2418, 24, 31, 26, 1, -31 },
  { 2511, 25, 31, 26, 1, -31 },
  { 2608, 25, 31, 26, 1, -31 },
  { 2705, 23, 33, 26, 2, -32 },
  { 2800, 26, 31, 26, 0, -31 },
  { 2901, 23, 31, 26, 2, -31 },
  { 2991, 25, 31, 26, 1, -31 },
  { 3088, 27, 31, 26, 1, -31 },
  { 3193, 21, 31, 26, 1, -31 },
  { 3275, 25, 31, 26, 1, -31 },
  { 3372, 26, 31, 26, 0, -31 },
  { 3473, 23, 32, 26, 2, -32 },
  { 3565, 25, 31, 26, 1, -31 },
  { 3662, 23, 37, 26, 2, -32 },
  { 3769, 24, 31, 26, 1, -31 },
  { 3862, 24, 32, 26, 1, -32 },
  { 3958, 25, 31, 26, 3, -31 },
  { 4055, 24, 32, 26, 2, -31 },
  { 4151, 24, 31, 26, 4, -31 },
  { 4244, 25, 31, 26, 3, -31 },
  { 4341, 29, 31, 26, -1, -31 },
  { 4454, 24, 31, 26, 4, -31 },
  { 4547, 26, 31, 26, 0, -31 },
  { 4648, 16, 43, 26, 5, -36 },
  { 4734, 11, 34, 26, 8, -31 },
  { 4781, 16, 43, 26, 5, -36 },
  { 4867, 17, 16, 26, 5, -31 },
  { 4901, 20, 4, 26, 0, 0 },
  { 4911, 8, 6, 26, 12, -32 },
  { 4917, 20, 24, 26, 2, -24 },
  { 4977, 22, 33, 26, 1, -33 },
  { 5068, 21, 25, 26, 2, -24 },
  { 5134, 24, 33, 26, 2, -33 },
  { 5233, 21, 24, 26, 2, -24 },
  { 5296, 23, 34, 26, 4, -34 },
  { 5394, 23, 33, 26, 1, -24 },
  { 5489, 22, 33, 26, 1, -33 },
  { 5580, 20, 32, 26, 2, -32 },
  { 5660, 20, 41, 26, 1, -32 },
  { 5763, 24, 33, 26, 1, -33 },
  { 5862, 20, 33, 26, 2, -33 },
  { 5945, 26, 24, 26, -1, -24 },
  { 6023, 22, 24, 26, 1, -24 },
  { 6089, 21, 25, 26, 2, -24 },
  { 6155, 24, 33, 26, -1, -24 },
  { 6254, 22, 33, 26, 2, -24 },
  { 6345, 21, 24, 26, 4, -24 },
  { 6408, 21, 24, 26, 2, -24 },
  { 6471, 20, 29, 26, 4, -29 },
  { 6544, 21, 24, 26, 3, -23 },
  { 6607, 23, 23, 26, 3, -23 },
  { 6674, 24, 23, 26, 3, -23 },
  { 6743, 26, 23, 26, 0, -23 },
  { 6818, 27, 32, 26, 0, -23 },
  { 6926, 23, 23, 26, 1, -23 },
  { 6993, 17, 42, 26, 6, -34 },
  { 7083, 9, 40, 26, 8, -31 },
  { 7128, 17, 42, 26, 4, -34 },
  { 7218, 25, 10, 26, 0, -18 },
};

const GFXfont RobotoMono_MediumItalic44pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic44pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _ROBOTOMONO_MEDIUMITALIC44PT7B_H_
