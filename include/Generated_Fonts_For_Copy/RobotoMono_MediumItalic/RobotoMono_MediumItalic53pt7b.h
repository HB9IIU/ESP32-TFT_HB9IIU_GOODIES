#ifndef _ROBOTOMONO_MEDIUMITALIC53PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x7E, 0x03, 0xF0, 0x3F, 0xC1, 0xFE, 0x07,
  0xE0, 0x1E, 0x00, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x3E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x78, 0x3E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x84, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF8, 0x3C, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFC,
  0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF8,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x83, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1E,
  0x0F, 0x81, 0x87, 0x83, 0xE0, 0xF3, 0xE0, 0xF8, 0x78, 0xF8, 0x3C, 0x3E,
  0x3E, 0x0F, 0x0F, 0x0F, 0x83, 0xC7, 0x83, 0xE1, 0xF3, 0xE0, 0x7F, 0xF8,
  0xF0, 0x1F, 0xFE, 0x78, 0x03, 0xFF, 0x3E, 0x00, 0x7F, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x8F, 0xC0, 0x03, 0xC7,
  0xFC, 0x01, 0xF3, 0xFF, 0x00, 0x79, 0xFF, 0xE0, 0x3C, 0xF8, 0x78, 0x1E,
  0x3C, 0x1F, 0x0F, 0x8F, 0x07, 0xC3, 0xC3, 0xC1, 0xF1, 0xE1, 0xF0, 0x7C,
  0x78, 0x7C, 0x1E, 0x04, 0x1F, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF9,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x0F,
  0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x0F, 0x87, 0xFF, 0xC0, 0xFC, 0x7F, 0x7F,
  0x07, 0xC7, 0xF1, 0xF8, 0x3E, 0x7F, 0x0F, 0xE3, 0xF3, 0xF8, 0x3F, 0x9F,
  0x9F, 0x80, 0xFD, 0xF9, 0xFC, 0x07, 0xFF, 0xCF, 0xC0, 0x1F, 0xFC, 0x7E,
  0x00, 0xFF, 0xC3, 0xF8, 0x03, 0xFE, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x01,
  0xFF, 0x03, 0xFE, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFC, 0xFC, 0x03, 0xFF, 0x87, 0xF0, 0x00, 0xC0, 0x00, 0x00,
  0x3D, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0xFB, 0xEF, 0x3C, 0xF3, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x70, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x40, 0x3C, 0x02, 0x78, 0x1E, 0x07, 0x3F, 0x0F, 0x0F, 0xBF, 0xE7,
  0x3F, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xF7, 0x80, 0x01,
  0xF3, 0xE0, 0x01, 0xF8, 0xF0, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x3F, 0x01,
  0xFC, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x1C, 0x01, 0xC0, 0x04, 0x00, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xC1, 0xF8,
  0x1E, 0x00, 0x80, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFC, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xE0,
  0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x03,
  0xF1, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0,
  0x0F, 0xF3, 0xF0, 0x07, 0xFC, 0xFC, 0x07, 0xFF, 0x3F, 0x03, 0xFF, 0x9F,
  0x83, 0xFF, 0xE7, 0xE1, 0xF9, 0xF9, 0xF9, 0xFC, 0x7E, 0x7E, 0xFE, 0x1F,
  0x9F, 0xFE, 0x0F, 0xE7, 0xFF, 0x03, 0xF3, 0xFF, 0x00, 0xFC, 0xFF, 0x80,
  0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x0F, 0xF3, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xE0, 0x7F, 0xF1, 0xFF, 0xFB,
  0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x7E, 0x3F, 0x38, 0x1F, 0x90, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E,
  0x0F, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x3F,
  0x0F, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x83, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x07, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F,
  0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0x81,
  0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x0E, 0x00, 0x03, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xC0,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x87, 0xF0, 0x07, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xFD, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0,
  0x3F, 0x3F, 0xF0, 0x7E, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x7F, 0xE1, 0xFE, 0xFF, 0x80, 0xFE, 0xFF, 0x00, 0x7E, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x30, 0x00, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x03, 0xF0,
  0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81,
  0xF8, 0x07, 0xE0, 0x3F, 0x83, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xC3, 0xFC, 0x07, 0xF0, 0x1F, 0xC1, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0xCF, 0xE0,
  0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF8,
  0x7F, 0x01, 0xFE, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x1F, 0xE0, 0xFE, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E,
  0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0xFE, 0x7F, 0x01, 0xFE,
  0x3F, 0xC7, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0x7C,
  0x07, 0xFC, 0xFC, 0x00, 0x60, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0xFC,
  0x3F, 0xE1, 0xFF, 0x07, 0xF0, 0x3F, 0x00, 0x20, 0x00, 0x00, 0x3C, 0x00,
  0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x38, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0x0C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F, 0xBF, 0x80, 0x7F, 0x7F,
  0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x07, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1E, 0x07,
  0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0xF0, 0xE0, 0xF0, 0x7F, 0xE3, 0x83, 0xC3,
  0xFF, 0x8E, 0x1E, 0x1F, 0x1E, 0x38, 0x78, 0xF8, 0x70, 0xE3, 0xC3, 0xC1,
  0xC3, 0x8F, 0x1E, 0x07, 0x0E, 0x38, 0x78, 0x3C, 0x39, 0xE1, 0xE0, 0xF0,
  0xE7, 0x8F, 0x03, 0x83, 0x9E, 0x3C, 0x1E, 0x1E, 0x78, 0xF0, 0x78, 0x79,
  0xC3, 0xC1, 0xE1, 0xCF, 0x0F, 0x07, 0x07, 0x3C, 0x38, 0x3C, 0x3C, 0xF0,
  0xF0, 0xF0, 0xE3, 0xC3, 0xC7, 0xC7, 0x8F, 0x0F, 0xFF, 0xBC, 0x3C, 0x3F,
  0xDF, 0xE0, 0x70, 0x7E, 0x7F, 0x01, 0xE0, 0xF0, 0xF8, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x01, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x7E, 0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x01, 0xF0,
  0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x7C, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F,
  0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFC, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xF8, 0x1F, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0,
  0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x01,
  0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8,
  0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xF1, 0xF8,
  0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF8, 0x7E, 0x00, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0x81,
  0xFE, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF1,
  0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03,
  0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x03, 0xF8, 0xFF, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC,
  0x01, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFC,
  0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0x7E,
  0x00, 0x3F, 0x87, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x01,
  0xFC, 0x0F, 0xC0, 0x3F, 0xC0, 0x7E, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x07, 0xE0,
  0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0x80,
  0x03, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xFE, 0x7E, 0x03, 0xFF,
  0xE7, 0xE0, 0x3F, 0xFC, 0xFE, 0x03, 0xFF, 0xCF, 0xC0, 0x7F, 0xFC, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x01,
  0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x83,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0,
  0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F,
  0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0,
  0x01, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFC,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x03,
  0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8,
  0x1F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7C, 0x0F,
  0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0x7F, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0x7F, 0x80, 0xFC,
  0x00, 0x7F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x07,
  0xE0, 0x3F, 0xC0, 0x03, 0xF0, 0x3F, 0xC0, 0x01, 0xF8, 0x3F, 0xC0, 0x00,
  0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7E, 0x3F, 0xC0, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xC0,
  0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F,
  0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0x80,
  0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x01,
  0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFF,
  0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xF8, 0xFB, 0xE0, 0x7F, 0xF1, 0xFF, 0xC0, 0xFD, 0xE7, 0xDF, 0x81,
  0xF3, 0xCF, 0xBE, 0x03, 0xE7, 0xBE, 0x7C, 0x07, 0xCF, 0x7C, 0xF8, 0x1F,
  0x9F, 0xF3, 0xF0, 0x3F, 0x3F, 0xE7, 0xE0, 0x7E, 0x7F, 0x8F, 0xC0, 0xF8,
  0xFF, 0x1F, 0x01, 0xF0, 0xFC, 0x3E, 0x03, 0xE1, 0xF8, 0xFC, 0x0F, 0xC3,
  0xE1, 0xF8, 0x1F, 0x87, 0xC3, 0xF0, 0x3F, 0x0F, 0x07, 0xE0, 0x7E, 0x1E,
  0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x0F,
  0xC0, 0xFE, 0x00, 0x3F, 0x07, 0xF8, 0x01, 0xF8, 0x1F, 0xF0, 0x07, 0xE0,
  0x7F, 0xC0, 0x1F, 0x81, 0xFF, 0x00, 0x7E, 0x07, 0xFC, 0x01, 0xF8, 0x1F,
  0xF8, 0x0F, 0xE0, 0xFF, 0xE0, 0x3F, 0x03, 0xFF, 0x80, 0xFC, 0x0F, 0xFF,
  0x03, 0xF0, 0x3F, 0x7C, 0x0F, 0xC0, 0xFD, 0xF0, 0x3F, 0x07, 0xF7, 0xC1,
  0xFC, 0x1F, 0xCF, 0x87, 0xE0, 0x7E, 0x3E, 0x1F, 0x81, 0xF8, 0xF8, 0x7E,
  0x07, 0xE3, 0xF1, 0xF8, 0x1F, 0x87, 0xC7, 0xE0, 0xFE, 0x1F, 0x3F, 0x83,
  0xF0, 0x7C, 0xFC, 0x0F, 0xC0, 0xFB, 0xF0, 0x3F, 0x03, 0xEF, 0xC0, 0xFC,
  0x0F, 0xBF, 0x03, 0xF0, 0x3F, 0xFC, 0x1F, 0xC0, 0x7F, 0xE0, 0x7E, 0x01,
  0xFF, 0x81, 0xF8, 0x07, 0xFE, 0x07, 0xE0, 0x0F, 0xF8, 0x1F, 0x80, 0x3F,
  0xE0, 0x7E, 0x00, 0xFF, 0x83, 0xF8, 0x03, 0xFC, 0x0F, 0xC0, 0x07, 0xF0,
  0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xC3, 0xFC, 0x07, 0xF0, 0x0F,
  0xC0, 0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x3F, 0x3F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFC,
  0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0,
  0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7F,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7E, 0x03,
  0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF8, 0x3F, 0x00, 0x3F,
  0xC0, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xC3,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x01, 0xF8, 0x1F, 0xF8, 0x0F, 0xC0, 0x1F, 0xE0, 0xFC, 0x00, 0x7F, 0x07,
  0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x81, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xFC, 0x0F, 0xC0,
  0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F,
  0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x81,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F,
  0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00,
  0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0,
  0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xFC, 0x7E,
  0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x03,
  0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0x07, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF9,
  0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x07, 0x80, 0xFD, 0xF0, 0x3E, 0x03, 0xE7, 0xC0,
  0xF8, 0x1F, 0x9F, 0x03, 0xE0, 0x7E, 0x7C, 0x1F, 0x81, 0xF3, 0xF0, 0x7E,
  0x0F, 0xCF, 0xC1, 0xF8, 0x3F, 0x3F, 0x0F, 0xE0, 0xFC, 0xFC, 0x3F, 0x83,
  0xE3, 0xF0, 0xFE, 0x1F, 0x8F, 0xC7, 0xF8, 0x7E, 0x3F, 0x1F, 0xE1, 0xF0,
  0xFC, 0x7F, 0x87, 0xC3, 0xF1, 0xFE, 0x3F, 0x0F, 0xCF, 0xF8, 0xFC, 0x3E,
  0x3D, 0xE3, 0xE0, 0xF8, 0xF7, 0x8F, 0x83, 0xE7, 0xDE, 0x7E, 0x0F, 0x9E,
  0x79, 0xF0, 0x3E, 0x79, 0xE7, 0xC0, 0xFB, 0xE7, 0xBF, 0x03, 0xEF, 0x1E,
  0xFC, 0x0F, 0xBC, 0x7B, 0xE0, 0x3F, 0xF1, 0xEF, 0x80, 0xFF, 0xC7, 0xFE,
  0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00,
  0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F,
  0x81, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0,
  0x7F, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xF0, 0x1F,
  0xC0, 0x03, 0xF8, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xC7, 0xF0,
  0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07,
  0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F,
  0x1F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0,
  0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xF7, 0x80, 0x1F,
  0x78, 0x01, 0xF7, 0x80, 0x3E, 0x7C, 0x07, 0xE7, 0xC0, 0x7C, 0x7C, 0x0F,
  0x83, 0xC0, 0xF8, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x3E, 0x03, 0xE7,
  0xE0, 0x1E, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFE, 0x1F,
  0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F,
  0x87, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xC0, 0x3F,
  0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x03, 0xF9, 0xFC, 0x07, 0xFC, 0xFF, 0x9F,
  0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xDF, 0x83, 0xFF, 0xCF, 0xC0, 0xFF,
  0x87, 0xE0, 0x04, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x20, 0x00, 0x7E, 0x7F,
  0xC0, 0x0F, 0xDF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x81, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F,
  0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x8F, 0xF0, 0x0F, 0xE1,
  0xFF, 0x03, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x1F, 0x3F, 0xFC, 0x07, 0xE1, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0x01, 0xFC, 0x7F, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x3F, 0x80, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF1, 0xF8, 0x03, 0xF0,
  0xFE, 0x03, 0xF8, 0x3F, 0xCF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x80, 0xFC, 0x00, 0xFF, 0x8F, 0xC0, 0x3F, 0xFC, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFC, 0x07,
  0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFE, 0xF8, 0x00, 0x7F, 0x8F, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xF8, 0x7F, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x3F, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0x03, 0xF0, 0x01,
  0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0xFB, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFE, 0x06, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0x00, 0xFF, 0xFB, 0xF0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xF0, 0x1F,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xC3,
  0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00,
  0x1F, 0x83, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x0F, 0xF0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFB, 0xF0, 0x01, 0xFE, 0x3F, 0x00, 0x01, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x30, 0x00, 0xFC, 0x07, 0x80, 0x1F, 0xC0, 0x7E,
  0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x10,
  0x00, 0x7E, 0x3F, 0xE0, 0x0F, 0xCF, 0xFE, 0x01, 0xF3, 0xFF, 0xE0, 0x7E,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0x03, 0xF8, 0x3F, 0x80, 0x3F,
  0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0,
  0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x83, 0xF0, 0x07,
  0xF8, 0x1F, 0x80, 0x7F, 0x80, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00,
  0x7E, 0x0F, 0xF0, 0x03, 0xF0, 0xFF, 0x00, 0x1F, 0x8F, 0xF0, 0x00, 0xFC,
  0xFF, 0x00, 0x0F, 0xCF, 0xF0, 0x00, 0x7E, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFE, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFE,
  0x1F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xF0,
  0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xF0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0x00, 0x40, 0x0F, 0x9F, 0xC7, 0xE0, 0x1F, 0x7F, 0xDF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xF0,
  0xFE, 0x1F, 0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07,
  0xE0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x07, 0xE1, 0xF8, 0x3E,
  0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xC1, 0xF8, 0x3E, 0x0F, 0x83, 0xF0,
  0x7C, 0x1F, 0x07, 0xE0, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0x07,
  0xE1, 0xF8, 0x3E, 0x0F, 0xC3, 0xE0, 0xFC, 0x1F, 0x07, 0xC1, 0xF8, 0x3E,
  0x1F, 0x83, 0xF0, 0x7C, 0x3F, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0x83, 0xF0,
  0xFC, 0x1F, 0x07, 0xE1, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x0F,
  0xC1, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x20, 0x00, 0xF8, 0x7F, 0xC0, 0x1F,
  0x1F, 0xFC, 0x03, 0xEF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x83, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0x7F, 0xC0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F,
  0xC0, 0x07, 0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F,
  0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0xFE, 0x7E,
  0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xE0, 0xFC, 0x07, 0xF8,
  0x3F, 0xE7, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x0F, 0xCF, 0xF8, 0x00, 0x7C, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00,
  0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xFE,
  0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x1F,
  0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0x7F,
  0xF8, 0x03, 0xF9, 0xFF, 0x80, 0x1F, 0x80, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x3F, 0xE3, 0xF0, 0x3F, 0xFC, 0xFC, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF,
  0xFF, 0x87, 0xFE, 0xFF, 0xE1, 0xFC, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x3F,
  0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xE7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0,
  0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x1F, 0xC1,
  0xFC, 0x0F, 0xF0, 0x7F, 0xDF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFB, 0xE0, 0x0F, 0xF9, 0xF8, 0x00, 0x20, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x18, 0x03, 0xE0,
  0xFF, 0xC1, 0xF1, 0xFF, 0xC1, 0xF9, 0xFF, 0xE0, 0xFD, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x1F, 0xE0, 0xFE, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x1F, 0x00,
  0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0x81, 0xFE, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x3F, 0x80, 0x1F, 0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE7, 0xF0, 0x03, 0xF9,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03,
  0xF1, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x7F, 0x87,
  0xE0, 0x3F, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xBF,
  0x01, 0xFF, 0xCF, 0xC0, 0x3F, 0xE3, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x81, 0xF0,
  0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE1,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF0, 0x00,
  0x3E, 0x7E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x0F,
  0x01, 0xFF, 0xC0, 0x78, 0x0F, 0xBE, 0x07, 0xE0, 0x7D, 0xF0, 0x3F, 0x07,
  0xEF, 0x81, 0xF8, 0x3E, 0x7C, 0x1F, 0xC1, 0xF3, 0xE0, 0xFE, 0x1F, 0x9F,
  0x07, 0xF0, 0xF8, 0xF8, 0x7F, 0x87, 0xC7, 0xC3, 0xFC, 0x7E, 0x3E, 0x3D,
  0xE3, 0xE1, 0xF1, 0xEF, 0x1F, 0x0F, 0x8F, 0x79, 0xF8, 0x7C, 0xF3, 0xCF,
  0x83, 0xE7, 0x9E, 0x7C, 0x1F, 0x3C, 0xF3, 0xC0, 0xFB, 0xC7, 0xBE, 0x07,
  0xDE, 0x3D, 0xF0, 0x3F, 0xE1, 0xEF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8,
  0x7F, 0xC0, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0xF8, 0x01,
  0xF8, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x1F,
  0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x01,
  0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F,
  0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0xF8, 0x7F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0xFE,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x01,
  0xD1, 0xFF, 0xE0, 0x07, 0x8F, 0xFF, 0xE0, 0x1E, 0x3F, 0xFF, 0xC0, 0xF9,
  0xF8, 0x7F, 0xCF, 0xE7, 0xC0, 0xFF, 0xFF, 0x1E, 0x00, 0xFF, 0xFC, 0xF8,
  0x01, 0xFF, 0xE0, 0x20, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00,
};

const GFXglyph RobotoMono_MediumItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 13, 38, 31, 9, -38 },
  { 63, 16, 13, 31, 10, -40 },
  { 89, 31, 38, 31, 0, -38 },
  { 237, 27, 49, 31, 3, -44 },
  { 403, 26, 39, 31, 3, -38 },
  { 530, 29, 39, 31, 1, -38 },
  { 672, 6, 14, 31, 14, -40 },
  { 683, 18, 54, 31, 8, -42 },
  { 805, 18, 54, 31, 4, -42 },
  { 927, 25, 26, 31, 5, -38 },
  { 1009, 26, 27, 31, 3, -31 },
  { 1097, 11, 16, 31, 5, -6 },
  { 1119, 21, 5, 31, 6, -19 },
  { 1133, 9, 9, 31, 9, -8 },
  { 1144, 28, 41, 31, 2, -38 },
  { 1288, 26, 39, 31, 3, -38 },
  { 1415, 17, 38, 31, 7, -38 },
  { 1496, 28, 38, 31, 0, -38 },
  { 1629, 27, 39, 31, 1, -38 },
  { 1761, 27, 38, 31, 1, -38 },
  { 1890, 27, 39, 31, 3, -38 },
  { 2022, 24, 39, 31, 3, -38 },
  { 2139, 27, 38, 31, 4, -38 },
  { 2268, 27, 39, 31, 2, -38 },
  { 2400, 24, 38, 31, 4, -38 },
  { 2514, 13, 31, 31, 10, -30 },
  { 2565, 16, 40, 31, 7, -30 },
  { 2645, 24, 25, 31, 4, -29 },
  { 2720, 26, 16, 31, 3, -24 },
  { 2772, 25, 24, 31, 2, -28 },
  { 2847, 23, 38, 31, 7, -38 },
  { 2957, 30, 38, 31, 1, -38 },
  { 3100, 29, 38, 31, -2, -38 },
  { 3238, 29, 38, 31, 1, -38 },
  { 3376, 28, 39, 31, 2, -38 },
  { 3513, 29, 38, 31, 1, -38 },
  { 3651, 31, 38, 31, 1, -38 },
  { 3799, 31, 38, 31, 1, -38 },
  { 3947, 28, 39, 31, 2, -38 },
  { 4084, 30, 38, 31, 1, -38 },
  { 4227, 28, 38, 31, 2, -38 },
  { 4360, 29, 39, 31, 2, -38 },
  { 4502, 33, 38, 31, 1, -38 },
  { 4659, 24, 38, 31, 2, -38 },
  { 4773, 31, 38, 31, 1, -38 },
  { 4921, 30, 38, 31, 1, -38 },
  { 5064, 28, 39, 31, 2, -38 },
  { 5201, 30, 38, 31, 1, -38 },
  { 5344, 28, 45, 31, 2, -38 },
  { 5502, 29, 38, 31, 1, -38 },
  { 5640, 29, 39, 31, 2, -38 },
  { 5782, 30, 38, 31, 4, -38 },
  { 5925, 28, 39, 31, 3, -38 },
  { 6062, 28, 38, 31, 5, -38 },
  { 6195, 30, 38, 31, 4, -38 },
  { 6338, 34, 38, 31, -1, -38 },
  { 6500, 29, 38, 31, 5, -38 },
  { 6638, 31, 38, 31, 0, -38 },
  { 6786, 18, 51, 31, 7, -43 },
  { 6901, 12, 41, 31, 10, -38 },
  { 6963, 19, 51, 31, 6, -43 },
  { 7085, 20, 20, 31, 6, -38 },
  { 7135, 24, 5, 31, 0, 0 },
  { 7150, 10, 7, 31, 14, -38 },
  { 7159, 25, 30, 31, 2, -29 },
  { 7253, 27, 41, 31, 1, -40 },
  { 7392, 25, 30, 31, 3, -29 },
  { 7486, 28, 41, 31, 3, -40 },
  { 7630, 26, 30, 31, 2, -29 },
  { 7728, 28, 41, 31, 5, -41 },
  { 7872, 28, 40, 31, 1, -29 },
  { 8012, 27, 40, 31, 1, -40 },
  { 8147, 23, 39, 31, 3, -39 },
  { 8260, 24, 50, 31, 1, -39 },
  { 8410, 29, 40, 31, 1, -40 },
  { 8555, 24, 40, 31, 2, -40 },
  { 8675, 31, 29, 31, -1, -29 },
  { 8788, 27, 29, 31, 1, -29 },
  { 8886, 26, 30, 31, 2, -29 },
  { 8984, 29, 40, 31, -1, -29 },
  { 9129, 26, 40, 31, 3, -29 },
  { 9259, 25, 29, 31, 5, -29 },
  { 9350, 26, 30, 31, 2, -29 },
  { 9448, 23, 36, 31, 5, -35 },
  { 9552, 26, 29, 31, 3, -28 },
  { 9647, 27, 28, 31, 4, -28 },
  { 9742, 29, 28, 31, 3, -28 },
  { 9844, 31, 28, 31, 0, -28 },
  { 9953, 32, 39, 31, 0, -28 },
  { 10109, 28, 28, 31, 1, -28 },
  { 10207, 20, 50, 31, 8, -41 },
  { 10332, 12, 48, 31, 9, -38 },
  { 10404, 20, 50, 31, 5, -41 },
  { 10529, 30, 11, 31, 0, -21 },
};

const GFXfont RobotoMono_MediumItalic53pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic53pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic53pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOMONO_MEDIUMITALIC53PT7B_H_
