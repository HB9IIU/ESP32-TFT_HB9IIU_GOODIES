#ifndef _ROBOTOMONO_MEDIUMITALIC64PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x81, 0xF1,
  0xF0, 0x1F, 0x1F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3E,
  0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xE3, 0xE0, 0x7E, 0x7E, 0x07,
  0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0x8F, 0x80,
  0xF8, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x02, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC,
  0x1F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03,
  0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F,
  0x03, 0xE0, 0x18, 0x7E, 0x07, 0xC0, 0x7C, 0xF8, 0x0F, 0x81, 0xF1, 0xF0,
  0x1F, 0x03, 0xE3, 0xE0, 0x3E, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x0F, 0x81,
  0xF8, 0xFC, 0x1F, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0xC7, 0xC0, 0x3F, 0xFF,
  0x1F, 0x80, 0x7F, 0xFE, 0x3E, 0x00, 0x7F, 0xF8, 0xF8, 0x00, 0x7F, 0xE3,
  0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0xFF,
  0x00, 0x07, 0xC7, 0xFF, 0x00, 0x1F, 0x9F, 0xFF, 0x00, 0x3E, 0x7F, 0xFF,
  0x00, 0xF8, 0xFC, 0x7E, 0x03, 0xF3, 0xF0, 0x7C, 0x07, 0xC7, 0xC0, 0xFC,
  0x1F, 0x0F, 0x81, 0xF8, 0x7C, 0x1F, 0x03, 0xF0, 0xF8, 0x3E, 0x07, 0xC3,
  0xE0, 0xFC, 0x0F, 0x83, 0x81, 0xF8, 0x1F, 0x01, 0x03, 0xF0, 0x3E, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x07, 0xE0, 0xFF, 0xFF, 0x00, 0xFC, 0x3F, 0xFF, 0xE0,
  0x3F, 0x8F, 0xF9, 0xFE, 0x07, 0xF1, 0xFE, 0x1F, 0xC0, 0xFC, 0x7F, 0x83,
  0xFC, 0x3F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF3, 0xFC, 0x07, 0xF9, 0xFC, 0x7F,
  0x00, 0x7F, 0xBF, 0x8F, 0xE0, 0x0F, 0xFF, 0xE1, 0xFC, 0x00, 0xFF, 0xFC,
  0x3F, 0x80, 0x0F, 0xFF, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0xFE, 0x00, 0x1F,
  0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF3,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x8F, 0xF0, 0x03, 0xFF, 0xC0, 0xFF,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x8F, 0x87, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7C, 0x3E, 0x3F, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xF1, 0xF8, 0x00,
  0x00, 0x10, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0xC0, 0x1F, 0x00, 0x23, 0xC0, 0x7C, 0x07, 0x9F, 0xC1, 0xF0,
  0x7E, 0x7F, 0xC7, 0xC7, 0xFB, 0xFF, 0xDE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x3F, 0x9F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xE0,
  0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0x80,
  0x01, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x01, 0xC0, 0x04, 0x00, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x0E, 0x07, 0xF1, 0xFF, 0x3F,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0xC7, 0xF0, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x01,
  0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xFE, 0x7F, 0x00, 0x1F, 0xFC,
  0xFE, 0x00, 0xFF, 0xF1, 0xFC, 0x03, 0xFF, 0xE7, 0xF8, 0x1F, 0xFF, 0xCF,
  0xF0, 0x7F, 0xBF, 0x9F, 0xC1, 0xFE, 0x7F, 0x3F, 0x8F, 0xF1, 0xFE, 0x7F,
  0x3F, 0xC3, 0xFC, 0xFF, 0xFE, 0x07, 0xF1, 0xFF, 0xF8, 0x0F, 0xE7, 0xFF,
  0xC0, 0x1F, 0xCF, 0xFF, 0x00, 0x3F, 0x9F, 0xF8, 0x00, 0xFF, 0x3F, 0xE0,
  0x01, 0xFE, 0x7F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x01,
  0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0xCF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xF3, 0xF9, 0xFE, 0x1F,
  0xCF, 0x80, 0xFE, 0x60, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0,
  0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x3F, 0xE0, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE7, 0xF8,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F,
  0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0xC0,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0xFE, 0x7F, 0xF8, 0x07, 0xF7, 0xFF, 0xE0, 0x7F, 0x7F, 0xFF,
  0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF9, 0xFF, 0xE0, 0x7F, 0xCF,
  0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xC0,
  0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF9, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x03,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07,
  0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x03,
  0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0xFF,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F,
  0xF1, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF1,
  0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xF7, 0xF0,
  0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF9, 0xFE,
  0x00, 0x7F, 0xCF, 0xF0, 0x07, 0xFE, 0x3F, 0xE0, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0xFE,
  0x01, 0xFF, 0xCF, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x01, 0xFC, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF0,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x04,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x7F,
  0xE7, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x0F, 0xC0, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0x78, 0x1F, 0x03, 0xFF, 0x0F, 0x07, 0xC0, 0xFF, 0xF1, 0xE0, 0xF8, 0x3F,
  0xFE, 0x1E, 0x3E, 0x0F, 0xFF, 0xC3, 0xC7, 0xC3, 0xF0, 0xF8, 0x79, 0xF0,
  0xFC, 0x1E, 0x0F, 0x3E, 0x1F, 0x03, 0xC1, 0xE7, 0x87, 0xC0, 0x78, 0x3D,
  0xF0, 0xF8, 0x1F, 0x0F, 0xBE, 0x1F, 0x03, 0xC1, 0xF7, 0x87, 0xC0, 0x78,
  0x3D, 0xF0, 0xF8, 0x0F, 0x07, 0xBE, 0x1F, 0x03, 0xE0, 0xF7, 0xC3, 0xC0,
  0x78, 0x1E, 0xF8, 0x78, 0x0F, 0x03, 0xDE, 0x1F, 0x01, 0xE0, 0xF3, 0xC3,
  0xE0, 0x7C, 0x1E, 0x78, 0x7C, 0x0F, 0x83, 0xCF, 0x0F, 0x81, 0xE0, 0xF1,
  0xE1, 0xF0, 0x7C, 0x1E, 0x3C, 0x1F, 0x3F, 0x87, 0x87, 0x83, 0xFF, 0xFF,
  0xE0, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0x07, 0xF9, 0xFF, 0x03, 0xE0, 0x7C,
  0x1F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x40, 0x00,
  0x1F, 0xE0, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFC, 0x7E,
  0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xE0, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x80,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF8,
  0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xF9, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x0F, 0xE0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x07,
  0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xF8, 0x0F,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07,
  0xF1, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0x3F, 0x80,
  0x3F, 0xFF, 0x9F, 0xC0, 0x1F, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF, 0xE7, 0xF0,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x1F,
  0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1,
  0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x80,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x40,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xFC,
  0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0xFF,
  0x80, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x1F,
  0xF0, 0x00, 0x03, 0xF8, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0xE0, 0x00,
  0x07, 0xF8, 0xFF, 0xC0, 0x00, 0x07, 0xF9, 0xFF, 0x80, 0x00, 0x07, 0xF1,
  0xFF, 0x00, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xEF, 0x83, 0xFF,
  0xC0, 0x3F, 0x7C, 0x3F, 0x7E, 0x03, 0xFB, 0xE1, 0xFB, 0xF0, 0x1F, 0xDF,
  0x1F, 0xBF, 0x80, 0xFE, 0xF8, 0xFD, 0xFC, 0x07, 0xF7, 0xCF, 0xCF, 0xE0,
  0x3F, 0x3F, 0x7E, 0x7E, 0x01, 0xF9, 0xFF, 0xE3, 0xF0, 0x1F, 0xCF, 0xFF,
  0x3F, 0x80, 0xFE, 0x3F, 0xF1, 0xFC, 0x07, 0xF1, 0xFF, 0x8F, 0xE0, 0x3F,
  0x8F, 0xF8, 0x7F, 0x01, 0xF8, 0x7F, 0xC3, 0xF0, 0x0F, 0xC3, 0xFC, 0x3F,
  0x80, 0xFE, 0x1F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0x3F, 0x87,
  0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0x83, 0xF8, 0x0F, 0xE0, 0xF8, 0x3F, 0x80,
  0x7E, 0x07, 0xC1, 0xFC, 0x07, 0xF0, 0x3C, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xF0, 0x00,
  0x7F, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x7F,
  0xF0, 0x01, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x1F, 0xFC, 0x00, 0x7F,
  0x00, 0xFF, 0xF0, 0x03, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xFC,
  0x01, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x00,
  0xFE, 0xFC, 0x03, 0xF8, 0x07, 0xF7, 0xE0, 0x3F, 0xC0, 0x3F, 0x9F, 0x81,
  0xFE, 0x03, 0xFC, 0xFC, 0x0F, 0xF0, 0x1F, 0xE7, 0xE0, 0x7F, 0x00, 0xFF,
  0x3F, 0x83, 0xF8, 0x07, 0xF0, 0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xE1, 0xFE,
  0x01, 0xFC, 0x3F, 0x0F, 0xF0, 0x1F, 0xE0, 0xFC, 0x7F, 0x80, 0xFF, 0x07,
  0xE3, 0xF8, 0x07, 0xF8, 0x3F, 0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0xFE, 0x01,
  0xFC, 0x07, 0xEF, 0xF0, 0x0F, 0xE0, 0x3F, 0x7F, 0x80, 0xFF, 0x01, 0xFB,
  0xF8, 0x07, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0x80, 0x3F, 0xFE, 0x01, 0xFC,
  0x01, 0xFF, 0xF0, 0x0F, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xFC,
  0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xFE, 0x01, 0xFC, 0x00,
  0x7F, 0xF0, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xFC, 0x07,
  0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFE, 0x1F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x07, 0xFB, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFD, 0xFE, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xBF, 0x80,
  0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0xCF, 0xE0, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x80,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07,
  0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xE3, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x1F,
  0xC0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F,
  0xE0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01,
  0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00,
  0x07, 0xF8, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x0F,
  0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x1F,
  0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F,
  0x8F, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x03,
  0xF9, 0xF8, 0x07, 0xE0, 0x3F, 0x8F, 0xC0, 0x7F, 0x01, 0xFC, 0x7E, 0x03,
  0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0xFE, 0x07, 0xF1,
  0xFC, 0x0F, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x81, 0xFC, 0x7F, 0x03, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFF, 0x07, 0xF0, 0xFE,
  0x0F, 0xF8, 0x3F, 0x07, 0xF0, 0xFF, 0xC3, 0xF8, 0x3F, 0x87, 0xFE, 0x1F,
  0xC1, 0xFC, 0x3F, 0xF0, 0xFE, 0x0F, 0xE3, 0xFF, 0x87, 0xE0, 0x7F, 0x1F,
  0x7C, 0x7F, 0x03, 0xF8, 0xFB, 0xE3, 0xF8, 0x1F, 0x8F, 0xDF, 0x1F, 0x80,
  0xFC, 0x7E, 0xF8, 0xFC, 0x07, 0xE3, 0xE7, 0xCF, 0xE0, 0x3F, 0x1F, 0x3E,
  0x7F, 0x01, 0xF9, 0xF9, 0xF3, 0xF0, 0x0F, 0xCF, 0x8F, 0xBF, 0x80, 0x7E,
  0x7C, 0x7D, 0xFC, 0x03, 0xF7, 0xE3, 0xEF, 0xC0, 0x1F, 0xBE, 0x1F, 0x7E,
  0x00, 0xFD, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x3F, 0xF8,
  0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xFE, 0x0F, 0xE0, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x8F,
  0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC1, 0xF0, 0x0F, 0xE0, 0xF8, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x83, 0xF0, 0x07, 0xC3, 0xF8,
  0x03, 0xF1, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFE,
  0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0x87, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC,
  0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xC3, 0xFE, 0x00, 0x3F, 0x8F, 0xF8,
  0x00, 0x7F, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xFC, 0x7F, 0x00,
  0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0xFF, 0x87, 0xF8, 0x07, 0xFF, 0x0F, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xEF, 0xF0, 0x1F, 0xFF, 0x9F,
  0xE0, 0x0F, 0xFC, 0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0xE0, 0x03, 0xF9, 0xFF, 0xF0, 0x07,
  0xF7, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC3, 0xFC,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0,
  0x01, 0xFC, 0x7F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07,
  0xF9, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x0F, 0xF0,
  0xFF, 0xC0, 0x3F, 0xE3, 0xFF, 0xF7, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F,
  0xEF, 0xFF, 0xFC, 0x1F, 0xDF, 0xFF, 0xF0, 0x3F, 0x9F, 0xFF, 0x80, 0x7E,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0x01,
  0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x1F,
  0xCF, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0xFF,
  0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE7, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFF, 0xE7, 0xF8, 0x01, 0xFF, 0xFE, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xF8,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xE0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xDF, 0xC0, 0x01, 0xFF, 0xF3, 0xF0, 0x00,
  0x1F, 0xF8, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8,
  0x7F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0x01, 0xFE, 0x00, 0x06, 0x03, 0xFE, 0x00, 0x1E, 0x03, 0xFE, 0x00,
  0xFE, 0x03, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x08, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x83, 0xF0, 0x01, 0xFF, 0xF1, 0xFC, 0x01,
  0xFF, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0xDF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFB, 0xF8, 0x00, 0x7F, 0xFC, 0xFE, 0x00, 0x0F,
  0xFC, 0x7F, 0x80, 0x00, 0x38, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x01, 0x00, 0x00, 0xFF, 0x00, 0x60, 0x00, 0x7F, 0x80,
  0x3C, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x80,
  0x07, 0xF1, 0xFF, 0xF0, 0x03, 0xF9, 0xFF, 0xFC, 0x01, 0xFD, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x03, 0xF8, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x07,
  0xDF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0x80,
  0x07, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xF0, 0x03,
  0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x07, 0xF8, 0x1F, 0xF8,
  0x00, 0x7F, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0x0F,
  0xF8, 0x00, 0x07, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x0F,
  0xF7, 0xFC, 0x00, 0x00, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xDF, 0xE0, 0x00, 0x1F,
  0xF9, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x03, 0xF8, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x5F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x03, 0xF1, 0xFC, 0x1F,
  0xC0, 0x1F, 0x9F, 0xF3, 0xFF, 0x00, 0xFD, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0x7F,
  0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x3F, 0x03, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0,
  0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF8,
  0x3F, 0x03, 0xF8, 0x1F, 0xC1, 0xF8, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x07, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x3F,
  0x81, 0xF8, 0x1F, 0xC1, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0x81,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x7E, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0x81, 0xF8, 0x00, 0x03, 0xF8,
  0x3F, 0xE0, 0x01, 0xFC, 0x7F, 0xFC, 0x00, 0xFE, 0x7F, 0xFF, 0x00, 0x7E,
  0x7F, 0xFF, 0xC0, 0x3F, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03,
  0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFC,
  0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0xFF,
  0x7F, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x07,
  0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0x9F, 0xFF, 0x00,
  0x0F, 0xEF, 0xFF, 0xE0, 0x03, 0xF7, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xF8, 0x1F, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0x7F, 0xFF, 0x80, 0x1F, 0xCF, 0xFF, 0xC0, 0x07,
  0xF0, 0xFF, 0xC0, 0x03, 0xFC, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0x00, 0x7F, 0xFC, 0x7F, 0x01,
  0xFF, 0xFE, 0x7F, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F,
  0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F,
  0x00, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0xFF,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xEF, 0xE0, 0x07,
  0xFF, 0xDF, 0xC0, 0x03, 0xFF, 0x1F, 0xC0, 0x00, 0x38, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x0F, 0xE0, 0xFF, 0xF0, 0x3F, 0x0F, 0xFF, 0xC1, 0xFC,
  0x7F, 0xFE, 0x07, 0xF3, 0xFF, 0xF8, 0x1F, 0xDF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x10, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x83, 0xFE,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0x80,
  0x01, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x87,
  0xFE, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x10, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F,
  0x8F, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xFC,
  0x7F, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F, 0xC7,
  0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFE, 0x3F,
  0x80, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFE,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x83, 0xFC, 0x07, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xEF, 0xE0, 0x1F, 0xFF, 0x1F, 0xC0, 0x0F, 0xFC, 0x3F, 0x80, 0x03, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80,
  0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0x80,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0,
  0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xFF, 0x80,
  0x7E, 0x03, 0xFB, 0xF0, 0x0F, 0xC0, 0x7F, 0x7E, 0x03, 0xF8, 0x0F, 0xCF,
  0xC0, 0x7F, 0x01, 0xF9, 0xF8, 0x0F, 0xE0, 0x7F, 0x3F, 0x03, 0xFC, 0x0F,
  0xC7, 0xE0, 0x7F, 0x81, 0xF8, 0xFC, 0x1F, 0xF0, 0x7F, 0x1F, 0x83, 0xFE,
  0x0F, 0xC3, 0xF0, 0x7F, 0xC1, 0xF8, 0x7E, 0x1F, 0xF8, 0x7F, 0x0F, 0xC3,
  0xFF, 0x0F, 0xC1, 0xF8, 0x7B, 0xE1, 0xF8, 0x3F, 0x1F, 0x7C, 0x7F, 0x07,
  0xE3, 0xEF, 0x8F, 0xC0, 0xFC, 0xF9, 0xF1, 0xF8, 0x1F, 0x9F, 0x3E, 0x7E,
  0x03, 0xF3, 0xC3, 0xCF, 0xC0, 0x7E, 0xF8, 0x79, 0xF8, 0x0F, 0xDF, 0x0F,
  0x7E, 0x01, 0xFB, 0xC1, 0xEF, 0xC0, 0x3F, 0xF8, 0x3D, 0xF8, 0x07, 0xFF,
  0x07, 0xBE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0xFE, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xDF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xE0, 0xFF, 0xFC, 0x00, 0x3F,
  0x1F, 0xFF, 0xF0, 0x03, 0xE3, 0xFF, 0xFF, 0x80, 0x7E, 0x3F, 0xFF, 0xFC,
  0x0F, 0xE7, 0xF0, 0x7F, 0xF9, 0xFC, 0x7E, 0x01, 0xFF, 0xFF, 0xC7, 0xC0,
  0x0F, 0xFF, 0xF8, 0x7C, 0x00, 0x7F, 0xFF, 0x8F, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoMono_MediumItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 16, 46, 38, 11, -46 },
  { 93, 20, 16, 38, 11, -48 },
  { 133, 38, 46, 38, 0, -46 },
  { 352, 33, 60, 38, 3, -53 },
  { 600, 31, 47, 38, 4, -46 },
  { 783, 35, 47, 38, 1, -46 },
  { 989, 9, 16, 38, 16, -48 },
  { 1007, 21, 65, 38, 10, -51 },
  { 1178, 22, 66, 38, 5, -51 },
  { 1360, 30, 32, 38, 6, -46 },
  { 1480, 32, 33, 38, 3, -38 },
  { 1612, 13, 19, 38, 6, -7 },
  { 1643, 26, 6, 38, 7, -23 },
  { 1663, 11, 11, 38, 11, -10 },
  { 1679, 33, 50, 38, 3, -46 },
  { 1886, 31, 47, 38, 4, -46 },
  { 2069, 21, 46, 38, 8, -46 },
  { 2190, 34, 46, 38, 0, -46 },
  { 2386, 32, 47, 38, 2, -46 },
  { 2574, 33, 46, 38, 1, -46 },
  { 2764, 34, 47, 38, 3, -46 },
  { 2964, 29, 47, 38, 3, -46 },
  { 3135, 32, 46, 38, 5, -46 },
  { 3319, 32, 47, 38, 3, -46 },
  { 3507, 29, 46, 38, 5, -46 },
  { 3674, 15, 37, 38, 12, -36 },
  { 3744, 19, 48, 38, 9, -36 },
  { 3858, 29, 30, 38, 5, -35 },
  { 3967, 32, 19, 38, 3, -29 },
  { 4043, 30, 29, 38, 3, -34 },
  { 4152, 28, 46, 38, 8, -46 },
  { 4313, 35, 45, 38, 2, -45 },
  { 4510, 35, 46, 38, -2, -46 },
  { 4712, 36, 46, 38, 1, -46 },
  { 4919, 34, 47, 38, 3, -46 },
  { 5119, 35, 46, 38, 1, -46 },
  { 5321, 36, 46, 38, 2, -46 },
  { 5528, 36, 46, 38, 2, -46 },
  { 5735, 33, 47, 38, 3, -46 },
  { 5929, 37, 46, 38, 1, -46 },
  { 6142, 34, 46, 38, 2, -46 },
  { 6338, 35, 47, 38, 2, -46 },
  { 6544, 40, 46, 38, 1, -46 },
  { 6774, 29, 46, 38, 2, -46 },
  { 6941, 37, 46, 38, 1, -46 },
  { 7154, 37, 46, 38, 1, -46 },
  { 7367, 33, 47, 38, 3, -46 },
  { 7561, 36, 46, 38, 2, -46 },
  { 7768, 34, 54, 38, 2, -46 },
  { 7998, 36, 46, 38, 1, -46 },
  { 8205, 35, 47, 38, 2, -46 },
  { 8411, 36, 46, 38, 5, -46 },
  { 8618, 35, 47, 38, 3, -46 },
  { 8824, 34, 46, 38, 6, -46 },
  { 9020, 37, 46, 38, 4, -46 },
  { 9233, 42, 46, 38, -2, -46 },
  { 9475, 35, 46, 38, 6, -46 },
  { 9677, 38, 46, 38, 0, -46 },
  { 9896, 23, 62, 38, 8, -52 },
  { 10075, 15, 50, 38, 12, -46 },
  { 10169, 22, 62, 38, 8, -52 },
  { 10340, 25, 25, 38, 7, -46 },
  { 10419, 29, 6, 38, 0, 0 },
  { 10441, 12, 8, 38, 17, -46 },
  { 10453, 31, 36, 38, 2, -35 },
  { 10593, 31, 49, 38, 2, -48 },
  { 10783, 30, 36, 38, 3, -35 },
  { 10918, 35, 49, 38, 3, -48 },
  { 11133, 31, 36, 38, 3, -35 },
  { 11273, 34, 49, 38, 6, -49 },
  { 11482, 34, 48, 38, 1, -35 },
  { 11686, 33, 48, 38, 1, -48 },
  { 11884, 28, 47, 38, 3, -47 },
  { 12049, 30, 61, 38, 1, -47 },
  { 12278, 36, 48, 38, 1, -48 },
  { 12494, 29, 48, 38, 3, -48 },
  { 12668, 37, 34, 38, -1, -34 },
  { 12826, 33, 34, 38, 1, -34 },
  { 12967, 31, 36, 38, 3, -35 },
  { 13107, 34, 47, 38, -1, -34 },
  { 13307, 32, 48, 38, 3, -35 },
  { 13499, 30, 35, 38, 6, -35 },
  { 13631, 31, 35, 38, 3, -34 },
  { 13767, 28, 43, 38, 6, -42 },
  { 13918, 31, 35, 38, 4, -34 },
  { 14054, 32, 34, 38, 5, -34 },
  { 14190, 35, 34, 38, 4, -34 },
  { 14339, 38, 34, 38, 0, -34 },
  { 14501, 39, 48, 38, 0, -34 },
  { 14735, 34, 34, 38, 1, -34 },
  { 14880, 25, 61, 38, 9, -50 },
  { 15071, 14, 59, 38, 11, -46 },
  { 15175, 25, 61, 38, 6, -50 },
  { 15366, 36, 14, 38, 0, -26 },
};

const GFXfont RobotoMono_MediumItalic64pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic64pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic64pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _ROBOTOMONO_MEDIUMITALIC64PT7B_H_
