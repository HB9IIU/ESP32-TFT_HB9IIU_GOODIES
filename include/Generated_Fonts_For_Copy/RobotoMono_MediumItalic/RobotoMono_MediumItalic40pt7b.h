#ifndef _ROBOTOMONO_MEDIUMITALIC40PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F,
  0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xE0,
  0x38, 0x79, 0xC3, 0x9E, 0x1C, 0xF0, 0xE7, 0x0F, 0x38, 0x79, 0xC3, 0x8E,
  0x1C, 0xF0, 0xE7, 0x07, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x70, 0x00,
  0x78, 0x70, 0x00, 0x70, 0xF1, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x00, 0xE1, 0xC0, 0x01, 0xE1, 0xC0, 0x01, 0xC3, 0xC0, 0x01,
  0xC3, 0x80, 0x03, 0x83, 0x80, 0x03, 0x87, 0x80, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x0F, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x3C,
  0x38, 0x00, 0x38, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0xFF, 0xFC, 0x0F, 0xC3, 0xF0, 0x7C, 0x0F, 0x87, 0xC0, 0x3C, 0x3E, 0x01,
  0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0xF8, 0x03, 0xE7, 0xC0,
  0x1F, 0x3E, 0x00, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0xFC, 0x3F, 0xDF, 0xC0,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0xE0, 0x07, 0x8E, 0x00, 0x70, 0xE0, 0x87, 0x0E, 0x1E, 0x70, 0xE3,
  0xCF, 0x0E, 0x38, 0x71, 0xE7, 0x07, 0x1C, 0xE0, 0x7F, 0xCE, 0x03, 0xF9,
  0xC0, 0x06, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0xF8, 0x03, 0x9F, 0xE0, 0x73, 0xFE, 0x07, 0x78, 0xE0,
  0xE7, 0x0F, 0x1C, 0x70, 0xF3, 0xC7, 0x0F, 0x18, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0x79, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x0F,
  0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x3E, 0x00,
  0x79, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x0F, 0x1F, 0xF8, 0x78, 0xFB, 0xE1, 0xE7, 0xC7, 0xC7,
  0x9E, 0x0F, 0x3E, 0xF8, 0x3E, 0xF3, 0xE0, 0x7F, 0xCF, 0x81, 0xFE, 0x3E,
  0x03, 0xF0, 0xF8, 0x0F, 0xC1, 0xF9, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x0F, 0xF1, 0xF0, 0x39, 0xDE, 0xF7, 0xB9, 0xCE, 0xF7, 0x80, 0x00,
  0x08, 0x00, 0x60, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x02, 0x00, 0x02,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0x40, 0x00, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x18, 0x38,
  0x3F, 0x8E, 0x3F, 0xFB, 0xBF, 0xFF, 0xFF, 0xC7, 0xFF, 0xC0, 0x3E, 0x00,
  0x1F, 0x80, 0x0F, 0x70, 0x07, 0x9C, 0x01, 0xE7, 0x80, 0xF0, 0xF0, 0xF8,
  0x3E, 0x0E, 0x07, 0x01, 0x01, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0xF0, 0x60, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x79, 0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0F, 0xC3, 0xE0, 0xF0, 0x1E, 0x1F, 0x01, 0xE1, 0xE0, 0x1F, 0x3E, 0x01,
  0xF3, 0xE0, 0x1F, 0x3C, 0x03, 0xF3, 0xC0, 0xFF, 0x3C, 0x1F, 0xE7, 0xC7,
  0xFE, 0x7C, 0xF9, 0xE7, 0xDF, 0x3E, 0x7F, 0xC3, 0xE7, 0xF8, 0x3E, 0x7E,
  0x03, 0xCF, 0xC0, 0x3C, 0xF8, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0x87,
  0x80, 0xF8, 0x7C, 0x1F, 0x03, 0xE3, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0x38, 0x0F, 0xC3, 0xFC, 0x7F, 0xE7, 0xFF, 0x7F,
  0xFB, 0xE7, 0xD8, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFC, 0x1F, 0x07, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1E, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xC3, 0xF1, 0xF8, 0x1F, 0x1F, 0x00, 0xF1,
  0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x1F, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xCF, 0x80,
  0x3C, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xFC, 0x0F, 0x87, 0xF3, 0xF8, 0x3F,
  0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xBC, 0x00, 0x79, 0xE0, 0x07, 0x8F, 0x00, 0x7C, 0xF8,
  0x07, 0xC7, 0xC0, 0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x0F, 0x03, 0xE0,
  0xF8, 0x3E, 0x07, 0xC1, 0xE0, 0x3E, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF1, 0xC0, 0x07,
  0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0x87, 0xE0, 0x10, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x8F, 0x00, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x0F, 0x81, 0xF0,
  0x7F, 0x3F, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x02, 0x80, 0x07, 0xE0, 0x07, 0xF8, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC7, 0xC0,
  0xF7, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xF0, 0xFD, 0xF0, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7D, 0xE0, 0x3E, 0x7C, 0x1F, 0x9F, 0xDF, 0xC3, 0xFF, 0xE0,
  0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F,
  0xFE, 0x0F, 0xC3, 0xE1, 0xF8, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1E,
  0x01, 0xF1, 0xE0, 0x1E, 0x1F, 0x03, 0xE1, 0xF0, 0x7C, 0x0F, 0xDF, 0xC0,
  0x7F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0x1F, 0x87, 0xC0, 0x78,
  0x7C, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x07,
  0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0x87, 0xF3, 0xF0, 0x7F, 0xFF, 0x03, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F,
  0xFE, 0x3F, 0x0F, 0x8F, 0x81, 0xF7, 0xC0, 0x7D, 0xF0, 0x0F, 0x78, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xF7,
  0xC0, 0xFD, 0xF8, 0x7E, 0x3F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFE, 0xF8, 0x0E,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x0F,
  0xC7, 0xE7, 0xF1, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xE0,
  0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81,
  0xE0, 0x3C, 0x0F, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00,
  0x7C, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x80,
  0xFF, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x18, 0x00, 0x03, 0xC0, 0x00,
  0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0xFE, 0x00, 0x03, 0xC0, 0x03, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xE1,
  0xFB, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0xF0, 0x1E, 0x07, 0x00, 0x38, 0x38, 0x00, 0x61, 0xE3, 0xF1, 0xC7,
  0x1F, 0xE7, 0x38, 0xF3, 0x9C, 0xE7, 0x8E, 0x77, 0x1C, 0x31, 0xDC, 0x70,
  0xC7, 0x73, 0x87, 0x1D, 0x8E, 0x1C, 0x7E, 0x38, 0x71, 0xB8, 0xE1, 0x86,
  0xE7, 0x0E, 0x3B, 0x9C, 0x38, 0xCE, 0x39, 0xE7, 0x38, 0xFF, 0xF8, 0xE3,
  0xF7, 0xE3, 0x87, 0x1E, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x04,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xE7,
  0x80, 0x0F, 0x9E, 0x00, 0x3C, 0x78, 0x01, 0xF1, 0xF0, 0x07, 0x83, 0xC0,
  0x3E, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0xC0, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7C, 0x03, 0xE1, 0xE0, 0x0F,
  0x8F, 0x80, 0x1E, 0x3C, 0x00, 0x79, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xE1,
  0xFE, 0x0F, 0x00, 0xFC, 0x3C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0x78, 0x7C, 0x03, 0xE1, 0xE0, 0x1F, 0x07, 0x83, 0xFC, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0x80, 0xF8, 0x3C, 0x01,
  0xF0, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x7C, 0x01, 0xF1,
  0xE0, 0x07, 0xC7, 0x80, 0x3F, 0x1E, 0x01, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFC, 0x3F, 0x0F, 0x80, 0xF8, 0x78,
  0x03, 0xC7, 0xC0, 0x1F, 0x3C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x3E, 0x78, 0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0x7C, 0x0F,
  0x83, 0xF9, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1E, 0x3F, 0xC0, 0xF0,
  0x3F, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8,
  0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xF3, 0xE0, 0x07, 0x9F, 0x00,
  0x7C, 0xF8, 0x03, 0xE7, 0x80, 0x1F, 0x3C, 0x00, 0xFB, 0xE0, 0x07, 0x9F,
  0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x3C, 0x03, 0xE1, 0xE0, 0x3F,
  0x1F, 0x07, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFC, 0x3F, 0x0F, 0x80, 0xF8,
  0x7C, 0x03, 0xC7, 0xC0, 0x1F, 0x3C, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x07, 0xFE, 0xF8, 0x3F, 0xE7, 0x81, 0xFF, 0x3C, 0x00, 0x79, 0xE0, 0x07,
  0xCF, 0x00, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x78, 0x7C,
  0x07, 0xC3, 0xFD, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80,
  0x3E, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3C, 0x0F, 0x00,
  0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x3C, 0x00,
  0xF0, 0x3C, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01,
  0xE0, 0x7C, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x07, 0x80, 0x7C, 0x1F, 0x03, 0xE0,
  0x7F, 0x3F, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x07,
  0x80, 0x3F, 0x87, 0xC0, 0x3F, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x3F, 0x00,
  0xF0, 0x3F, 0x00, 0x78, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x1F, 0x80,
  0x1F, 0x1F, 0x80, 0x0F, 0x9F, 0x80, 0x07, 0x9F, 0x80, 0x03, 0xDF, 0x80,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xBE, 0x00, 0x1F, 0x9F, 0x00, 0x1F, 0x87, 0xC0, 0x0F, 0x83,
  0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1E,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x0F, 0xC0,
  0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0x73, 0xDE, 0x1E, 0xE7, 0xF8,
  0x3D, 0xDE, 0xF0, 0x7B, 0xBD, 0xE1, 0xF7, 0xF3, 0xC3, 0xCF, 0xE7, 0x87,
  0x9F, 0x9F, 0x0F, 0x3F, 0x3C, 0x1E, 0x3C, 0x78, 0x3C, 0x78, 0xF0, 0xF8,
  0xE1, 0xE1, 0xE1, 0xC7, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x1E, 0x0F, 0x00,
  0x3C, 0x3E, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF0, 0x03, 0xE1, 0xE0, 0x07,
  0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x00, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1E, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x0F, 0xF0,
  0x3E, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0x70, 0x7C, 0x0F, 0x78,
  0x7C, 0x1F, 0x78, 0x7C, 0x1F, 0x78, 0x78, 0x1F, 0x3C, 0x78, 0x1F, 0x3C,
  0xF8, 0x1E, 0x3C, 0xF8, 0x1E, 0x1C, 0xF8, 0x3E, 0x1E, 0xF8, 0x3E, 0x1E,
  0xF0, 0x3E, 0x1E, 0xF0, 0x3E, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x7C, 0x07, 0xF0, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x07,
  0xE0, 0x78, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xC7, 0xE1, 0xF0, 0x1F, 0x1E, 0x01,
  0xF3, 0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0xC0, 0x0F, 0x7C, 0x00, 0xF7, 0x80,
  0x0F, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF,
  0x00, 0x3C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0x7C, 0x1F, 0x87, 0xFF, 0xF0,
  0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xE0, 0xFE, 0x0F, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x7C, 0x01, 0xF1,
  0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x1E, 0x01, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0xFC, 0x7E, 0x0F, 0x80, 0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x1E, 0x3C, 0x00,
  0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7B, 0xE0, 0x03, 0xDF, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80, 0x0F,
  0xBC, 0x00, 0x7D, 0xE0, 0x03, 0xCF, 0x00, 0x3E, 0x78, 0x01, 0xF3, 0xE0,
  0x1F, 0x1F, 0x00, 0xF0, 0x7C, 0x1F, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x03, 0xE0, 0xFE, 0x0F, 0x00, 0xF8, 0x3C, 0x01, 0xF0,
  0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xE0,
  0x0F, 0x87, 0x80, 0x3E, 0x1E, 0x03, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xF0, 0x7C, 0x07, 0xC0, 0xF0, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0x7C, 0x1E, 0x01,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0xE1, 0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00,
  0x3C, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x03,
  0xC7, 0x80, 0x1F, 0x1F, 0x00, 0x7C, 0x7E, 0x03, 0xE0, 0xFF, 0x7F, 0x81,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3E,
  0x1E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x3C,
  0x00, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01,
  0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xE3,
  0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x1F, 0x0F, 0x80, 0xF8, 0x1F, 0x07, 0xE0, 0x7F, 0x7F, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBE,
  0x00, 0x7D, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xE1, 0xE0, 0x1F,
  0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC3, 0xE0, 0x1E, 0x1F, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x80,
  0x3C, 0x78, 0x01, 0xE7, 0xC0, 0x0F, 0xBC, 0x00, 0x7F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x78, 0x3F, 0xE1,
  0xE1, 0xFF, 0x87, 0x87, 0xBE, 0x3E, 0x1E, 0xF0, 0xF8, 0x7B, 0xC3, 0xE3,
  0xEF, 0x1F, 0x8F, 0x3C, 0x7E, 0x3C, 0xF1, 0xF8, 0xF3, 0xCF, 0xE7, 0xCF,
  0x3F, 0x9E, 0x3C, 0xEE, 0x78, 0xF3, 0xB9, 0xE3, 0xDE, 0xEF, 0x0F, 0x73,
  0xBC, 0x3D, 0xCE, 0xF0, 0xFF, 0x3F, 0xC3, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8,
  0x3F, 0x8F, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3E,
  0x0F, 0xC0, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x03, 0xE0, 0x3C, 0x0F,
  0x00, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x07,
  0x80, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x0F, 0x80,
  0x03, 0xE7, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0x7C, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0xE3, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xFF, 0xE0,
  0x07, 0xC7, 0x80, 0x1F, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xC0, 0xF0, 0x1F,
  0x03, 0xC0, 0xF8, 0x0F, 0x83, 0xC0, 0x1E, 0x1F, 0x00, 0x78, 0xF8, 0x01,
  0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x0F, 0x78, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x80, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x00, 0xF8, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFE, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xBC, 0x07, 0xBC, 0x0F, 0x1C, 0x0F, 0x1C,
  0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x1E, 0x3C, 0x0E, 0x78, 0x0E, 0xF8, 0x0F,
  0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF1, 0xF1,
  0xE1, 0xE0, 0x00, 0x10, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1,
  0xF8, 0x7E, 0x3E, 0x07, 0xC7, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x3F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xF0, 0x3C, 0xF8, 0x07, 0x9F,
  0x00, 0xF3, 0xC0, 0x3E, 0xF8, 0x07, 0xCF, 0x01, 0xF9, 0xF9, 0xFF, 0x3F,
  0xFF, 0xC3, 0xFF, 0x7C, 0x3F, 0xCF, 0x80, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x0C, 0x00, 0xF7, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0xC7, 0xE1, 0xF0, 0x3E, 0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E,
  0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x1F, 0x3C, 0x01, 0xF7,
  0xC0, 0x1E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xC7, 0xE0, 0x7C,
  0x7F, 0xBF, 0x8F, 0xFF, 0xF8, 0xFB, 0xFF, 0x0F, 0x1F, 0xC0, 0x00, 0x10,
  0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xF8, 0xFC, 0x7C, 0x07,
  0x8F, 0x80, 0xFB, 0xE0, 0x0F, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x3E,
  0x78, 0x07, 0x8F, 0x81, 0xF1, 0xFC, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x41, 0xF0, 0x1F, 0xCF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xF8,
  0xFE, 0x1F, 0x03, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x78, 0x03, 0xE7,
  0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0xFC, 0x1F,
  0xDF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xE7, 0x80, 0x00, 0x30,
  0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xF8, 0xFC, 0x7E, 0x07,
  0x8F, 0x80, 0xFB, 0xE0, 0x0F, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x01, 0x0F, 0x80, 0xE1, 0xFE, 0x7E, 0x1F, 0xFF, 0xC1, 0xFF, 0xE0,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xE0, 0x1F, 0x81, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x0F, 0xF3, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0xFC, 0x7F, 0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01,
  0xF1, 0xE0, 0x0F, 0x9F, 0x00, 0x78, 0xF8, 0x03, 0xC7, 0xC0, 0x3E, 0x3E,
  0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xC1, 0xF0, 0x7E,
  0x0F, 0xEF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFB, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x20, 0x0F, 0x83, 0x80, 0xF8, 0x3F, 0x3F, 0xC1,
  0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x04, 0x01, 0xF3, 0xF8, 0x1F, 0x7F, 0xC1,
  0xEF, 0xFE, 0x1F, 0xE7, 0xE1, 0xF0, 0x1F, 0x1E, 0x01, 0xF3, 0xE0, 0x1F,
  0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3C, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x01,
  0xE7, 0xC0, 0x1E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x03, 0xE7, 0x80,
  0x3C, 0xF8, 0x03, 0xCF, 0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x21, 0xFC, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x07, 0xF1, 0xF0,
  0x3F, 0x07, 0xC1, 0xF8, 0x1F, 0x0F, 0xC0, 0x78, 0x7E, 0x01, 0xE3, 0xF0,
  0x0F, 0x9F, 0x80, 0x3E, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFD, 0xF0, 0x07, 0xE3, 0xE0, 0x1F, 0x0F,
  0x80, 0x78, 0x1F, 0x01, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x3E, 0x03, 0xF0,
  0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0xFF, 0xE0, 0x00, 0x10, 0x20, 0x7B, 0xF7, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x1F, 0x7F, 0x7C, 0xF8, 0xF8, 0xF3, 0xC3, 0xC3, 0xCF, 0x0F, 0x0F,
  0x3C, 0x3C, 0x3C, 0xF0, 0xF0, 0xF3, 0xC7, 0xC7, 0xDF, 0x1E, 0x1E, 0x78,
  0x78, 0x79, 0xE1, 0xE1, 0xE7, 0x87, 0x87, 0x9E, 0x1E, 0x1E, 0xF8, 0xF8,
  0xFB, 0xE3, 0xC3, 0xCF, 0x0F, 0x0F, 0x3C, 0x3C, 0x3C, 0xF0, 0xF0, 0xF3,
  0xC7, 0xC7, 0xC0, 0x00, 0x04, 0x01, 0xF3, 0xF8, 0x1E, 0x7F, 0xC1, 0xEF,
  0xFE, 0x1F, 0xE7, 0xE1, 0xF8, 0x1F, 0x1E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E,
  0x01, 0xF3, 0xE0, 0x1F, 0x3C, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE7,
  0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x03, 0xE7, 0x80, 0x3C,
  0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0x00, 0x20,
  0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xF8, 0xFC, 0x7C, 0x0F,
  0x9F, 0x00, 0xFB, 0xE0, 0x1F, 0x78, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xF7, 0xC0, 0x3E,
  0xF8, 0x07, 0x8F, 0x81, 0xF1, 0xF8, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0,
  0x1F, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x7D, 0xFE, 0x03, 0xDF, 0xF8, 0x1F,
  0xFF, 0xE0, 0xFE, 0x7F, 0x07, 0xC0, 0xF8, 0x3C, 0x03, 0xE3, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF1, 0xE0,
  0x0F, 0x9F, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE1,
  0xF0, 0x3F, 0x0F, 0xE7, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3E, 0x7F,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x3F, 0x8F, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0x8F, 0xE3, 0xE0,
  0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x03, 0xEF, 0x80, 0x3C, 0xF8,
  0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF,
  0x80, 0x78, 0xF8, 0x0F, 0x87, 0xC1, 0xF8, 0x7F, 0x7F, 0x87, 0xFF, 0xF8,
  0x3F, 0xFF, 0x01, 0xFC, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x06, 0x07, 0xCF, 0xF1, 0xE7, 0xFC, 0x7B, 0xFF, 0x1F, 0xFF,
  0x87, 0xF8, 0x23, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xE1, 0xF0, 0x7E, 0x7C, 0x07, 0xCF, 0x00, 0x79, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0x00, 0x01, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0xDF, 0x00, 0xF9, 0xF0, 0x7E,
  0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x03, 0xFE, 0x00, 0x1E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3,
  0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07,
  0xC7, 0x80, 0x7C, 0x78, 0x07, 0xC7, 0x80, 0xF8, 0x7C, 0x1F, 0x87, 0xE7,
  0xF8, 0x7F, 0xF7, 0x83, 0xFE, 0x78, 0x1F, 0xCF, 0x80, 0xF8, 0x01, 0xFF,
  0x80, 0x1E, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0x78, 0x07, 0xC7, 0xC0, 0x78,
  0x3C, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x1F, 0x03, 0xC1, 0xE0, 0x3E, 0x3E,
  0x01, 0xE3, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x00, 0xEF,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x78, 0x3F, 0xC1, 0xE1, 0xFF, 0x07, 0x87, 0xBC, 0x3E,
  0x1E, 0xF0, 0xF8, 0xF3, 0xC7, 0xE3, 0xCF, 0x1F, 0x8F, 0x3C, 0x7E, 0x38,
  0xF3, 0xB9, 0xE3, 0xCE, 0xE7, 0x8F, 0x3B, 0x9C, 0x1D, 0xCE, 0xF0, 0x77,
  0x3B, 0xC1, 0xF8, 0xEE, 0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xE0, 0x7C, 0x3F,
  0x01, 0xF0, 0xFC, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x00,
  0x0F, 0x80, 0x3E, 0x0F, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x1E, 0x0F, 0x80,
  0x3E, 0x3F, 0x00, 0x3C, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x87,
  0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x0F, 0xC0, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x3E, 0x0F, 0x00,
  0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0xF8, 0x07, 0x81,
  0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC7, 0xC0, 0x03, 0xC7,
  0xC0, 0x03, 0xCF, 0x80, 0x03, 0xEF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x1F, 0x81, 0xFE,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0xE0,
  0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0x80, 0x73, 0xFF, 0x01, 0xDF, 0xFE, 0x0F, 0x78, 0x7F, 0xF9, 0xC0, 0xFF,
  0xEF, 0x01, 0xFF, 0x00, 0x03, 0xF8,
};

const GFXglyph RobotoMono_MediumItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 10, 28, 23, 7, -28 },
  { 36, 13, 10, 23, 7, -30 },
  { 53, 24, 28, 23, 0, -28 },
  { 137, 21, 37, 23, 2, -33 },
  { 235, 20, 29, 23, 2, -29 },
  { 308, 22, 29, 23, 1, -29 },
  { 388, 5, 10, 23, 10, -30 },
  { 395, 14, 41, 23, 6, -32 },
  { 467, 14, 41, 23, 3, -32 },
  { 539, 18, 19, 23, 4, -28 },
  { 582, 20, 21, 23, 2, -24 },
  { 635, 8, 12, 23, 4, -5 },
  { 647, 16, 3, 23, 5, -14 },
  { 653, 7, 6, 23, 7, -6 },
  { 659, 20, 30, 23, 2, -28 },
  { 734, 20, 29, 23, 2, -29 },
  { 807, 13, 28, 23, 5, -28 },
  { 853, 21, 29, 23, 0, -29 },
  { 930, 20, 29, 23, 1, -29 },
  { 1003, 21, 28, 23, 0, -28 },
  { 1077, 21, 28, 23, 2, -28 },
  { 1151, 18, 29, 23, 2, -29 },
  { 1217, 20, 28, 23, 3, -28 },
  { 1287, 20, 29, 23, 2, -29 },
  { 1360, 18, 29, 23, 3, -29 },
  { 1426, 9, 23, 23, 8, -23 },
  { 1452, 11, 30, 23, 6, -23 },
  { 1494, 18, 19, 23, 3, -22 },
  { 1537, 20, 12, 23, 2, -18 },
  { 1567, 19, 18, 23, 2, -21 },
  { 1610, 17, 29, 23, 5, -29 },
  { 1672, 22, 28, 23, 1, -28 },
  { 1749, 22, 28, 23, -1, -28 },
  { 1826, 22, 28, 23, 1, -28 },
  { 1903, 21, 29, 23, 2, -29 },
  { 1980, 21, 28, 23, 1, -28 },
  { 2054, 23, 28, 23, 1, -28 },
  { 2135, 23, 28, 23, 1, -28 },
  { 2216, 21, 29, 23, 2, -29 },
  { 2293, 24, 28, 23, 0, -28 },
  { 2377, 22, 28, 23, 1, -28 },
  { 2454, 22, 28, 23, 1, -28 },
  { 2531, 25, 28, 23, 1, -28 },
  { 2619, 19, 28, 23, 1, -28 },
  { 2686, 23, 28, 23, 1, -28 },
  { 2767, 24, 28, 23, 0, -28 },
  { 2851, 20, 29, 23, 2, -29 },
  { 2924, 22, 28, 23, 1, -28 },
  { 3001, 21, 34, 23, 2, -29 },
  { 3091, 22, 28, 23, 1, -28 },
  { 3168, 22, 29, 23, 1, -29 },
  { 3248, 22, 28, 23, 3, -28 },
  { 3325, 22, 28, 23, 2, -28 },
  { 3402, 21, 28, 23, 4, -28 },
  { 3476, 22, 28, 23, 3, -28 },
  { 3553, 26, 28, 23, -1, -28 },
  { 3644, 22, 28, 23, 4, -28 },
  { 3721, 23, 28, 23, 0, -28 },
  { 3802, 14, 39, 23, 5, -33 },
  { 3871, 10, 30, 23, 7, -28 },
  { 3909, 14, 39, 23, 5, -33 },
  { 3978, 16, 15, 23, 4, -28 },
  { 4008, 18, 4, 23, 0, 0 },
  { 4017, 7, 5, 23, 11, -29 },
  { 4022, 19, 22, 23, 1, -22 },
  { 4075, 20, 30, 23, 1, -30 },
  { 4150, 19, 22, 23, 2, -22 },
  { 4203, 21, 30, 23, 2, -30 },
  { 4282, 19, 22, 23, 2, -22 },
  { 4335, 21, 31, 23, 4, -31 },
  { 4417, 21, 30, 23, 1, -22 },
  { 4496, 20, 30, 23, 1, -30 },
  { 4571, 18, 29, 23, 2, -29 },
  { 4637, 18, 38, 23, 1, -29 },
  { 4723, 22, 30, 23, 1, -30 },
  { 4806, 18, 30, 23, 2, -30 },
  { 4874, 22, 22, 23, 0, -22 },
  { 4935, 20, 22, 23, 1, -22 },
  { 4990, 19, 22, 23, 2, -22 },
  { 5043, 21, 30, 23, 0, -22 },
  { 5122, 20, 30, 23, 2, -22 },
  { 5197, 18, 22, 23, 4, -22 },
  { 5247, 19, 22, 23, 2, -22 },
  { 5300, 17, 26, 23, 4, -26 },
  { 5356, 20, 21, 23, 2, -21 },
  { 5409, 20, 21, 23, 3, -21 },
  { 5462, 22, 21, 23, 2, -21 },
  { 5520, 23, 21, 23, 0, -21 },
  { 5581, 24, 30, 23, 0, -21 },
  { 5671, 21, 21, 23, 1, -21 },
  { 5727, 15, 38, 23, 6, -31 },
  { 5799, 9, 36, 23, 7, -28 },
  { 5840, 15, 38, 23, 4, -31 },
  { 5912, 22, 8, 23, 0, -16 },
};

const GFXfont RobotoMono_MediumItalic40pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic40pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOMONO_MEDIUMITALIC40PT7B_H_
