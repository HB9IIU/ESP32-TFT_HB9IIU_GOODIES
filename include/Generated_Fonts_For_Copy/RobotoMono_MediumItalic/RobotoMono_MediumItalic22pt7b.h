#ifndef _ROBOTOMONO_MEDIUMITALIC22PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0xCE, 0x73, 0x18, 0xCE, 0x73, 0x18, 0x00, 0x23, 0x9C, 0x66,
  0xCF, 0x16, 0x6C, 0xD9, 0x80, 0x03, 0x10, 0x19, 0x80, 0xCC, 0x0C, 0xC0,
  0x66, 0x1F, 0xFC, 0xFF, 0xE1, 0x98, 0x08, 0x80, 0xCC, 0x3F, 0xF9, 0xFF,
  0xC3, 0x30, 0x19, 0x80, 0x88, 0x0C, 0xC0, 0x01, 0x80, 0x20, 0x1E, 0x0F,
  0xE3, 0xCE, 0x70, 0xCC, 0x19, 0x80, 0x38, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x0D, 0xC1, 0xB8, 0x37, 0x0E, 0x7F, 0x87, 0xE0, 0x20, 0x04, 0x00, 0x38,
  0x0F, 0x81, 0x31, 0x66, 0x6C, 0xD8, 0xFA, 0x1E, 0xC0, 0x30, 0x04, 0x01,
  0xB0, 0x6F, 0x1B, 0x33, 0x66, 0xCC, 0xC1, 0xB0, 0x1E, 0x03, 0x80, 0xFC,
  0x0C, 0xC1, 0xCE, 0x18, 0xC1, 0xDC, 0x0F, 0x80, 0xE0, 0x1E, 0x03, 0xF3,
  0x73, 0x36, 0x3F, 0x61, 0xE6, 0x1C, 0x7F, 0xE3, 0xE7, 0xFB, 0x6D, 0x00,
  0x01, 0x03, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60,
  0x60, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x60, 0x30, 0x18, 0x10, 0x10,
  0x30, 0x60, 0x60, 0xC0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x61, 0xC3,
  0x06, 0x1C, 0x30, 0xE1, 0x86, 0x18, 0x20, 0x00, 0x06, 0x01, 0x80, 0x61,
  0x11, 0xF5, 0xDF, 0xF0, 0xC0, 0x78, 0x36, 0x38, 0xC6, 0x30, 0x07, 0x00,
  0xC0, 0x18, 0x03, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x60, 0x0C, 0x01, 0x80,
  0x70, 0x00, 0x33, 0x37, 0x66, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x60,
  0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x00, 0x07, 0x83,
  0xF8, 0xE3, 0x18, 0x77, 0x06, 0xE1, 0xDC, 0x7B, 0x3F, 0x6E, 0xEF, 0x1B,
  0xC3, 0x70, 0xEE, 0x1C, 0xC7, 0x1F, 0xC1, 0xF0, 0x02, 0x3D, 0xFF, 0xE8,
  0xC1, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x18, 0x07, 0x81,
  0xFE, 0x3C, 0xE3, 0x86, 0x30, 0x60, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xEF, 0xFC, 0x0F, 0x03,
  0xF8, 0xE7, 0x38, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x7C, 0x1F, 0x80, 0x30,
  0x07, 0x00, 0xEC, 0x1D, 0xC7, 0x3F, 0xC3, 0xF0, 0x00, 0x60, 0x0E, 0x01,
  0xE0, 0x3E, 0x07, 0xE0, 0x6E, 0x0C, 0xC1, 0x8C, 0x38, 0xC3, 0x1C, 0x7F,
  0xFF, 0xFE, 0xFF, 0xE0, 0x18, 0x03, 0x80, 0x38, 0x1F, 0xF1, 0xFE, 0x1F,
  0xE1, 0x80, 0x38, 0x03, 0x00, 0x3F, 0x87, 0xFC, 0x31, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0xE1, 0xCE, 0x18, 0x7F, 0x83, 0xE0, 0x01, 0x81, 0xE1, 0xF0,
  0xF0, 0x30, 0x1C, 0x06, 0xF9, 0xFE, 0xF1, 0xF8, 0x3E, 0x0F, 0x87, 0xE1,
  0xD8, 0xE7, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x18, 0x07,
  0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x18,
  0x07, 0x00, 0x07, 0x83, 0xF8, 0xE3, 0x9C, 0x73, 0x0E, 0x61, 0xCE, 0x70,
  0xFC, 0x3F, 0x8E, 0x3B, 0x87, 0x70, 0x6E, 0x1D, 0xC3, 0x1F, 0xE1, 0xF8,
  0x1E, 0x0F, 0xC7, 0x3B, 0x86, 0xE1, 0xF0, 0x7C, 0x1F, 0x86, 0xE3, 0x9F,
  0xE3, 0xB8, 0x0C, 0x07, 0x07, 0x87, 0xC3, 0xC0, 0x39, 0xCE, 0x00, 0x00,
  0x00, 0x07, 0xBD, 0xC0, 0x1C, 0x3C, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0xC1, 0x87, 0x0E, 0x18, 0x60, 0x00, 0x40, 0xE0, 0xF9, 0xF8, 0xF0,
  0x38, 0x0F, 0x80, 0xFC, 0x0F, 0x00, 0x40, 0x7F, 0xEF, 0xFC, 0x00, 0x00,
  0x07, 0xFD, 0xFF, 0xBF, 0xF0, 0x40, 0x1C, 0x07, 0xE0, 0x7E, 0x03, 0xC0,
  0x70, 0xF9, 0xF8, 0xF0, 0x30, 0x00, 0x1E, 0x3F, 0xBC, 0xFC, 0x30, 0x18,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0E, 0x00, 0x00, 0x01, 0x01, 0xC0, 0xE0,
  0x03, 0x00, 0xFC, 0x18, 0x63, 0x02, 0x67, 0xB4, 0xDB, 0xD9, 0xBD, 0x93,
  0x91, 0x29, 0x32, 0x93, 0x69, 0xFC, 0x89, 0x8C, 0x00, 0x76, 0x03, 0xE0,
  0x00, 0xC0, 0x1C, 0x01, 0xE0, 0x3E, 0x03, 0x60, 0x76, 0x06, 0x60, 0x66,
  0x0E, 0x60, 0xC7, 0x1F, 0xF1, 0xFF, 0x38, 0x73, 0x03, 0x70, 0x3E, 0x03,
  0x1F, 0x80, 0xFF, 0x07, 0xFC, 0x30, 0x63, 0x83, 0x9C, 0x18, 0xE1, 0xC7,
  0xFC, 0x3F, 0xE1, 0x83, 0x1C, 0x1C, 0xE0, 0xE7, 0x06, 0x30, 0x71, 0xFF,
  0x1F, 0xF0, 0x07, 0x81, 0xFC, 0x38, 0xE3, 0x06, 0x70, 0x76, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x0C, 0xE1, 0xCE, 0x1C, 0x7F,
  0x83, 0xF0, 0x1F, 0x01, 0xFC, 0x19, 0xE3, 0x87, 0x38, 0x73, 0x83, 0x38,
  0x33, 0x03, 0x30, 0x77, 0x07, 0x70, 0x77, 0x06, 0x60, 0xE6, 0x3C, 0x7F,
  0x8F, 0xE0, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x07, 0xFC, 0x7F, 0xC6, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF,
  0xCF, 0xFC, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x07, 0xFC, 0x7F, 0xC6, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0x07, 0x81, 0xFC, 0x3C, 0xE3, 0x06, 0x70, 0x76, 0x00, 0xE0,
  0x0E, 0x00, 0xE3, 0xEE, 0x7E, 0xC0, 0xEE, 0x0C, 0xE0, 0xC6, 0x1C, 0x7F,
  0xC3, 0xF0, 0x18, 0x38, 0xC1, 0xC6, 0x0E, 0x70, 0x63, 0x83, 0x1C, 0x18,
  0xC1, 0xC7, 0xFE, 0x3F, 0xF3, 0x83, 0x1C, 0x18, 0xC0, 0xC6, 0x0E, 0x30,
  0x73, 0x83, 0x9C, 0x18, 0x3F, 0xE7, 0xFC, 0xFF, 0x83, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x3F,
  0xE7, 0xFC, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xCC, 0x1C, 0xC1, 0xCE, 0x38, 0x7F,
  0x03, 0xE0, 0x1C, 0x1C, 0x60, 0xE1, 0x87, 0x06, 0x38, 0x39, 0xC0, 0xEE,
  0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x07, 0xB8, 0x1C, 0x70, 0x71,
  0xC1, 0x83, 0x86, 0x0E, 0x38, 0x1C, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30,
  0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0F,
  0xFF, 0xFE, 0x1C, 0x38, 0xE3, 0xC7, 0x1E, 0x79, 0xF3, 0xEF, 0x1B, 0x78,
  0xDE, 0xC6, 0xF6, 0x37, 0x73, 0xBB, 0x9D, 0x98, 0xC0, 0xC6, 0x06, 0x30,
  0x31, 0x83, 0x9C, 0x1C, 0x18, 0x38, 0xE1, 0xC7, 0x0E, 0x78, 0x63, 0xE3,
  0x1F, 0x18, 0xD9, 0xC6, 0xCE, 0x33, 0x73, 0x9B, 0x1C, 0xD8, 0xE7, 0xC6,
  0x1E, 0x30, 0xF1, 0x87, 0x1C, 0x18, 0x07, 0x83, 0xF8, 0xE7, 0x98, 0x77,
  0x06, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x6E, 0x1D,
  0xC7, 0x1F, 0xE1, 0xF0, 0x3F, 0x03, 0xFC, 0x31, 0xE3, 0x07, 0x30, 0x77,
  0x07, 0x70, 0x77, 0x0E, 0x7F, 0xC7, 0xF8, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x0C, 0x00, 0x07, 0x83, 0xF8, 0xF3, 0x98, 0x37, 0x06, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x6E, 0x1D, 0xC7, 0x1F,
  0xC1, 0xFC, 0x03, 0x80, 0x38, 0x02, 0x00, 0x1F, 0x80, 0xFF, 0x06, 0x3C,
  0x30, 0x63, 0x83, 0x9C, 0x18, 0xE1, 0xC6, 0x1E, 0x3F, 0xE1, 0xFC, 0x1C,
  0x60, 0xE3, 0x87, 0x1C, 0x30, 0x61, 0x83, 0x9C, 0x1C, 0x07, 0x81, 0xFC,
  0x38, 0xE7, 0x07, 0x70, 0x77, 0x00, 0x38, 0x03, 0xF0, 0x0F, 0x80, 0x3C,
  0x00, 0xCC, 0x0E, 0xC0, 0xEE, 0x1C, 0x7F, 0x83, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x33, 0x07,
  0x30, 0x77, 0x06, 0x70, 0x67, 0x06, 0x60, 0xE6, 0x0E, 0x60, 0xEE, 0x0C,
  0xE0, 0xCE, 0x0C, 0xE1, 0xCE, 0x38, 0x7F, 0x83, 0xE0, 0xE0, 0x7E, 0x0E,
  0xE0, 0xEE, 0x0C, 0x61, 0xC6, 0x18, 0x63, 0x86, 0x38, 0x77, 0x07, 0x70,
  0x76, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x63, 0x1B, 0x19,
  0xD9, 0xCC, 0xCE, 0x66, 0x77, 0x37, 0xB1, 0xBD, 0x8D, 0xEC, 0x7B, 0xE3,
  0xDE, 0x1E, 0xF0, 0xE7, 0x87, 0x38, 0x39, 0xC1, 0x8E, 0x1C, 0x70, 0x1C,
  0x0E, 0x18, 0x38, 0x38, 0xE0, 0x71, 0xC0, 0x67, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x3B, 0x00, 0x77, 0x01, 0xCE, 0x07,
  0x0C, 0x0E, 0x1C, 0x78, 0x38, 0xE0, 0x7E, 0x0E, 0x60, 0xE7, 0x1C, 0x71,
  0x83, 0x38, 0x37, 0x03, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x1F, 0xF9, 0xFF, 0xCF, 0xFC, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x03, 0xFF, 0x9F, 0xFC, 0x1F, 0x1E, 0x18, 0x18, 0x38,
  0x38, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0x60, 0x60,
  0xE0, 0xE0, 0xF0, 0xF0, 0xC7, 0x38, 0xC6, 0x31, 0x8E, 0x31, 0x8C, 0x63,
  0x1C, 0x63, 0x18, 0x1E, 0x3C, 0x18, 0x70, 0xE1, 0xC3, 0x06, 0x0C, 0x18,
  0x70, 0xE1, 0x83, 0x06, 0x0C, 0x38, 0x70, 0xE7, 0x8F, 0x00, 0x06, 0x03,
  0x03, 0x83, 0x61, 0xB1, 0x98, 0xCC, 0xC3, 0xE1, 0x80, 0xFF, 0xFF, 0xF0,
  0xE6, 0x30, 0x0F, 0x0F, 0xE7, 0x1D, 0xC3, 0x00, 0xCF, 0xF7, 0xFF, 0x87,
  0xC1, 0xB8, 0xEF, 0xF9, 0xF6, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0x6E, 0x1F, 0xF3, 0xCE, 0x70, 0xCC, 0x19, 0x83, 0x70, 0x6E, 0x0D, 0xC3,
  0xB8, 0xE7, 0xFC, 0xDF, 0x00, 0x0F, 0x03, 0xF0, 0xE7, 0x38, 0x66, 0x0D,
  0xC0, 0x38, 0x07, 0x00, 0xE1, 0xCC, 0x31, 0xFE, 0x1F, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0xEE, 0x3F, 0xE7, 0x9E, 0x70, 0xC6,
  0x0C, 0xE0, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE3, 0x87, 0xF8, 0x3D, 0x80,
  0x0F, 0x03, 0xF0, 0xE7, 0x38, 0x66, 0x0F, 0xFF, 0xFF, 0xF7, 0x00, 0xE0,
  0x0C, 0x31, 0xFF, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x0E, 0x00, 0xC0, 0x1C,
  0x0F, 0xFC, 0xFF, 0xC1, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x00, 0x07, 0x31, 0xFF, 0x3C, 0xF3,
  0x87, 0x30, 0x67, 0x06, 0x70, 0x67, 0x0E, 0x70, 0xE7, 0x1E, 0x3F, 0xC1,
  0xEC, 0x00, 0xC4, 0x1C, 0xF7, 0x87, 0xF0, 0x0C, 0x00, 0x1C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x9C, 0x3F, 0xE3, 0xCE, 0x38, 0x63, 0x07,
  0x30, 0x67, 0x06, 0x70, 0x67, 0x0E, 0x60, 0xE6, 0x0E, 0xE0, 0xC0, 0x03,
  0x80, 0xE0, 0x30, 0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0x1C, 0x06, 0x01, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x8F, 0xFF, 0xFE, 0x00, 0xC0, 0x1C, 0x03, 0x00,
  0x00, 0xFC, 0x1F, 0x83, 0xE0, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC1, 0x78, 0x3E, 0x0F, 0x00,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x0F, 0x71, 0xC7, 0x38,
  0x67, 0x06, 0xE0, 0x7C, 0x0F, 0xE0, 0xF6, 0x0E, 0x70, 0xC3, 0x8C, 0x38,
  0xC1, 0xC0, 0x1F, 0x87, 0xE3, 0xF8, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE3, 0xFF, 0xFF, 0xC0,
  0x36, 0x63, 0xFF, 0x77, 0x37, 0x33, 0x67, 0x36, 0x73, 0x66, 0x76, 0x67,
  0xE6, 0x6C, 0x66, 0xCE, 0x6C, 0xCE, 0x3B, 0xC3, 0xFE, 0x3C, 0xE3, 0x86,
  0x30, 0x73, 0x06, 0x70, 0x67, 0x0E, 0x70, 0xE6, 0x0E, 0x60, 0xEE, 0x0C,
  0x0F, 0x07, 0xF1, 0xE7, 0x38, 0x6E, 0x0F, 0xC1, 0xF8, 0x37, 0x06, 0xE1,
  0xDC, 0x71, 0xFE, 0x1F, 0x00, 0x1B, 0x87, 0xFC, 0xF3, 0x9C, 0x33, 0x06,
  0x60, 0xDC, 0x1B, 0x83, 0x70, 0xEE, 0x39, 0xFF, 0x37, 0xCE, 0x01, 0xC0,
  0x38, 0x06, 0x00, 0x0E, 0x67, 0xFD, 0xE7, 0xB8, 0x76, 0x0D, 0xC1, 0xB8,
  0x77, 0x0E, 0xE1, 0xDC, 0x71, 0xFE, 0x1E, 0xC0, 0x18, 0x07, 0x00, 0xE0,
  0x18, 0x33, 0xCD, 0xF3, 0xFC, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60,
  0x38, 0x0E, 0x03, 0x80, 0x0F, 0x07, 0xF9, 0xC3, 0x38, 0x77, 0x00, 0x7C,
  0x07, 0xE0, 0x1E, 0xC1, 0xDC, 0x39, 0xFE, 0x1F, 0x80, 0x1C, 0x07, 0x0F,
  0xFF, 0xFF, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xE0,
  0x3F, 0x07, 0xC0, 0x30, 0x6E, 0x1D, 0xC3, 0xB8, 0x76, 0x0C, 0xC1, 0x98,
  0x37, 0x0E, 0xE1, 0xDC, 0x79, 0xFE, 0x1E, 0xC0, 0xC0, 0xF8, 0x1B, 0x87,
  0x70, 0xC6, 0x38, 0xC6, 0x19, 0x83, 0x30, 0x3C, 0x07, 0x80, 0xE0, 0x1C,
  0x00, 0xE6, 0x3C, 0x63, 0xC6, 0x7C, 0xE6, 0xCA, 0x6D, 0xAC, 0xDA, 0xCD,
  0x2C, 0xF3, 0x8F, 0x38, 0xE3, 0x8E, 0x30, 0x38, 0x38, 0xC3, 0x87, 0x38,
  0x1B, 0x80, 0xF8, 0x03, 0xC0, 0x1C, 0x01, 0xF0, 0x1D, 0x81, 0xCE, 0x1C,
  0x31, 0xC1, 0xC0, 0x30, 0x19, 0x81, 0xCE, 0x1C, 0x70, 0xE1, 0x8E, 0x0C,
  0x60, 0x77, 0x03, 0xB0, 0x0F, 0x80, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x0E, 0x02, 0xE0, 0x1E, 0x00, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x7F, 0xEF,
  0xFE, 0x03, 0x83, 0x81, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x7C,
  0x38, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0E, 0x03, 0x80,
  0xC0, 0x18, 0xC4, 0x23, 0x18, 0xC6, 0x21, 0x18, 0xC6, 0x31, 0x88, 0xC6,
  0x31, 0x80, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0E,
  0x03, 0xC1, 0xC1, 0xC1, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x1C,
  0x0C, 0x00, 0x38, 0x07, 0xE3, 0x6F, 0x7C, 0x3E, 0x01, 0xC0,
};

const GFXglyph RobotoMono_MediumItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 16, 13, 4, -16 },
  { 11, 7, 6, 13, 4, -17 },
  { 17, 13, 16, 13, 0, -16 },
  { 43, 11, 20, 13, 1, -18 },
  { 71, 11, 16, 13, 1, -16 },
  { 93, 12, 16, 13, 0, -16 },
  { 117, 3, 6, 13, 6, -17 },
  { 120, 8, 23, 13, 3, -18 },
  { 143, 7, 23, 13, 2, -18 },
  { 164, 10, 11, 13, 2, -16 },
  { 178, 11, 11, 13, 1, -13 },
  { 194, 4, 7, 13, 2, -3 },
  { 198, 8, 2, 13, 3, -8 },
  { 200, 3, 3, 13, 4, -3 },
  { 202, 11, 17, 13, 1, -16 },
  { 226, 11, 16, 13, 1, -16 },
  { 248, 7, 16, 13, 3, -16 },
  { 262, 12, 16, 13, 0, -16 },
  { 286, 11, 16, 13, 1, -16 },
  { 308, 12, 16, 13, 0, -16 },
  { 332, 12, 16, 13, 1, -16 },
  { 356, 10, 16, 13, 1, -16 },
  { 376, 11, 16, 13, 2, -16 },
  { 398, 11, 16, 13, 1, -16 },
  { 420, 10, 16, 13, 2, -16 },
  { 440, 5, 12, 13, 4, -12 },
  { 448, 7, 16, 13, 3, -12 },
  { 462, 10, 10, 13, 2, -12 },
  { 475, 11, 7, 13, 1, -10 },
  { 485, 10, 10, 13, 1, -12 },
  { 498, 9, 16, 13, 3, -16 },
  { 516, 12, 16, 13, 1, -16 },
  { 540, 12, 16, 13, -1, -16 },
  { 564, 13, 16, 13, 0, -16 },
  { 590, 12, 16, 13, 1, -16 },
  { 614, 12, 16, 13, 0, -16 },
  { 638, 12, 16, 13, 1, -16 },
  { 662, 12, 16, 13, 1, -16 },
  { 686, 12, 16, 13, 1, -16 },
  { 710, 13, 16, 13, 0, -16 },
  { 736, 11, 16, 13, 1, -16 },
  { 758, 12, 16, 13, 1, -16 },
  { 782, 14, 16, 13, 0, -16 },
  { 810, 10, 16, 13, 1, -16 },
  { 830, 13, 16, 13, 0, -16 },
  { 856, 13, 16, 13, 0, -16 },
  { 882, 11, 16, 13, 1, -16 },
  { 904, 12, 16, 13, 1, -16 },
  { 928, 11, 19, 13, 1, -16 },
  { 955, 13, 16, 13, 0, -16 },
  { 981, 12, 16, 13, 1, -16 },
  { 1005, 12, 16, 13, 2, -16 },
  { 1029, 12, 16, 13, 1, -16 },
  { 1053, 12, 16, 13, 2, -16 },
  { 1077, 13, 16, 13, 1, -16 },
  { 1103, 15, 16, 13, -1, -16 },
  { 1133, 12, 16, 13, 2, -16 },
  { 1157, 13, 16, 13, 0, -16 },
  { 1183, 8, 21, 13, 3, -18 },
  { 1204, 5, 17, 13, 4, -16 },
  { 1215, 7, 21, 13, 3, -18 },
  { 1234, 9, 9, 13, 2, -16 },
  { 1245, 10, 2, 13, 0, 0 },
  { 1248, 4, 3, 13, 6, -16 },
  { 1250, 10, 12, 13, 1, -12 },
  { 1265, 11, 17, 13, 1, -17 },
  { 1289, 11, 12, 13, 1, -12 },
  { 1306, 12, 17, 13, 1, -17 },
  { 1332, 11, 12, 13, 1, -12 },
  { 1349, 12, 17, 13, 2, -17 },
  { 1375, 12, 17, 13, 0, -12 },
  { 1401, 12, 17, 13, 0, -17 },
  { 1427, 10, 16, 13, 1, -16 },
  { 1447, 11, 21, 13, 0, -16 },
  { 1476, 12, 17, 13, 1, -17 },
  { 1502, 10, 17, 13, 1, -17 },
  { 1524, 12, 12, 13, 0, -12 },
  { 1542, 12, 12, 13, 0, -12 },
  { 1560, 11, 12, 13, 1, -12 },
  { 1577, 11, 16, 13, 0, -12 },
  { 1599, 11, 16, 13, 1, -12 },
  { 1621, 10, 12, 13, 2, -12 },
  { 1636, 11, 12, 13, 1, -12 },
  { 1653, 10, 14, 13, 2, -14 },
  { 1671, 11, 12, 13, 1, -12 },
  { 1688, 11, 12, 13, 2, -12 },
  { 1705, 12, 12, 13, 1, -12 },
  { 1723, 13, 12, 13, 0, -12 },
  { 1743, 13, 17, 13, 0, -12 },
  { 1771, 12, 12, 13, 0, -12 },
  { 1789, 9, 21, 13, 3, -17 },
  { 1813, 5, 20, 13, 4, -16 },
  { 1826, 9, 21, 13, 2, -17 },
  { 1850, 12, 5, 13, 0, -9 },
};

const GFXfont RobotoMono_MediumItalic22pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic22pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOMONO_MEDIUMITALIC22PT7B_H_
