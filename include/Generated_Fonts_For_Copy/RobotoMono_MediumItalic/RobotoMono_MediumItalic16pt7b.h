#ifndef _ROBOTOMONO_MEDIUMITALIC16PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x66, 0x66, 0x40, 0x0C, 0xC0, 0xDE, 0xE5, 0x20, 0x0D, 0x84,
  0x82, 0x4F, 0xF1, 0x20, 0x90, 0xD9, 0xFE, 0x24, 0x36, 0x12, 0x00, 0x04,
  0x0C, 0x3E, 0x63, 0x63, 0x60, 0x30, 0x1C, 0x06, 0x06, 0xC6, 0xEE, 0x7C,
  0x30, 0x20, 0x20, 0xF0, 0x92, 0x94, 0xF4, 0x08, 0x10, 0x3E, 0x2B, 0x5B,
  0x1A, 0x0E, 0x04, 0x0F, 0x0C, 0xC6, 0x63, 0x60, 0xE0, 0xE0, 0xDB, 0x4D,
  0xE3, 0x9B, 0xCF, 0xE0, 0x7E, 0x04, 0x31, 0x8C, 0x21, 0x86, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x06, 0x0C, 0x10, 0x10, 0xC1, 0x82, 0x08, 0x30, 0xC3,
  0x0C, 0x21, 0x86, 0x10, 0xC6, 0x30, 0x80, 0x0C, 0x08, 0x6B, 0xBE, 0x18,
  0x2C, 0x66, 0x04, 0x18, 0x18, 0x18, 0xFF, 0xFE, 0x10, 0x30, 0x30, 0x32,
  0x66, 0xC0, 0xFF, 0xF0, 0xF0, 0x03, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10,
  0x30, 0x20, 0x60, 0x40, 0xC0, 0x08, 0x3E, 0x62, 0x63, 0x43, 0xCF, 0xDA,
  0xE6, 0xC6, 0xC6, 0xCC, 0x78, 0x1F, 0xF6, 0x31, 0x18, 0xC6, 0x31, 0x98,
  0x04, 0x3F, 0x33, 0x61, 0x03, 0x03, 0x06, 0x0C, 0x38, 0x70, 0xFF, 0xFF,
  0x04, 0x0F, 0x8C, 0xC4, 0x30, 0x30, 0xF8, 0x78, 0x06, 0x03, 0x61, 0x99,
  0x87, 0x80, 0x03, 0x07, 0x0F, 0x1B, 0x12, 0x26, 0x66, 0xFF, 0x06, 0x06,
  0x0C, 0x3F, 0x20, 0x60, 0x60, 0x7C, 0x46, 0x06, 0x06, 0xC6, 0xCC, 0x78,
  0x1E, 0x61, 0x82, 0x4F, 0xD8, 0xF1, 0xE3, 0xC7, 0xD9, 0xE0, 0x7F, 0x83,
  0x06, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x30, 0x60, 0xC0, 0x08, 0x3E, 0x63,
  0x63, 0x62, 0x7E, 0x7C, 0xC6, 0xC6, 0xC6, 0xCC, 0x78, 0x08, 0x3E, 0x66,
  0x42, 0xC2, 0xC2, 0x66, 0x7E, 0x06, 0x0C, 0x78, 0x70, 0x77, 0x00, 0x00,
  0x0E, 0xE0, 0x39, 0xC0, 0x00, 0x00, 0x04, 0x63, 0x19, 0x80, 0x01, 0x06,
  0x3E, 0xF0, 0xE0, 0x3C, 0x0E, 0x02, 0x7F, 0x80, 0x00, 0xFE, 0xFE, 0x40,
  0xC1, 0xE0, 0x70, 0xEF, 0x38, 0x40, 0x10, 0xFB, 0x18, 0x30, 0x61, 0x8E,
  0x18, 0x20, 0x01, 0x83, 0x00, 0x1F, 0x18, 0x4B, 0xAB, 0x55, 0x2A, 0x97,
  0x53, 0xBA, 0x52, 0x22, 0x0F, 0x00, 0x06, 0x0E, 0x0A, 0x1A, 0x12, 0x33,
  0x33, 0x7F, 0x63, 0xC3, 0xC3, 0x3F, 0x18, 0xCC, 0x64, 0x37, 0xF3, 0xF9,
  0x8C, 0xC3, 0x63, 0x3F, 0xBF, 0x80, 0x08, 0x3E, 0x63, 0x43, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC2, 0xC6, 0xEC, 0x78, 0x3E, 0x19, 0x8C, 0x64, 0x36, 0x1B,
  0x0D, 0x86, 0xC6, 0x63, 0x7F, 0x3E, 0x00, 0x3F, 0xCC, 0x03, 0x00, 0xC0,
  0x3F, 0x1F, 0xC6, 0x01, 0x80, 0x60, 0x1F, 0xCF, 0xF0, 0x3F, 0xCC, 0x03,
  0x00, 0xC0, 0x20, 0x1F, 0xC6, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x00, 0x08,
  0x3E, 0x63, 0x43, 0xC0, 0xC0, 0xCF, 0xCF, 0xC2, 0xC6, 0xEE, 0x7C, 0x31,
  0x98, 0xC8, 0x6C, 0x37, 0xFB, 0xF9, 0x8C, 0xC6, 0x43, 0x61, 0xB0, 0xC0,
  0x7F, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0xFC, 0xFC, 0x03,
  0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x86, 0xCC, 0x78, 0x31, 0xCC,
  0xE3, 0x70, 0xB8, 0x6C, 0x1F, 0x07, 0xC1, 0x98, 0x66, 0x10, 0xCC, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0x7F, 0xFF, 0x39,
  0xCE, 0xE3, 0xB8, 0xBE, 0x6D, 0x9B, 0x66, 0x91, 0x84, 0x43, 0x30, 0xCC,
  0x30, 0x31, 0x98, 0xCE, 0x6D, 0x36, 0x9B, 0x69, 0xBC, 0xCE, 0x47, 0x63,
  0xB0, 0xC0, 0x08, 0x3E, 0x63, 0x43, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6,
  0xEC, 0x78, 0x3F, 0x18, 0xCC, 0x66, 0x32, 0x1B, 0xF9, 0xF0, 0xC0, 0x60,
  0x30, 0x30, 0x00, 0x08, 0x3E, 0x63, 0x43, 0xC3, 0xC3, 0xC3, 0xC3, 0x82,
  0xC6, 0xEC, 0x7C, 0x0E, 0x04, 0x3F, 0x18, 0xCC, 0x64, 0x36, 0x1B, 0xF9,
  0xF8, 0xCC, 0x66, 0x21, 0xB0, 0xC0, 0x08, 0x3E, 0x63, 0x63, 0x60, 0x70,
  0x3C, 0x06, 0x02, 0xC6, 0xEE, 0x7C, 0xFF, 0x84, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x00, 0x61, 0x63, 0x43, 0x43, 0xC3,
  0xC2, 0xC6, 0xC6, 0xC6, 0xEC, 0x78, 0xC1, 0xB1, 0x98, 0xCC, 0xC6, 0x63,
  0x61, 0xB0, 0x50, 0x38, 0x1C, 0x0C, 0x00, 0xC9, 0xEC, 0xF6, 0x5B, 0x6F,
  0xB7, 0xD3, 0xA9, 0xDC, 0xEE, 0x66, 0x33, 0x00, 0x31, 0xCC, 0x61, 0xB0,
  0x78, 0x0E, 0x03, 0x01, 0xE0, 0xD8, 0x76, 0x18, 0xCC, 0x30, 0xC3, 0xC6,
  0xCC, 0x4C, 0x78, 0x70, 0x30, 0x20, 0x60, 0x60, 0x60, 0x3F, 0x80, 0xC0,
  0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x7F, 0xBF, 0xC0, 0x3C, 0xC3,
  0x0C, 0x20, 0x86, 0x18, 0x61, 0x86, 0x10, 0xC3, 0x0E, 0x38, 0xCC, 0xC4,
  0x46, 0x66, 0x22, 0x33, 0x3C, 0x21, 0x86, 0x18, 0x61, 0x84, 0x30, 0xC3,
  0x0C, 0x30, 0x8E, 0x38, 0x18, 0xE2, 0x9A, 0xCE, 0x30, 0xFE, 0xCC, 0x80,
  0x18, 0xFF, 0x18, 0x37, 0xF8, 0xE1, 0xE6, 0xF6, 0x30, 0x30, 0x30, 0x34,
  0x3F, 0x33, 0x61, 0x63, 0x63, 0x63, 0x66, 0xDE, 0x18, 0xFD, 0x9E, 0x1C,
  0x18, 0x31, 0xE6, 0x78, 0x03, 0x03, 0x03, 0x13, 0x7F, 0x66, 0xC6, 0xC6,
  0xC6, 0xC6, 0xCE, 0x74, 0x18, 0xFD, 0x9E, 0x1F, 0xF8, 0x30, 0x77, 0x7C,
  0x0F, 0x8E, 0x06, 0x03, 0x0F, 0xF0, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x0C, 0x00, 0x0C, 0x1F, 0xCC, 0xCC, 0x66, 0x33, 0x19, 0x8C, 0xEE, 0x3A,
  0x03, 0x31, 0x8F, 0x80, 0x30, 0x30, 0x30, 0x36, 0x2F, 0x73, 0x61, 0x63,
  0x63, 0x63, 0x43, 0xC3, 0x0C, 0x18, 0x00, 0x27, 0x83, 0x06, 0x0C, 0x18,
  0x33, 0xFF, 0xF0, 0x02, 0x03, 0x00, 0x00, 0x1E, 0x06, 0x06, 0x04, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0xF8, 0x30, 0x18, 0x0C, 0x06, 0x13, 0x31,
  0x31, 0xB0, 0xF0, 0x7C, 0x33, 0x11, 0x98, 0x60, 0x3C, 0x78, 0x30, 0x60,
  0x83, 0x06, 0x0C, 0x18, 0x33, 0xFF, 0xF0, 0x09, 0x3F, 0xDB, 0x69, 0xB4,
  0x9E, 0x4B, 0x65, 0xB6, 0xDB, 0x00, 0x06, 0x2F, 0x73, 0x61, 0x63, 0x63,
  0x63, 0x43, 0xC3, 0x18, 0xFD, 0x9E, 0x1C, 0x38, 0xF1, 0xE6, 0x78, 0x04,
  0x3F, 0x33, 0x63, 0x63, 0x63, 0x63, 0x66, 0xDC, 0xC0, 0xC0, 0xC0, 0x18,
  0x7F, 0x66, 0xC6, 0xC6, 0xC6, 0xC6, 0xCE, 0x74, 0x0C, 0x0C, 0x0C, 0x07,
  0x3F, 0x38, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0x18, 0xFD, 0x8B, 0x07,
  0x81, 0xF1, 0xE7, 0x7C, 0x18, 0x18, 0x11, 0xFE, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x32, 0x3E, 0x63, 0x43, 0xC2, 0xC6, 0xC6, 0xC6, 0xCE, 0x74, 0xC3,
  0x46, 0x66, 0x6C, 0x6C, 0x38, 0x38, 0x30, 0xD9, 0xED, 0xA6, 0xD5, 0x4A,
  0xE7, 0x73, 0x31, 0x98, 0x73, 0x89, 0x87, 0x81, 0x81, 0xC1, 0xB1, 0x99,
  0xC6, 0x61, 0xC8, 0x63, 0x30, 0xD8, 0x36, 0x07, 0x01, 0xC0, 0x60, 0x10,
  0x0C, 0x0E, 0x00, 0x7F, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFD, 0xFE,
  0x02, 0x1C, 0x60, 0xC1, 0x83, 0x04, 0x78, 0xE0, 0x40, 0xC1, 0x82, 0x04,
  0x0C, 0x08, 0x24, 0x96, 0x92, 0x4B, 0x49, 0x00, 0x18, 0x10, 0x20, 0xC1,
  0x83, 0x03, 0x87, 0x18, 0x20, 0xC1, 0x83, 0x1C, 0x10, 0x00, 0x78, 0xE7,
  0xD1, 0xC0,
};

const GFXglyph RobotoMono_MediumItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 11, 9, 3, -11 },
  { 7, 5, 4, 9, 3, -12 },
  { 10, 9, 11, 9, 0, -11 },
  { 23, 8, 15, 9, 1, -13 },
  { 38, 8, 12, 9, 1, -12 },
  { 50, 9, 12, 9, 0, -12 },
  { 64, 2, 4, 9, 4, -12 },
  { 65, 6, 17, 9, 2, -13 },
  { 78, 6, 17, 9, 1, -13 },
  { 91, 8, 8, 9, 1, -11 },
  { 99, 8, 8, 9, 1, -9 },
  { 107, 4, 5, 9, 1, -2 },
  { 110, 6, 2, 9, 2, -6 },
  { 112, 2, 2, 9, 3, -2 },
  { 113, 8, 12, 9, 1, -11 },
  { 125, 8, 12, 9, 1, -12 },
  { 137, 5, 11, 9, 2, -11 },
  { 144, 8, 12, 9, 0, -12 },
  { 156, 9, 12, 9, 0, -12 },
  { 170, 8, 11, 9, 0, -11 },
  { 181, 8, 11, 9, 1, -11 },
  { 192, 7, 11, 9, 1, -11 },
  { 202, 8, 11, 9, 1, -11 },
  { 213, 8, 12, 9, 1, -12 },
  { 225, 8, 12, 9, 1, -12 },
  { 237, 4, 9, 9, 3, -9 },
  { 242, 5, 12, 9, 2, -9 },
  { 250, 8, 8, 9, 1, -9 },
  { 258, 8, 5, 9, 1, -7 },
  { 263, 7, 8, 9, 1, -9 },
  { 270, 7, 12, 9, 2, -12 },
  { 281, 9, 11, 9, 0, -11 },
  { 294, 8, 11, 9, 0, -11 },
  { 305, 9, 11, 9, 0, -11 },
  { 318, 8, 12, 9, 1, -12 },
  { 330, 9, 11, 9, 0, -11 },
  { 343, 10, 11, 9, 0, -11 },
  { 357, 10, 11, 9, 0, -11 },
  { 371, 8, 12, 9, 1, -12 },
  { 383, 9, 11, 9, 0, -11 },
  { 396, 8, 11, 9, 1, -11 },
  { 407, 8, 11, 9, 1, -11 },
  { 418, 10, 11, 9, 0, -11 },
  { 432, 8, 11, 9, 0, -11 },
  { 443, 10, 11, 9, 0, -11 },
  { 457, 9, 11, 9, 0, -11 },
  { 470, 8, 12, 9, 1, -12 },
  { 482, 9, 11, 9, 0, -11 },
  { 495, 8, 14, 9, 1, -12 },
  { 509, 9, 11, 9, 0, -11 },
  { 522, 8, 12, 9, 1, -12 },
  { 534, 9, 11, 9, 1, -11 },
  { 547, 8, 11, 9, 1, -11 },
  { 558, 9, 11, 9, 1, -11 },
  { 571, 9, 11, 9, 1, -11 },
  { 584, 10, 11, 9, 0, -11 },
  { 598, 8, 11, 9, 2, -11 },
  { 609, 9, 11, 9, 0, -11 },
  { 622, 6, 16, 9, 2, -13 },
  { 634, 4, 12, 9, 3, -11 },
  { 640, 6, 16, 9, 2, -13 },
  { 652, 6, 6, 9, 2, -11 },
  { 657, 7, 1, 9, 0, 0 },
  { 658, 3, 3, 9, 4, -12 },
  { 660, 7, 9, 9, 1, -9 },
  { 668, 8, 12, 9, 0, -12 },
  { 680, 7, 9, 9, 1, -9 },
  { 688, 8, 12, 9, 1, -12 },
  { 700, 7, 9, 9, 1, -9 },
  { 708, 9, 12, 9, 1, -12 },
  { 722, 9, 12, 9, 0, -9 },
  { 736, 8, 12, 9, 0, -12 },
  { 748, 7, 12, 9, 1, -12 },
  { 759, 8, 15, 9, 0, -12 },
  { 774, 9, 12, 9, 0, -12 },
  { 788, 7, 12, 9, 1, -12 },
  { 799, 9, 9, 9, 0, -9 },
  { 810, 8, 9, 9, 0, -9 },
  { 819, 7, 9, 9, 1, -9 },
  { 827, 8, 12, 9, 0, -9 },
  { 839, 8, 12, 9, 1, -9 },
  { 851, 8, 9, 9, 1, -9 },
  { 860, 7, 9, 9, 1, -9 },
  { 868, 8, 11, 9, 1, -11 },
  { 879, 8, 8, 9, 1, -8 },
  { 887, 8, 8, 9, 1, -8 },
  { 895, 9, 8, 9, 1, -8 },
  { 904, 9, 8, 9, 0, -8 },
  { 913, 10, 11, 9, 0, -8 },
  { 927, 9, 8, 9, 0, -8 },
  { 936, 7, 16, 9, 2, -13 },
  { 950, 3, 14, 9, 3, -11 },
  { 956, 7, 15, 9, 1, -12 },
  { 970, 9, 3, 9, 0, -6 },
};

const GFXfont RobotoMono_MediumItalic16pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic16pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOMONO_MEDIUMITALIC16PT7B_H_
