#ifndef _ROBOTOMONO_MEDIUMITALIC72PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xC0, 0x01, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF3, 0xF8, 0x0F,
  0xCF, 0xE0, 0x7F, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F,
  0xC0, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xC7, 0xE0, 0x3F, 0x1F, 0x80,
  0xFC, 0x7E, 0x03, 0xF1, 0xF0, 0x0F, 0xCF, 0xC0, 0x3E, 0x3F, 0x00, 0xF8,
  0xFC, 0x07, 0xE3, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF,
  0x83, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x60, 0x7E, 0x03, 0xF0, 0x0F, 0x0F, 0xC0, 0x7E, 0x03, 0xF1,
  0xF8, 0x0F, 0xC0, 0xFC, 0x3E, 0x01, 0xF8, 0x3F, 0x07, 0xC0, 0x3F, 0x07,
  0xE1, 0xF8, 0x07, 0xC1, 0xF8, 0x1F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x3F,
  0x0F, 0x80, 0x7E, 0x0F, 0xE3, 0xF0, 0x0F, 0xF7, 0xF8, 0xFC, 0x00, 0xFF,
  0xFE, 0x1F, 0x00, 0x1F, 0xFF, 0xC7, 0xE0, 0x01, 0xFF, 0xE1, 0xF8, 0x00,
  0x0F, 0xF8, 0x7E, 0x00, 0x00, 0x18, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0xF0,
  0x00, 0x1F, 0x8F, 0xFF, 0x00, 0x07, 0xE3, 0xFF, 0xF0, 0x01, 0xF8, 0xFF,
  0xFF, 0x00, 0x3E, 0x3F, 0xCF, 0xE0, 0x0F, 0xC7, 0xE0, 0xFE, 0x03, 0xF1,
  0xF8, 0x0F, 0xC0, 0x7C, 0x3F, 0x01, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x07,
  0xE0, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xE0, 0x1F,
  0x83, 0xC0, 0xFC, 0x03, 0xF0, 0x30, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x00, 0x3F, 0x83,
  0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0x01, 0xFF, 0xFE, 0x00, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0xFE, 0x07, 0xFE, 0xFF, 0x00, 0xFE, 0x0F, 0xFC, 0xFF, 0x80, 0xFE,
  0x1F, 0xF8, 0x7F, 0x81, 0xFE, 0x3F, 0xF0, 0x7F, 0xC1, 0xFC, 0x3F, 0xE0,
  0x3F, 0xE3, 0xFC, 0x3F, 0xC0, 0x3F, 0xE3, 0xFC, 0x7F, 0xC0, 0x1F, 0xF7,
  0xF8, 0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x7F,
  0x80, 0x07, 0xFF, 0xF0, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x7F, 0x80, 0x03,
  0xFF, 0xC0, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0xFE, 0x1F, 0xF0, 0x00,
  0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xC7, 0xF1,
  0xF8, 0x7E, 0x1F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xF1, 0xFC,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x04, 0x00, 0x3E, 0x00, 0x11, 0xC0, 0x0F, 0x80,
  0x1C, 0xFC, 0x03, 0xE0, 0x3F, 0x3F, 0xC0, 0xF8, 0x3F, 0xCF, 0xFC, 0x3C,
  0x7F, 0xF7, 0xFF, 0xDF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0xFE, 0x7E, 0x00,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xE0, 0x7E,
  0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0xC0,
  0x01, 0xC0, 0x00, 0x10, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x83,
  0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x03, 0xFC,
  0x7F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xE7, 0xFC,
  0x3F, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07,
  0xFC, 0x7F, 0x80, 0x01, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0xF1, 0xFE, 0x00,
  0x3F, 0xFE, 0x7F, 0xC0, 0x0F, 0xFF, 0xCF, 0xF0, 0x07, 0xFF, 0xF9, 0xFE,
  0x01, 0xFF, 0xFE, 0x3F, 0xC0, 0xFF, 0xBF, 0xC7, 0xF8, 0x3F, 0xE7, 0xF8,
  0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xE7, 0xFC, 0x1F, 0xE7, 0xFF, 0xFE, 0x07,
  0xFC, 0xFF, 0xFF, 0x80, 0xFF, 0x1F, 0xFF, 0xE0, 0x1F, 0xE3, 0xFF, 0xF0,
  0x03, 0xFC, 0x7F, 0xFC, 0x00, 0x7F, 0x8F, 0xFE, 0x00, 0x0F, 0xF3, 0xFF,
  0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0xC3, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFE, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F,
  0x00, 0xFF, 0x30, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03,
  0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x40, 0x00, 0x01, 0xFE, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x78,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x0F, 0xC0, 0x00, 0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0x9F, 0xFF, 0xC0,
  0x1F, 0xEF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x00,
  0x7F, 0xC3, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0,
  0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03,
  0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFC, 0x1F,
  0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x7F,
  0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0xFE, 0x7F, 0xC0, 0x0F, 0xFE, 0x7F,
  0xE0, 0x1F, 0xFE, 0x3F, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFB, 0xFC, 0x03,
  0xFF, 0xE7, 0xF8, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x7F,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFC, 0x0F, 0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x07,
  0xFD, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x0F, 0xF0, 0x3E,
  0x03, 0xE0, 0x3F, 0xFC, 0x3E, 0x07, 0xE0, 0x7F, 0xFE, 0x3E, 0x07, 0xC0,
  0xFF, 0xFE, 0x1E, 0x0F, 0x81, 0xFF, 0xFC, 0x1E, 0x0F, 0x83, 0xF8, 0x3C,
  0x1E, 0x1F, 0x07, 0xF0, 0x7C, 0x1E, 0x1F, 0x07, 0xE0, 0x7C, 0x1E, 0x3F,
  0x0F, 0xC0, 0x78, 0x1E, 0x3E, 0x0F, 0x80, 0x78, 0x1E, 0x3E, 0x1F, 0x80,
  0xF8, 0x1E, 0x7E, 0x1F, 0x80, 0xF8, 0x3E, 0x7C, 0x1F, 0x00, 0xF8, 0x3E,
  0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x7C, 0x3F, 0x01, 0xF0, 0x3C, 0xFC, 0x3E,
  0x01, 0xF0, 0x3C, 0xF8, 0x3E, 0x01, 0xF0, 0x3C, 0xF8, 0x3E, 0x03, 0xE0,
  0x7C, 0xF8, 0x3E, 0x03, 0xE0, 0x78, 0xF8, 0x3E, 0x03, 0xE0, 0x78, 0xF8,
  0x3E, 0x03, 0xE0, 0xF8, 0xF8, 0x3E, 0x07, 0xE0, 0xF0, 0xF8, 0x3E, 0x0F,
  0xC1, 0xF0, 0xF8, 0x3F, 0x1F, 0xE3, 0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xF8, 0x1F, 0xFB, 0xFF, 0x80, 0xFC, 0x0F,
  0xF1, 0xFF, 0x00, 0x7C, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0x00, 0x00, 0x1F, 0xE0, 0x0F,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x7F,
  0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0xE0, 0x3F,
  0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFF,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFE,
  0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x7F,
  0x80, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x01, 0xFF, 0xFF, 0x1F, 0xE0, 0x07, 0xFF, 0xFC, 0x7F, 0x80, 0x1F,
  0xFF, 0xF3, 0xFE, 0x00, 0xFF, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0xFE, 0x3F,
  0xE0, 0x0F, 0xFF, 0xF8, 0xFF, 0x00, 0x3F, 0xFF, 0xE3, 0xFC, 0x00, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x7F, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFC, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x3F,
  0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xC3, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF7, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF1,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x3F, 0x7F, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x3F, 0xDF, 0x87, 0xEF,
  0xF0, 0x0F, 0xF7, 0xE3, 0xFB, 0xF8, 0x03, 0xF9, 0xF8, 0xFC, 0xFE, 0x00,
  0xFE, 0x7E, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0x9F, 0x9F, 0xE0, 0x1F, 0xE7,
  0xEF, 0xE7, 0xF8, 0x07, 0xF9, 0xFB, 0xF1, 0xFE, 0x01, 0xFE, 0x7F, 0xFC,
  0x7F, 0x00, 0x7F, 0x1F, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xFF, 0x87, 0xF0,
  0x07, 0xF0, 0xFF, 0xE3, 0xFC, 0x03, 0xFC, 0x3F, 0xF0, 0xFF, 0x00, 0xFF,
  0x0F, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF,
  0x83, 0xF8, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x7F,
  0x80, 0x7F, 0x81, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7E, 0x07, 0xF8, 0x07,
  0xF8, 0x1F, 0x01, 0xFC, 0x01, 0xFE, 0x07, 0xC0, 0xFF, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x00,
  0x1F, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x07, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0xFC, 0x03, 0xFF,
  0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xC0,
  0x3F, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0xFF,
  0xE0, 0x07, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFC, 0x03, 0xFD, 0xFC, 0x03,
  0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x7F, 0x00, 0xFF, 0x00,
  0xFF, 0xBF, 0x80, 0x7F, 0x80, 0x7F, 0x8F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC7,
  0xF0, 0x3F, 0xE0, 0x1F, 0xE3, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0xFE, 0x0F,
  0xF0, 0x0F, 0xF8, 0x7F, 0x07, 0xF8, 0x07, 0xFC, 0x3F, 0x83, 0xFC, 0x03,
  0xFC, 0x1F, 0xC3, 0xFE, 0x01, 0xFE, 0x07, 0xF1, 0xFF, 0x00, 0xFF, 0x03,
  0xF8, 0xFF, 0x00, 0x7F, 0x81, 0xFC, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0x3F,
  0xC0, 0x3F, 0xE0, 0x3F, 0x9F, 0xE0, 0x1F, 0xE0, 0x1F, 0xDF, 0xF0, 0x0F,
  0xF0, 0x0F, 0xEF, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFC, 0x01,
  0xFF, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xFF, 0xC0, 0x3F,
  0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xF0, 0x00,
  0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xFC,
  0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0x03, 0xFD, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0xFF, 0x7F,
  0xC0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x03,
  0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0xC0,
  0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x03, 0xFE,
  0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0xCF,
  0xF0, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x3F,
  0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x03, 0xFC,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xFC, 0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0x8F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x07,
  0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0xFF, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFE,
  0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0x80, 0x7F, 0x9F,
  0xE0, 0x1F, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE0, 0x1F, 0xE7, 0xF8, 0x0F,
  0xF0, 0x0F, 0xE3, 0xFC, 0x07, 0xF8, 0x0F, 0xF1, 0xFE, 0x07, 0xFC, 0x07,
  0xF8, 0xFE, 0x03, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFF, 0x01, 0xFC, 0x3F,
  0x80, 0xFF, 0x81, 0xFE, 0x1F, 0xC0, 0xFF, 0xC0, 0xFF, 0x0F, 0xE0, 0x7F,
  0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xF8, 0x3F,
  0xC1, 0xFC, 0x1F, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xFE, 0x0F, 0xE0, 0x7F,
  0x0F, 0xFF, 0x0F, 0xF0, 0x3F, 0x87, 0xFF, 0x87, 0xF8, 0x1F, 0xC3, 0xFF,
  0xC3, 0xF8, 0x0F, 0xE3, 0xFF, 0xE1, 0xFC, 0x07, 0xF1, 0xFB, 0xF1, 0xFE,
  0x03, 0xF8, 0xFD, 0xF8, 0xFE, 0x01, 0xFC, 0x7E, 0xFC, 0x7F, 0x00, 0xFE,
  0x7E, 0x7E, 0x7F, 0x80, 0x7F, 0x3F, 0x3F, 0x3F, 0xC0, 0x3F, 0x9F, 0x9F,
  0x9F, 0xC0, 0x1F, 0xDF, 0x8F, 0xCF, 0xE0, 0x1F, 0xEF, 0xC7, 0xEF, 0xF0,
  0x0F, 0xF7, 0xE3, 0xF7, 0xF0, 0x07, 0xF7, 0xE1, 0xFB, 0xF8, 0x03, 0xFB,
  0xF0, 0xFD, 0xFC, 0x01, 0xFD, 0xF8, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0xFF,
  0xC7, 0xFC, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x02, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xE3, 0xF0,
  0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8,
  0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xE0,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x8F, 0xF0, 0x03, 0xF1, 0xFC, 0x00,
  0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0x3F, 0xC3, 0xFF, 0x00, 0x0F, 0xF1,
  0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0xE3, 0xFE, 0x00,
  0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFB, 0xFC, 0x03,
  0xFF, 0xF8, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x7C, 0x00,
  0x03, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xCF, 0xFF, 0xC0, 0x03, 0xFD, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFF,
  0x1F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0x87, 0xFE,
  0x00, 0x1F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x7F, 0xFF,
  0xF8, 0x0F, 0xF3, 0xFF, 0xFF, 0x00, 0xFF, 0x1F, 0xFF, 0xC0, 0x0F, 0xE0,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xF9,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xF8,
  0x07, 0xF8, 0x00, 0x1F, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0xFC, 0x7F, 0x80,
  0x0F, 0xFF, 0xF9, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F,
  0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0xFE, 0x00, 0x07, 0xFF, 0xE3, 0xF8, 0x00, 0x07, 0xFE,
  0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F,
  0xE1, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0x00, 0x7F, 0x80, 0x00, 0x70, 0x0F, 0xF8, 0x00, 0x1F, 0x01,
  0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x3C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x80, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFC, 0x00, 0x3F,
  0xFF, 0xC7, 0xF0, 0x00, 0xFF, 0xFF, 0xDF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xF0, 0x7F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00,
  0xFF, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF7, 0xF8,
  0x00, 0x1F, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFE, 0x3F, 0xC0, 0x00, 0x03,
  0xC0, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x40, 0x00, 0x1F, 0xF0, 0x01, 0xC0,
  0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x3E, 0x00,
  0x03, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xC7, 0xFF, 0xF0, 0x03, 0xFC, 0xFF,
  0xFF, 0x80, 0x3F, 0x9F, 0xFF, 0xF8, 0x07, 0xFB, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFE,
  0x1F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x0F,
  0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x03,
  0xFC, 0x07, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0xC0, 0x00, 0x7F, 0x87, 0xFF, 0x00, 0x00,
  0xFF, 0x1F, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x03, 0xFD, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xFE, 0x7F, 0xC1, 0xFE,
  0x00, 0xFF, 0x7F, 0xF3, 0xFF, 0x80, 0x7F, 0x7F, 0xFB, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFC, 0x7F, 0xF1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0xFE,
  0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x7F, 0x81, 0xFE, 0x03, 0xF8,
  0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x1F, 0xE0,
  0x3F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x1F, 0xE0,
  0x3F, 0x83, 0xFC, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x1F, 0xE0,
  0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x7F, 0x80,
  0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x87,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0xC0, 0x03, 0xF8, 0x7F, 0xFF, 0x00,
  0x3F, 0x8F, 0xFF, 0xF8, 0x03, 0xF9, 0xFF, 0xFF, 0xC0, 0x7F, 0xBF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01,
  0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF0,
  0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x03,
  0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0xC3,
  0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0xFF, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE3, 0xFE,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x07, 0xFB,
  0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x0F,
  0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x0F, 0xFE, 0x00, 0x01,
  0xFE, 0x7F, 0xFE, 0x00, 0x03, 0xF9, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0xFF,
  0xC0, 0x03, 0xFC, 0x7F, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xF8, 0x00, 0x0F,
  0xF0, 0x0F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC1, 0xFC, 0x01, 0xFF,
  0xFC, 0x7F, 0x80, 0x7F, 0xFF, 0xEF, 0xF0, 0x1F, 0xFF, 0xFD, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x80,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xF8,
  0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xCF, 0xF0, 0x00,
  0x7F, 0xF1, 0xFE, 0x00, 0x03, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x01, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F,
  0x8F, 0xFF, 0xF0, 0x3F, 0x9F, 0xFF, 0xF0, 0x1F, 0xDF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x00, 0x81, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8,
  0x07, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F,
  0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x3F,
  0xF0, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xBF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC1, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01,
  0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE1,
  0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xE0,
  0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07,
  0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0xFE, 0x07,
  0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFB, 0xFC, 0x00, 0xFF, 0xFF, 0x3F, 0xC0, 0x07, 0xFF,
  0xE3, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F,
  0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x07, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x03, 0xFB, 0xFC,
  0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0xFF, 0xFC, 0x01, 0xF8, 0x03,
  0xFF, 0xF8, 0x03, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xF0, 0x0F, 0xEF, 0xE0,
  0x1F, 0xE0, 0x3F, 0xDF, 0xC0, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0xFF, 0x80,
  0xFE, 0x7F, 0x01, 0xFF, 0x01, 0xFC, 0xFE, 0x03, 0xFE, 0x07, 0xF1, 0xFC,
  0x0F, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0xF0,
  0x7F, 0x0F, 0xE0, 0xFF, 0xE0, 0xFE, 0x1F, 0xC1, 0xF7, 0xC1, 0xFC, 0x3F,
  0x87, 0xEF, 0x87, 0xF0, 0x7F, 0x0F, 0x9F, 0x0F, 0xE0, 0xFE, 0x1F, 0x3E,
  0x1F, 0xC1, 0xFC, 0x7E, 0x7C, 0x7F, 0x03, 0xF8, 0xF8, 0xF8, 0xFE, 0x07,
  0xF1, 0xF1, 0xF1, 0xF8, 0x07, 0xE7, 0xE3, 0xE7, 0xF0, 0x0F, 0xCF, 0x87,
  0xCF, 0xE0, 0x1F, 0xBF, 0x0F, 0x9F, 0x80, 0x3F, 0x7C, 0x1F, 0x7F, 0x00,
  0x7E, 0xF8, 0x3E, 0xFE, 0x00, 0xFF, 0xF0, 0x7D, 0xF8, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFD, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xE0, 0xFF, 0xFF, 0x80, 0x03, 0xF1, 0xFF, 0xFF, 0x80, 0x07, 0xE7,
  0xFF, 0xFF, 0x80, 0x1F, 0xDF, 0xFF, 0xFF, 0x80, 0x3F, 0x3F, 0xE7, 0xFF,
  0xC1, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0xFD, 0xFC, 0x01, 0xFF, 0xFF, 0xF3,
  0xF0, 0x01, 0xFF, 0xFF, 0xC7, 0xE0, 0x01, 0xFF, 0xFF, 0x8F, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00,
};

const GFXglyph RobotoMono_MediumItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 17, 52, 42, 13, -51 },
  { 112, 22, 18, 42, 13, -54 },
  { 162, 42, 51, 42, 0, -51 },
  { 430, 37, 66, 42, 4, -59 },
  { 736, 35, 53, 42, 4, -52 },
  { 968, 40, 53, 42, 1, -52 },
  { 1233, 10, 18, 42, 18, -54 },
  { 1256, 24, 73, 42, 11, -57 },
  { 1475, 24, 73, 42, 6, -57 },
  { 1694, 34, 35, 42, 6, -51 },
  { 1843, 36, 37, 42, 3, -42 },
  { 2010, 14, 21, 42, 7, -8 },
  { 2047, 29, 7, 42, 8, -26 },
  { 2073, 12, 12, 42, 13, -11 },
  { 2091, 37, 55, 42, 3, -51 },
  { 2346, 35, 53, 42, 4, -52 },
  { 2578, 23, 51, 42, 9, -51 },
  { 2725, 38, 52, 42, 0, -52 },
  { 2972, 37, 53, 42, 2, -52 },
  { 3218, 37, 51, 42, 1, -51 },
  { 3454, 37, 52, 42, 4, -51 },
  { 3695, 34, 52, 42, 3, -51 },
  { 3916, 37, 51, 42, 5, -51 },
  { 4152, 36, 53, 42, 3, -52 },
  { 4391, 32, 52, 42, 6, -52 },
  { 4599, 17, 42, 42, 14, -41 },
  { 4689, 21, 54, 42, 10, -41 },
  { 4831, 33, 33, 42, 5, -39 },
  { 4968, 35, 22, 42, 4, -33 },
  { 5065, 34, 33, 42, 3, -39 },
  { 5206, 31, 53, 42, 9, -52 },
  { 5412, 40, 51, 42, 2, -51 },
  { 5667, 39, 51, 42, -2, -51 },
  { 5916, 40, 51, 42, 1, -51 },
  { 6171, 38, 53, 42, 3, -52 },
  { 6423, 39, 51, 42, 1, -51 },
  { 6672, 41, 51, 42, 2, -51 },
  { 6934, 41, 51, 42, 2, -51 },
  { 7196, 38, 53, 42, 3, -52 },
  { 7448, 41, 51, 42, 1, -51 },
  { 7710, 38, 51, 42, 3, -51 },
  { 7953, 40, 52, 42, 2, -51 },
  { 8213, 46, 51, 42, 1, -51 },
  { 8507, 33, 51, 42, 2, -51 },
  { 8718, 42, 51, 42, 1, -51 },
  { 8986, 41, 51, 42, 1, -51 },
  { 9248, 37, 53, 42, 3, -52 },
  { 9494, 40, 51, 42, 2, -51 },
  { 9749, 38, 61, 42, 3, -52 },
  { 10039, 39, 51, 42, 2, -51 },
  { 10288, 40, 53, 42, 2, -52 },
  { 10553, 40, 51, 42, 6, -51 },
  { 10808, 40, 52, 42, 3, -51 },
  { 11068, 39, 51, 42, 6, -51 },
  { 11317, 41, 51, 42, 5, -51 },
  { 11579, 48, 51, 42, -2, -51 },
  { 11885, 39, 51, 42, 7, -51 },
  { 12134, 42, 51, 42, 0, -51 },
  { 12402, 25, 70, 42, 9, -59 },
  { 12621, 18, 55, 42, 13, -51 },
  { 12745, 25, 70, 42, 9, -59 },
  { 12964, 27, 27, 42, 8, -51 },
  { 13056, 33, 7, 42, 0, 0 },
  { 13085, 13, 10, 42, 19, -52 },
  { 13102, 34, 40, 42, 3, -39 },
  { 13272, 36, 55, 42, 2, -54 },
  { 13520, 34, 40, 42, 4, -39 },
  { 13690, 38, 55, 42, 4, -54 },
  { 13952, 35, 40, 42, 3, -39 },
  { 14127, 39, 56, 42, 6, -56 },
  { 14400, 39, 54, 42, 1, -39 },
  { 14664, 36, 54, 42, 2, -54 },
  { 14907, 32, 53, 42, 3, -53 },
  { 15119, 32, 68, 42, 2, -53 },
  { 15391, 39, 54, 42, 2, -54 },
  { 15655, 33, 54, 42, 3, -54 },
  { 15878, 41, 39, 42, -1, -39 },
  { 16078, 36, 39, 42, 2, -39 },
  { 16254, 35, 40, 42, 3, -39 },
  { 16429, 39, 54, 42, -1, -39 },
  { 16693, 35, 54, 42, 4, -39 },
  { 16930, 33, 39, 42, 7, -39 },
  { 17091, 35, 40, 42, 3, -39 },
  { 17266, 33, 48, 42, 6, -47 },
  { 17464, 36, 39, 42, 4, -38 },
  { 17640, 36, 38, 42, 6, -38 },
  { 17811, 39, 38, 42, 4, -38 },
  { 17997, 42, 38, 42, 0, -38 },
  { 18197, 44, 53, 42, 0, -38 },
  { 18489, 39, 38, 42, 1, -38 },
  { 18675, 27, 69, 42, 11, -56 },
  { 18908, 16, 65, 42, 13, -51 },
  { 19038, 27, 69, 42, 7, -56 },
  { 19271, 39, 15, 42, 1, -29 },
};

const GFXfont RobotoMono_MediumItalic72pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic72pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic72pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _ROBOTOMONO_MEDIUMITALIC72PT7B_H_
