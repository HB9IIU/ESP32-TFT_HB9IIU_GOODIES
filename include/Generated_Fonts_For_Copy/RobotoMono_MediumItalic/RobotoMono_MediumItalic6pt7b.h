#ifndef _ROBOTOMONO_MEDIUMITALIC6PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0xF0, 0x6F, 0xEC, 0x2D, 0x1E, 0x80, 0xE9, 0xB0, 0x6B, 0xF0,
  0xC0, 0x6A, 0xA0, 0x44, 0x95, 0x80, 0x6C, 0x3D, 0x20, 0xC0, 0xC0, 0x80,
  0x25, 0x60, 0x77, 0xB0, 0xDA, 0xE5, 0x70, 0x6C, 0xF0, 0x2F, 0x90, 0x6C,
  0xF0, 0x7E, 0xB0, 0x72, 0x4C, 0x6E, 0xF0, 0x75, 0xA0, 0x48, 0x4A, 0x78,
  0x80, 0x7C, 0x4E, 0x00, 0xDA, 0x7E, 0xF0, 0x2D, 0xD0, 0x7E, 0xF0, 0x72,
  0x70, 0x76, 0xF0, 0x7E, 0x8E, 0x7E, 0x88, 0x72, 0xB0, 0x5E, 0xAA, 0x69,
  0x70, 0x12, 0x2E, 0x74, 0xAA, 0x52, 0x70, 0x76, 0xEA, 0x56, 0xAA, 0x76,
  0xF0, 0x7A, 0xC8, 0x76, 0xF2, 0x77, 0xD0, 0x68, 0xF0, 0xF4, 0x44, 0x5A,
  0xAE, 0xBA, 0x40, 0xBE, 0xEA, 0x76, 0x6A, 0xFA, 0x40, 0x72, 0x4E, 0x6A,
  0xA0, 0xA9, 0x56, 0xA0, 0x70, 0xE0, 0x80, 0xFF, 0x80, 0x49, 0xDE, 0x71,
  0x80, 0x12, 0x6A, 0xE0, 0x7D, 0x80, 0x73, 0x48, 0x77, 0xF0, 0x4A, 0xDA,
  0x2D, 0x70, 0x2C, 0xAC, 0x4A, 0xEA, 0x64, 0xAE, 0xFF, 0x80, 0x76, 0x80,
  0x77, 0x80, 0xF7, 0xC0, 0x77, 0x90, 0xE8, 0xEF, 0x80, 0xBB, 0xB7, 0x80,
  0xAD, 0x00, 0xDE, 0xA0, 0x74, 0xA0, 0xB6, 0x4C, 0x6B, 0x80, 0x56, 0xA0,
  0xF8, 0x99, 0xA0, 0xE0,
};

const GFXglyph RobotoMono_MediumItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 4, 4, 1, -4 },
  { 2, 2, 2, 4, 1, -5 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 3, 4, 4, 0, -4 },
  { 10, 3, 4, 4, 0, -4 },
  { 12, 1, 2, 4, 1, -5 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 3, 6, 4, 0, -5 },
  { 18, 2, 3, 4, 1, -4 },
  { 19, 3, 4, 4, 0, -4 },
  { 21, 1, 2, 4, 1, -1 },
  { 22, 2, 1, 4, 1, -2 },
  { 23, 1, 1, 4, 1, -1 },
  { 24, 3, 4, 4, 0, -4 },
  { 26, 3, 4, 4, 0, -4 },
  { 28, 2, 4, 4, 1, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 3, 4, 4, 0, -4 },
  { 35, 3, 4, 4, 0, -4 },
  { 37, 3, 4, 4, 0, -4 },
  { 39, 4, 4, 4, 0, -4 },
  { 41, 3, 4, 4, 0, -4 },
  { 43, 3, 4, 4, 0, -4 },
  { 45, 2, 3, 4, 1, -3 },
  { 46, 2, 4, 4, 1, -3 },
  { 47, 3, 3, 4, 0, -3 },
  { 49, 3, 2, 4, 0, -3 },
  { 50, 3, 3, 4, 0, -3 },
  { 52, 2, 4, 4, 1, -4 },
  { 53, 3, 4, 4, 0, -4 },
  { 55, 3, 4, 4, 0, -4 },
  { 57, 3, 4, 4, 0, -4 },
  { 59, 3, 4, 4, 0, -4 },
  { 61, 3, 4, 4, 0, -4 },
  { 63, 4, 4, 4, 0, -4 },
  { 65, 4, 4, 4, 0, -4 },
  { 67, 3, 4, 4, 0, -4 },
  { 69, 4, 4, 4, 0, -4 },
  { 71, 3, 4, 4, 0, -4 },
  { 73, 4, 4, 4, 0, -4 },
  { 75, 4, 4, 4, 0, -4 },
  { 77, 3, 4, 4, 0, -4 },
  { 79, 4, 4, 4, 0, -4 },
  { 81, 4, 4, 4, 0, -4 },
  { 83, 3, 4, 4, 0, -4 },
  { 85, 4, 4, 4, 0, -4 },
  { 87, 3, 5, 4, 0, -4 },
  { 89, 3, 4, 4, 0, -4 },
  { 91, 3, 4, 4, 0, -4 },
  { 93, 4, 4, 4, 0, -4 },
  { 95, 4, 4, 4, 0, -4 },
  { 97, 3, 4, 4, 1, -4 },
  { 99, 4, 4, 4, 0, -4 },
  { 101, 4, 4, 4, 0, -4 },
  { 103, 3, 4, 4, 1, -4 },
  { 105, 4, 4, 4, 0, -4 },
  { 107, 2, 6, 4, 1, -5 },
  { 109, 2, 4, 4, 1, -4 },
  { 110, 2, 6, 4, 1, -5 },
  { 112, 2, 2, 4, 1, -4 },
  { 113, 3, 1, 4, 0, 0 },
  { 114, 1, 1, 4, 2, -4 },
  { 115, 3, 3, 4, 0, -3 },
  { 117, 3, 5, 4, 0, -5 },
  { 119, 3, 3, 4, 0, -3 },
  { 121, 4, 5, 4, 0, -5 },
  { 124, 3, 3, 4, 0, -3 },
  { 126, 3, 5, 4, 1, -5 },
  { 128, 3, 4, 4, 0, -3 },
  { 130, 3, 5, 4, 0, -5 },
  { 132, 3, 4, 4, 0, -4 },
  { 134, 3, 5, 4, 0, -4 },
  { 136, 3, 5, 4, 0, -5 },
  { 138, 3, 5, 4, 0, -5 },
  { 140, 3, 3, 4, 0, -3 },
  { 142, 3, 3, 4, 0, -3 },
  { 144, 3, 3, 4, 0, -3 },
  { 146, 3, 4, 4, 0, -3 },
  { 148, 3, 4, 4, 0, -3 },
  { 150, 2, 3, 4, 1, -3 },
  { 151, 3, 3, 4, 0, -3 },
  { 153, 2, 4, 4, 1, -4 },
  { 154, 3, 3, 4, 0, -3 },
  { 156, 3, 3, 4, 0, -3 },
  { 158, 4, 3, 4, 0, -3 },
  { 160, 4, 3, 4, 0, -3 },
  { 162, 4, 4, 4, 0, -3 },
  { 164, 3, 3, 4, 0, -3 },
  { 166, 2, 6, 4, 1, -5 },
  { 168, 1, 5, 4, 1, -4 },
  { 169, 2, 6, 4, 1, -5 },
  { 171, 3, 1, 4, 0, -2 },
};

const GFXfont RobotoMono_MediumItalic6pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic6pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOMONO_MEDIUMITALIC6PT7B_H_
