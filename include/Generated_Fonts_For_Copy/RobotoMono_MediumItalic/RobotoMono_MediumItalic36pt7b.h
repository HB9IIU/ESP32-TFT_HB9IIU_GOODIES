#ifndef _ROBOTOMONO_MEDIUMITALIC36PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x01, 0xE1, 0xF0, 0xF8, 0x3C, 0x00, 0x38, 0xF3, 0x8E, 0x78, 0xE7,
  0x0E, 0x70, 0xE7, 0x0E, 0x71, 0xC7, 0x1C, 0xE1, 0xC0, 0x00, 0x1C, 0x70,
  0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x61, 0xC0, 0x07, 0x0E, 0x00, 0x38,
  0x60, 0x01, 0x87, 0x00, 0x1C, 0x38, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFE, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x38,
  0x00, 0xE1, 0xC0, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x1C,
  0x38, 0x00, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xC0, 0x03, 0x0E, 0x00,
  0x38, 0x70, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE,
  0x1F, 0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xCF, 0x00, 0xFB, 0xC0, 0x3C,
  0xF0, 0x0F, 0x3E, 0x07, 0xC7, 0xC3, 0xF1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07,
  0xFC, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x1F,
  0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xC7, 0x08, 0xE1, 0xC3, 0xB8, 0x71,
  0xCE, 0x1C, 0xE3, 0x87, 0x30, 0x73, 0x9C, 0x1F, 0xCE, 0x03, 0xE7, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x78, 0x07,
  0x3F, 0x03, 0x9F, 0xE0, 0xEE, 0x38, 0x73, 0x86, 0x38, 0xE3, 0x8E, 0x38,
  0xE1, 0x0E, 0x38, 0x03, 0x9E, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xEF, 0x80, 0x78, 0xF0, 0x1E, 0x0E,
  0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x1E, 0x01, 0xEF, 0x80, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x39, 0xFF, 0x8F,
  0x7C, 0xF1, 0xFF, 0x0F, 0x3B, 0xC1, 0xFF, 0x78, 0x1F, 0xCF, 0x03, 0xF9,
  0xE0, 0x3E, 0x3E, 0x1F, 0xC3, 0xFF, 0xFC, 0x3F, 0xF7, 0x83, 0xFC, 0xF8,
  0x3B, 0xDE, 0xE7, 0x39, 0xDC, 0xE0, 0x00, 0x20, 0x06, 0x00, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xC0,
  0x04, 0x00, 0x04, 0x00, 0x60, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x01, 0x07, 0x05, 0xE3,
  0x0E, 0xFD, 0xBF, 0xFF, 0xFF, 0x87, 0xFE, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0xF7, 0x00, 0xF3, 0x80, 0xF1, 0xE0, 0xF0, 0x78, 0x38, 0x38, 0x08, 0x08,
  0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x78,
  0x78, 0xF0, 0x20, 0x7F, 0xFE, 0xFF, 0xFB, 0xFF, 0xF0, 0x7D, 0xFF, 0xFF,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0x7E, 0x1F, 0x07, 0x87, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x0F, 0x3C, 0x03,
  0xDF, 0x03, 0xE7, 0x81, 0xF9, 0xE1, 0xFE, 0x78, 0xF7, 0x9E, 0xF9, 0xE7,
  0xF8, 0x7B, 0xFC, 0x3E, 0xFC, 0x0F, 0x3E, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x3C, 0xF0, 0x1E, 0x1E, 0x07, 0x87, 0xC7, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x03, 0xF8, 0x00, 0x00, 0x10, 0x07, 0x03, 0xF1, 0xFF, 0x7F, 0xE7, 0xFE,
  0x79, 0xE4, 0x1E, 0x81, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x1F,
  0xFE, 0x07, 0xFF, 0xE0, 0xF0, 0x3C, 0x3E, 0x07, 0xC7, 0x80, 0x78, 0xF0,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3F, 0x7F, 0x1F, 0x07, 0xC7, 0x80, 0xF3, 0xE0, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0xFB, 0xC0, 0x3C, 0xF0, 0x0F, 0x3E, 0x07, 0xC7, 0xC3, 0xE1,
  0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1E, 0xF0,
  0x03, 0xFC, 0x00, 0xF7, 0x80, 0x3C, 0xF0, 0x0F, 0x1E, 0x01, 0xC3, 0xC0,
  0x78, 0x78, 0x1E, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x38, 0x0F, 0x0F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xE0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x9E, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF0, 0x38, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xF1, 0xF0,
  0x3C, 0x1F, 0x1F, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x00,
  0x0E, 0x00, 0x7E, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0xF0, 0x7B, 0xFC, 0x7F, 0xFE, 0x7F,
  0x7E, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF8, 0x3E, 0x7C, 0x7C, 0x7F, 0xFC, 0x3F,
  0xF8, 0x0F, 0xE0, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0x7E, 0x1F,
  0x07, 0x87, 0x81, 0xF3, 0xE0, 0x7C, 0xF0, 0x1E, 0x3C, 0x07, 0x87, 0x81,
  0xE1, 0xE0, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xE1,
  0xF0, 0x78, 0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0,
  0x1F, 0x3C, 0x07, 0x8F, 0x87, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8,
  0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x1E, 0x78,
  0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x1F, 0x78, 0x3F, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xDE, 0x03,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0xE0, 0x7F,
  0xC0, 0x7F, 0x00, 0x7C, 0x00, 0x1F, 0x1F, 0x3F, 0x1F, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xFC, 0xFC, 0xFC,
  0x78, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x70, 0x1E,
  0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x7F, 0x03, 0xFF, 0x0F,
  0xFC, 0x3F, 0xE0, 0xFF, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x08, 0x3F,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0,
  0x30, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0xFF, 0x83, 0xFF, 0x0F,
  0xFC, 0x0F, 0xF8, 0x07, 0xE0, 0x03, 0xC0, 0x01, 0x00, 0x00, 0x07, 0xE0,
  0x3F, 0xF1, 0xFF, 0xF3, 0xFF, 0xEF, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x7C, 0x1C, 0x0F, 0x00, 0xE0,
  0xE0, 0x06, 0x1C, 0x7C, 0x63, 0x8F, 0xE7, 0x39, 0xE6, 0x77, 0x1C, 0x67,
  0x73, 0x8E, 0x76, 0x30, 0xC7, 0xE7, 0x0C, 0x6E, 0x70, 0xC6, 0xE7, 0x1C,
  0x6E, 0x71, 0xCE, 0xC7, 0x18, 0xCC, 0x73, 0x9C, 0xE7, 0xFF, 0x8E, 0x3D,
  0xF0, 0xE1, 0x04, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE7, 0x00, 0x1F,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x73, 0x80, 0x0F, 0x38, 0x00, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3,
  0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x07, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1E, 0x01, 0xE3, 0xC0, 0x1E, 0x3C,
  0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xEF, 0x80, 0x1F, 0x0F, 0xF0, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x03, 0xE1, 0xE0, 0x1E,
  0x1E, 0x01, 0xF1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x3E, 0x3E, 0x07,
  0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3C, 0x1F, 0x87, 0xC0,
  0x7C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78,
  0x07, 0xCF, 0x80, 0xF8, 0xF0, 0x7F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0F, 0x83, 0xE1, 0xF0, 0x1E, 0x1E, 0x01, 0xE3, 0xC0, 0x1F, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x03, 0xC7, 0x80, 0x78, 0x78, 0x07, 0x87, 0xC0, 0xF8, 0x3E, 0x3F, 0x03,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x80,
  0x3F, 0xFC, 0x0F, 0xFF, 0xC1, 0xE0, 0xFC, 0x3C, 0x0F, 0x87, 0x80, 0xF0,
  0xF0, 0x1F, 0x1E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3,
  0xC0, 0x1E, 0x78, 0x03, 0xDF, 0x00, 0xFB, 0xE0, 0x1E, 0x78, 0x03, 0xCF,
  0x00, 0x79, 0xE0, 0x1E, 0x3C, 0x07, 0xCF, 0x81, 0xF1, 0xE0, 0x7E, 0x3C,
  0x7F, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xF0, 0x7C, 0x7C,
  0x07, 0x8F, 0x00, 0xF3, 0xE0, 0x1F, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0xFF, 0xBC, 0x1F, 0xE7, 0x83,
  0xFC, 0xF0, 0x87, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x00,
  0xF1, 0xF0, 0x1E, 0x1F, 0x0F, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFE,
  0x00, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0,
  0xF0, 0x0F, 0x87, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x1E, 0x00,
  0xF0, 0xF0, 0x07, 0x87, 0x80, 0x78, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0x80, 0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x1E,
  0x0F, 0x00, 0xF0, 0x78, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0,
  0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x87, 0xC0, 0x3C, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x43, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x8F,
  0x00, 0xF8, 0xF8, 0x0F, 0x07, 0x81, 0xF0, 0x7C, 0x3E, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x7C, 0x3C, 0x03, 0xE0, 0xF0,
  0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0x78, 0x3F, 0x01, 0xE1, 0xF8,
  0x07, 0x87, 0xC0, 0x1E, 0x3E, 0x00, 0x79, 0xF0, 0x03, 0xEF, 0x80, 0x0F,
  0x7C, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xDE,
  0x00, 0x7E, 0x7C, 0x01, 0xF0, 0xF0, 0x07, 0x83, 0xE0, 0x1E, 0x07, 0x80,
  0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xE0, 0xF0,
  0x07, 0x83, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x02, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0x80, 0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x7F, 0x83, 0xB9, 0xDC, 0x0E,
  0xEF, 0xF0, 0x7B, 0xBB, 0xC1, 0xEE, 0xEF, 0x07, 0xBF, 0x3C, 0x1E, 0xFC,
  0xE0, 0x73, 0xE3, 0x83, 0xC7, 0x9E, 0x0F, 0x1C, 0x78, 0x3C, 0x71, 0xE0,
  0xF1, 0x87, 0x83, 0xC0, 0x1C, 0x0E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0,
  0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0x83, 0xC0, 0x1E,
  0x00, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC3, 0xF0, 0x1E, 0x1F, 0x81, 0xF0,
  0xFC, 0x0F, 0x07, 0xE0, 0x78, 0x3F, 0x83, 0xC1, 0xFC, 0x1E, 0x1F, 0xE0,
  0xF0, 0xF7, 0x8F, 0x87, 0xBC, 0x78, 0x3C, 0xE3, 0xC1, 0xE7, 0x1E, 0x0F,
  0x3C, 0xF0, 0xF9, 0xE7, 0x87, 0x87, 0x7C, 0x3C, 0x3B, 0xC1, 0xE1, 0xFE,
  0x0F, 0x07, 0xF0, 0x78, 0x3F, 0x87, 0xC1, 0xFC, 0x3C, 0x0F, 0xE1, 0xE0,
  0x3E, 0x0F, 0x01, 0xF0, 0x78, 0x0F, 0x87, 0xC0, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xF8, 0x3C, 0x3E, 0x07,
  0xC7, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3D, 0xF0, 0x07,
  0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0xFB, 0xC0, 0x1E,
  0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x1F, 0x3C, 0x03, 0xC7, 0x80, 0xF8,
  0xF8, 0x1E, 0x0F, 0x8F, 0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x03,
  0xE0, 0xF0, 0x1F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0,
  0x0F, 0x1E, 0x01, 0xE1, 0xE0, 0x3E, 0x3C, 0x0F, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0x03, 0xFF, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x1F, 0xFE,
  0x03, 0xFF, 0xE0, 0xF8, 0x3C, 0x3E, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x0F,
  0x3C, 0x01, 0xE7, 0x80, 0x3D, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E,
  0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x1F, 0xF8, 0x03, 0xDF, 0x00, 0x79,
  0xE0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF8, 0x1E, 0x0F, 0x8F, 0x81,
  0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x1F, 0x03, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xF1, 0xE0,
  0x1F, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x3E, 0x03, 0xE3, 0xC0, 0x7C, 0x3C,
  0x1F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7C, 0x3C, 0x07,
  0x83, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0x80, 0xF0,
  0xF0, 0x0F, 0x0F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0x78, 0x00, 0x7E,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x83, 0xE1, 0xF0,
  0x1F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C,
  0xF8, 0x07, 0xC7, 0x80, 0x78, 0x7E, 0x1F, 0x83, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE3, 0xC0,
  0x3C, 0x78, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0x8F, 0x00,
  0xF1, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03,
  0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F,
  0x9E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xF1, 0xF0, 0x7C,
  0x1F, 0x1F, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0xF8, 0x01,
  0xFF, 0x80, 0x3E, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0x78, 0x07, 0xC7, 0x80,
  0x78, 0x78, 0x0F, 0x87, 0x80, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x3C,
  0x1E, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC7, 0xC0, 0x3C, 0x78, 0x03,
  0xCF, 0x80, 0x3C, 0xF0, 0x01, 0xCF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x78, 0x70, 0x7B, 0xC3, 0x83, 0x9E, 0x1C, 0x3C, 0xF1,
  0xE1, 0xE7, 0x8F, 0x0F, 0x3C, 0x78, 0x71, 0xE7, 0xC7, 0x8F, 0x3E, 0x3C,
  0x79, 0xF1, 0xE3, 0x9D, 0x9E, 0x1C, 0xEC, 0xF0, 0xE7, 0x67, 0x87, 0x3B,
  0x38, 0x3B, 0x9B, 0xC1, 0xDC, 0xDE, 0x0E, 0xE6, 0xF0, 0x7E, 0x37, 0x03,
  0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F,
  0x03, 0xE0, 0xF8, 0x1F, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0x81, 0xE0, 0x00,
  0x07, 0x80, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x7C,
  0x03, 0xE0, 0xF8, 0x01, 0xE1, 0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xF3, 0xE0,
  0x00, 0xF7, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xEF, 0x00, 0x03, 0xCF, 0x80, 0x07, 0xC7, 0x80,
  0x0F, 0x87, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x3E, 0x03, 0xE0,
  0x7C, 0x01, 0xE0, 0xFC, 0x01, 0xF0, 0xF8, 0x01, 0xF7, 0x80, 0x1E, 0x78,
  0x03, 0xE7, 0xC0, 0x7C, 0x3C, 0x07, 0x83, 0xC0, 0xF8, 0x3C, 0x0F, 0x01,
  0xE1, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x1E, 0x7C, 0x00, 0xF7, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x0F, 0xF0, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x00, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0,
  0x70, 0x70, 0x78, 0x78, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C,
  0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x07, 0xF0, 0x1D, 0xC0, 0xF7, 0x03, 0x9C,
  0x1E, 0x70, 0xF1, 0xE3, 0xC3, 0x9E, 0x0E, 0x70, 0x3B, 0xC0, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xE7, 0x8F, 0x1C, 0x03, 0xFC, 0x07,
  0xFF, 0x87, 0xFF, 0xC3, 0xE1, 0xF3, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x01, 0xFF, 0x0F, 0xFF, 0x9F, 0xFF, 0xCF, 0x83, 0xEF, 0x01, 0xE7, 0x80,
  0xF7, 0xC0, 0x7B, 0xE0, 0x7C, 0xF0, 0xFE, 0x7F, 0xFF, 0x1F, 0xF7, 0x87,
  0xF3, 0xC0, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0xFE, 0x07, 0xFF,
  0xC1, 0xFF, 0xF8, 0x7E, 0x3E, 0x3E, 0x07, 0x8F, 0x01, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x7D, 0xE0, 0x1E, 0x78,
  0x07, 0x9E, 0x03, 0xE7, 0x80, 0xF3, 0xF8, 0xFC, 0xFF, 0xFE, 0x3D, 0xFF,
  0x0F, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xC3, 0xE3,
  0xC0, 0xFB, 0xC0, 0x3D, 0xE0, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x17, 0x80, 0xF3, 0xE0, 0x78, 0xF8,
  0x7C, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x07, 0xF7, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x0F,
  0xC7, 0xC0, 0xF8, 0xF0, 0x0F, 0x1E, 0x03, 0xE7, 0x80, 0x78, 0xF0, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xF1, 0xE0, 0x3C,
  0x3E, 0x0F, 0x83, 0xE3, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7E, 0x78,
  0x00, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xE3, 0xE3, 0xC0, 0x7B,
  0xC0, 0x3D, 0xE0, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x30, 0xF8, 0x3C, 0x3F,
  0xFE, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF9, 0xE0, 0xFF, 0xBC, 0x3F, 0xFF, 0x0F, 0xC7, 0xE3, 0xE0,
  0x7C, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xE0, 0x3E, 0x78, 0x07, 0x8F, 0x00,
  0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1F, 0x1F, 0x03,
  0xC1, 0xF1, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x80, 0x7C, 0x3C, 0x1F, 0x07, 0xFF, 0xE0, 0x7F, 0xF0,
  0x07, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x7E, 0x07, 0xBF, 0xE1, 0xFF, 0xF8, 0xFE, 0x3F, 0x3E, 0x07, 0xCF,
  0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0xDF, 0x01, 0xE7, 0x80,
  0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xFB, 0xE0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF0, 0x20, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC1, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x03, 0xF1, 0xE0, 0x7C, 0x1E, 0x0F, 0x81, 0xE3,
  0xF0, 0x3C, 0x7E, 0x03, 0xCF, 0xC0, 0x3D, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xEF, 0x80, 0x7C, 0x78, 0x07,
  0x87, 0xC0, 0x78, 0x3C, 0x0F, 0x83, 0xE0, 0xF0, 0x1F, 0x0F, 0x01, 0xF0,
  0xF0, 0x0F, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x1D, 0xF3, 0xE1,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xE7, 0xCF, 0x3C, 0x78, 0xF3, 0xC7, 0x8F,
  0x3C, 0x78, 0xF3, 0x87, 0x0F, 0x78, 0x70, 0xE7, 0x8F, 0x1E, 0x78, 0xF1,
  0xE7, 0x8F, 0x1E, 0x70, 0xF1, 0xE7, 0x0E, 0x1E, 0xF0, 0xE1, 0xCF, 0x1E,
  0x3C, 0xF1, 0xE3, 0xCF, 0x1E, 0x3C, 0xE1, 0xE3, 0xC0, 0x1E, 0x7F, 0x07,
  0xBF, 0xE1, 0xDF, 0xF8, 0xFE, 0x3F, 0x3E, 0x07, 0xCF, 0x00, 0xF3, 0xC0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0xDF, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E,
  0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xFB, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C,
  0x03, 0xCF, 0x00, 0xF0, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x87, 0xC3,
  0xE7, 0xC0, 0xF3, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0xFB, 0xC0, 0x78,
  0xF0, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0x7F, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xC3, 0xE1, 0xF0, 0x3C, 0x3C, 0x07, 0xC7,
  0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x7C, 0xF0, 0x0F, 0x1E,
  0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x8F, 0x01, 0xE3, 0xF0, 0xFC, 0x7F,
  0xFF, 0x0F, 0x7F, 0xC1, 0xE7, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xF3, 0xC3, 0xFF, 0xE1, 0xFF, 0xF8, 0xF8, 0x7E, 0x7C, 0x0F, 0x9E, 0x01,
  0xE7, 0x80, 0xFB, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x3C, 0xF0, 0x1F, 0x3C, 0x07, 0x8F, 0x81, 0xE1, 0xF1, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFF, 0x81, 0xF9, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x3F,
  0x8F, 0x3F, 0xC7, 0xFF, 0xE3, 0xFF, 0xE1, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xC1, 0xF3,
  0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xF0,
  0x3C, 0x7F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1F, 0x04, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x3C, 0x03, 0xCF, 0x00,
  0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x7C, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79,
  0xE0, 0x3E, 0x78, 0x0F, 0x1E, 0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x07, 0xCF, 0x81, 0xE1, 0xE1, 0xF8, 0x7F, 0xFE, 0x0F, 0xF7,
  0x81, 0xF9, 0xE0, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0xF9, 0xE0, 0x3C,
  0x78, 0x1F, 0x1E, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x78, 0x0F,
  0x1E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x1D, 0xE0, 0x07, 0x78, 0x01, 0xDC,
  0x00, 0x7F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0xE0,
  0xFF, 0x0E, 0x1E, 0xF0, 0xE1, 0xEF, 0x1E, 0x1C, 0xF1, 0xE1, 0xCF, 0x3E,
  0x3C, 0xF3, 0xE3, 0x8F, 0x36, 0x38, 0xF7, 0x67, 0x8F, 0x77, 0x70, 0xEE,
  0x77, 0x0E, 0xE7, 0xF0, 0xEC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F,
  0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x00, 0x1F, 0x00,
  0xF8, 0x78, 0x0F, 0x81, 0xE0, 0xF8, 0x0F, 0x0F, 0x80, 0x3C, 0x78, 0x01,
  0xE7, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xCF, 0x00, 0x3C,
  0x7C, 0x03, 0xE1, 0xE0, 0x3E, 0x0F, 0x83, 0xE0, 0x3C, 0x3E, 0x00, 0xF0,
  0x1E, 0x00, 0x7C, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x87, 0xC0, 0x7C, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xE1, 0xF0, 0x07, 0x87,
  0x80, 0x1E, 0x3C, 0x00, 0x79, 0xF0, 0x00, 0xE7, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC,
  0x00, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xD0, 0x07, 0x80, 0x0E,
  0x00, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0x03, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x1F, 0xC0, 0xF8, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x1F, 0x80,
  0x03, 0xFE, 0x07, 0x7F, 0xF0, 0xF7, 0x9F, 0x9E, 0x70, 0x7F, 0xEE, 0x03,
  0xFC, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoMono_MediumItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 9, 26, 21, 6, -26 },
  { 31, 12, 9, 21, 6, -27 },
  { 45, 21, 26, 21, 0, -26 },
  { 114, 18, 34, 21, 2, -30 },
  { 191, 18, 26, 21, 2, -26 },
  { 250, 19, 26, 21, 1, -26 },
  { 312, 5, 9, 21, 9, -27 },
  { 318, 12, 37, 21, 6, -29 },
  { 374, 12, 37, 21, 3, -29 },
  { 430, 17, 18, 21, 3, -26 },
  { 469, 17, 18, 21, 2, -21 },
  { 508, 8, 11, 21, 3, -4 },
  { 519, 15, 3, 21, 4, -13 },
  { 525, 6, 5, 21, 6, -5 },
  { 529, 18, 28, 21, 2, -26 },
  { 592, 18, 26, 21, 2, -26 },
  { 651, 12, 26, 21, 4, -26 },
  { 690, 19, 26, 21, 0, -26 },
  { 752, 18, 26, 21, 1, -26 },
  { 811, 19, 26, 21, 0, -26 },
  { 873, 19, 26, 21, 2, -26 },
  { 935, 16, 26, 21, 2, -26 },
  { 987, 18, 26, 21, 3, -26 },
  { 1046, 18, 26, 21, 2, -26 },
  { 1105, 16, 26, 21, 3, -26 },
  { 1157, 8, 20, 21, 7, -20 },
  { 1177, 11, 27, 21, 5, -20 },
  { 1215, 16, 16, 21, 3, -19 },
  { 1247, 18, 11, 21, 2, -17 },
  { 1272, 17, 16, 21, 2, -19 },
  { 1306, 15, 26, 21, 5, -26 },
  { 1355, 20, 26, 21, 1, -26 },
  { 1420, 20, 26, 21, -1, -26 },
  { 1485, 20, 26, 21, 1, -26 },
  { 1550, 20, 26, 21, 1, -26 },
  { 1615, 19, 26, 21, 1, -26 },
  { 1677, 20, 26, 21, 1, -26 },
  { 1742, 21, 26, 21, 1, -26 },
  { 1811, 19, 26, 21, 2, -26 },
  { 1873, 21, 26, 21, 0, -26 },
  { 1942, 19, 26, 21, 1, -26 },
  { 2004, 20, 26, 21, 1, -26 },
  { 2069, 22, 26, 21, 1, -26 },
  { 2141, 17, 26, 21, 1, -26 },
  { 2197, 22, 26, 21, 0, -26 },
  { 2269, 21, 26, 21, 0, -26 },
  { 2338, 19, 26, 21, 1, -26 },
  { 2400, 20, 26, 21, 1, -26 },
  { 2465, 19, 30, 21, 1, -26 },
  { 2537, 20, 26, 21, 1, -26 },
  { 2602, 20, 26, 21, 1, -26 },
  { 2667, 20, 26, 21, 3, -26 },
  { 2732, 19, 26, 21, 2, -26 },
  { 2794, 20, 26, 21, 3, -26 },
  { 2859, 21, 26, 21, 2, -26 },
  { 2928, 24, 26, 21, -1, -26 },
  { 3006, 20, 26, 21, 3, -26 },
  { 3071, 21, 26, 21, 0, -26 },
  { 3140, 13, 36, 21, 4, -30 },
  { 3199, 8, 28, 21, 7, -26 },
  { 3227, 13, 36, 21, 4, -30 },
  { 3286, 14, 14, 21, 4, -26 },
  { 3311, 16, 3, 21, 0, 0 },
  { 3317, 6, 5, 21, 10, -26 },
  { 3321, 17, 19, 21, 1, -19 },
  { 3362, 18, 27, 21, 1, -27 },
  { 3423, 17, 19, 21, 2, -19 },
  { 3464, 19, 27, 21, 2, -27 },
  { 3529, 17, 19, 21, 2, -19 },
  { 3570, 19, 28, 21, 3, -28 },
  { 3637, 19, 27, 21, 1, -19 },
  { 3702, 18, 27, 21, 1, -27 },
  { 3763, 16, 26, 21, 2, -26 },
  { 3815, 16, 34, 21, 1, -26 },
  { 3883, 20, 27, 21, 1, -27 },
  { 3951, 16, 27, 21, 2, -27 },
  { 4005, 20, 19, 21, 0, -19 },
  { 4053, 18, 19, 21, 1, -19 },
  { 4096, 17, 19, 21, 2, -19 },
  { 4137, 19, 26, 21, 0, -19 },
  { 4199, 18, 26, 21, 2, -19 },
  { 4258, 17, 19, 21, 3, -19 },
  { 4299, 17, 19, 21, 2, -19 },
  { 4340, 16, 24, 21, 3, -24 },
  { 4388, 18, 19, 21, 2, -19 },
  { 4431, 18, 19, 21, 3, -19 },
  { 4474, 20, 19, 21, 2, -19 },
  { 4522, 21, 19, 21, 0, -19 },
  { 4572, 22, 27, 21, 0, -19 },
  { 4647, 19, 19, 21, 1, -19 },
  { 4693, 14, 34, 21, 5, -28 },
  { 4753, 8, 33, 21, 6, -26 },
  { 4786, 14, 34, 21, 3, -28 },
  { 4846, 20, 7, 21, 0, -14 },
};

const GFXfont RobotoMono_MediumItalic36pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic36pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOMONO_MEDIUMITALIC36PT7B_H_
