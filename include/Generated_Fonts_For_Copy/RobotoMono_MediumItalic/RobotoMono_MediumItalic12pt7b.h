#ifndef _ROBOTOMONO_MEDIUMITALIC12PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0xA4, 0x82, 0xC0, 0x59, 0xA0, 0x0A, 0x28, 0x53, 0xF2, 0x85,
  0x3F, 0x28, 0x50, 0x10, 0xC7, 0x93, 0x41, 0xC1, 0xA2, 0x9B, 0xC6, 0x00,
  0x42, 0xAA, 0xB4, 0x20, 0xE6, 0xAA, 0x38, 0x18, 0x78, 0xB1, 0xC3, 0x0E,
  0xF7, 0x66, 0x74, 0xE8, 0x13, 0x64, 0xC8, 0x88, 0x88, 0x84, 0x40, 0x42,
  0x31, 0x11, 0x13, 0x22, 0x6C, 0x80, 0x10, 0x4D, 0xDE, 0x73, 0x60, 0x30,
  0x8F, 0xFE, 0x21, 0x80, 0x6B, 0x00, 0xF8, 0xF0, 0x0C, 0x21, 0x84, 0x30,
  0x86, 0x10, 0xC2, 0x00, 0x31, 0xEC, 0xB3, 0xBB, 0x28, 0xA6, 0xF0, 0x17,
  0xD1, 0x33, 0x22, 0x20, 0x19, 0xF4, 0x41, 0x08, 0x42, 0x10, 0xFC, 0x18,
  0xF6, 0x41, 0x38, 0x30, 0xF3, 0x78, 0x04, 0x31, 0x4F, 0x2D, 0x2F, 0xC2,
  0x18, 0x7D, 0xF4, 0x1C, 0xF8, 0x20, 0xA6, 0xF0, 0x09, 0xD1, 0xED, 0xC6,
  0x33, 0xF0, 0xFF, 0xF0, 0x86, 0x10, 0x86, 0x10, 0xC0, 0x31, 0xEC, 0xD2,
  0x73, 0x68, 0xA6, 0xF0, 0x33, 0xF3, 0x1C, 0xBC, 0x66, 0xE0, 0x6C, 0x00,
  0xB0, 0x6C, 0x00, 0x16, 0x80, 0x1B, 0xB0, 0xE1, 0x80, 0xFF, 0xE0, 0x3E,
  0x60, 0x70, 0xDC, 0xC0, 0x67, 0xA6, 0x23, 0x20, 0x08, 0xC0, 0x08, 0x69,
  0x6A, 0xDA, 0xB5, 0x6F, 0x20, 0x70, 0x08, 0x61, 0x8E, 0x2D, 0xB7, 0xF1,
  0x84, 0x38, 0x7D, 0x9B, 0x37, 0x88, 0x91, 0x66, 0xF8, 0x18, 0x79, 0x9A,
  0x04, 0x08, 0x11, 0x26, 0x78, 0x30, 0xF9, 0x93, 0x34, 0x68, 0x91, 0x66,
  0xF0, 0x3E, 0x7D, 0x83, 0x07, 0xC8, 0x10, 0x20, 0xFC, 0x3E, 0x7D, 0x83,
  0x07, 0xC8, 0x10, 0x20, 0xC0, 0x31, 0xEC, 0xE0, 0x86, 0xE8, 0xA2, 0xF0,
  0x22, 0xC5, 0x9A, 0x37, 0xC8, 0x91, 0x62, 0xCC, 0x3E, 0x7C, 0x60, 0xC1,
  0x02, 0x04, 0x1A, 0xF8, 0x02, 0x0C, 0x18, 0x20, 0x40, 0xA1, 0x26, 0x78,
  0x23, 0x26, 0x6C, 0x78, 0x70, 0x78, 0x48, 0xCC, 0xC4, 0x20, 0x86, 0x18,
  0x61, 0x04, 0x10, 0xFC, 0x26, 0xCD, 0xFA, 0xF5, 0xEA, 0x91, 0x62, 0xCC,
  0x22, 0xC5, 0xDA, 0xB5, 0x4A, 0x93, 0x66, 0xCC, 0x18, 0x79, 0x9A, 0x34,
  0x68, 0x91, 0x26, 0x78, 0x38, 0x7D, 0x8B, 0x14, 0xCF, 0x10, 0x20, 0xC0,
  0x18, 0x79, 0x9A, 0x34, 0x68, 0xF1, 0x26, 0x78, 0x18, 0x38, 0x7D, 0x9B,
  0x34, 0xCF, 0x12, 0x26, 0xCC, 0x18, 0x7D, 0x8B, 0x03, 0x81, 0xB1, 0x22,
  0x78, 0xFF, 0xF8, 0xC1, 0x82, 0x04, 0x08, 0x30, 0x60, 0x47, 0x1C, 0xE3,
  0x8A, 0x28, 0xA6, 0xF0, 0xC7, 0x8B, 0x32, 0x45, 0x8A, 0x1C, 0x30, 0x60,
  0x97, 0x6A, 0xD5, 0xEB, 0x9B, 0x36, 0x6C, 0x90, 0x63, 0x26, 0x24, 0x38,
  0x18, 0x38, 0x28, 0x4C, 0xC4, 0xC7, 0x99, 0x22, 0xC7, 0x04, 0x08, 0x30,
  0x60, 0x7E, 0xFC, 0x10, 0x41, 0x06, 0x18, 0x20, 0xFC, 0x39, 0x08, 0x42,
  0x31, 0x8C, 0x42, 0x11, 0xC0, 0x99, 0x24, 0x9B, 0x24, 0x38, 0x84, 0x21,
  0x08, 0xC6, 0x21, 0x09, 0xC0, 0x11, 0x8C, 0xBC, 0x80, 0xF8, 0xD0, 0x7D,
  0x13, 0xD3, 0xCD, 0xF0, 0x20, 0x86, 0x1F, 0x45, 0x14, 0x53, 0xF8, 0x7C,
  0x61, 0x09, 0xF8, 0x04, 0x30, 0xDE, 0x8A, 0x28, 0xA6, 0xF8, 0x7C, 0x7F,
  0x08, 0xF8, 0x1C, 0xC2, 0x7E, 0x21, 0x86, 0x10, 0x40, 0x3E, 0x89, 0x12,
  0x24, 0xCF, 0x82, 0x7C, 0x20, 0x20, 0x86, 0x1F, 0x45, 0x14, 0x53, 0xCC,
  0x10, 0x81, 0xE3, 0x10, 0x84, 0xF8, 0x0C, 0x30, 0x0E, 0x08, 0x61, 0x86,
  0x10, 0x4F, 0x30, 0x20, 0x41, 0x8B, 0x65, 0x8E, 0x1E, 0x24, 0xCC, 0x70,
  0x84, 0x63, 0x10, 0x84, 0xF8, 0x7E, 0xAF, 0x56, 0xA9, 0x56, 0x80, 0x7D,
  0x14, 0x51, 0x4F, 0x30, 0x7C, 0x63, 0x19, 0xF8, 0x7D, 0x14, 0x51, 0x4F,
  0xEC, 0x20, 0x7E, 0x28, 0xA2, 0x9B, 0xE1, 0x04, 0x7D, 0x84, 0x10, 0xC3,
  0x00, 0x7E, 0x58, 0x38, 0xF8, 0x21, 0x3E, 0xC6, 0x21, 0x0F, 0xCE, 0x28,
  0xA2, 0x9B, 0xE0, 0x8F, 0x25, 0x14, 0x61, 0x80, 0xA6, 0xBD, 0xB6, 0xDA,
  0x40, 0x66, 0x50, 0x61, 0xC6, 0x99, 0x80, 0x46, 0xC8, 0xB1, 0x43, 0x06,
  0x08, 0x70, 0x80, 0x7E, 0x18, 0x61, 0x86, 0x1F, 0x80, 0x12, 0x22, 0x48,
  0x44, 0x44, 0x60, 0x25, 0x24, 0x92, 0x52, 0x00, 0x21, 0x8C, 0x63, 0x0C,
  0x84, 0x62, 0x30, 0x61, 0xEC, 0x30,
};

const GFXglyph RobotoMono_MediumItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 9, 7, 2, -9 },
  { 5, 4, 3, 7, 2, -9 },
  { 7, 7, 9, 7, 0, -9 },
  { 15, 6, 11, 7, 1, -10 },
  { 24, 6, 9, 7, 1, -9 },
  { 31, 7, 9, 7, 0, -9 },
  { 39, 2, 3, 7, 3, -9 },
  { 40, 4, 13, 7, 2, -10 },
  { 47, 4, 13, 7, 1, -10 },
  { 54, 6, 6, 7, 1, -9 },
  { 59, 6, 6, 7, 1, -7 },
  { 64, 3, 3, 7, 1, -1 },
  { 66, 5, 1, 7, 1, -4 },
  { 67, 2, 2, 7, 2, -2 },
  { 68, 6, 10, 7, 1, -9 },
  { 76, 6, 9, 7, 1, -9 },
  { 83, 4, 9, 7, 1, -9 },
  { 88, 6, 9, 7, 0, -9 },
  { 95, 6, 9, 7, 0, -9 },
  { 102, 6, 9, 7, 0, -9 },
  { 109, 6, 9, 7, 1, -9 },
  { 116, 5, 9, 7, 1, -9 },
  { 122, 6, 9, 7, 1, -9 },
  { 129, 6, 9, 7, 1, -9 },
  { 136, 5, 9, 7, 1, -9 },
  { 142, 3, 7, 7, 2, -7 },
  { 145, 3, 9, 7, 2, -7 },
  { 149, 5, 5, 7, 1, -6 },
  { 153, 6, 4, 7, 1, -6 },
  { 156, 6, 5, 7, 0, -6 },
  { 160, 5, 9, 7, 2, -9 },
  { 166, 7, 9, 7, 0, -9 },
  { 174, 6, 9, 7, 0, -9 },
  { 181, 7, 9, 7, 0, -9 },
  { 189, 7, 9, 7, 0, -9 },
  { 197, 7, 9, 7, 0, -9 },
  { 205, 7, 9, 7, 0, -9 },
  { 213, 7, 9, 7, 0, -9 },
  { 221, 6, 9, 7, 1, -9 },
  { 228, 7, 9, 7, 0, -9 },
  { 236, 7, 9, 7, 0, -9 },
  { 244, 7, 9, 7, 0, -9 },
  { 252, 8, 9, 7, 0, -9 },
  { 261, 6, 9, 7, 0, -9 },
  { 268, 7, 9, 7, 0, -9 },
  { 276, 7, 9, 7, 0, -9 },
  { 284, 7, 9, 7, 0, -9 },
  { 292, 7, 9, 7, 0, -9 },
  { 300, 7, 10, 7, 0, -9 },
  { 309, 7, 9, 7, 0, -9 },
  { 317, 7, 9, 7, 0, -9 },
  { 325, 7, 9, 7, 1, -9 },
  { 333, 6, 9, 7, 1, -9 },
  { 340, 7, 9, 7, 1, -9 },
  { 348, 7, 9, 7, 1, -9 },
  { 356, 8, 9, 7, 0, -9 },
  { 365, 7, 9, 7, 1, -9 },
  { 373, 7, 9, 7, 0, -9 },
  { 381, 5, 12, 7, 1, -10 },
  { 389, 3, 10, 7, 2, -9 },
  { 393, 5, 12, 7, 1, -10 },
  { 401, 5, 5, 7, 1, -9 },
  { 405, 5, 1, 7, 0, 0 },
  { 406, 2, 2, 7, 3, -9 },
  { 407, 6, 6, 7, 0, -6 },
  { 412, 6, 9, 7, 0, -9 },
  { 419, 5, 6, 7, 1, -6 },
  { 423, 6, 9, 7, 1, -9 },
  { 430, 5, 6, 7, 1, -6 },
  { 434, 6, 9, 7, 1, -9 },
  { 441, 7, 9, 7, 0, -6 },
  { 449, 6, 9, 7, 0, -9 },
  { 456, 5, 9, 7, 1, -9 },
  { 462, 6, 12, 7, 0, -9 },
  { 471, 7, 9, 7, 0, -9 },
  { 479, 5, 9, 7, 1, -9 },
  { 485, 7, 6, 7, 0, -6 },
  { 491, 6, 6, 7, 0, -6 },
  { 496, 5, 6, 7, 1, -6 },
  { 500, 6, 8, 7, 0, -6 },
  { 506, 6, 8, 7, 1, -6 },
  { 512, 6, 6, 7, 1, -6 },
  { 517, 5, 6, 7, 1, -6 },
  { 521, 5, 8, 7, 1, -8 },
  { 526, 6, 6, 7, 1, -6 },
  { 531, 6, 6, 7, 1, -6 },
  { 536, 6, 6, 7, 1, -6 },
  { 541, 7, 6, 7, 0, -6 },
  { 547, 7, 9, 7, 0, -6 },
  { 555, 7, 6, 7, 0, -6 },
  { 561, 4, 11, 7, 2, -9 },
  { 567, 3, 11, 7, 2, -9 },
  { 572, 5, 11, 7, 1, -9 },
  { 579, 7, 3, 7, 0, -5 },
};

const GFXfont RobotoMono_MediumItalic12pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic12pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOMONO_MEDIUMITALIC12PT7B_H_
