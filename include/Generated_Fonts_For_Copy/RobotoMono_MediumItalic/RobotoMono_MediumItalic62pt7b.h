#ifndef _ROBOTOMONO_MEDIUMITALIC62PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x00,
  0x1F, 0x03, 0xE7, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x81, 0xF3, 0xE0, 0x7E,
  0x7C, 0x0F, 0xCF, 0x81, 0xF3, 0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9,
  0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF0, 0x1F, 0x3E, 0x03, 0xE7,
  0xC0, 0x78, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x07, 0xC1, 0xF0, 0x08, 0x3E, 0x07, 0xE0, 0x78, 0xF8, 0x0F, 0x81, 0xF3,
  0xE0, 0x7C, 0x0F, 0x8F, 0x81, 0xF0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0xF8,
  0x1F, 0x0F, 0x83, 0xE0, 0x7C, 0x7C, 0x0F, 0xC3, 0xE3, 0xE0, 0x1F, 0xFF,
  0x8F, 0x80, 0x7F, 0xFC, 0x7C, 0x00, 0xFF, 0xE3, 0xE0, 0x01, 0xFF, 0x0F,
  0x00, 0x00, 0xE0, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x1F, 0xF0, 0x00,
  0xF8, 0xFF, 0xF0, 0x03, 0xE7, 0xFF, 0xC0, 0x1F, 0x3F, 0xFF, 0x80, 0xF8,
  0xFC, 0x3E, 0x03, 0xE3, 0xE0, 0xF8, 0x1F, 0x1F, 0x03, 0xE0, 0xF8, 0x7C,
  0x0F, 0xC3, 0xE1, 0xF0, 0x3E, 0x1F, 0x07, 0xC0, 0xF8, 0xF8, 0x1F, 0x03,
  0xE0, 0x40, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x7F,
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xBF, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xC1, 0xFF, 0xFC, 0x03, 0xF0, 0xFF, 0xFF,
  0x81, 0xFC, 0x7F, 0x8F, 0xE0, 0x7E, 0x3F, 0xC3, 0xFC, 0x1F, 0x8F, 0xF0,
  0x7F, 0x8F, 0xE7, 0xF8, 0x1F, 0xE3, 0xF1, 0xFC, 0x03, 0xFD, 0xFC, 0x7F,
  0x00, 0x7F, 0xFF, 0x1F, 0xC0, 0x1F, 0xFF, 0x8F, 0xF0, 0x03, 0xFF, 0xC3,
  0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0x00, 0x1F, 0xF8, 0x1F, 0xC0, 0x07, 0xFC,
  0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xDF, 0xC0, 0x1F, 0xFF,
  0xC7, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F,
  0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC,
  0xF8, 0xF8, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x20, 0x07, 0xC0, 0x11,
  0xC0, 0x3C, 0x03, 0x9F, 0x81, 0xE0, 0xFC, 0xFF, 0x0F, 0x1F, 0xEF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F,
  0x87, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x07, 0x80,
  0x02, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x2F, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87,
  0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xF8, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE,
  0x3F, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x03,
  0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E,
  0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xFC, 0xFE, 0x00, 0x7F, 0xF3, 0xF8,
  0x07, 0xFF, 0x9F, 0xC0, 0x3F, 0xFE, 0x7F, 0x01, 0xFF, 0xF9, 0xFC, 0x1F,
  0xEF, 0xE7, 0xF0, 0xFF, 0x3F, 0x9F, 0xCF, 0xF1, 0xFE, 0x7F, 0x7F, 0x87,
  0xF3, 0xFF, 0xF8, 0x1F, 0xCF, 0xFF, 0xC0, 0x7F, 0x3F, 0xFC, 0x01, 0xFC,
  0xFF, 0xE0, 0x07, 0xF3, 0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFE, 0x3F,
  0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0,
  0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x01,
  0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFD, 0xFC, 0xFE, 0x1F, 0xCF,
  0x01, 0xFC, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xC7, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xC1,
  0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x03,
  0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x0F,
  0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x1F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x07, 0xEF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xC0, 0x0F,
  0xF0, 0x00, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x7F,
  0xC0, 0x3F, 0xE1, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x3F,
  0xC0, 0x1F, 0xCF, 0xFE, 0x03, 0xFB, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0x03, 0xFE, 0x7F, 0xC0,
  0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0x7F,
  0x80, 0x3F, 0xC3, 0xFC, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xC3,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x03,
  0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xF0, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03,
  0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x7F, 0xC1, 0xFE, 0x01,
  0xFC, 0x3F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xE7,
  0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xEF, 0xF0,
  0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xE7, 0xF8, 0x07, 0xFE, 0x7F, 0xE1, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xDF, 0xC0, 0x3F, 0xF3, 0xF8, 0x00, 0x30, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x1F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1,
  0xFE, 0x03, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xE0,
  0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFE, 0x07, 0xF0,
  0x03, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFC, 0x7F, 0xF3, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xDF, 0xE0,
  0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x1F, 0xC0,
  0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0x0F, 0x81, 0xF8, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0xF8, 0x78, 0x3E,
  0x0F, 0xFF, 0x1E, 0x0F, 0x07, 0xFF, 0xC7, 0x87, 0xC3, 0xFD, 0xF0, 0xF1,
  0xE0, 0xF8, 0x3C, 0x3C, 0xF8, 0x7C, 0x1E, 0x0F, 0x3C, 0x1E, 0x07, 0x83,
  0xDF, 0x0F, 0x81, 0xE0, 0xF7, 0xC3, 0xC0, 0x78, 0x79, 0xE1, 0xF0, 0x3C,
  0x1E, 0x78, 0x7C, 0x0F, 0x07, 0xBE, 0x1E, 0x03, 0xC1, 0xEF, 0x87, 0x80,
  0xF0, 0x7B, 0xC3, 0xE0, 0x7C, 0x1E, 0xF0, 0xF8, 0x1E, 0x0F, 0x3C, 0x3E,
  0x07, 0x83, 0xCF, 0x0F, 0x81, 0xE0, 0xF3, 0xC3, 0xE0, 0xF8, 0x38, 0xF0,
  0xF8, 0x3C, 0x1E, 0x3C, 0x3E, 0x3F, 0x8F, 0x0F, 0x0F, 0xFF, 0xE7, 0xC3,
  0xC1, 0xFF, 0x7F, 0xE0, 0xF0, 0x7F, 0x9F, 0xF0, 0x3E, 0x0F, 0xC3, 0xF8,
  0x0F, 0x80, 0x80, 0x30, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x01, 0x00, 0x00, 0x7F, 0x03,
  0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x00,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x1F, 0xDF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xE0, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x7F,
  0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xE0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x1F,
  0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x3F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0x1F,
  0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x3F, 0xC0, 0x3F, 0xE1, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x7F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0,
  0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x3F,
  0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x3F, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFC, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0xFE, 0xFE, 0x00, 0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xFC,
  0xFE, 0x01, 0xFF, 0xFC, 0xFE, 0x01, 0xFF, 0xFC, 0xFE, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF0,
  0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF0,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF8,
  0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0x1F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFC, 0x00,
  0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x80,
  0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x00,
  0x3F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x03, 0xFE, 0x00,
  0x07, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xC0,
  0xFF, 0x80, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0x01, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0xC0, 0x00, 0x07, 0xF1,
  0xFF, 0x00, 0x00, 0x0F, 0xE7, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFD, 0xFC, 0x00, 0x00, 0x7F,
  0xF3, 0xFC, 0x00, 0x00, 0xFF, 0xC3, 0xF8, 0x00, 0x01, 0xFF, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0xC0, 0x7F, 0xF8, 0x3E, 0xFC, 0x07, 0xFF, 0xC7, 0xEF, 0xC0,
  0x7E, 0xFC, 0x7D, 0xFC, 0x07, 0xE7, 0xCF, 0xDF, 0xC0, 0x7E, 0x7C, 0xF9,
  0xF8, 0x07, 0xE7, 0xDF, 0x9F, 0x80, 0xFE, 0x7D, 0xF1, 0xF8, 0x0F, 0xE7,
  0xFF, 0x3F, 0x80, 0xFE, 0x7F, 0xF3, 0xF8, 0x0F, 0xC7, 0xFE, 0x3F, 0x80,
  0xFC, 0x7F, 0xE3, 0xF0, 0x0F, 0xC3, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0xC3,
  0xF0, 0x1F, 0xC3, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x87, 0xF0, 0x1F, 0x83,
  0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x7E, 0x03,
  0xF8, 0x3E, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00,
  0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xF0, 0x01, 0xFE, 0x03, 0xFF,
  0x00, 0x1F, 0xC0, 0x3F, 0xF8, 0x01, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xC0,
  0x3F, 0xF8, 0x01, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xFC, 0x03,
  0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFC, 0x03, 0xF8, 0x07, 0xF7,
  0xC0, 0x3F, 0x80, 0x7F, 0x7E, 0x03, 0xF8, 0x0F, 0xF7, 0xE0, 0x7F, 0x80,
  0xFF, 0x7E, 0x07, 0xF0, 0x0F, 0xE3, 0xF0, 0x7F, 0x00, 0xFE, 0x3F, 0x07,
  0xF0, 0x0F, 0xE3, 0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0x07, 0xF0, 0x1F, 0xE1,
  0xF8, 0xFF, 0x01, 0xFC, 0x1F, 0x8F, 0xE0, 0x1F, 0xC1, 0xF8, 0xFE, 0x01,
  0xFC, 0x0F, 0xCF, 0xE0, 0x1F, 0xC0, 0xFC, 0xFE, 0x01, 0xFC, 0x0F, 0xDF,
  0xE0, 0x3F, 0xC0, 0xFD, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x80,
  0x7F, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x3F, 0xFC, 0x03,
  0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xFC, 0x07, 0xF0, 0x03, 0xFF,
  0x80, 0x7F, 0x00, 0x1F, 0xF8, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0x00,
  0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xDF, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x01,
  0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xFB, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xF8, 0x0F,
  0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0x80, 0x07, 0xFC, 0x0F, 0xE0, 0x03, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xBF, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x03, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xFC,
  0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xFB, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x31, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x0F, 0xE0,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0x1F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xBF,
  0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFC,
  0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F,
  0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F,
  0x01, 0xFD, 0xFC, 0x07, 0xE0, 0x3F, 0xBF, 0x81, 0xFC, 0x07, 0xE7, 0xF0,
  0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF0, 0x3F, 0x9F, 0xC1, 0xFE, 0x07, 0xE3,
  0xF8, 0x3F, 0xC0, 0xFC, 0x7F, 0x07, 0xF8, 0x3F, 0x8F, 0xC1, 0xFF, 0x07,
  0xF1, 0xF8, 0x3F, 0xE0, 0xFC, 0x3F, 0x07, 0xFC, 0x3F, 0x87, 0xE0, 0xFF,
  0x87, 0xF0, 0xFC, 0x3F, 0xF0, 0xFC, 0x1F, 0x87, 0xFE, 0x1F, 0x83, 0xF0,
  0xFF, 0xC7, 0xF0, 0x7E, 0x3F, 0xF8, 0xFE, 0x0F, 0xC7, 0xDF, 0x1F, 0x81,
  0xF8, 0xFB, 0xE3, 0xF0, 0x3F, 0x3F, 0x7C, 0xFE, 0x07, 0xE7, 0xCF, 0x9F,
  0x80, 0xFC, 0xF9, 0xF3, 0xF0, 0x1F, 0xBF, 0x3E, 0x7E, 0x03, 0xF7, 0xC7,
  0xDF, 0xC0, 0x7E, 0xF8, 0xFB, 0xF0, 0x0F, 0xFF, 0x1F, 0x7E, 0x01, 0xFF,
  0xC3, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x00,
  0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xE7, 0xF0, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x1F, 0x83, 0xFC, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0x3F, 0x3F, 0xC0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7D, 0xF0, 0x00,
  0xFD, 0xF0, 0x00, 0xFD, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xF9, 0xF8, 0x03,
  0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0x7E, 0x7F,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0x83, 0xFC, 0x00, 0xFE, 0x0F,
  0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF1,
  0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0xFF,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xFE, 0x1F, 0xF0,
  0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0xFE, 0x03, 0xFF, 0xF3, 0xF8, 0x07, 0xFF, 0x0F, 0xE0, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0xE0, 0x01,
  0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01,
  0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F,
  0xC7, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC,
  0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0xF8, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x07, 0xF7, 0xFF, 0xF8, 0x0F, 0xC7, 0xFF, 0xE0, 0x3F,
  0x83, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x3F, 0xC3, 0xFC, 0x00, 0xFF,
  0x1F, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7E, 0x7F,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x83,
  0xF8, 0x01, 0xFF, 0xF3, 0xFC, 0x01, 0xFF, 0xFD, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F,
  0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0,
  0x1F, 0xF1, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFD, 0xFC, 0x00, 0x7F, 0xFC, 0xFE, 0x00, 0x0F, 0xFC, 0x7E,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x1F,
  0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0x01, 0xFE, 0x00, 0x1E, 0x03, 0xFC, 0x00, 0xFC, 0x0F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFC, 0x06, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x1F, 0x80, 0x1F, 0xFF, 0x9F, 0xC0, 0x1F, 0xFF,
  0xEF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xEF,
  0xE0, 0x00, 0xFF, 0xC7, 0xF0, 0x00, 0x06, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x01, 0x00, 0x01, 0xFE, 0x00, 0xC0, 0x01,
  0xFE, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x03,
  0xF8, 0xFF, 0xF0, 0x03, 0xF3, 0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x1F,
  0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFC, 0x0F, 0xE0, 0x03, 0xFE, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x3F, 0xE0, 0x07,
  0xF0, 0x3F, 0xF0, 0x01, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0x0F, 0xF8, 0x00,
  0x1F, 0xC7, 0xFC, 0x00, 0x0F, 0xE3, 0xFE, 0x00, 0x03, 0xF9, 0xFF, 0x00,
  0x00, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x01, 0xFF,
  0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F,
  0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xF8, 0x1F, 0xC0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xF1, 0xF8, 0x3F, 0x80, 0x3F, 0x7F, 0xC7, 0xFC,
  0x03, 0xFF, 0xFE, 0xFF, 0xC0, 0x7E, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x7E,
  0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFE,
  0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC,
  0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0xC1, 0xFC,
  0x1F, 0x81, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xFC, 0x3F, 0x81, 0xF8,
  0x1F, 0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x83, 0xF0,
  0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xF8,
  0x7F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0,
  0x3F, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x7F, 0xC0,
  0x03, 0xF0, 0xFF, 0xF0, 0x03, 0xF3, 0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFE,
  0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x07, 0xF8,
  0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80,
  0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x07,
  0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0xE0, 0x00, 0x7E, 0x7F, 0xFC,
  0x00, 0x3F, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x07,
  0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x7F, 0xFF, 0x80,
  0x3F, 0x9F, 0xFF, 0x00, 0x1F, 0xC7, 0xFF, 0x00, 0x1F, 0xE0, 0x38, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0xFE, 0x01, 0xFF, 0xF1, 0xFC, 0x07, 0xFF,
  0xFB, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xEF,
  0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xC0, 0x03,
  0xFC, 0x7F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x1F,
  0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0x7F,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0x01, 0xFF,
  0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xCF, 0xE0, 0x03, 0xFF, 0x1F, 0x80, 0x00, 0xF0,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x3F, 0xF8, 0x3F, 0x87, 0xFF, 0x81, 0xFC, 0xFF, 0xFC,
  0x0F, 0xEF, 0xFF, 0xE0, 0x7E, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x04, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFC, 0x7F,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xF9, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3C, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC,
  0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F,
  0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x8F, 0xE0,
  0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x01,
  0xFF, 0x0F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF1, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x7E, 0x03, 0xFF, 0xF9, 0xF8, 0x07, 0xFF, 0xCF, 0xE0,
  0x07, 0xFC, 0x3F, 0x80, 0x03, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F,
  0x80, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0xFE, 0x01, 0xF0, 0x0F,
  0xFF, 0x01, 0xF8, 0x0F, 0xFF, 0x80, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0x03,
  0xF7, 0xE0, 0x7F, 0x03, 0xFB, 0xF0, 0x3F, 0x81, 0xF9, 0xF8, 0x3F, 0xC0,
  0xFC, 0xFC, 0x1F, 0xE0, 0xFC, 0x7E, 0x0F, 0xF0, 0x7E, 0x3F, 0x0F, 0xF8,
  0x3F, 0x1F, 0x87, 0xBC, 0x3F, 0x0F, 0xC7, 0xDE, 0x1F, 0x87, 0xE3, 0xEF,
  0x0F, 0xC3, 0xF1, 0xE7, 0x8F, 0xC1, 0xF9, 0xF3, 0xC7, 0xE0, 0xF8, 0xF9,
  0xE3, 0xF0, 0x7C, 0xF8, 0xF3, 0xF0, 0x3E, 0x7C, 0x79, 0xF8, 0x1F, 0x3C,
  0x3C, 0xFC, 0x0F, 0xBE, 0x1E, 0xFC, 0x07, 0xDF, 0x0F, 0x7E, 0x03, 0xEF,
  0x07, 0xBE, 0x01, 0xFF, 0x83, 0xDF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xF0,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x01, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0x8F, 0xFF, 0xE0, 0x03, 0xE1,
  0xFF, 0xFE, 0x00, 0x7C, 0x7F, 0xFF, 0xF0, 0x1F, 0x8F, 0xF7, 0xFF, 0x07,
  0xF3, 0xF0, 0x1F, 0xFF, 0xFC, 0x7E, 0x01, 0xFF, 0xFF, 0x8F, 0x80, 0x1F,
  0xFF, 0xE3, 0xE0, 0x01, 0xFF, 0xF8, 0x04, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00,
};

const GFXglyph RobotoMono_MediumItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 15, 44, 36, 11, -44 },
  { 84, 19, 16, 36, 11, -47 },
  { 122, 37, 44, 36, 0, -44 },
  { 326, 32, 57, 36, 3, -51 },
  { 554, 30, 46, 36, 4, -45 },
  { 727, 34, 46, 36, 1, -45 },
  { 923, 8, 16, 36, 16, -47 },
  { 939, 20, 63, 36, 10, -49 },
  { 1097, 21, 63, 36, 5, -49 },
  { 1263, 29, 31, 36, 6, -44 },
  { 1376, 31, 33, 36, 3, -37 },
  { 1504, 12, 18, 36, 6, -7 },
  { 1531, 25, 6, 36, 7, -22 },
  { 1550, 10, 10, 36, 11, -9 },
  { 1563, 32, 48, 36, 3, -44 },
  { 1755, 30, 46, 36, 4, -45 },
  { 1928, 20, 44, 36, 8, -44 },
  { 2038, 32, 45, 36, 0, -45 },
  { 2218, 31, 46, 36, 2, -45 },
  { 2397, 32, 44, 36, 1, -44 },
  { 2573, 32, 45, 36, 3, -44 },
  { 2753, 28, 45, 36, 3, -44 },
  { 2911, 31, 44, 36, 5, -44 },
  { 3082, 31, 46, 36, 3, -45 },
  { 3261, 28, 45, 36, 5, -45 },
  { 3419, 14, 36, 36, 12, -35 },
  { 3482, 18, 46, 36, 9, -35 },
  { 3586, 29, 29, 36, 4, -34 },
  { 3692, 31, 19, 36, 3, -29 },
  { 3766, 29, 28, 36, 3, -33 },
  { 3868, 27, 45, 36, 8, -45 },
  { 4020, 34, 44, 36, 2, -44 },
  { 4207, 34, 44, 36, -2, -44 },
  { 4394, 35, 44, 36, 1, -44 },
  { 4587, 32, 46, 36, 3, -45 },
  { 4771, 34, 44, 36, 1, -44 },
  { 4958, 35, 44, 36, 2, -44 },
  { 5151, 35, 44, 36, 2, -44 },
  { 5344, 32, 46, 36, 3, -45 },
  { 5528, 36, 44, 36, 1, -44 },
  { 5726, 33, 44, 36, 2, -44 },
  { 5908, 34, 45, 36, 2, -44 },
  { 6100, 39, 44, 36, 1, -44 },
  { 6315, 28, 44, 36, 2, -44 },
  { 6469, 36, 44, 36, 1, -44 },
  { 6667, 36, 44, 36, 1, -44 },
  { 6865, 32, 46, 36, 3, -45 },
  { 7049, 34, 44, 36, 2, -44 },
  { 7236, 33, 53, 36, 2, -45 },
  { 7455, 35, 44, 36, 1, -44 },
  { 7648, 34, 46, 36, 2, -45 },
  { 7844, 34, 44, 36, 5, -44 },
  { 8031, 34, 45, 36, 3, -44 },
  { 8223, 33, 44, 36, 6, -44 },
  { 8405, 35, 44, 36, 4, -44 },
  { 8598, 40, 44, 36, -1, -44 },
  { 8818, 34, 44, 36, 6, -44 },
  { 9005, 36, 44, 36, 0, -44 },
  { 9203, 22, 61, 36, 8, -51 },
  { 9371, 14, 48, 36, 12, -44 },
  { 9455, 22, 61, 36, 7, -51 },
  { 9623, 24, 23, 36, 7, -44 },
  { 9692, 28, 6, 36, 0, 0 },
  { 9713, 12, 8, 36, 16, -45 },
  { 9725, 30, 34, 36, 2, -33 },
  { 9853, 31, 48, 36, 1, -47 },
  { 10039, 29, 34, 36, 3, -33 },
  { 10163, 33, 48, 36, 3, -47 },
  { 10361, 30, 34, 36, 3, -33 },
  { 10489, 32, 48, 36, 6, -48 },
  { 10681, 33, 46, 36, 1, -33 },
  { 10871, 32, 47, 36, 1, -47 },
  { 11059, 27, 45, 36, 3, -45 },
  { 11211, 29, 58, 36, 1, -45 },
  { 11422, 34, 47, 36, 1, -47 },
  { 11622, 28, 47, 36, 3, -47 },
  { 11787, 36, 33, 36, -1, -33 },
  { 11936, 32, 33, 36, 1, -33 },
  { 12068, 30, 34, 36, 3, -33 },
  { 12196, 33, 46, 36, -1, -33 },
  { 12386, 31, 46, 36, 3, -33 },
  { 12565, 29, 33, 36, 6, -33 },
  { 12685, 30, 34, 36, 3, -33 },
  { 12813, 28, 42, 36, 5, -41 },
  { 12960, 30, 34, 36, 4, -33 },
  { 13088, 31, 33, 36, 5, -33 },
  { 13216, 33, 33, 36, 4, -33 },
  { 13353, 36, 33, 36, 0, -33 },
  { 13502, 38, 46, 36, 0, -33 },
  { 13721, 33, 33, 36, 1, -33 },
  { 13858, 24, 59, 36, 9, -48 },
  { 14035, 14, 56, 36, 11, -44 },
  { 14133, 24, 59, 36, 6, -48 },
  { 14310, 35, 13, 36, 0, -25 },
};

const GFXfont RobotoMono_MediumItalic62pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic62pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic62pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _ROBOTOMONO_MEDIUMITALIC62PT7B_H_
