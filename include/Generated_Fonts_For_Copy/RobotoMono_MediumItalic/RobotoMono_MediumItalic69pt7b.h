#ifndef _ROBOTOMONO_MEDIUMITALIC69PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x3F,
  0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C, 0x3F, 0x01,
  0xF0, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xE1,
  0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0xFC, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x10, 0x1F,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x30, 0x7C, 0x07, 0xE0, 0x3E,
  0x3E, 0x03, 0xF0, 0x3F, 0x1F, 0x01, 0xF8, 0x1F, 0x1F, 0x80, 0xFC, 0x1F,
  0x8F, 0xC0, 0x7E, 0x1F, 0x87, 0xE0, 0x3E, 0x0F, 0x83, 0xF0, 0x3F, 0x0F,
  0xC0, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x87, 0xC0, 0x3F, 0xFF, 0xC7,
  0xC0, 0x0F, 0xFF, 0xC7, 0xE0, 0x03, 0xFF, 0xC7, 0xE0, 0x00, 0xFF, 0xC3,
  0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x7C, 0x3F, 0xF0, 0x00, 0x7E, 0x7F, 0xFC, 0x00,
  0x7E, 0x3F, 0xFF, 0x00, 0x3E, 0x3F, 0xFF, 0x80, 0x3E, 0x3F, 0x8F, 0xE0,
  0x3F, 0x1F, 0x83, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0x1F, 0x0F, 0xC0, 0x7C,
  0x1F, 0x87, 0xE0, 0x3E, 0x1F, 0x83, 0xE0, 0x1F, 0x0F, 0x81, 0xF0, 0x0F,
  0x8F, 0xC0, 0xF8, 0x0F, 0xC1, 0xC0, 0x7C, 0x07, 0xE0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x7F,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xF9, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x07, 0xFF, 0xFE, 0x01, 0xFC,
  0x3F, 0xF7, 0xF8, 0x0F, 0xE1, 0xFF, 0x9F, 0xF0, 0x3F, 0x87, 0xFC, 0x3F,
  0xC0, 0xFE, 0x3F, 0xE0, 0x7F, 0x87, 0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xC7,
  0xFC, 0x03, 0xFC, 0xFF, 0x1F, 0xE0, 0x0F, 0xFB, 0xF8, 0x7F, 0x80, 0x1F,
  0xFF, 0xE1, 0xFE, 0x00, 0x7F, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0xFC, 0x1F,
  0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0x80, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0xFC, 0x3F, 0xE0, 0x03,
  0xFF, 0xC0, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x08, 0x00, 0xF8, 0x00, 0x8F, 0x00, 0x7C,
  0x03, 0xC7, 0xE0, 0x3E, 0x07, 0xE7, 0xFC, 0x1E, 0x1F, 0xF3, 0xFF, 0x8F,
  0x3F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x01,
  0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x01,
  0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC,
  0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x07, 0x00, 0x08, 0x00, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x04,
  0x03, 0xF1, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xEF,
  0xF8, 0xFE, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x3F, 0xE1, 0xFC, 0x00, 0x1F, 0xF8,
  0xFF, 0x00, 0x1F, 0xFE, 0x3F, 0xC0, 0x0F, 0xFF, 0x8F, 0xF0, 0x0F, 0xFF,
  0xE3, 0xFC, 0x07, 0xFF, 0xF8, 0xFF, 0x03, 0xFD, 0xFE, 0x3F, 0x83, 0xFE,
  0x7F, 0x1F, 0xE1, 0xFE, 0x3F, 0xC7, 0xF9, 0xFF, 0x0F, 0xF1, 0xFE, 0xFF,
  0x03, 0xFC, 0x7F, 0xFF, 0x80, 0xFF, 0x1F, 0xFF, 0xC0, 0x3F, 0xC7, 0xFF,
  0xC0, 0x0F, 0xF3, 0xFF, 0xE0, 0x03, 0xF8, 0xFF, 0xE0, 0x01, 0xFE, 0x3F,
  0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x03,
  0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFE, 0xFF, 0x3F, 0xE3,
  0xFC, 0xFC, 0x0F, 0xF3, 0x80, 0x3F, 0xC8, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0,
  0x1F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xF8,
  0x1F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF3, 0xFF, 0xE0, 0x0F,
  0xF8, 0x07, 0xFE, 0x00, 0x0E, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x08, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFF, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE1, 0xFF, 0x80, 0x1F, 0xE7, 0xFF, 0xE0,
  0x1F, 0xCF, 0xFF, 0xF0, 0x1F, 0xDF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x03, 0xFE,
  0x7F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFF,
  0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE,
  0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC,
  0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x03,
  0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x80,
  0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0xC0,
  0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFC,
  0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xF3, 0xF8, 0x03, 0xFF, 0xCF, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x20, 0x01, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x1F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x0E, 0x00, 0x00,
  0x02, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x7F,
  0xC0, 0x0F, 0xFB, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x3F,
  0x00, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0xF8, 0x1E, 0x07, 0xE0, 0xFF, 0xF8,
  0x78, 0x1F, 0x07, 0xFF, 0xE1, 0xE0, 0xF8, 0x3F, 0xFF, 0x87, 0xC7, 0xE0,
  0xFE, 0x1E, 0x1F, 0x1F, 0x07, 0xE0, 0xF8, 0x7C, 0x7C, 0x3F, 0x03, 0xC1,
  0xF3, 0xE0, 0xF8, 0x0F, 0x07, 0xCF, 0x87, 0xE0, 0x7C, 0x1F, 0x3E, 0x1F,
  0x01, 0xF0, 0x79, 0xF0, 0x7C, 0x07, 0xC1, 0xE7, 0xC3, 0xF0, 0x1E, 0x07,
  0x9F, 0x0F, 0x80, 0xF8, 0x1E, 0x78, 0x3E, 0x03, 0xE0, 0x7B, 0xE0, 0xF8,
  0x0F, 0x83, 0xEF, 0x87, 0xE0, 0x3C, 0x0F, 0x3E, 0x1F, 0x01, 0xF0, 0x3C,
  0xF8, 0x7C, 0x07, 0xC0, 0xF3, 0xE1, 0xF0, 0x1F, 0x07, 0x8F, 0x87, 0xC0,
  0x78, 0x1E, 0x3E, 0x1F, 0x03, 0xE0, 0xF8, 0xF8, 0x7E, 0x1F, 0x83, 0xC3,
  0xE1, 0xFD, 0xFF, 0x1F, 0x0F, 0x83, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0xFD,
  0xFF, 0xC0, 0xF8, 0x1F, 0xE3, 0xFE, 0x03, 0xE0, 0x3F, 0x07, 0xF0, 0x07,
  0xC0, 0x00, 0x06, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x20, 0x00, 0x07,
  0xF0, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xFE,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x7F,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x07,
  0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFE, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xFE, 0x7F, 0x80,
  0x3F, 0xFF, 0xCF, 0xF0, 0x03, 0xFF, 0xFC, 0xFF, 0x00, 0x3F, 0xFF, 0xCF,
  0xF0, 0x07, 0xFF, 0xFC, 0xFF, 0x00, 0x7F, 0xFF, 0xCF, 0xF0, 0x07, 0xFF,
  0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xE0,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF0, 0x07,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xF8, 0x00, 0x01,
  0xFE, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x00, 0x03, 0xFC,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x8F, 0xFC, 0x00, 0x00, 0x07, 0xF9, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xBF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xBF, 0xC0, 0x00, 0x00, 0xFF, 0xF3, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE,
  0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFB,
  0xE0, 0x7F, 0xFC, 0x03, 0xFB, 0xE0, 0xFF, 0xFC, 0x03, 0xFB, 0xF0, 0xFD,
  0xFC, 0x03, 0xFB, 0xF1, 0xFD, 0xFC, 0x03, 0xFB, 0xF1, 0xF9, 0xFC, 0x03,
  0xFB, 0xF3, 0xFB, 0xFC, 0x07, 0xFB, 0xF3, 0xF3, 0xF8, 0x07, 0xF3, 0xF7,
  0xF3, 0xF8, 0x07, 0xF1, 0xF7, 0xE3, 0xF8, 0x07, 0xF1, 0xFF, 0xE3, 0xF8,
  0x07, 0xF1, 0xFF, 0xC7, 0xF8, 0x07, 0xF1, 0xFF, 0xC7, 0xF0, 0x0F, 0xF1,
  0xFF, 0x87, 0xF0, 0x0F, 0xE1, 0xFF, 0x87, 0xF0, 0x0F, 0xE1, 0xFF, 0x07,
  0xF0, 0x0F, 0xE1, 0xFF, 0x0F, 0xF0, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0x1F,
  0xE0, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFC,
  0x0F, 0xE0, 0x1F, 0xC0, 0xFC, 0x1F, 0xE0, 0x1F, 0xC0, 0xF8, 0x1F, 0xE0,
  0x1F, 0xC0, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0xC0,
  0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFC,
  0x01, 0xFF, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFC, 0x03, 0xFF,
  0xE0, 0x03, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFC, 0x03, 0xFF, 0xF0, 0x07,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xF8, 0x03,
  0xFF, 0xF8, 0x07, 0xF8, 0x07, 0xFB, 0xF8, 0x07, 0xF8, 0x07, 0xFB, 0xF8,
  0x07, 0xF8, 0x07, 0xF9, 0xF8, 0x0F, 0xF0, 0x07, 0xF9, 0xFC, 0x0F, 0xF0,
  0x07, 0xF9, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x1F,
  0xE0, 0x0F, 0xF0, 0x7E, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x1F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F,
  0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xBF, 0xC0, 0x1F, 0xE0, 0x3F, 0xBF, 0xC0,
  0x1F, 0xE0, 0x1F, 0xBF, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xC0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0x7F,
  0x80, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x07,
  0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00,
  0xFF, 0x1F, 0xC0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0x80, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x7F, 0x00, 0x07, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x80,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xE7, 0xF8,
  0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x01, 0xFF,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00,
  0x7F, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0x03,
  0xF9, 0xFC, 0x03, 0xF8, 0x07, 0xF3, 0xF8, 0x07, 0xF0, 0x1F, 0xE7, 0xF0,
  0x1F, 0xE0, 0x3F, 0x8F, 0xE0, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x81,
  0xFE, 0x3F, 0x81, 0xFF, 0x03, 0xFC, 0x7F, 0x03, 0xFE, 0x07, 0xF0, 0xFE,
  0x07, 0xFC, 0x0F, 0xE1, 0xFC, 0x1F, 0xF8, 0x3F, 0xC3, 0xF8, 0x3F, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFF, 0xC1, 0xFC, 0x1F,
  0xC3, 0xFF, 0x87, 0xF8, 0x3F, 0x87, 0xFF, 0x0F, 0xE0, 0x7E, 0x1F, 0xFE,
  0x1F, 0xC0, 0xFC, 0x3F, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0xF8, 0xFE, 0x07,
  0xF0, 0xFB, 0xF1, 0xFC, 0x0F, 0xE3, 0xF7, 0xE3, 0xF8, 0x1F, 0xC7, 0xEF,
  0xCF, 0xF0, 0x3F, 0x8F, 0x9F, 0x9F, 0xC0, 0x7F, 0x3F, 0x3F, 0x3F, 0x80,
  0xFE, 0x7E, 0x7E, 0x7F, 0x01, 0xFC, 0xF8, 0xFD, 0xFC, 0x03, 0xFB, 0xF1,
  0xFB, 0xF8, 0x07, 0xF7, 0xE3, 0xF7, 0xF0, 0x0F, 0xEF, 0xC7, 0xEF, 0xE0,
  0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0,
  0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x00,
  0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x3F, 0xC0, 0x00, 0x3F, 0x83, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x01, 0xFC, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC1,
  0xFC, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x07,
  0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x03,
  0xF1, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E,
  0x01, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xC0, 0x0F, 0xF1, 0xFF, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x07,
  0xF8, 0xFF, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0xFF, 0x00, 0xFF, 0xFC, 0x7F, 0x80, 0x3F, 0xF8, 0x3F, 0xC0, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03,
  0xF8, 0xFF, 0xF0, 0x00, 0xFE, 0x7F, 0xFF, 0x00, 0x7F, 0xBF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xE0,
  0x07, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xDF, 0xFF, 0xF8, 0x0F,
  0xE3, 0xFF, 0xF8, 0x03, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0x9F, 0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03,
  0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0xFE, 0x1F, 0xE0, 0x03, 0xFF, 0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xEF, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xDF, 0xC0,
  0x00, 0xFF, 0xF8, 0xFE, 0x00, 0x03, 0xFF, 0x8F, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xE0, 0x1F, 0xF8, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0x8F, 0xF0,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x80, 0x3F, 0xC0, 0x00, 0xF0, 0x0F, 0xF8, 0x00, 0x7E, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x87, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x1F,
  0xC0, 0x07, 0xFF, 0xF9, 0xFE, 0x00, 0x7F, 0xFF, 0xEF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xDF, 0xFF, 0xC0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xBF, 0x80, 0x01, 0xFF, 0xFB,
  0xFC, 0x00, 0x07, 0xFF, 0x1F, 0xE0, 0x00, 0x03, 0xC0, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x08, 0x00, 0x03, 0xFC,
  0x00, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0x00, 0x03, 0xFE, 0x00, 0x7E, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0xF8, 0x00,
  0xFE, 0x3F, 0xFF, 0x80, 0x7F, 0x9F, 0xFF, 0xF0, 0x1F, 0xEF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03,
  0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x40, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xBF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xC0, 0x03,
  0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xF0,
  0x00, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0x87,
  0xFF, 0x00, 0x03, 0xFC, 0x7F, 0xF0, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x00,
  0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xF7, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xDF, 0xF0, 0x00, 0x1F, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0xC3,
  0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFC,
  0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xFC,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0xC1, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xF3, 0xFE, 0x1F, 0xF0, 0x0F,
  0xEF, 0xFE, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x83,
  0xFE, 0x1F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F,
  0x81, 0xFC, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x07, 0xF0,
  0xFF, 0x03, 0xF8, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xE0, 0x7F, 0x87, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x81, 0xFC,
  0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0xFE, 0x03,
  0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x3F, 0xC0,
  0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x1F,
  0xE1, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0,
  0x3F, 0x80, 0xFE, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE0, 0x3F, 0x87, 0xF8, 0x1F, 0xC0, 0x7F, 0x0F, 0xF0, 0x3F, 0x80,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x1F, 0xFF, 0x00, 0x7F,
  0x8F, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0xFC, 0x07, 0xF7, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFF,
  0x0F, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x3F, 0xF8, 0x1F, 0xF8, 0x07,
  0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x1F, 0xE7, 0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xFB, 0xFE, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0xC7,
  0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFB, 0xFF, 0xFE, 0x00, 0x3F,
  0xCF, 0xFF, 0xE0, 0x01, 0xFE, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC3, 0xFC, 0x01, 0xFF,
  0xFE, 0x7F, 0x00, 0x7F, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE,
  0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01,
  0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xF8,
  0x0F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xF3, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0x80, 0x00, 0x7C, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0x1F, 0xFF, 0xC0, 0x7F, 0x9F,
  0xFF, 0xE0, 0x3F, 0x9F, 0xFF, 0xF0, 0x1F, 0xDF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x06, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x01, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xF1, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x70, 0x01, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8,
  0x7F, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF7, 0xF0, 0x07, 0xFF, 0xF9, 0xFC, 0x00,
  0xFF, 0xFC, 0x7F, 0x00, 0x0F, 0xFC, 0x1F, 0xC0, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xE0, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F,
  0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xE0, 0x0F,
  0xEF, 0xE0, 0x1F, 0x80, 0x7F, 0xBF, 0x80, 0x7E, 0x01, 0xFC, 0xFE, 0x03,
  0xF8, 0x07, 0xF3, 0xF8, 0x0F, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0xC0, 0xFE,
  0x3F, 0x81, 0xFF, 0x03, 0xF8, 0xFE, 0x07, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F,
  0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0xC1, 0xFC, 0x3F, 0x83, 0xFF, 0x07, 0xE0,
  0xFE, 0x1F, 0x7C, 0x3F, 0x83, 0xF8, 0x7D, 0xF0, 0xFE, 0x0F, 0xE3, 0xF7,
  0xC3, 0xF0, 0x3F, 0x8F, 0x9F, 0x1F, 0xC0, 0xFE, 0x3E, 0x7C, 0x7F, 0x03,
  0xF9, 0xF1, 0xF1, 0xF8, 0x0F, 0xE7, 0xC7, 0xCF, 0xE0, 0x3F, 0x3F, 0x1F,
  0x3F, 0x00, 0xFC, 0xF8, 0x7C, 0xFC, 0x03, 0xF3, 0xE1, 0xF7, 0xF0, 0x0F,
  0xDF, 0x87, 0xDF, 0x80, 0x3F, 0x7C, 0x1F, 0x7E, 0x00, 0xFD, 0xF0, 0x7F,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x38, 0x3F, 0xFF, 0xC0, 0x01, 0xF3, 0xFF, 0xFF,
  0x00, 0x1F, 0x9F, 0xFF, 0xFC, 0x00, 0xFD, 0xFF, 0xFF, 0xF0, 0x0F, 0xEF,
  0xF1, 0xFF, 0xE0, 0xFE, 0xFE, 0x03, 0xFF, 0xFF, 0xF7, 0xE0, 0x07, 0xFF,
  0xFF, 0x3F, 0x00, 0x1F, 0xFF, 0xF9, 0xF0, 0x00, 0x7F, 0xFF, 0x87, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00,
};

const GFXglyph RobotoMono_MediumItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 17, 50, 41, 12, -49 },
  { 108, 22, 17, 41, 12, -52 },
  { 155, 41, 49, 41, 0, -49 },
  { 407, 36, 64, 41, 3, -57 },
  { 695, 33, 51, 41, 4, -50 },
  { 906, 38, 51, 41, 1, -50 },
  { 1149, 9, 18, 41, 18, -52 },
  { 1170, 23, 71, 41, 11, -55 },
  { 1375, 24, 71, 41, 5, -55 },
  { 1588, 33, 34, 41, 6, -49 },
  { 1729, 34, 36, 41, 3, -41 },
  { 1882, 14, 21, 41, 6, -8 },
  { 1919, 27, 7, 41, 8, -25 },
  { 1943, 11, 12, 41, 12, -11 },
  { 1960, 36, 53, 41, 3, -49 },
  { 2199, 34, 51, 41, 4, -50 },
  { 2416, 22, 49, 41, 9, -49 },
  { 2551, 36, 50, 41, 0, -50 },
  { 2776, 35, 51, 41, 2, -50 },
  { 3000, 35, 49, 41, 1, -49 },
  { 3215, 36, 50, 41, 3, -49 },
  { 3440, 32, 50, 41, 3, -49 },
  { 3640, 35, 49, 41, 5, -49 },
  { 3855, 35, 51, 41, 3, -50 },
  { 4079, 31, 50, 41, 6, -50 },
  { 4273, 16, 41, 41, 13, -40 },
  { 4355, 20, 53, 41, 10, -40 },
  { 4488, 32, 31, 41, 5, -37 },
  { 4612, 34, 21, 41, 4, -32 },
  { 4702, 32, 32, 41, 3, -37 },
  { 4830, 29, 51, 41, 9, -50 },
  { 5015, 38, 49, 41, 2, -49 },
  { 5248, 38, 49, 41, -2, -49 },
  { 5481, 39, 49, 41, 1, -49 },
  { 5720, 36, 51, 41, 3, -50 },
  { 5950, 38, 49, 41, 1, -49 },
  { 6183, 39, 49, 41, 2, -49 },
  { 6422, 39, 49, 41, 2, -49 },
  { 6661, 36, 51, 41, 3, -50 },
  { 6891, 40, 49, 41, 1, -49 },
  { 7136, 37, 49, 41, 2, -49 },
  { 7363, 38, 50, 41, 2, -49 },
  { 7601, 44, 49, 41, 1, -49 },
  { 7871, 32, 49, 41, 2, -49 },
  { 8067, 40, 49, 41, 1, -49 },
  { 8312, 40, 49, 41, 1, -49 },
  { 8557, 36, 51, 41, 3, -50 },
  { 8787, 38, 49, 41, 2, -49 },
  { 9020, 36, 58, 41, 3, -50 },
  { 9281, 39, 49, 41, 1, -49 },
  { 9520, 38, 51, 41, 2, -50 },
  { 9763, 39, 49, 41, 5, -49 },
  { 10002, 38, 50, 41, 3, -49 },
  { 10240, 37, 49, 41, 6, -49 },
  { 10467, 39, 49, 41, 5, -49 },
  { 10706, 46, 49, 41, -2, -49 },
  { 10988, 37, 49, 41, 7, -49 },
  { 11215, 40, 49, 41, 0, -49 },
  { 11460, 24, 68, 41, 9, -57 },
  { 11664, 16, 53, 41, 13, -49 },
  { 11770, 25, 68, 41, 8, -57 },
  { 11983, 27, 26, 41, 7, -49 },
  { 12071, 31, 6, 41, 0, 0 },
  { 12095, 13, 9, 41, 18, -50 },
  { 12110, 33, 38, 41, 2, -37 },
  { 12267, 34, 53, 41, 2, -52 },
  { 12493, 32, 38, 41, 4, -37 },
  { 12645, 37, 53, 41, 3, -52 },
  { 12891, 34, 38, 41, 3, -37 },
  { 13053, 37, 53, 41, 6, -53 },
  { 13299, 37, 51, 41, 1, -37 },
  { 13535, 34, 52, 41, 2, -52 },
  { 13756, 31, 50, 41, 3, -50 },
  { 13950, 32, 65, 41, 1, -50 },
  { 14210, 37, 52, 41, 2, -52 },
  { 14451, 31, 52, 41, 3, -52 },
  { 14653, 39, 37, 41, -1, -37 },
  { 14834, 34, 37, 41, 2, -37 },
  { 14992, 33, 38, 41, 3, -37 },
  { 15149, 37, 51, 41, -1, -37 },
  { 15385, 35, 51, 41, 3, -37 },
  { 15609, 33, 37, 41, 6, -37 },
  { 15762, 34, 38, 41, 3, -37 },
  { 15924, 31, 46, 41, 6, -45 },
  { 16103, 34, 37, 41, 4, -36 },
  { 16261, 35, 36, 41, 5, -36 },
  { 16419, 38, 36, 41, 4, -36 },
  { 16590, 41, 36, 41, 0, -36 },
  { 16775, 42, 51, 41, 0, -36 },
  { 17043, 37, 36, 41, 1, -36 },
  { 17210, 27, 66, 41, 10, -54 },
  { 17433, 15, 63, 41, 12, -49 },
  { 17552, 27, 66, 41, 6, -54 },
  { 17775, 37, 15, 41, 1, -28 },
};

const GFXfont RobotoMono_MediumItalic69pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic69pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic69pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _ROBOTOMONO_MEDIUMITALIC69PT7B_H_
