#ifndef _ROBOTOMONO_MEDIUMITALIC46PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x78, 0x00, 0x3C,
  0x1E, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0E,
  0x3C, 0x3C, 0x78, 0x78, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0x80, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0xF0, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0,
  0x70, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x1E,
  0x00, 0x07, 0x83, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x1E, 0x00, 0x07,
  0x83, 0x80, 0x00, 0xF0, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x07, 0x83, 0x80, 0x00, 0xE0,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0xF0, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF8, 0xFE, 0x07, 0xE0, 0x7E, 0x0F,
  0xC0, 0x3E, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF0,
  0x23, 0xC1, 0xC1, 0xEF, 0x07, 0x0F, 0x3C, 0x3C, 0x38, 0xF0, 0xF1, 0xE3,
  0xC3, 0xCF, 0x0F, 0x1E, 0x78, 0x1F, 0xF9, 0xC0, 0x7F, 0xCF, 0x00, 0x7C,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0xF0, 0x0E, 0x7F, 0xE0,
  0x79, 0xE7, 0x83, 0xCF, 0x0F, 0x0E, 0x3C, 0x3C, 0x78, 0xE0, 0xF3, 0xC3,
  0x83, 0xCE, 0x1E, 0x0F, 0x08, 0x78, 0x38, 0x00, 0xF1, 0xE0, 0x03, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x9F,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0x81, 0xF0, 0x03, 0xC0,
  0xF8, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xFE, 0x07, 0xC7, 0xFF, 0x83, 0xE7, 0xF7, 0xC1, 0xF3,
  0xF3, 0xF0, 0xF3, 0xF0, 0xF8, 0xF9, 0xF0, 0x7E, 0x7D, 0xF8, 0x1F, 0xFC,
  0xF8, 0x07, 0xFE, 0x7C, 0x03, 0xFE, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7E,
  0x07, 0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC,
  0xF8, 0x0F, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xF7, 0x9E, 0x79,
  0xE7, 0xBC, 0xF3, 0xCF, 0x3C, 0x00, 0x02, 0x00, 0x06, 0x00, 0x1E, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x02, 0x03, 0x80, 0x4C, 0x0E, 0x0E, 0x7E, 0x38, 0xF9, 0xFE, 0xEF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xC0, 0x01, 0xF7, 0x00, 0x0F, 0x9E, 0x00, 0x3C, 0x7C, 0x01, 0xF0, 0xF0,
  0x1F, 0x83, 0xE0, 0x3C, 0x07, 0xC0, 0x60, 0x1C, 0x00, 0x80, 0x40, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x87, 0xC3,
  0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x07, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFC,
  0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xE3, 0xF8, 0x3E, 0x03, 0xE1,
  0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0,
  0x07, 0xDF, 0x80, 0x3F, 0x7E, 0x03, 0xFD, 0xF0, 0x1F, 0xF7, 0xC1, 0xFF,
  0xDF, 0x0F, 0xFE, 0x7C, 0xFC, 0xFB, 0xF7, 0xE3, 0xEF, 0xFE, 0x0F, 0xBF,
  0xF0, 0x3E, 0xFF, 0x01, 0xFB, 0xF8, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00,
  0x7C, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3F, 0x01, 0xF0,
  0x7E, 0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x38, 0x03, 0xF0, 0x3F,
  0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0x7F, 0x7C, 0xF0, 0xF9, 0x81, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xE0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x80,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xF0,
  0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3F, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x7F, 0x07,
  0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xFC, 0x01, 0xF0,
  0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x81,
  0xF8, 0x1F, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0x83, 0xF8, 0x02, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xFC, 0x01,
  0xF8, 0x7C, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x1C, 0x03, 0xE7, 0xF8, 0x1F,
  0x7F, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0x83, 0xFB, 0xF8, 0x0F,
  0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0xFC,
  0xFC, 0x07, 0xE3, 0xF0, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF,
  0xE0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0x1F,
  0xC1, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0xC1,
  0xF8, 0x3F, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x7F, 0x3F, 0xC1, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x8F, 0x80,
  0x1F, 0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF8, 0x03,
  0xF3, 0xF0, 0x07, 0xC7, 0xE0, 0x1F, 0x87, 0xE0, 0x7F, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xCF,
  0xE3, 0xF0, 0x3E, 0x7E, 0x03, 0xF7, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xF7, 0xE0, 0xFF, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x1F, 0xFB, 0xE0, 0xFE, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0x81, 0xF8, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0x83, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0x80, 0x00,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFE,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x00,
  0x10, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0x8F, 0xE7, 0xE0,
  0x7E, 0xFC, 0x03, 0xEF, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xF0,
  0x1F, 0x00, 0xF0, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x3C, 0x0E, 0x0E, 0x0E,
  0x0F, 0xE3, 0x87, 0x8F, 0xFC, 0xE1, 0xC3, 0xE7, 0x38, 0xF1, 0xE3, 0x8E,
  0x38, 0xF0, 0xE3, 0x8E, 0x38, 0x38, 0xE7, 0x9E, 0x0E, 0x39, 0xC7, 0x87,
  0x0E, 0x71, 0xC1, 0xC3, 0x9C, 0x70, 0x70, 0xEF, 0x1C, 0x1C, 0x33, 0xCF,
  0x0F, 0x1C, 0xE3, 0xC3, 0x87, 0x38, 0xF1, 0xE1, 0x8E, 0x1E, 0xF8, 0xE3,
  0xC7, 0xFF, 0xF0, 0xF1, 0xF9, 0xF8, 0x1C, 0x3C, 0x3C, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC1, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03,
  0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0x78, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7E, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xE0, 0x03,
  0xE3, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x7D, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3E, 0x01, 0xFC,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07,
  0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x0F, 0xC3, 0xE0, 0x03, 0xE1, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3E,
  0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x3F, 0x87, 0xC0, 0xFF, 0xC7,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x3F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7E,
  0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x07,
  0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8,
  0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F,
  0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x03,
  0xF1, 0xF0, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x7C, 0x00,
  0xFC, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0xFE, 0x0F, 0x80, 0xFE, 0x0F, 0xC3,
  0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x04, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xF8, 0xFE, 0x0F, 0xE0,
  0x7E, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0xFE, 0xFC, 0x0F,
  0xFE, 0xFC, 0x0F, 0xFE, 0xF8, 0x0F, 0xFE, 0xF8, 0x1F, 0xFC, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0x7C, 0x00,
  0xFC, 0x7C, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81,
  0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00,
  0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x07,
  0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xF8,
  0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x0F,
  0xE0, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x3F,
  0x00, 0x3F, 0x81, 0xF0, 0x03, 0xF8, 0x0F, 0x80, 0x3F, 0x80, 0x7C, 0x03,
  0xF8, 0x03, 0xE0, 0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x3F, 0x80,
  0x0F, 0x81, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x1F,
  0x1F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7D, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x03,
  0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x05, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F,
  0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xEF, 0x1F, 0xF0,
  0x3D, 0xE7, 0xBE, 0x0F, 0xBC, 0xF7, 0xC1, 0xF7, 0xBC, 0xF0, 0x3E, 0xF7,
  0xBE, 0x07, 0xDF, 0xE7, 0xC0, 0xF1, 0xFC, 0xF8, 0x3E, 0x3F, 0x1F, 0x07,
  0xC7, 0xE3, 0xE0, 0xF8, 0xF8, 0x78, 0x1F, 0x1F, 0x1F, 0x03, 0xE3, 0xC3,
  0xE0, 0x7C, 0x78, 0x7C, 0x1F, 0x0E, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C,
  0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xC0,
  0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xC1, 0xF8, 0x01,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xF0, 0x0F, 0x83, 0xFC,
  0x03, 0xE0, 0xFF, 0x00, 0xF8, 0x3F, 0xC0, 0x3E, 0x0F, 0xF8, 0x1F, 0x83,
  0xFE, 0x07, 0xE1, 0xFF, 0x81, 0xF0, 0x7F, 0xF0, 0x7C, 0x1F, 0x7C, 0x1F,
  0x07, 0xCF, 0x0F, 0xC1, 0xF3, 0xC3, 0xF0, 0x7C, 0xF8, 0xF8, 0x3F, 0x1E,
  0x3E, 0x0F, 0xC7, 0x8F, 0x83, 0xE1, 0xF3, 0xE0, 0xF8, 0x7D, 0xF8, 0x3E,
  0x0F, 0x7E, 0x0F, 0x83, 0xDF, 0x07, 0xE0, 0xFF, 0xC1, 0xF8, 0x1F, 0xF0,
  0x7C, 0x07, 0xFC, 0x1F, 0x01, 0xFF, 0x07, 0xC0, 0x7F, 0xC3, 0xF0, 0x0F,
  0xE0, 0xFC, 0x03, 0xF8, 0x3E, 0x00, 0xFE, 0x0F, 0x80, 0x1F, 0x83, 0xE0,
  0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xF9, 0xFC, 0x0F, 0xC0, 0x7E,
  0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3F,
  0x3E, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xFC, 0x01, 0xF8,
  0x7C, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xF0, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x1F,
  0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xFC,
  0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xE1, 0xF8, 0x03,
  0xF8, 0x7E, 0x01, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x07, 0xF9, 0xFC, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7E, 0x03, 0xF0,
  0x7F, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x3E, 0x01, 0xFC, 0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x0F, 0x80,
  0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x7C, 0x01, 0xFC, 0x3E, 0x01, 0xFC, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03,
  0xE0, 0x7C, 0x01, 0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3F,
  0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xF1, 0xF0, 0x01,
  0xF8, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0x9F, 0xE0, 0x7E, 0x01, 0xF8,
  0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x0F,
  0xC7, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x87, 0xF0, 0x3F, 0x81,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xF1, 0xF8, 0x01,
  0xF8, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xE0,
  0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x7E,
  0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87,
  0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0,
  0xFC, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x7E,
  0x07, 0xF0, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xCF, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xE3,
  0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x7E, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x0F,
  0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF3,
  0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0x7C, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x1E, 0x07, 0xDF, 0x07, 0x81, 0xF7, 0xC1,
  0xE0, 0x7D, 0xF0, 0xF8, 0x3E, 0x7C, 0x3E, 0x0F, 0x9F, 0x0F, 0x83, 0xE7,
  0xC7, 0xE0, 0xF1, 0xF1, 0xF8, 0x7C, 0x78, 0x7E, 0x1F, 0x1E, 0x1F, 0x87,
  0xC7, 0x8F, 0xE3, 0xE1, 0xE3, 0xF8, 0xF8, 0x78, 0xFE, 0x3E, 0x1E, 0x7B,
  0x8F, 0x07, 0x9E, 0xE7, 0xC1, 0xE7, 0xB9, 0xF0, 0x7B, 0xCE, 0x7C, 0x1E,
  0xF3, 0x9E, 0x0F, 0xBC, 0xEF, 0x83, 0xFE, 0x3B, 0xE0, 0xFF, 0x8E, 0xF0,
  0x3F, 0xE3, 0xBC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F,
  0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0xFC,
  0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x03,
  0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C,
  0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x1F,
  0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xBE,
  0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1,
  0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x03, 0xF0,
  0x0F, 0x81, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xFC,
  0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03,
  0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x0F, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0x78, 0x07, 0xDF,
  0x01, 0xE3, 0xC0, 0xF8, 0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x0F, 0x81, 0xE3,
  0xC0, 0x79, 0xF0, 0x1E, 0x78, 0x07, 0xBE, 0x01, 0xF0, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F, 0x0F, 0x83,
  0xE0, 0xF0, 0x3C, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xFC, 0x1F, 0xE7, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x0F, 0x8F, 0x80,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xF0, 0x1F, 0x3F, 0x00, 0x7C, 0xF8,
  0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x3E, 0x01, 0xF8, 0xFC, 0x1F,
  0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFE, 0xF8, 0x1F, 0xE3, 0xF0,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0xFF, 0x00, 0xFB,
  0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xF0, 0x7E, 0x1F, 0x80,
  0x7E, 0x3F, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03,
  0xE7, 0xE0, 0x07, 0xCF, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x7E,
  0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0x8F,
  0xC0, 0x3F, 0x1F, 0xE0, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xF3,
  0xFF, 0x83, 0xE3, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x07,
  0xE1, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7D, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x80, 0xFC, 0x3F, 0x07, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x3F, 0xE7, 0xC0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0x87, 0xC0,
  0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xFC,
  0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x07,
  0xC0, 0x1F, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x3F, 0xC0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFC, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x7F, 0x03, 0xE1, 0xF8, 0x07, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7D, 0xF8,
  0x01, 0xF7, 0xC0, 0x07, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x04, 0x1F, 0x80, 0x38, 0x3F, 0x03, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x20, 0x00, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03,
  0xF8, 0x08, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0x9F, 0x03, 0xFF, 0xDF, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xE0, 0xFF, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3E,
  0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7E,
  0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C,
  0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3F, 0x01, 0xF8,
  0x3F, 0x87, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x03, 0xF9, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x20, 0x03, 0xF0,
  0x30, 0x07, 0xE0, 0x78, 0x0F, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x0F, 0x00, 0x7C, 0x7F, 0x80, 0xFB, 0xFF, 0x81, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xF0, 0x7F, 0x1F, 0x80, 0x7E, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xE0, 0x07,
  0xCF, 0x80, 0x1F, 0x9F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF9,
  0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF8, 0x03, 0xF3, 0xE0,
  0x07, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x07,
  0xF0, 0xF8, 0x07, 0xE0, 0x7C, 0x0F, 0xE0, 0x3E, 0x0F, 0xE0, 0x3F, 0x0F,
  0xE0, 0x1F, 0x8F, 0xE0, 0x0F, 0x8F, 0xE0, 0x07, 0xCF, 0xE0, 0x03, 0xEF,
  0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F,
  0xC1, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x3F,
  0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x00, 0x0E, 0x0F,
  0x00, 0xF7, 0xF3, 0xF0, 0x3F, 0xFE, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0x1F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x3C, 0x1E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xE0, 0xF8, 0x7C, 0x7C, 0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78,
  0x3E, 0x3E, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x3C, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x1F, 0x1F, 0xE0, 0x3E, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC3, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xE7,
  0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xFC,
  0x01, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80,
  0x1F, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x7E, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x7E, 0x00, 0x7D, 0xF0,
  0x01, 0xF7, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFB, 0xF0, 0x07, 0xE7,
  0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0x7E, 0x07, 0xE0, 0xFF, 0xFF, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x01, 0xF3, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x3F, 0x07,
  0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0x83, 0xF0, 0x0F,
  0xC1, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7E, 0xFF,
  0xE0, 0x3F, 0x3F, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xFE, 0x7C, 0x1F, 0xFE, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3,
  0xF0, 0x3F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x3E, 0x7E, 0x00, 0x7C, 0xFC,
  0x01, 0xF9, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x80,
  0x1F, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF8, 0x03,
  0xE1, 0xF0, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xF0, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xF3, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x3E, 0x3F, 0xF0, 0xF9, 0xFF, 0x83, 0xEF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07,
  0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xE3, 0xFC, 0x7E, 0x03,
  0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0xBF, 0x00, 0x7E, 0x7E, 0x03, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x05,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x04, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF3,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xFD, 0xF8, 0x03, 0xE7, 0xE0,
  0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xE7, 0xC0, 0x1F,
  0xBF, 0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E,
  0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0x8F, 0xC0, 0x7E, 0x3F, 0x07,
  0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xEF, 0x83, 0xFF, 0x3C, 0x07, 0xF9, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xE7,
  0xC0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x3E,
  0x03, 0xF0, 0x3C, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0xF8, 0x03, 0xE1, 0xF0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0xBE,
  0x00, 0x1F, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0xF0, 0x3C, 0x0F, 0xF8, 0x1E, 0x0F, 0xBC, 0x1F, 0x07, 0xDE, 0x0F, 0x83,
  0xCF, 0x07, 0xC3, 0xE7, 0x87, 0xE1, 0xF3, 0xC3, 0xF0, 0xF1, 0xE3, 0xF8,
  0xF8, 0xF1, 0xDC, 0x7C, 0x78, 0xEE, 0x3C, 0x3C, 0xF7, 0x1E, 0x1E, 0x73,
  0x9F, 0x0F, 0x39, 0xCF, 0x07, 0xBC, 0xE7, 0x83, 0xDC, 0x77, 0x81, 0xFE,
  0x3B, 0xC0, 0xFE, 0x1D, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F,
  0x83, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x7E, 0x01,
  0xF0, 0x1E, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x0F, 0x80,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0x3E, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE0, 0xFC, 0x01, 0xF8,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x03, 0xF0,
  0x1F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xC0, 0xFC,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x3F,
  0x00, 0x7E, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x3F,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xF7, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFD, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x78, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0xF3, 0xFF, 0xC0, 0x38, 0xFF, 0xF8, 0x1E, 0x7C,
  0x7F, 0x8F, 0x9E, 0x07, 0xFF, 0xC7, 0x00, 0xFF, 0xF3, 0xC0, 0x1F, 0xF8,
  0x00, 0x01, 0xFC, 0x00,
};

const GFXglyph RobotoMono_MediumItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 11, 33, 27, 8, -33 },
  { 47, 15, 12, 27, 8, -35 },
  { 70, 27, 33, 27, 0, -33 },
  { 182, 24, 43, 27, 2, -38 },
  { 311, 22, 34, 27, 3, -33 },
  { 405, 25, 34, 27, 1, -33 },
  { 512, 6, 12, 27, 12, -35 },
  { 521, 16, 47, 27, 7, -37 },
  { 615, 15, 47, 27, 4, -37 },
  { 704, 22, 23, 27, 4, -33 },
  { 768, 23, 24, 27, 2, -27 },
  { 837, 9, 13, 27, 4, -5 },
  { 852, 19, 5, 27, 5, -17 },
  { 864, 8, 7, 27, 8, -7 },
  { 871, 24, 36, 27, 2, -33 },
  { 979, 22, 34, 27, 3, -33 },
  { 1073, 15, 33, 27, 6, -33 },
  { 1135, 24, 33, 27, 0, -33 },
  { 1234, 24, 34, 27, 1, -33 },
  { 1336, 24, 33, 27, 0, -33 },
  { 1435, 24, 34, 27, 2, -33 },
  { 1537, 21, 34, 27, 2, -33 },
  { 1627, 24, 33, 27, 3, -33 },
  { 1726, 23, 34, 27, 2, -33 },
  { 1824, 20, 33, 27, 4, -33 },
  { 1907, 11, 26, 27, 9, -26 },
  { 1943, 14, 34, 27, 6, -26 },
  { 2003, 21, 21, 27, 3, -25 },
  { 2059, 23, 14, 27, 2, -21 },
  { 2100, 22, 21, 27, 2, -25 },
  { 2158, 20, 33, 27, 6, -33 },
  { 2241, 26, 33, 27, 1, -33 },
  { 2349, 25, 33, 27, -1, -33 },
  { 2453, 25, 33, 27, 1, -33 },
  { 2557, 24, 34, 27, 2, -33 },
  { 2659, 25, 33, 27, 1, -33 },
  { 2763, 26, 33, 27, 1, -33 },
  { 2871, 27, 33, 27, 1, -33 },
  { 2983, 24, 34, 27, 2, -33 },
  { 3085, 27, 33, 27, 0, -33 },
  { 3197, 24, 33, 27, 2, -33 },
  { 3296, 25, 34, 27, 2, -33 },
  { 3403, 29, 33, 27, 1, -33 },
  { 3523, 22, 33, 27, 1, -33 },
  { 3614, 27, 33, 27, 1, -33 },
  { 3726, 26, 33, 27, 1, -33 },
  { 3834, 24, 34, 27, 2, -33 },
  { 3936, 26, 33, 27, 1, -33 },
  { 4044, 24, 39, 27, 2, -33 },
  { 4161, 25, 33, 27, 1, -33 },
  { 4265, 25, 33, 27, 2, -33 },
  { 4369, 25, 33, 27, 4, -33 },
  { 4473, 25, 34, 27, 2, -33 },
  { 4580, 25, 33, 27, 4, -33 },
  { 4684, 26, 33, 27, 3, -33 },
  { 4792, 30, 33, 27, -1, -33 },
  { 4916, 25, 33, 27, 4, -33 },
  { 5020, 27, 33, 27, 0, -33 },
  { 5132, 16, 45, 27, 6, -38 },
  { 5222, 11, 36, 27, 9, -33 },
  { 5272, 17, 45, 27, 5, -38 },
  { 5368, 18, 18, 27, 5, -33 },
  { 5409, 21, 4, 27, 0, 0 },
  { 5420, 9, 6, 27, 12, -33 },
  { 5427, 22, 25, 27, 2, -25 },
  { 5496, 23, 36, 27, 1, -35 },
  { 5600, 22, 26, 27, 2, -25 },
  { 5672, 25, 35, 27, 2, -35 },
  { 5782, 22, 25, 27, 2, -25 },
  { 5851, 25, 36, 27, 4, -36 },
  { 5964, 24, 35, 27, 1, -25 },
  { 6069, 23, 35, 27, 1, -35 },
  { 6170, 20, 34, 27, 2, -34 },
  { 6255, 21, 44, 27, 1, -34 },
  { 6371, 25, 35, 27, 1, -35 },
  { 6481, 21, 35, 27, 2, -35 },
  { 6573, 27, 25, 27, -1, -25 },
  { 6658, 23, 25, 27, 1, -25 },
  { 6730, 22, 26, 27, 2, -25 },
  { 6802, 25, 34, 27, -1, -25 },
  { 6909, 23, 34, 27, 2, -25 },
  { 7007, 22, 25, 27, 4, -25 },
  { 7076, 22, 26, 27, 2, -25 },
  { 7148, 21, 31, 27, 4, -30 },
  { 7230, 22, 25, 27, 3, -24 },
  { 7299, 23, 24, 27, 4, -24 },
  { 7368, 25, 24, 27, 3, -24 },
  { 7443, 27, 24, 27, 0, -24 },
  { 7524, 28, 34, 27, 0, -24 },
  { 7643, 24, 24, 27, 1, -24 },
  { 7715, 18, 44, 27, 7, -36 },
  { 7814, 10, 42, 27, 8, -33 },
  { 7867, 18, 44, 27, 4, -36 },
  { 7966, 26, 9, 27, 0, -18 },
};

const GFXfont RobotoMono_MediumItalic46pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic46pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOMONO_MEDIUMITALIC46PT7B_H_
