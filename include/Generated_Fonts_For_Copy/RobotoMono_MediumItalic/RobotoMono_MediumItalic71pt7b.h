#ifndef _ROBOTOMONO_MEDIUMITALIC71PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x02,
  0x00, 0x00, 0x3F, 0x80, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0xFC,
  0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x00, 0xF8, 0x7C,
  0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xF8, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03,
  0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x81, 0xF8, 0x0F, 0x80, 0x30, 0x7E, 0x03, 0xF0, 0x1F, 0x9F,
  0x00, 0xFC, 0x0F, 0xC7, 0xC0, 0x3E, 0x07, 0xE1, 0xF0, 0x0F, 0x81, 0xF0,
  0xFC, 0x03, 0xE0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xC0, 0x7E, 0x1F,
  0x01, 0xF8, 0x3F, 0x0F, 0xC0, 0x7F, 0x1F, 0xC7, 0xE0, 0x1F, 0xFF, 0xE1,
  0xF0, 0x03, 0xFF, 0xF8, 0xFC, 0x00, 0x7F, 0xFC, 0x7E, 0x00, 0x0F, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x7F, 0xC0, 0x00, 0x7C, 0x3F,
  0xFC, 0x00, 0x3F, 0x1F, 0xFF, 0x80, 0x1F, 0x8F, 0xFF, 0xE0, 0x07, 0xC7,
  0xFF, 0xFC, 0x03, 0xF1, 0xF8, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xC0, 0xFC,
  0x3F, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x87, 0xE0, 0x1F, 0x0F,
  0xC1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7E, 0x03, 0xF0, 0xF8, 0x1F, 0x80, 0xFC,
  0x0C, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xE0,
  0xFF, 0xFF, 0xE0, 0x1F, 0xC3, 0xFF, 0x3F, 0xC0, 0x7F, 0x0F, 0xFC, 0x7F,
  0xC0, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x7F, 0xC0, 0xFF, 0x87, 0xF8,
  0xFF, 0x00, 0xFF, 0x8F, 0xE3, 0xFE, 0x00, 0xFF, 0x3F, 0xC7, 0xF8, 0x01,
  0xFF, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0xFE, 0x1F, 0xE0, 0x03, 0xFF, 0xF8,
  0x3F, 0xC0, 0x03, 0xFF, 0xF0, 0x7F, 0x80, 0x07, 0xFF, 0xC0, 0xFF, 0x00,
  0x07, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xBF,
  0xE0, 0x07, 0xFF, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0xE0, 0x7F, 0xC0, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC,
  0x7E, 0x3F, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF1, 0xF8, 0xFC, 0x7E,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x3E, 0x00, 0x21, 0xE0,
  0x1F, 0x80, 0x78, 0xFE, 0x07, 0xC0, 0x7E, 0x3F, 0xE1, 0xF0, 0xFF, 0x9F,
  0xFE, 0x7C, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x01, 0xFC,
  0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x00, 0x40, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0,
  0x1F, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x07, 0xF1, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0x80, 0x03, 0xFF, 0x0F, 0xF0, 0x01, 0xFF,
  0xE3, 0xFE, 0x00, 0x7F, 0xFC, 0x7F, 0x80, 0x3F, 0xFF, 0x8F, 0xF0, 0x0F,
  0xFF, 0xF1, 0xFE, 0x07, 0xFD, 0xFE, 0x3F, 0xC1, 0xFF, 0x7F, 0xC7, 0xF8,
  0x7F, 0xCF, 0xF1, 0xFF, 0x3F, 0xE1, 0xFE, 0x3F, 0xCF, 0xF8, 0x3F, 0xC7,
  0xFF, 0xFC, 0x07, 0xF8, 0xFF, 0xFF, 0x00, 0xFF, 0x1F, 0xFF, 0x80, 0x1F,
  0xE3, 0xFF, 0xE0, 0x07, 0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0x1F, 0xFC, 0x00,
  0x1F, 0xE3, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF1, 0xFF, 0xDF, 0xE7, 0xFC, 0x3F, 0xCF, 0xC0, 0x7F, 0x9C, 0x00,
  0xFF, 0x20, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFE, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F,
  0xF3, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x01, 0xFD, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x00, 0x10, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFC,
  0x7F, 0xFC, 0x01, 0xFE, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x1F, 0xE7,
  0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x01,
  0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x40, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xF8,
  0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0xFF, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03,
  0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0,
  0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xC0,
  0x0F, 0xFE, 0x7F, 0xC0, 0x1F, 0xFE, 0x7F, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFB, 0xF8, 0x03, 0xFF, 0xE7, 0xF8, 0x01, 0xFF, 0x87, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x01, 0xFC, 0x03, 0xFE,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0,
  0x7F, 0x80, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x78, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFC,
  0xFF, 0x80, 0x07, 0xFB, 0xFE, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xFF, 0x81, 0xE0, 0x7E, 0x07,
  0xFF, 0xC3, 0xC0, 0xF8, 0x1F, 0xFF, 0x87, 0xC3, 0xF0, 0x7F, 0xFF, 0x0F,
  0x87, 0xC1, 0xFC, 0x3E, 0x1F, 0x1F, 0x87, 0xF0, 0x7C, 0x3E, 0x3E, 0x0F,
  0xC0, 0xF0, 0x7C, 0xFC, 0x3F, 0x01, 0xE0, 0xF9, 0xF0, 0x7C, 0x07, 0xC1,
  0xF3, 0xE1, 0xF8, 0x0F, 0x83, 0xEF, 0xC3, 0xE0, 0x1E, 0x07, 0xDF, 0x07,
  0xC0, 0x7C, 0x0F, 0x3E, 0x1F, 0x80, 0xF8, 0x1E, 0x7C, 0x3F, 0x01, 0xF0,
  0x3D, 0xF8, 0x7C, 0x03, 0xC0, 0xFB, 0xE0, 0xF8, 0x0F, 0x81, 0xF7, 0xC1,
  0xF0, 0x1F, 0x03, 0xCF, 0x83, 0xE0, 0x3E, 0x07, 0x9F, 0x07, 0xC0, 0x7C,
  0x1F, 0x3E, 0x1F, 0x81, 0xF0, 0x3C, 0x7C, 0x3F, 0x03, 0xE0, 0x78, 0xF8,
  0x3E, 0x0F, 0xC1, 0xE1, 0xF0, 0x7E, 0x3F, 0x87, 0xC3, 0xE0, 0xFF, 0xFF,
  0x9F, 0x07, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0x81, 0xFF, 0xBF, 0xF8, 0x1F,
  0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x08, 0x00, 0x01, 0xFE, 0x00,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x00, 0xFF,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x07,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF,
  0xE0, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE1,
  0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0xF8, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x3F,
  0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xE0,
  0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0x9F, 0xE0, 0x07, 0xFF, 0xF8,
  0xFF, 0x00, 0x7F, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0xFE, 0x7F, 0xC0, 0x1F,
  0xFF, 0xF3, 0xFC, 0x00, 0xFF, 0xFF, 0x9F, 0xE0, 0x07, 0xFF, 0xFC, 0xFF,
  0x00, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0xC0,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF,
  0xC1, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x3F, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xF9, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xDF, 0xFC, 0x00, 0x00,
  0x03, 0xFD, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xEF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xDF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x83, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xBF,
  0x80, 0x3F, 0xBF, 0x0F, 0xEF, 0xE0, 0x0F, 0xEF, 0xC3, 0xF3, 0xF8, 0x03,
  0xF9, 0xF1, 0xFD, 0xFE, 0x00, 0xFE, 0x7E, 0x7E, 0x7F, 0x00, 0x7F, 0x9F,
  0xBF, 0x9F, 0xC0, 0x1F, 0xE7, 0xEF, 0xC7, 0xF0, 0x07, 0xF1, 0xFF, 0xF1,
  0xFC, 0x01, 0xFC, 0x7F, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xFE, 0x3F, 0xC0,
  0x1F, 0xC7, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFF, 0xC3, 0xF8, 0x03, 0xFC,
  0x3F, 0xE0, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0x83, 0xFC,
  0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0x81, 0xFC,
  0x01, 0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x83, 0xF0, 0x3F, 0xC0, 0x1F,
  0xE0, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x1E, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xF0,
  0x0F, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFF,
  0xC0, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xC0,
  0x3F, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFD, 0xF8, 0x03,
  0xFC, 0x03, 0xFE, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x7F, 0x01, 0xFF, 0x00,
  0xFF, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x8F, 0xE0, 0x7F, 0x80, 0x3F, 0xC7,
  0xF0, 0x3F, 0xC0, 0x1F, 0xE3, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0xFC, 0x1F,
  0xF0, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x87, 0xF8, 0x03,
  0xFC, 0x1F, 0xC3, 0xFC, 0x01, 0xFE, 0x07, 0xE1, 0xFE, 0x00, 0xFF, 0x03,
  0xF8, 0xFF, 0x00, 0xFF, 0x81, 0xFC, 0xFF, 0x80, 0x7F, 0x80, 0x7E, 0x7F,
  0x80, 0x3F, 0xC0, 0x3F, 0xBF, 0xC0, 0x1F, 0xE0, 0x1F, 0xDF, 0xE0, 0x0F,
  0xF0, 0x0F, 0xEF, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFC, 0x01,
  0xFF, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x7F,
  0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xE0, 0x00,
  0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xF8,
  0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x3F,
  0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xF9, 0xFF, 0x00,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00,
  0x3F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFE,
  0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x07,
  0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xF8, 0x07,
  0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xFB, 0xFC, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00,
  0x7F, 0xDF, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xE3, 0xFC, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xF8, 0x07,
  0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF0,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFD, 0xFE, 0x00,
  0x00, 0x3F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0x00,
  0xFE, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x7F,
  0x00, 0xFF, 0x01, 0xFE, 0x7F, 0x01, 0xFF, 0x01, 0xFC, 0x7F, 0x01, 0xFF,
  0x03, 0xFC, 0x7F, 0x01, 0xFF, 0x03, 0xFC, 0x7F, 0x03, 0xFF, 0x03, 0xF8,
  0x7F, 0x03, 0xFF, 0x03, 0xF8, 0x7F, 0x03, 0xFF, 0x07, 0xF8, 0x7F, 0x03,
  0xFF, 0x07, 0xF8, 0x7F, 0x07, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xFF, 0x07,
  0xF0, 0x7F, 0x07, 0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xFF, 0x0F, 0xE0, 0x7F,
  0x0F, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xFF, 0x1F, 0xE0, 0x7F, 0x1F, 0xBF,
  0x1F, 0xE0, 0x7F, 0x1F, 0xBF, 0x1F, 0xC0, 0x7F, 0x1F, 0xBF, 0x1F, 0xC0,
  0x7F, 0x3F, 0x3F, 0x3F, 0xC0, 0x7F, 0x3F, 0x3F, 0x3F, 0x80, 0xFF, 0x3F,
  0x3F, 0x3F, 0x80, 0xFE, 0x7E, 0x3F, 0x3F, 0x80, 0xFE, 0x7E, 0x3F, 0x7F,
  0x80, 0xFE, 0x7E, 0x3F, 0x7F, 0x00, 0xFE, 0x7E, 0x3F, 0x7F, 0x00, 0xFE,
  0xFC, 0x3F, 0x7F, 0x00, 0xFE, 0xFC, 0x3F, 0xFE, 0x00, 0xFE, 0xFC, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x87, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE3,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x01, 0xFF, 0x83,
  0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x3F,
  0x80, 0x0F, 0xE3, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0x7E,
  0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xE0,
  0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE,
  0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xF8, 0x0F, 0xF1, 0xFF, 0x80,
  0x0F, 0xF9, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x80,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x7F, 0xE3, 0xFE,
  0x00, 0x7F, 0xF1, 0xFF, 0x80, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x7F, 0x80,
  0xFF, 0xFE, 0x3F, 0xC0, 0x1F, 0xFC, 0x1F, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC,
  0x7F, 0xF8, 0x00, 0x7F, 0xBF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x87, 0xF8,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF,
  0x87, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xEF,
  0xFF, 0xFE, 0x03, 0xFC, 0xFF, 0xFF, 0x80, 0x7F, 0x8F, 0xFF, 0xE0, 0x0F,
  0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF8,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xFE, 0x3F, 0xE0, 0x03,
  0xFF, 0xFC, 0xFF, 0x80, 0x1F, 0xFF, 0xFB, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x03, 0xFC,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xEF, 0xE0, 0x00,
  0xFF, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0xF9, 0xFE, 0x00, 0x03, 0xFF, 0x87,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x07,
  0xF3, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x08, 0x07, 0xFC, 0x00,
  0x03, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0xFF,
  0xE0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x06,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xE0, 0x7F, 0x87, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x01,
  0xFC, 0x00, 0x1F, 0xFF, 0x8F, 0xF0, 0x01, 0xFF, 0xFF, 0x3F, 0xC0, 0x0F,
  0xFF, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFC, 0x00, 0x00, 0xF8, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x80, 0x00, 0x3F, 0xC0, 0x07, 0x00, 0x01, 0xFF,
  0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xFC, 0x3F, 0xFC, 0x00, 0x7F,
  0x9F, 0xFF, 0xE0, 0x0F, 0xE7, 0xFF, 0xFE, 0x03, 0xFD, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x3F,
  0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE3, 0xFE, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF1,
  0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x03,
  0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x00,
  0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFC, 0x0F,
  0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x00,
  0x3F, 0xC3, 0xFF, 0x80, 0x00, 0x7F, 0x8F, 0xFE, 0x00, 0x00, 0xFF, 0x3F,
  0xF0, 0x00, 0x01, 0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFE,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x7F, 0x03,
  0xF8, 0x01, 0xFC, 0x7F, 0xC3, 0xFE, 0x00, 0xFE, 0xFF, 0xF7, 0xFF, 0x80,
  0x7F, 0x7F, 0xFB, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x7F, 0xE1,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x83, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x3F,
  0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0xFE,
  0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0x03,
  0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x07, 0xFF, 0xC0, 0x0F, 0xE3, 0xFF, 0xFC,
  0x01, 0xFC, 0xFF, 0xFF, 0xC0, 0x7F, 0xBF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x9F,
  0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF,
  0x87, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0xFC, 0x00, 0x07,
  0xF3, 0xFF, 0xFC, 0x00, 0x1F, 0xDF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x01, 0xFF, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFB, 0xFF, 0xFF, 0x00, 0x1F, 0xE3, 0xFF, 0xF8, 0x00, 0x7F, 0x87, 0xFF,
  0x80, 0x01, 0xFE, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x0F,
  0xE0, 0x07, 0xFF, 0xC3, 0xFC, 0x03, 0xFF, 0xFE, 0x7F, 0x80, 0xFF, 0xFF,
  0xEF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xF7, 0xFF, 0xF0, 0x7F, 0xE0, 0x1F, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x8F,
  0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFB, 0xFC, 0x00, 0x7F, 0xFE,
  0x7F, 0x80, 0x07, 0xFF, 0x0F, 0xE0, 0x00, 0x0F, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x07, 0xFF,
  0x01, 0xFE, 0x0F, 0xFF, 0xC0, 0xFE, 0x1F, 0xFF, 0xC0, 0x7F, 0x1F, 0xFF,
  0xE0, 0x7F, 0x9F, 0xFF, 0xF0, 0x3F, 0xDF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x06, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x87, 0xF8, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x8F,
  0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F,
  0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x81, 0xE0, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xE0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFF,
  0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFE,
  0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x01,
  0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xF8, 0x1F,
  0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xEF, 0xE0, 0x0F, 0xFF, 0xF9,
  0xFC, 0x00, 0xFF, 0xFC, 0x3F, 0x80, 0x07, 0xFF, 0x0F, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x7C, 0x01, 0xFF, 0xFC, 0x01, 0xF8, 0x03, 0xFF,
  0xF8, 0x03, 0xF0, 0x07, 0xF7, 0xF0, 0x07, 0xE0, 0x1F, 0xEF, 0xE0, 0x1F,
  0xC0, 0x3F, 0x9F, 0xC0, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0xFF, 0x01, 0xFE,
  0x7F, 0x01, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0x07, 0xF1, 0xFC, 0x0F,
  0xF8, 0x0F, 0xE3, 0xF8, 0x1F, 0xF0, 0x3F, 0x87, 0xF0, 0x7F, 0xE0, 0x7F,
  0x0F, 0xE0, 0xFF, 0xC0, 0xFE, 0x1F, 0xC1, 0xFF, 0x83, 0xF8, 0x3F, 0x87,
  0xFF, 0x87, 0xF0, 0x7F, 0x0F, 0xBF, 0x0F, 0xC0, 0xFE, 0x1F, 0x7E, 0x3F,
  0x81, 0xFC, 0x7E, 0xFC, 0x7F, 0x03, 0xF8, 0xF8, 0xF8, 0xFC, 0x07, 0xF3,
  0xF1, 0xF3, 0xF8, 0x0F, 0xE7, 0xC3, 0xE7, 0xF0, 0x1F, 0xCF, 0x87, 0xCF,
  0xC0, 0x3F, 0xBF, 0x0F, 0xBF, 0x80, 0x7F, 0x7C, 0x1F, 0x7F, 0x00, 0x7E,
  0xF8, 0x3E, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00,
  0x07, 0xFB, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFD, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xF0,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xBF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0x80, 0x01,
  0xF8, 0xFF, 0xFF, 0x80, 0x03, 0xE3, 0xFF, 0xFF, 0x80, 0x0F, 0xCF, 0xFF,
  0xFF, 0x80, 0x3F, 0x9F, 0xFF, 0xFF, 0xC0, 0xFF, 0x3F, 0x81, 0xFF, 0xE7,
  0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0xF9, 0xF8, 0x00, 0xFF, 0xFF, 0xE3, 0xF0,
  0x00, 0xFF, 0xFF, 0x87, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
};

const GFXglyph RobotoMono_MediumItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 17, 51, 42, 13, -50 },
  { 110, 22, 17, 42, 13, -53 },
  { 157, 42, 50, 42, 0, -50 },
  { 420, 36, 66, 42, 4, -59 },
  { 717, 34, 52, 42, 4, -51 },
  { 938, 39, 52, 42, 1, -51 },
  { 1192, 9, 18, 42, 18, -53 },
  { 1213, 24, 73, 42, 11, -57 },
  { 1432, 24, 72, 42, 6, -56 },
  { 1648, 34, 35, 42, 6, -50 },
  { 1797, 35, 37, 42, 3, -42 },
  { 1959, 14, 21, 42, 7, -8 },
  { 1996, 29, 7, 42, 8, -26 },
  { 2022, 11, 12, 42, 13, -11 },
  { 2039, 37, 54, 42, 3, -50 },
  { 2289, 35, 52, 42, 4, -51 },
  { 2517, 23, 50, 42, 9, -50 },
  { 2661, 37, 51, 42, 0, -51 },
  { 2897, 36, 52, 42, 2, -51 },
  { 3131, 36, 50, 42, 1, -50 },
  { 3356, 37, 51, 42, 4, -50 },
  { 3592, 33, 52, 42, 3, -51 },
  { 3807, 36, 50, 42, 5, -50 },
  { 4032, 36, 52, 42, 3, -51 },
  { 4266, 32, 51, 42, 6, -51 },
  { 4470, 16, 41, 42, 14, -40 },
  { 4552, 21, 53, 42, 10, -40 },
  { 4692, 33, 32, 42, 5, -38 },
  { 4824, 35, 22, 42, 4, -33 },
  { 4921, 33, 32, 42, 3, -38 },
  { 5053, 31, 52, 42, 9, -51 },
  { 5255, 39, 50, 42, 2, -50 },
  { 5499, 39, 50, 42, -2, -50 },
  { 5743, 40, 50, 42, 1, -50 },
  { 5993, 38, 52, 42, 3, -51 },
  { 6240, 39, 50, 42, 1, -50 },
  { 6484, 40, 50, 42, 2, -50 },
  { 6734, 41, 50, 42, 2, -50 },
  { 6991, 37, 52, 42, 3, -51 },
  { 7232, 41, 50, 42, 1, -50 },
  { 7489, 37, 50, 42, 3, -50 },
  { 7721, 39, 51, 42, 2, -50 },
  { 7970, 45, 50, 42, 1, -50 },
  { 8252, 33, 50, 42, 2, -50 },
  { 8459, 42, 50, 42, 1, -50 },
  { 8722, 41, 50, 42, 1, -50 },
  { 8979, 37, 52, 42, 3, -51 },
  { 9220, 40, 50, 42, 2, -50 },
  { 9470, 37, 60, 42, 3, -51 },
  { 9748, 40, 50, 42, 1, -50 },
  { 9998, 39, 52, 42, 2, -51 },
  { 10252, 39, 50, 42, 6, -50 },
  { 10496, 39, 51, 42, 3, -50 },
  { 10745, 38, 50, 42, 6, -50 },
  { 10983, 40, 50, 42, 5, -50 },
  { 11233, 47, 50, 42, -2, -50 },
  { 11527, 38, 50, 42, 7, -50 },
  { 11765, 42, 50, 42, 0, -50 },
  { 12028, 25, 69, 42, 9, -58 },
  { 12244, 17, 54, 42, 13, -50 },
  { 12359, 26, 69, 42, 8, -58 },
  { 12584, 27, 26, 42, 8, -50 },
  { 12672, 32, 7, 42, 0, 0 },
  { 12700, 13, 9, 42, 19, -51 },
  { 12715, 33, 39, 42, 3, -38 },
  { 12876, 35, 54, 42, 2, -53 },
  { 13113, 33, 39, 42, 4, -38 },
  { 13274, 38, 54, 42, 4, -53 },
  { 13531, 35, 39, 42, 3, -38 },
  { 13702, 38, 55, 42, 6, -55 },
  { 13964, 38, 53, 42, 1, -38 },
  { 14216, 35, 53, 42, 2, -53 },
  { 14448, 32, 52, 42, 3, -52 },
  { 14656, 33, 67, 42, 1, -52 },
  { 14933, 39, 53, 42, 2, -53 },
  { 15192, 32, 53, 42, 3, -53 },
  { 15404, 41, 38, 42, -1, -38 },
  { 15599, 35, 38, 42, 2, -38 },
  { 15766, 35, 39, 42, 3, -38 },
  { 15937, 38, 52, 42, -1, -38 },
  { 16184, 35, 52, 42, 4, -38 },
  { 16412, 33, 38, 42, 7, -38 },
  { 16569, 35, 39, 42, 3, -38 },
  { 16740, 32, 48, 42, 6, -47 },
  { 16932, 35, 39, 42, 4, -38 },
  { 17103, 35, 38, 42, 6, -38 },
  { 17270, 39, 38, 42, 4, -38 },
  { 17456, 42, 38, 42, 0, -38 },
  { 17656, 43, 53, 42, 0, -38 },
  { 17941, 38, 38, 42, 1, -38 },
  { 18122, 28, 68, 42, 10, -55 },
  { 18360, 15, 64, 42, 13, -50 },
  { 18480, 28, 68, 42, 6, -55 },
  { 18718, 39, 15, 42, 1, -28 },
};

const GFXfont RobotoMono_MediumItalic71pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic71pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic71pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _ROBOTOMONO_MEDIUMITALIC71PT7B_H_
