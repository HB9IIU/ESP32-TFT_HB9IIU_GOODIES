#ifndef _ROBOTOMONO_MEDIUMITALIC42PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xC0, 0x78, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x01, 0xF0, 0x7E, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x7B, 0xC3, 0x9E, 0x1C,
  0xE1, 0xE7, 0x0F, 0x78, 0x7B, 0xC3, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x38,
  0x78, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x03, 0x87, 0x80, 0x03,
  0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0xE0, 0x00,
  0x70, 0x70, 0x00, 0x78, 0x78, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE0, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x07, 0x87, 0x80,
  0x03, 0x83, 0x80, 0x01, 0xC3, 0xC0, 0x01, 0xE1, 0xC0, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0x1C, 0x3C,
  0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x87,
  0x00, 0x03, 0x83, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x3F, 0x07, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x00, 0x7C, 0x7C,
  0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xCF, 0x80,
  0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xE0, 0x7E,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F,
  0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0x1E, 0x00, 0xE1, 0xE0, 0xEE,
  0x0E, 0x1C, 0xE1, 0xE3, 0xCE, 0x1E, 0x78, 0xE1, 0xC7, 0x0F, 0x3C, 0xE0,
  0xFF, 0x9E, 0x07, 0xF9, 0xC0, 0x1E, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x70, 0x03, 0x9F, 0xC0, 0x73,
  0xFE, 0x0F, 0x79, 0xE0, 0xE7, 0x0F, 0x1C, 0x70, 0xF3, 0xC7, 0x0F, 0x78,
  0xF0, 0xF1, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xC0,
  0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x3E, 0x7E, 0xF8, 0x79, 0xF9, 0xF0, 0xF3, 0xE1, 0xF3, 0xEF,
  0xC3, 0xF7, 0xDF, 0x03, 0xFF, 0x3E, 0x07, 0xFE, 0x7C, 0x07, 0xF8, 0xF8,
  0x07, 0xE1, 0xF8, 0x1F, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF,
  0xDF, 0x01, 0xFE, 0x1F, 0x00, 0x7B, 0xDE, 0xF7, 0xBB, 0xDE, 0xF7, 0x38,
  0x00, 0x18, 0x00, 0xE0, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0E, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x60, 0x70, 0x67, 0x87, 0x1E, 0xFE, 0x6F, 0xEF, 0xFF, 0xFF,
  0x0F, 0xFF, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0x38,
  0x01, 0xF3, 0xC0, 0x3E, 0x3C, 0x07, 0xC1, 0xE0, 0x78, 0x1F, 0x03, 0x80,
  0xC0, 0x10, 0x08, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x3E, 0x3E, 0x3C, 0x7C,
  0xF8, 0xF0, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0,
  0x3C, 0xFF, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F,
  0x83, 0xE1, 0xF0, 0x1E, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3C, 0x01, 0xF7,
  0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xC0, 0xFF, 0x78, 0x1F, 0xF7, 0x87, 0xFE,
  0xF8, 0xFB, 0xEF, 0x9F, 0x3E, 0xFF, 0xC3, 0xEF, 0xF8, 0x3E, 0xFE, 0x03,
  0xEF, 0xC0, 0x3C, 0xF8, 0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00,
  0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F,
  0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x1F, 0x83, 0xFE, 0x7F,
  0xF9, 0xFF, 0xE7, 0xFF, 0x9E, 0x3E, 0xC0, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xE0, 0xF8, 0x3E,
  0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xC1, 0xF8, 0x3E, 0x03,
  0xE1, 0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x8F, 0x80, 0x1E, 0x3E,
  0x00, 0xF8, 0xF8, 0x07, 0xE1, 0xF0, 0x3F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0xBE, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0xC0, 0x0F,
  0x9F, 0x00, 0x3C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0x80, 0x7C, 0x1E,
  0x01, 0xE0, 0xF8, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x1F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF1, 0x00,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFD, 0xFE, 0x03,
  0x81, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8,
  0xF8, 0x07, 0xC1, 0xF0, 0x3F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0xF0, 0x1E, 0x7F, 0x87, 0xFF, 0xF8,
  0xFF, 0xFF, 0x9F, 0xE3, 0xF3, 0xF0, 0x3F, 0x7C, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x3E, 0x7C, 0x07, 0xCF, 0x81, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x81,
  0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0,
  0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x1F, 0x07, 0xE0,
  0xFC, 0x7E, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x81, 0xF0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C,
  0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x07, 0xC7, 0xE0, 0x7E,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xF0, 0x7C, 0x7C,
  0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x01, 0xEF, 0x00, 0x3D, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xFB, 0xF0,
  0x7F, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xF3, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x7F,
  0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x87, 0xF1, 0xFC, 0x7F, 0x1F, 0xC3, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0xE3, 0xF8,
  0xFE, 0x3F, 0x87, 0xC0, 0x03, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x03, 0xF0,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x0F,
  0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8,
  0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00,
  0x00, 0x03, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0xFF, 0xFF, 0x7E, 0x0F,
  0xDF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0x83, 0xC0, 0x3C, 0x03, 0xC0,
  0xF0, 0x03, 0x83, 0xC1, 0x03, 0x8F, 0x0F, 0xC7, 0x1C, 0x7F, 0xCE, 0x78,
  0xF3, 0x9C, 0xE3, 0xC7, 0x39, 0xCF, 0x0C, 0x77, 0x1C, 0x38, 0xEE, 0x38,
  0x71, 0xDC, 0xE0, 0xE3, 0xF1, 0xC1, 0x87, 0xE3, 0x87, 0x0D, 0xC7, 0x0E,
  0x3B, 0x8E, 0x1C, 0x77, 0x1C, 0x78, 0xCE, 0x3D, 0xF3, 0x9C, 0x7F, 0xFE,
  0x38, 0x7D, 0xF8, 0x38, 0x20, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x10, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3E, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x0F,
  0x8F, 0x00, 0x1F, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE0,
  0xF8, 0x07, 0xC0, 0xF0, 0x1F, 0x01, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0xF9, 0xF8, 0x00, 0xF3, 0xE0, 0x01, 0xE7, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0xF8, 0x1F, 0xC1, 0xF0, 0x0F, 0xC3, 0xE0, 0x0F, 0x87,
  0xC0, 0x1F, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8,
  0x07, 0xE1, 0xF0, 0x3F, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x03, 0xE1, 0xE0, 0x07,
  0xC7, 0xC0, 0x07, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x7C, 0x01, 0xF0, 0xF0, 0x0F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xC1, 0xF8, 0x7E, 0x03, 0xE1, 0xF0,
  0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xCF, 0x80, 0x1E, 0x3E, 0x00, 0xF8,
  0x78, 0x07, 0xE1, 0xF0, 0x3F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0xF8, 0x7F, 0x01, 0xF0,
  0x3F, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x01, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0xF0, 0x01, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x1F,
  0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x78, 0x0F, 0xE1, 0xF0, 0x3F, 0x83, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xC1,
  0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7D,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xFE, 0xF8, 0x1F, 0xFB, 0xE0, 0xFF,
  0xCF, 0x83, 0xFF, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF,
  0x80, 0x1F, 0x3E, 0x00, 0x7C, 0x7C, 0x03, 0xE1, 0xF8, 0x1F, 0x83, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xC0,
  0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x3C, 0x0F,
  0x80, 0x1E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xE0, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x0F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F,
  0x03, 0xE0, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0x78, 0x01,
  0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x78, 0x1F, 0x00, 0x7C, 0x0F, 0x80,
  0x3E, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x3C, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xC0,
  0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0x78, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x0F,
  0x80, 0xFC, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x1F, 0x80,
  0x0F, 0x0F, 0xC0, 0x07, 0xC7, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0xFC,
  0x00, 0x1F, 0x7E, 0x00, 0x07, 0xBF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xF9, 0xF0, 0x00,
  0xFC, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xFC,
  0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x1E, 0x00, 0xF8, 0x0F, 0x80,
  0x3F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFE, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE,
  0x1F, 0xE1, 0xDE, 0x1F, 0xF3, 0xFE, 0x1E, 0xF3, 0xFE, 0x1E, 0xF7, 0xBC,
  0x1E, 0xF7, 0xBC, 0x1E, 0xFF, 0x3C, 0x3E, 0x7F, 0x7C, 0x3E, 0x7E, 0x7C,
  0x3C, 0x7E, 0x7C, 0x3C, 0x7C, 0x78, 0x3C, 0x7C, 0x78, 0x3C, 0x78, 0xF8,
  0x7C, 0x78, 0xF8, 0x7C, 0x70, 0xF8, 0x7C, 0x00, 0xF0, 0x78, 0x00, 0xF0,
  0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0xF8, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x0F,
  0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x7F, 0x01,
  0xF0, 0x3F, 0x80, 0xF8, 0x1F, 0xC0, 0x7C, 0x1F, 0xE0, 0x3C, 0x0F, 0xF8,
  0x3E, 0x07, 0xFC, 0x1F, 0x03, 0xFE, 0x0F, 0x81, 0xF7, 0x87, 0xC1, 0xF3,
  0xC3, 0xE0, 0xF9, 0xE1, 0xE0, 0x7C, 0xF1, 0xF0, 0x3E, 0x3C, 0xF8, 0x1F,
  0x1E, 0x7C, 0x0F, 0x8F, 0x3E, 0x0F, 0x83, 0xDF, 0x07, 0xC1, 0xFF, 0x03,
  0xE0, 0xFF, 0x81, 0xF0, 0x7F, 0xC0, 0xF8, 0x1F, 0xE0, 0x78, 0x0F, 0xF0,
  0x7C, 0x07, 0xF8, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E,
  0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xC1, 0xF0, 0x7E, 0x03, 0xE1,
  0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0x79, 0xF0, 0x01, 0xE7, 0xC0,
  0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7B, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0x3E,
  0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x3E, 0x00,
  0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0x80, 0xFE, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x1E,
  0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0xFC,
  0x1F, 0x07, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F,
  0xC1, 0xF0, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x1E, 0x3E, 0x00,
  0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x78, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0,
  0x03, 0xEF, 0x80, 0x0F, 0xBC, 0x00, 0x3C, 0xF8, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xFC, 0x07, 0xC1, 0xF0, 0x3F, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x18,
  0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0xF8, 0x1F, 0xC1, 0xF0, 0x0F, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F,
  0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE1,
  0xF0, 0x07, 0xC3, 0xE0, 0x3F, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x7C, 0x03, 0xC0,
  0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x03,
  0xE0, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x8F, 0x80, 0x1F,
  0x1F, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x7E, 0x0F, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F,
  0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x7C, 0x7C, 0x01, 0xF8, 0xFC, 0x07, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0xF8, 0x01,
  0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3,
  0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80,
  0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0x7C, 0x07,
  0xC0, 0xF8, 0x1F, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x3E, 0x1F,
  0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x7C, 0x03, 0xC1, 0xF0, 0x0F, 0x8F, 0x80,
  0x3E, 0x3E, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9E, 0x00, 0x1E,
  0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x3C, 0x1F, 0x78, 0x3C, 0x1E, 0x78, 0x7C, 0x3E,
  0x78, 0x7C, 0x3E, 0x78, 0x7C, 0x3C, 0x78, 0xFC, 0x3C, 0xF8, 0xFC, 0x7C,
  0xF8, 0xFC, 0x7C, 0xF8, 0xFC, 0x78, 0xF9, 0xFC, 0x78, 0xF9, 0xDC, 0xF8,
  0xF9, 0xDC, 0xF0, 0xFB, 0xDC, 0xF0, 0xF3, 0xDD, 0xF0, 0xF3, 0x9D, 0xF0,
  0xF7, 0x9D, 0xE0, 0xF7, 0x9D, 0xE0, 0xF7, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0,
  0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80,
  0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0xE0, 0x07,
  0xF0, 0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x01,
  0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x7D, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3F,
  0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC0, 0xF8,
  0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x7E,
  0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xF9,
  0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x07, 0xC0, 0x7C, 0x0F,
  0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x1E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C,
  0x7C, 0x00, 0xF9, 0xF8, 0x00, 0xF3, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80,
  0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xB8, 0x07,
  0xBC, 0x0F, 0xBC, 0x0F, 0x3C, 0x1E, 0x3C, 0x1E, 0x1C, 0x3C, 0x1E, 0x3C,
  0x1E, 0x78, 0x1E, 0xF8, 0x0E, 0xF0, 0x0F, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x3C, 0x3E, 0x1E, 0x0F, 0x00, 0x78,
  0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xF8, 0x7E, 0x7C, 0x07,
  0xCF, 0x80, 0xF8, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x0F, 0xFC, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFC, 0x07, 0xBE, 0x01, 0xF7, 0xC0, 0x3E,
  0xF0, 0x07, 0xDE, 0x01, 0xFB, 0xE0, 0x7F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8,
  0xFF, 0xEF, 0x07, 0xF1, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x70, 0x03, 0xCF, 0xF0, 0x1E, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xFB, 0xF8, 0x7E, 0x07, 0xC3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F,
  0x9F, 0x00, 0x7C, 0xF0, 0x03, 0xEF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0,
  0x0F, 0x9F, 0x00, 0xF8, 0xFC, 0x0F, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3,
  0xEF, 0xFC, 0x1F, 0x3F, 0xC0, 0x00, 0x38, 0x00, 0x1F, 0xF0, 0x07, 0xFF,
  0xC0, 0xFF, 0xFC, 0x1F, 0xCF, 0xE1, 0xF0, 0x3E, 0x3E, 0x01, 0xF7, 0xC0,
  0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x02, 0xF8, 0x03, 0xC7,
  0xC0, 0x7C, 0x7C, 0x0F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xC1, 0xF0, 0x0F, 0xF3, 0xE0, 0x3F,
  0xF7, 0xC0, 0xFF, 0xFF, 0x83, 0xF9, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0x87, 0xC0, 0x0F,
  0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0xF8, 0x03, 0xC1, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFD, 0xE0, 0x07, 0xF3, 0xC0, 0x00,
  0x38, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xCF, 0xE1,
  0xF0, 0x3E, 0x3E, 0x01, 0xF7, 0xE0, 0x1F, 0x7C, 0x00, 0xF7, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x18, 0x7E, 0x03, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x07, 0xF8, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xE7, 0xFC, 0x7E, 0x07, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E,
  0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xC0, 0x0F, 0x9F, 0x00, 0x3C, 0x7C, 0x01,
  0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF0,
  0xF8, 0x0F, 0x83, 0xE0, 0x7E, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x7F, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x80, 0x3F,
  0x07, 0x00, 0xF8, 0x3E, 0x0F, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0x80, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x30, 0x03, 0xC7, 0xF0, 0x3E, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xFB, 0xF8, 0x7E, 0x07, 0xE3, 0xE0, 0x1F, 0x1E,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F,
  0x9F, 0x00, 0x78, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0,
  0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xC7, 0x80, 0x3E, 0x7C, 0x01, 0xF3,
  0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x03, 0xF8, 0x78, 0x0F, 0xC1, 0xF0, 0x3F, 0x03, 0xE0, 0xFC, 0x07, 0xC3,
  0xF0, 0x0F, 0x8F, 0xC0, 0x1E, 0x7F, 0x00, 0x7D, 0xFC, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x3F, 0x9F, 0x00, 0x7E, 0x3F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7E, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0xFC, 0x1F, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x7C,
  0x01, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x18, 0x18, 0x0F, 0x3E, 0x7E,
  0x0F, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xDF, 0x0F, 0x0F, 0x0F,
  0x1F, 0x0F, 0x0F, 0x1F, 0x1F, 0x0F, 0x1E, 0x1F, 0x0F, 0x1E, 0x1F, 0x1F,
  0x1E, 0x1E, 0x1F, 0x3E, 0x1E, 0x1E, 0x3E, 0x1E, 0x1E, 0x3E, 0x3E, 0x1E,
  0x3C, 0x3E, 0x1E, 0x3C, 0x3E, 0x3E, 0x3C, 0x3C, 0x3E, 0x7C, 0x3C, 0x3E,
  0x7C, 0x3C, 0x3C, 0x7C, 0x7C, 0x3C, 0x78, 0x7C, 0x3C, 0x78, 0x78, 0x7C,
  0xF8, 0x78, 0x7C, 0x00, 0x06, 0x00, 0x78, 0xFE, 0x07, 0xDF, 0xF8, 0x3F,
  0xFF, 0xE1, 0xFF, 0x7F, 0x0F, 0xC0, 0xFC, 0x7C, 0x03, 0xE3, 0xC0, 0x1F,
  0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xE0,
  0x0F, 0x1E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3,
  0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01,
  0xF3, 0xE0, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x80,
  0xFF, 0xFC, 0x1F, 0xCF, 0xE3, 0xF0, 0x3E, 0x3E, 0x01, 0xF7, 0xC0, 0x1F,
  0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x7C, 0x7C, 0x0F, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0x9F, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x9F, 0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x1F,
  0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8,
  0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xE0, 0x07, 0x87, 0xC0, 0x1F, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xDF, 0xF8, 0x0F, 0x9F, 0xE0, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x1F, 0xE7, 0xC1, 0xFF, 0xBE, 0x1F, 0xFF, 0xF1, 0xFC,
  0xFF, 0x1F, 0x81, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3,
  0xE0, 0x0F, 0x1E, 0x00, 0x79, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01,
  0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x78, 0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x1F,
  0x03, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFB, 0xC0, 0x3F, 0x9E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0x90, 0xF1, 0xFE, 0x1F, 0x3F, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xFF, 0x04, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x87, 0xF3, 0xF0,
  0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xFC, 0x07, 0xC7, 0xE1, 0xFC,
  0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x3E,
  0x01, 0xF3, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xE7,
  0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF0, 0x07,
  0xCF, 0x00, 0x7C, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xFF, 0xFF, 0x87, 0xFF,
  0xF8, 0x7F, 0xEF, 0x81, 0xFC, 0xF0, 0xF8, 0x00, 0xFB, 0xC0, 0x0F, 0xDE,
  0x00, 0x7C, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x1E, 0x01, 0xE0, 0xF0, 0x1F,
  0x07, 0x80, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x78, 0x07, 0x87, 0xC0, 0x3C,
  0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x1E, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x38, 0x1F, 0xF0, 0x70, 0x7F, 0xE1, 0xF0,
  0xF3, 0xC3, 0xE1, 0xE7, 0x8F, 0xC7, 0xCF, 0x1F, 0x8F, 0x1E, 0x3F, 0x1E,
  0x3C, 0xEE, 0x7C, 0x71, 0xDC, 0xF0, 0xE3, 0xB9, 0xE1, 0xCE, 0x73, 0xC3,
  0x9C, 0xEF, 0x07, 0x79, 0xDE, 0x0E, 0xE3, 0xB8, 0x1D, 0xC7, 0xF0, 0x3F,
  0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF0, 0x7E, 0x03, 0xE0,
  0xF8, 0x07, 0x81, 0xF0, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3F, 0x83,
  0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x1F, 0x80,
  0x0F, 0x9F, 0x80, 0x07, 0xDF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xC7,
  0xC0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0x3E, 0x07, 0xE0,
  0x1F, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0xC7, 0xC0, 0x07, 0xE0,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE7, 0xC0, 0x00,
  0x79, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x7F,
  0x80, 0xFE, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03,
  0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x00, 0x02, 0x00, 0x03, 0xC0, 0x07,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x80, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x18, 0xFF,
  0xC0, 0x39, 0xFF, 0xE0, 0xF7, 0xCF, 0xE3, 0xEF, 0x07, 0xFF, 0xBC, 0x07,
  0xFF, 0x78, 0x07, 0xFC, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoMono_MediumItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 11, 30, 25, 7, -30 },
  { 43, 13, 11, 25, 8, -32 },
  { 61, 25, 30, 25, 0, -30 },
  { 155, 22, 39, 25, 2, -35 },
  { 263, 20, 30, 25, 3, -30 },
  { 338, 23, 30, 25, 1, -30 },
  { 425, 5, 11, 25, 11, -32 },
  { 432, 14, 42, 25, 7, -33 },
  { 506, 15, 43, 25, 3, -33 },
  { 587, 20, 21, 25, 4, -30 },
  { 640, 21, 22, 25, 2, -25 },
  { 698, 8, 13, 25, 4, -5 },
  { 711, 17, 4, 25, 5, -15 },
  { 720, 7, 6, 25, 7, -6 },
  { 726, 22, 33, 25, 2, -30 },
  { 817, 20, 30, 25, 3, -30 },
  { 892, 14, 30, 25, 5, -30 },
  { 945, 22, 30, 25, 0, -30 },
  { 1028, 22, 30, 25, 1, -30 },
  { 1111, 22, 30, 25, 0, -30 },
  { 1194, 22, 30, 25, 2, -30 },
  { 1277, 19, 30, 25, 2, -30 },
  { 1349, 22, 30, 25, 3, -30 },
  { 1432, 21, 30, 25, 2, -30 },
  { 1511, 19, 30, 25, 3, -30 },
  { 1583, 10, 23, 25, 8, -23 },
  { 1612, 12, 31, 25, 6, -23 },
  { 1659, 19, 20, 25, 3, -23 },
  { 1707, 21, 12, 25, 2, -19 },
  { 1739, 20, 20, 25, 2, -23 },
  { 1789, 18, 30, 25, 5, -30 },
  { 1857, 23, 30, 25, 1, -30 },
  { 1944, 23, 30, 25, -1, -30 },
  { 2031, 23, 30, 25, 1, -30 },
  { 2118, 22, 31, 25, 2, -30 },
  { 2204, 23, 30, 25, 1, -30 },
  { 2291, 24, 30, 25, 1, -30 },
  { 2381, 24, 30, 25, 1, -30 },
  { 2471, 22, 30, 25, 2, -30 },
  { 2554, 25, 30, 25, 0, -30 },
  { 2648, 22, 30, 25, 2, -30 },
  { 2731, 23, 30, 25, 1, -30 },
  { 2818, 26, 30, 25, 1, -30 },
  { 2916, 20, 30, 25, 1, -30 },
  { 2991, 24, 30, 25, 1, -30 },
  { 3081, 25, 30, 25, 0, -30 },
  { 3175, 22, 30, 25, 2, -30 },
  { 3258, 24, 30, 25, 1, -30 },
  { 3348, 22, 35, 25, 2, -30 },
  { 3445, 23, 30, 25, 1, -30 },
  { 3532, 23, 30, 25, 1, -30 },
  { 3619, 24, 30, 25, 3, -30 },
  { 3709, 23, 30, 25, 2, -30 },
  { 3796, 22, 30, 25, 4, -30 },
  { 3879, 24, 30, 25, 3, -30 },
  { 3969, 28, 30, 25, -1, -30 },
  { 4074, 23, 30, 25, 4, -30 },
  { 4161, 25, 30, 25, 0, -30 },
  { 4255, 15, 41, 25, 5, -34 },
  { 4332, 10, 33, 25, 8, -30 },
  { 4374, 15, 41, 25, 5, -34 },
  { 4451, 16, 16, 25, 5, -30 },
  { 4483, 19, 4, 25, 0, 0 },
  { 4493, 8, 5, 25, 11, -30 },
  { 4498, 19, 23, 25, 2, -23 },
  { 4553, 21, 32, 25, 1, -32 },
  { 4637, 20, 23, 25, 2, -23 },
  { 4695, 23, 32, 25, 2, -32 },
  { 4787, 20, 23, 25, 2, -23 },
  { 4845, 22, 32, 25, 4, -32 },
  { 4933, 22, 32, 25, 1, -23 },
  { 5021, 21, 32, 25, 1, -32 },
  { 5105, 19, 31, 25, 2, -31 },
  { 5179, 19, 40, 25, 1, -31 },
  { 5274, 23, 32, 25, 1, -32 },
  { 5366, 19, 32, 25, 2, -32 },
  { 5442, 24, 23, 25, -1, -23 },
  { 5511, 21, 23, 25, 1, -23 },
  { 5572, 20, 24, 25, 2, -23 },
  { 5632, 23, 32, 25, -1, -23 },
  { 5724, 21, 32, 25, 2, -23 },
  { 5808, 20, 23, 25, 4, -23 },
  { 5866, 20, 23, 25, 2, -23 },
  { 5924, 18, 28, 25, 4, -28 },
  { 5987, 20, 22, 25, 3, -22 },
  { 6042, 21, 22, 25, 3, -22 },
  { 6100, 23, 22, 25, 2, -22 },
  { 6164, 25, 22, 25, 0, -22 },
  { 6233, 26, 31, 25, 0, -22 },
  { 6334, 22, 22, 25, 1, -22 },
  { 6395, 16, 40, 25, 6, -33 },
  { 6475, 10, 38, 25, 7, -30 },
  { 6523, 16, 41, 25, 4, -33 },
  { 6605, 23, 9, 25, 0, -17 },
};

const GFXfont RobotoMono_MediumItalic42pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic42pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOMONO_MEDIUMITALIC42PT7B_H_
