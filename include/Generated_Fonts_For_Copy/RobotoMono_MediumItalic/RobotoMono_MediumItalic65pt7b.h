#ifndef _ROBOTOMONO_MEDIUMITALIC65PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF3,
  0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E,
  0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xCF, 0xC0, 0xFC, 0xF8, 0x0F,
  0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0x00, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x10, 0x3E, 0x07,
  0xE0, 0x38, 0xFC, 0x0F, 0xC0, 0xF9, 0xF8, 0x1F, 0x03, 0xF3, 0xE0, 0x3E,
  0x07, 0xC7, 0xC0, 0x7C, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x1F, 0x01, 0xF1,
  0xF8, 0x3F, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x8F, 0x80, 0x7F, 0xFE, 0x3F,
  0x00, 0x7F, 0xFC, 0x7C, 0x00, 0x7F, 0xF1, 0xF0, 0x00, 0x7F, 0x87, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x1C, 0x00, 0x03, 0xE1, 0xFF, 0x00,
  0x0F, 0x8F, 0xFF, 0x00, 0x1F, 0x3F, 0xFF, 0x00, 0x7C, 0xFF, 0xFE, 0x01,
  0xF1, 0xF8, 0x7E, 0x07, 0xE3, 0xE0, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0x3E,
  0x1F, 0x01, 0xF0, 0xFC, 0x3E, 0x03, 0xE1, 0xF0, 0x7C, 0x07, 0xC7, 0xC0,
  0xF8, 0x0F, 0x87, 0x01, 0xF0, 0x3F, 0x02, 0x03, 0xE0, 0x7E, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x07, 0xF8, 0x1F,
  0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x07, 0xF7, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0x07, 0xFF,
  0xF8, 0x07, 0xE0, 0xFF, 0xBF, 0xC0, 0x7E, 0x1F, 0xF3, 0xFC, 0x0F, 0xE1,
  0xFE, 0x1F, 0xE0, 0xFE, 0x3F, 0xC0, 0xFE, 0x0F, 0xC3, 0xFC, 0x0F, 0xF1,
  0xFC, 0x7F, 0x80, 0x7F, 0x9F, 0xC7, 0xF8, 0x07, 0xFB, 0xF8, 0x7F, 0x00,
  0x3F, 0xFF, 0x87, 0xF0, 0x03, 0xFF, 0xF0, 0x7F, 0x00, 0x1F, 0xFF, 0x07,
  0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0x80, 0x0F, 0xFC, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xBF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0xFF, 0x00,
  0x7F, 0xFF, 0x8F, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0x80, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C,
  0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x20, 0x03,
  0xE0, 0x04, 0xE0, 0x0F, 0x00, 0x73, 0xE0, 0x3C, 0x0F, 0xDF, 0xE1, 0xF0,
  0xFF, 0x7F, 0xE7, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xFC, 0x3E, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0x3F, 0x00, 0x38, 0x00, 0xF8, 0x00, 0x60, 0x03, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0x83,
  0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x01, 0xE0, 0x06, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x07, 0xF9, 0xFF, 0x3F, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xC7, 0xF0, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xE3, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFC,
  0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF1,
  0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x0F, 0xFC, 0xFE,
  0x00, 0x3F, 0xF9, 0xFC, 0x01, 0xFF, 0xF3, 0xF8, 0x07, 0xFF, 0xEF, 0xF0,
  0x3F, 0xFF, 0xDF, 0xE0, 0xFF, 0x7F, 0x3F, 0xC7, 0xFC, 0xFE, 0x7F, 0x1F,
  0xE1, 0xFC, 0xFE, 0xFF, 0x83, 0xF9, 0xFF, 0xFC, 0x0F, 0xF3, 0xFF, 0xF0,
  0x1F, 0xEF, 0xFF, 0x80, 0x3F, 0xDF, 0xFE, 0x00, 0x7F, 0x3F, 0xF0, 0x00,
  0xFE, 0x7F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE,
  0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xE7, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x07,
  0xC0, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xE3, 0xF9,
  0xF8, 0x1F, 0xCE, 0x00, 0xFE, 0x40, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE,
  0x3F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xFC, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xFD, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xFE,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x7F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0x80,
  0x1F, 0xE0, 0x00, 0x40, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x03,
  0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xF9,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x1C, 0x00, 0x1F, 0xC3, 0xFF, 0x00, 0x7F, 0x3F, 0xFE, 0x03,
  0xFD, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0x9F, 0xF8, 0x01, 0xFE, 0x7F, 0xC0,
  0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01,
  0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0x8F, 0xF8, 0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0,
  0x3F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xE3, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x1F,
  0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0xFE, 0x7F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x9F, 0xE0, 0x07, 0xFE, 0x7F,
  0xC0, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF7, 0xE0, 0x1F, 0xFF, 0xBF, 0x80, 0x3F, 0xF8,
  0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x7F, 0xC0, 0x3F, 0x80, 0x06, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xF8, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x02, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0xFF, 0xE3, 0xFE, 0x01,
  0xFF, 0x7F, 0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0x00, 0x3E, 0x07, 0xE0, 0x7F, 0x81, 0xE0, 0x7C, 0x0F, 0xFE, 0x1E,
  0x0F, 0x83, 0xFF, 0xF1, 0xE0, 0xF8, 0x7F, 0xFE, 0x1E, 0x1F, 0x07, 0xE1,
  0xE1, 0xE1, 0xF0, 0xFC, 0x1E, 0x1E, 0x3E, 0x1F, 0x83, 0xE1, 0xE3, 0xE1,
  0xF0, 0x3C, 0x1E, 0x3C, 0x1F, 0x03, 0xC1, 0xE7, 0xC3, 0xE0, 0x3C, 0x1E,
  0x7C, 0x3E, 0x07, 0xC1, 0xE7, 0x87, 0xC0, 0x78, 0x1E, 0xF8, 0x7C, 0x07,
  0x81, 0xEF, 0x87, 0xC0, 0x78, 0x3C, 0xF8, 0x7C, 0x0F, 0x83, 0xCF, 0x87,
  0xC0, 0xF8, 0x3C, 0xF0, 0x78, 0x0F, 0x03, 0xCF, 0x07, 0x80, 0xF0, 0x78,
  0xF0, 0xF8, 0x1F, 0x07, 0x8F, 0x07, 0x81, 0xF0, 0x78, 0xF0, 0x7C, 0x3F,
  0x0F, 0x0F, 0x07, 0xFF, 0xF1, 0xE0, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0x83,
  0xFE, 0xFF, 0xC0, 0xF8, 0x3F, 0xCF, 0xF8, 0x0F, 0x81, 0xF0, 0x3E, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0C, 0x00, 0x01, 0xFF,
  0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x7E, 0x00, 0x00, 0x0F, 0xE7, 0xE0,
  0x00, 0x01, 0xFE, 0x7E, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xE7, 0xF8,
  0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x01, 0xFF,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x07, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xE0, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x83, 0xF8,
  0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x03, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x01, 0xFF, 0xC0, 0x0F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x0F,
  0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0x80,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF8,
  0x1F, 0xC0, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F,
  0xF0, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x7F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x3F, 0xC0, 0x1F, 0xFF, 0xCF, 0xF0, 0x0F,
  0xFF, 0xF3, 0xFC, 0x03, 0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0x3F, 0x80,
  0x3F, 0xFF, 0x8F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x01,
  0xFF, 0x80, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFF, 0x80,
  0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xF8,
  0x01, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0xFF, 0xC0,
  0x00, 0x03, 0xFC, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0xFF, 0xC0, 0x00, 0x00,
  0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xCF, 0xF0, 0x00, 0x01, 0xFF, 0xC7,
  0xFC, 0x00, 0x00, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x1F, 0xBF, 0x00, 0xFD, 0xF0, 0x7F, 0xFC, 0x03, 0xF7, 0xC3, 0xFF,
  0xF0, 0x0F, 0xDF, 0x0F, 0xDF, 0xC0, 0x7F, 0x7E, 0x7F, 0x7E, 0x01, 0xFD,
  0xF9, 0xF9, 0xF8, 0x07, 0xF7, 0xE7, 0xEF, 0xE0, 0x1F, 0xCF, 0xBF, 0x3F,
  0x80, 0x7E, 0x3E, 0xFC, 0xFE, 0x03, 0xF8, 0xFF, 0xE3, 0xF8, 0x0F, 0xE3,
  0xFF, 0x8F, 0xC0, 0x3F, 0x8F, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0xF1, 0xFC,
  0x03, 0xF8, 0xFF, 0x87, 0xF0, 0x0F, 0xC3, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F,
  0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x7E, 0x0F, 0xE0,
  0x1F, 0xC1, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xC0, 0xFE, 0x01, 0xFC, 0x1F,
  0x03, 0xF8, 0x0F, 0xE0, 0x78, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00,
  0x7F, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x7F,
  0xF0, 0x01, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xFE, 0x00, 0x7F,
  0x80, 0xFF, 0xF0, 0x03, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0x3F, 0xFE,
  0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0x80,
  0xFF, 0xFE, 0x03, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0xC0, 0x3F, 0x9F, 0x80,
  0xFE, 0x03, 0xFC, 0xFC, 0x0F, 0xF0, 0x1F, 0xE7, 0xF0, 0x7F, 0x80, 0xFF,
  0x1F, 0x83, 0xFC, 0x07, 0xF8, 0xFC, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0xFE,
  0x01, 0xFC, 0x1F, 0x87, 0xF0, 0x1F, 0xE0, 0xFC, 0x7F, 0x80, 0xFF, 0x07,
  0xE3, 0xFC, 0x07, 0xF8, 0x3F, 0x9F, 0xE0, 0x3F, 0x80, 0xFC, 0xFE, 0x01,
  0xFC, 0x07, 0xE7, 0xF0, 0x0F, 0xE0, 0x3F, 0xBF, 0x80, 0xFF, 0x00, 0xFF,
  0xFC, 0x07, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xC0, 0x3F, 0xFF, 0x01, 0xFC,
  0x01, 0xFF, 0xF0, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xFC,
  0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xC0, 0x07, 0xFF, 0x01, 0xFE, 0x00,
  0x3F, 0xF8, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xFC, 0x03,
  0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0x80,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0xFE,
  0x7F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07,
  0xF9, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x00, 0xFF, 0x3F, 0x80, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x8F,
  0xE0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x03, 0xFE, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x00,
  0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0x80,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x0F, 0xF3, 0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x78,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x1F,
  0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xF3, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x1F,
  0xE0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01,
  0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0,
  0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x0F, 0xF8, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0xC3, 0xFC,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xE0, 0x1F, 0xCF,
  0xC0, 0x3F, 0x01, 0xFC, 0x7E, 0x03, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0xC0,
  0x7F, 0x1F, 0x80, 0xFE, 0x03, 0xF9, 0xFC, 0x0F, 0xF0, 0x3F, 0x8F, 0xE0,
  0x7F, 0x81, 0xFC, 0x7F, 0x03, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0xE0, 0x7E,
  0x1F, 0xC1, 0xFF, 0x07, 0xF0, 0xFE, 0x0F, 0xF8, 0x3F, 0x87, 0xF0, 0xFF,
  0xC1, 0xFC, 0x3F, 0x87, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0xF0, 0xFE, 0x0F,
  0xE3, 0xFF, 0x87, 0xF0, 0x7F, 0x1F, 0xFC, 0x3F, 0x03, 0xF8, 0xFB, 0xE3,
  0xF8, 0x1F, 0xC7, 0xDF, 0x1F, 0xC0, 0xFE, 0x7E, 0xF8, 0xFE, 0x07, 0xF3,
  0xE7, 0xC7, 0xE0, 0x3F, 0x1F, 0x3E, 0x7F, 0x01, 0xF9, 0xF9, 0xF3, 0xF8,
  0x0F, 0xCF, 0x8F, 0x9F, 0x80, 0x7E, 0x7C, 0x7C, 0xFC, 0x03, 0xF7, 0xE3,
  0xEF, 0xE0, 0x1F, 0xBF, 0x1F, 0x7F, 0x00, 0xFD, 0xF0, 0xFB, 0xF0, 0x07,
  0xFF, 0x87, 0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF,
  0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE7, 0xF8,
  0x00, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF7, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE1, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF7,
  0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00,
  0x3F, 0x8F, 0xF0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0x9F, 0xE0,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x20, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7E,
  0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x1F,
  0x87, 0xC0, 0x1F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFC, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x1F, 0x07, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE3,
  0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFE,
  0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x1F, 0xE3, 0xFE, 0x00, 0x3F, 0x8F, 0xF8,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xE7, 0xF8, 0x00,
  0xFF, 0x87, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x7F, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF7, 0xF0, 0x1F, 0xFF, 0x8F,
  0xE0, 0x0F, 0xFC, 0x1F, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF9, 0xFF,
  0xC0, 0x07, 0xF3, 0xFF, 0xF0, 0x07, 0xF7, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x8F, 0xFE, 0x0F, 0xFC, 0x03,
  0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0xFF, 0x1F, 0xC0, 0x00,
  0xFF, 0x1F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x01,
  0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03,
  0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0xFF, 0xFF,
  0xC0, 0xFE, 0x7F, 0xFF, 0x80, 0xFE, 0x3F, 0xFF, 0x00, 0xFE, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x01, 0xFE,
  0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xF9,
  0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0xBF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0xE3, 0xF8, 0x00,
  0xFF, 0xFE, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03,
  0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x1F,
  0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x0F, 0xF0,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFB, 0xF8, 0x00, 0x3F, 0xFE, 0x7F, 0x00, 0x03, 0xFF, 0x0F, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x01, 0xFE, 0x0F,
  0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xF9, 0xFE,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0x01, 0xFE, 0x00, 0x03,
  0x01, 0xFE, 0x00, 0x1F, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x18, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x10, 0x7F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE1, 0xFC, 0x00, 0xFF, 0xFE, 0x7F, 0x80, 0x3F,
  0xFF, 0xEF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xF0, 0xFF, 0xF0, 0x1F, 0xF0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x01, 0xFC, 0x0F, 0xF0, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x7F, 0x00, 0x01, 0xFF, 0x8F, 0xE0, 0x00, 0x07, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x04, 0x00, 0x03, 0xFC, 0x00,
  0xC0, 0x00, 0xFF, 0x80, 0x3C, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFF, 0xDF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x07, 0xF0,
  0xFF, 0xF0, 0x03, 0xF8, 0xFF, 0xFC, 0x01, 0xFC, 0xFF, 0xFF, 0x00, 0xFE,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xF0, 0x3F,
  0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x03, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F,
  0x0F, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F,
  0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03,
  0xF8, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x1C, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x08,
  0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x7F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xF8, 0x03, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x01,
  0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xE0, 0x03, 0xFC, 0x1F, 0xF8, 0x00, 0x7F,
  0x07, 0xFE, 0x00, 0x0F, 0xE1, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0xC0, 0x00,
  0x7F, 0x9F, 0xF0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x01, 0xFD, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xEF, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xE0,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x08, 0xFC, 0x0F, 0x80, 0x1F, 0x9F, 0xF1, 0xFF,
  0x00, 0xFD, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF3, 0xFF, 0x9F, 0xE0,
  0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x03, 0xF8,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0xFE,
  0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0x81, 0xF8, 0x1F,
  0xC1, 0xF8, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x0F, 0xC1,
  0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0,
  0x3F, 0x87, 0xF0, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x0F, 0xE1, 0xFC,
  0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x3F,
  0x87, 0xF0, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x87,
  0xF0, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x3F, 0xFC, 0x00, 0xFE, 0x3F, 0xFF, 0x00, 0x7F, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x1F,
  0xC0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0,
  0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x01, 0xFC,
  0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x03,
  0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x87,
  0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x03,
  0xF8, 0xFF, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xF9, 0xFE,
  0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x83, 0xFC,
  0x03, 0xFE, 0x07, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC7, 0xFF, 0x00, 0x03, 0xFB, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x7F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF8,
  0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xE0, 0x3F, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xF9, 0xFF, 0xFC, 0x00, 0x7F,
  0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x80, 0x1F, 0xFE, 0x1F, 0x80, 0x3F, 0xFF, 0x9F,
  0xC0, 0x3F, 0xFF, 0xEF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0x80,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x3F, 0x87, 0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F,
  0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0xDF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xE7, 0xF0, 0x00, 0xFF, 0xE3, 0xF8,
  0x00, 0x07, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xE0,
  0xFF, 0xF0, 0x3F, 0x8F, 0xFF, 0xC0, 0xFC, 0x7F, 0xFF, 0x07, 0xF3, 0xFF,
  0xF8, 0x1F, 0xDF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0xFF, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x03,
  0xF8, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xFC,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x0F, 0xFC,
  0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x10, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0,
  0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x7F, 0x80,
  0x03, 0xFC, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF,
  0xCF, 0xC0, 0x0F, 0xFF, 0x8F, 0xC0, 0x07, 0xFE, 0x1F, 0xC0, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x9F, 0xC0,
  0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x80,
  0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x01, 0xF0, 0x0F, 0xFF, 0x80, 0x7E, 0x01, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F,
  0x7E, 0x03, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x01, 0xFD, 0xF8, 0x0F, 0xE0,
  0x3F, 0x3F, 0x03, 0xFC, 0x0F, 0xE7, 0xE0, 0x7F, 0x81, 0xF8, 0xFC, 0x0F,
  0xF0, 0x3F, 0x1F, 0x83, 0xFE, 0x0F, 0xE3, 0xF0, 0x7F, 0xC1, 0xF8, 0x7E,
  0x1F, 0x78, 0x3F, 0x0F, 0xC3, 0xEF, 0x0F, 0xE1, 0xF8, 0x7D, 0xE1, 0xF8,
  0x3F, 0x1F, 0x3C, 0x3F, 0x07, 0xE3, 0xE7, 0x8F, 0xE0, 0xFC, 0x78, 0xF1,
  0xF8, 0x1F, 0x9F, 0x1E, 0x3F, 0x03, 0xF3, 0xE3, 0xCF, 0xC0, 0x7E, 0xF8,
  0x79, 0xF8, 0x0F, 0xDF, 0x0F, 0xBF, 0x01, 0xFB, 0xC1, 0xEF, 0xC0, 0x3F,
  0xF8, 0x3D, 0xF8, 0x07, 0xFF, 0x07, 0xBF, 0x00, 0xFF, 0xC0, 0xF7, 0xC0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00,
  0x7F, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xC3, 0xFE, 0x00, 0x00,
  0x7F, 0x9F, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0x80,
  0x7F, 0xC0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x00, 0x3F, 0x8F,
  0xF0, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00,
  0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x47,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0B, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0x8F, 0xFF,
  0xE0, 0x01, 0xF3, 0xFF, 0xFE, 0x00, 0x7E, 0xFF, 0xFF, 0xE0, 0x0F, 0xDF,
  0xEF, 0xFF, 0x07, 0xF7, 0xF0, 0x3F, 0xFF, 0xFE, 0xFC, 0x01, 0xFF, 0xFF,
  0x9F, 0x00, 0x1F, 0xFF, 0xF3, 0xE0, 0x01, 0xFF, 0xFC, 0x3C, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
};

const GFXglyph RobotoMono_MediumItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 15, 46, 38, 12, -46 },
  { 88, 20, 16, 38, 12, -49 },
  { 128, 38, 46, 38, 0, -46 },
  { 347, 34, 61, 38, 3, -54 },
  { 607, 31, 48, 38, 4, -47 },
  { 793, 36, 48, 38, 1, -47 },
  { 1009, 8, 17, 38, 17, -49 },
  { 1026, 22, 67, 38, 10, -52 },
  { 1211, 22, 67, 38, 5, -52 },
  { 1396, 30, 32, 38, 6, -46 },
  { 1516, 32, 33, 38, 3, -38 },
  { 1648, 13, 19, 38, 6, -7 },
  { 1679, 25, 6, 38, 8, -23 },
  { 1698, 11, 11, 38, 11, -10 },
  { 1714, 33, 50, 38, 3, -46 },
  { 1921, 31, 48, 38, 4, -47 },
  { 2107, 21, 46, 38, 8, -46 },
  { 2228, 34, 47, 38, 0, -47 },
  { 2428, 33, 48, 38, 2, -47 },
  { 2626, 33, 46, 38, 1, -46 },
  { 2816, 34, 47, 38, 3, -46 },
  { 3016, 30, 47, 38, 3, -46 },
  { 3193, 33, 46, 38, 5, -46 },
  { 3383, 33, 48, 38, 3, -47 },
  { 3581, 30, 47, 38, 5, -47 },
  { 3758, 16, 38, 38, 12, -37 },
  { 3834, 19, 49, 38, 9, -37 },
  { 3951, 30, 30, 38, 5, -35 },
  { 4064, 32, 20, 38, 3, -30 },
  { 4144, 30, 30, 38, 3, -35 },
  { 4257, 28, 47, 38, 8, -47 },
  { 4422, 36, 46, 38, 2, -46 },
  { 4629, 36, 46, 38, -2, -46 },
  { 4836, 36, 46, 38, 1, -46 },
  { 5043, 34, 48, 38, 3, -47 },
  { 5247, 35, 46, 38, 1, -46 },
  { 5449, 37, 46, 38, 2, -46 },
  { 5662, 37, 46, 38, 2, -46 },
  { 5875, 34, 48, 38, 3, -47 },
  { 6079, 37, 46, 38, 1, -46 },
  { 6292, 35, 46, 38, 2, -46 },
  { 6494, 36, 47, 38, 2, -46 },
  { 6706, 41, 46, 38, 1, -46 },
  { 6942, 30, 46, 38, 2, -46 },
  { 7115, 38, 46, 38, 1, -46 },
  { 7334, 37, 46, 38, 1, -46 },
  { 7547, 34, 48, 38, 3, -47 },
  { 7751, 36, 46, 38, 2, -46 },
  { 7958, 34, 55, 38, 3, -47 },
  { 8192, 36, 46, 38, 1, -46 },
  { 8399, 36, 48, 38, 2, -47 },
  { 8615, 36, 46, 38, 5, -46 },
  { 8822, 35, 47, 38, 3, -46 },
  { 9028, 35, 46, 38, 6, -46 },
  { 9230, 37, 46, 38, 4, -46 },
  { 9443, 43, 46, 38, -2, -46 },
  { 9691, 36, 46, 38, 6, -46 },
  { 9898, 38, 46, 38, 0, -46 },
  { 10117, 23, 63, 38, 8, -53 },
  { 10299, 16, 50, 38, 12, -46 },
  { 10399, 23, 63, 38, 8, -53 },
  { 10581, 25, 24, 38, 7, -46 },
  { 10656, 30, 6, 38, 0, 0 },
  { 10679, 12, 9, 38, 17, -47 },
  { 10693, 31, 36, 38, 2, -35 },
  { 10833, 32, 50, 38, 2, -49 },
  { 11033, 31, 36, 38, 3, -35 },
  { 11173, 35, 50, 38, 3, -49 },
  { 11392, 31, 36, 38, 3, -35 },
  { 11532, 34, 50, 38, 6, -50 },
  { 11745, 35, 49, 38, 1, -35 },
  { 11960, 33, 49, 38, 1, -49 },
  { 12163, 29, 48, 38, 3, -48 },
  { 12337, 30, 62, 38, 1, -48 },
  { 12570, 35, 49, 38, 2, -49 },
  { 12785, 29, 49, 38, 3, -49 },
  { 12963, 37, 35, 38, -1, -35 },
  { 13125, 33, 35, 38, 1, -35 },
  { 13270, 31, 36, 38, 3, -35 },
  { 13410, 35, 48, 38, -1, -35 },
  { 13620, 33, 48, 38, 3, -35 },
  { 13818, 30, 35, 38, 6, -35 },
  { 13950, 31, 36, 38, 3, -35 },
  { 14090, 29, 44, 38, 6, -43 },
  { 14250, 32, 35, 38, 4, -34 },
  { 14390, 33, 34, 38, 5, -34 },
  { 14531, 35, 34, 38, 4, -34 },
  { 14680, 38, 34, 38, 0, -34 },
  { 14842, 40, 48, 38, 0, -34 },
  { 15082, 35, 34, 38, 1, -34 },
  { 15231, 26, 62, 38, 9, -51 },
  { 15433, 15, 59, 38, 11, -46 },
  { 15544, 25, 63, 38, 6, -51 },
  { 15741, 35, 14, 38, 1, -26 },
};

const GFXfont RobotoMono_MediumItalic65pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic65pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic65pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _ROBOTOMONO_MEDIUMITALIC65PT7B_H_
