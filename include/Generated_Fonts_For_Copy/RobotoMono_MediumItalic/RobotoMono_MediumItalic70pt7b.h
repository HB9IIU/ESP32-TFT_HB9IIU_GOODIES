#ifndef _ROBOTOMONO_MEDIUMITALIC70PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x02,
  0x00, 0x00, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03,
  0xF3, 0xF0, 0x1F, 0x9F, 0x81, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E,
  0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xF8, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E,
  0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x20, 0x7E, 0x07, 0xE0, 0x1E, 0x1F, 0x00,
  0xF8, 0x0F, 0xC7, 0xC0, 0x3E, 0x07, 0xE1, 0xF0, 0x1F, 0x81, 0xF0, 0xFC,
  0x07, 0xE0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x01,
  0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC7, 0xE0, 0x1F, 0xFF, 0xE1, 0xF0,
  0x03, 0xFF, 0xF8, 0xF8, 0x00, 0xFF, 0xFC, 0x7E, 0x00, 0x1F, 0xFE, 0x3F,
  0x00, 0x01, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7C, 0x3F, 0xF8,
  0x00, 0x3F, 0x1F, 0xFF, 0x00, 0x1F, 0x8F, 0xFF, 0xC0, 0x07, 0xC7, 0xFF,
  0xF8, 0x03, 0xF3, 0xF8, 0x7E, 0x01, 0xF8, 0xFC, 0x0F, 0xC0, 0xFC, 0x3E,
  0x03, 0xF0, 0x3E, 0x1F, 0x80, 0xFC, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC1,
  0xF8, 0x0F, 0xC7, 0xE0, 0x7E, 0x03, 0xF0, 0xF8, 0x1F, 0x80, 0xF8, 0x0C,
  0x07, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x0F, 0xEF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0x03, 0xFF, 0xFE, 0x01, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xF0,
  0xFF, 0xDF, 0xF0, 0x1F, 0xC7, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xF0, 0xFF,
  0x83, 0xF8, 0xFF, 0x81, 0xFF, 0x0F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x9F,
  0xF0, 0x0F, 0xF9, 0xFC, 0x7F, 0x80, 0x1F, 0xEF, 0xF1, 0xFE, 0x00, 0x7F,
  0xFF, 0x87, 0xF8, 0x00, 0xFF, 0xFE, 0x1F, 0xE0, 0x03, 0xFF, 0xF0, 0x7F,
  0x80, 0x07, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0xFF, 0x80, 0x0F,
  0xFF, 0x01, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x8F, 0xCF, 0xE7,
  0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x08, 0x00, 0xFC, 0x00, 0x06, 0x00, 0x7C, 0x00, 0xC7, 0xE0, 0x3E, 0x03,
  0xF3, 0xFC, 0x1F, 0x07, 0xFB, 0xFF, 0x8F, 0x8F, 0xFD, 0xFF, 0xF7, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xFE,
  0x0F, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFF,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFD, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0x00, 0x10, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0x06, 0x01, 0xFC, 0x3F, 0xE7, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xE7, 0xFE, 0x3F, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x1F, 0xF1, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0x80, 0x07, 0xFF, 0x3F, 0xC0,
  0x07, 0xFF, 0xCF, 0xF0, 0x03, 0xFF, 0xF3, 0xFC, 0x03, 0xFF, 0xF8, 0xFF,
  0x01, 0xFF, 0xFE, 0x3F, 0xC1, 0xFF, 0x7F, 0x8F, 0xF0, 0xFF, 0x9F, 0xE7,
  0xF8, 0xFF, 0x87, 0xF9, 0xFE, 0x7F, 0xC1, 0xFE, 0x7F, 0xFF, 0xC0, 0x7F,
  0x9F, 0xFF, 0xE0, 0x3F, 0xC7, 0xFF, 0xE0, 0x0F, 0xF1, 0xFF, 0xF0, 0x03,
  0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0x3F, 0xF8, 0x00, 0x3F, 0xCF, 0xFC, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xF1, 0xFE, 0xFE,
  0x07, 0xF3, 0xC0, 0x3F, 0xCC, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFC, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x03,
  0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x03, 0x80, 0x00, 0x07, 0xF3, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0xFF, 0xF0, 0x03, 0xFC, 0xFF, 0xFE, 0x01, 0xFD, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFC, 0x07, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0,
  0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0xFF, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFE,
  0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x07,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xF8,
  0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0x03,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE7, 0xF0, 0x03, 0xFF, 0x8F,
  0xE0, 0x00, 0x70, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x1F,
  0xFE, 0x7F, 0xE0, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x07,
  0xE0, 0x00, 0x01, 0xE0, 0x1F, 0x80, 0xFF, 0x03, 0xE0, 0x7E, 0x07, 0xFF,
  0x87, 0xC0, 0xF8, 0x1F, 0xFF, 0x8F, 0x83, 0xF0, 0x7F, 0xFF, 0x0F, 0x07,
  0xC1, 0xFF, 0xFC, 0x1E, 0x1F, 0x87, 0xF0, 0x78, 0x3C, 0x3E, 0x0F, 0xC0,
  0xF0, 0x78, 0xFC, 0x3F, 0x03, 0xE0, 0xF1, 0xF0, 0x7C, 0x07, 0xC1, 0xE3,
  0xE1, 0xF8, 0x0F, 0x03, 0xCF, 0xC3, 0xE0, 0x3E, 0x0F, 0x9F, 0x07, 0xC0,
  0x7C, 0x1F, 0x3E, 0x1F, 0x80, 0xF8, 0x3E, 0x7C, 0x3E, 0x01, 0xE0, 0x7D,
  0xF8, 0x7C, 0x07, 0xC0, 0xF3, 0xE0, 0xF8, 0x0F, 0x81, 0xE7, 0xC1, 0xF0,
  0x1F, 0x03, 0xCF, 0x87, 0xE0, 0x3C, 0x0F, 0x9F, 0x0F, 0xC0, 0xF8, 0x1E,
  0x3E, 0x1F, 0x01, 0xF0, 0x3C, 0x7C, 0x3F, 0x03, 0xE0, 0xF0, 0xF8, 0x7E,
  0x0F, 0xC1, 0xE1, 0xF0, 0x7C, 0x3F, 0x87, 0xC3, 0xE0, 0xFF, 0xFF, 0x1F,
  0x07, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0x83, 0xFF, 0x3F, 0xF8, 0x1F, 0x03,
  0xFC, 0x7F, 0xC0, 0x3F, 0x03, 0xF0, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x08, 0x00, 0x01, 0xFE, 0x00, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xFB,
  0xF8, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x7F, 0x00, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFE, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0x7F, 0x87, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0xFF, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00,
  0xFF, 0xC0, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0x80, 0x01, 0xFF,
  0x80, 0xFF, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xF9, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF0,
  0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF8,
  0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0x1F,
  0xE0, 0x0F, 0xFF, 0xF9, 0xFF, 0x00, 0x7F, 0xFF, 0xCF, 0xF0, 0x03, 0xFF,
  0xFE, 0x7F, 0x80, 0x1F, 0xFF, 0xE3, 0xFC, 0x01, 0xFF, 0xFF, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0,
  0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x00,
  0x01, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x00, 0x03, 0xFC,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC3, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xCF, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x9F, 0xF8, 0x00, 0x00, 0x07, 0xFB, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFB,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC1, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xEF, 0xE0, 0x1F, 0xDF, 0x87, 0xF7,
  0xF0, 0x0F, 0xEF, 0xC3, 0xFF, 0xF0, 0x07, 0xF7, 0xE3, 0xFB, 0xF8, 0x03,
  0xFB, 0xF1, 0xFD, 0xFC, 0x01, 0xFD, 0xF8, 0xFC, 0xFE, 0x01, 0xFE, 0x7C,
  0xFE, 0x7F, 0x00, 0xFE, 0x3E, 0x7E, 0x7F, 0x80, 0x7F, 0x1F, 0xFF, 0x3F,
  0x80, 0x3F, 0x8F, 0xFF, 0x1F, 0xC0, 0x1F, 0xC7, 0xFF, 0x8F, 0xE0, 0x0F,
  0xE3, 0xFF, 0x87, 0xF0, 0x0F, 0xF1, 0xFF, 0xC7, 0xF8, 0x07, 0xF8, 0xFF,
  0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0xE1, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0xFE,
  0x00, 0xFE, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x7F, 0x80, 0x7F,
  0x83, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0xFC,
  0x0F, 0xE0, 0x0F, 0xE0, 0x7C, 0x07, 0xF0, 0x07, 0xF0, 0x3E, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFE,
  0x01, 0xFF, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFE, 0x01, 0xFF,
  0xE0, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0x03,
  0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFC, 0x03,
  0xFF, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xF8, 0x07, 0xFD, 0xF8, 0x07, 0xF8,
  0x07, 0xF9, 0xFC, 0x07, 0xF8, 0x07, 0xF9, 0xFC, 0x07, 0xF8, 0x07, 0xF9,
  0xFC, 0x07, 0xF8, 0x07, 0xF8, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0xFE, 0x0F,
  0xF0, 0x0F, 0xF8, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0x0F,
  0xF0, 0x7E, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F,
  0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0x9F, 0xE0,
  0x1F, 0xE0, 0x3F, 0x9F, 0xE0, 0x1F, 0xE0, 0x3F, 0x9F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xBF, 0xE0, 0x1F, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xC0, 0x07,
  0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFF, 0x80,
  0x7F, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0x80,
  0x03, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01,
  0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF8,
  0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x0F,
  0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x07, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00,
  0x3F, 0x8F, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xF3, 0xFC,
  0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xEF,
  0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xFC,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x07, 0xFC,
  0x7F, 0x80, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0xC0,
  0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0xFC, 0x03,
  0xFD, 0xFC, 0x03, 0xF8, 0x07, 0xFB, 0xF8, 0x07, 0xF0, 0x0F, 0xE7, 0xF0,
  0x0F, 0xE0, 0x1F, 0xCF, 0xE0, 0x3F, 0xC0, 0x7F, 0x9F, 0xC0, 0x7F, 0x80,
  0xFF, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x7F, 0x03, 0xFE, 0x03, 0xF8, 0xFE,
  0x07, 0xFC, 0x0F, 0xF1, 0xFC, 0x0F, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0xF0,
  0x3F, 0x87, 0xF0, 0x7F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0xC1, 0xFE, 0x1F,
  0xC3, 0xFF, 0x83, 0xF8, 0x3F, 0x87, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xFE,
  0x1F, 0xE0, 0xFE, 0x1F, 0x7C, 0x3F, 0x81, 0xFC, 0x7E, 0xF8, 0x7F, 0x03,
  0xF8, 0xFD, 0xF0, 0xFE, 0x07, 0xE1, 0xFB, 0xE3, 0xFC, 0x1F, 0xC7, 0xE7,
  0xC7, 0xF0, 0x3F, 0x8F, 0xCF, 0x8F, 0xE0, 0x7F, 0x1F, 0x9F, 0x1F, 0xC0,
  0xFE, 0x7E, 0x3E, 0x7F, 0x01, 0xFC, 0xFC, 0x7C, 0xFE, 0x03, 0xF9, 0xF8,
  0xF9, 0xFC, 0x07, 0xF7, 0xE1, 0xF7, 0xF8, 0x0F, 0xEF, 0xC3, 0xEF, 0xE0,
  0x1F, 0xDF, 0x87, 0xDF, 0xC0, 0x3F, 0xBE, 0x0F, 0xBF, 0x80, 0x7F, 0xFC,
  0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFF,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x8F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFD,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x8F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x07,
  0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0xFF, 0x80, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x7F, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x03,
  0xF9, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87, 0xF0,
  0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0xFE, 0x03,
  0xF8, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x07, 0xE3, 0xF8,
  0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F,
  0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x7F, 0x87, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xC0, 0x0F, 0xF1, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0xFF,
  0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x7F, 0xE3,
  0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xFE, 0x7F,
  0x00, 0xFF, 0xFE, 0x3F, 0xC0, 0x3F, 0xFC, 0x1F, 0xE0, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x78, 0x00, 0x03,
  0xFC, 0x7F, 0xF0, 0x00, 0x7F, 0x9F, 0xFF, 0x80, 0x0F, 0xEF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFC,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F,
  0xC3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00,
  0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xEF, 0xFF, 0xFE, 0x03, 0xFC, 0xFF, 0xFF, 0x80, 0x7F, 0x0F, 0xFF, 0xE0,
  0x0F, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x78, 0x07, 0xF8, 0x00, 0x0F, 0xFE, 0x1F, 0xE0,
  0x00, 0xFF, 0xFC, 0x7F, 0x80, 0x0F, 0xFF, 0xFD, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xBF, 0x80, 0x00, 0xFF, 0xFC, 0xFE, 0x00, 0x01, 0xFF,
  0xC3, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0xC0, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFD,
  0xFF, 0x00, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xEF, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x30, 0x0F,
  0xF8, 0x00, 0x1E, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x02, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x0F, 0xF0, 0x00, 0xFF, 0xFE, 0x3F, 0x80, 0x0F, 0xFF, 0xFD, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xBF, 0xC0, 0x00, 0xFF, 0xFC, 0xFF, 0x00,
  0x01, 0xFF, 0xC3, 0xF8, 0x00, 0x00, 0x78, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x20, 0x00, 0x0F, 0xF0, 0x00,
  0x80, 0x00, 0x7F, 0xC0, 0x07, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x1C, 0x00, 0x03, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0x0F, 0xFF, 0xC0, 0x0F,
  0xE7, 0xFF, 0xFC, 0x03, 0xFD, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0xFF, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x80,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFC, 0x0F,
  0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F,
  0x80, 0x7F, 0xE0, 0x01, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xF8,
  0x00, 0x3F, 0xC1, 0xFF, 0xC0, 0x00, 0xFF, 0x0F, 0xFE, 0x00, 0x03, 0xFC,
  0x7F, 0xF0, 0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF7,
  0xFC, 0x00, 0x03, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F,
  0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3C, 0x01, 0xC0, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0x03, 0xF9, 0xFF, 0x8F,
  0xFC, 0x03, 0xFB, 0xFF, 0xDF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x3F,
  0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x7F,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xF0,
  0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x80,
  0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x0F,
  0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F,
  0x81, 0xFC, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0,
  0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x03,
  0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x3F,
  0x80, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFC,
  0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x7F, 0x07, 0xFF, 0x00, 0x0F, 0xE1, 0xFF, 0xF8, 0x01, 0xFC, 0xFF,
  0xFF, 0x80, 0x7F, 0xBF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xC1,
  0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xE0,
  0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x3F, 0xCF, 0xF8, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xF0,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8,
  0x7F, 0xF0, 0x00, 0x1F, 0xCF, 0xFF, 0xC0, 0x00, 0xFE, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xDF, 0xFF, 0xF8, 0x01, 0xFE, 0x7F, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0xF0,
  0x00, 0x7F, 0x80, 0x7C, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x07, 0xF0, 0x07, 0xFF, 0xF1, 0xFC, 0x07, 0xFF, 0xFE, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xF8, 0x1F, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0xC0, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x03,
  0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xDF, 0xC0, 0x07, 0xFF, 0xEF, 0xF0, 0x00, 0xFF, 0xE3, 0xFC, 0x00,
  0x07, 0xC0, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x03, 0xF8, 0x1F, 0xFF, 0x03, 0xF8, 0x7F, 0xFF, 0x03,
  0xF8, 0xFF, 0xFF, 0x07, 0xF9, 0xFF, 0xFE, 0x07, 0xFB, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0xFC, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F,
  0xFE, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFB, 0xF8, 0x03, 0xFF, 0xFE, 0x7F,
  0x00, 0x7F, 0xFF, 0x9F, 0xE0, 0x07, 0xFF, 0xE3, 0xFC, 0x00, 0x3F, 0xF0,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07,
  0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0x80,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0xFF, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x80,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x00,
  0xFE, 0xFE, 0x01, 0xFC, 0x07, 0xFB, 0xF8, 0x0F, 0xF0, 0x1F, 0xCF, 0xE0,
  0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0xFE, 0x07, 0xFC, 0x0F,
  0xE3, 0xF8, 0x1F, 0xF0, 0x3F, 0x8F, 0xE0, 0xFF, 0xC0, 0xFE, 0x3F, 0x83,
  0xFF, 0x07, 0xF0, 0xFE, 0x0F, 0xFC, 0x1F, 0xC3, 0xF8, 0x7D, 0xF0, 0x7E,
  0x0F, 0xE1, 0xF7, 0xC3, 0xF8, 0x3F, 0x8F, 0xDF, 0x0F, 0xE0, 0xFE, 0x3E,
  0x7C, 0x3F, 0x03, 0xF8, 0xF9, 0xF1, 0xFC, 0x0F, 0xE7, 0xE7, 0xC7, 0xF0,
  0x3F, 0x9F, 0x1F, 0x1F, 0x80, 0xFE, 0x7C, 0x7C, 0xFE, 0x03, 0xFB, 0xE1,
  0xF3, 0xF8, 0x0F, 0xEF, 0x87, 0xCF, 0xC0, 0x3F, 0xFE, 0x0F, 0x7F, 0x00,
  0xFF, 0xF0, 0x3D, 0xF8, 0x03, 0xF7, 0xC0, 0xF7, 0xE0, 0x0F, 0xFF, 0x03,
  0xDF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xF3, 0xFC, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00,
  0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x00, 0x07,
  0xF1, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xC7, 0xFF, 0xF8, 0x00, 0x3F,
  0x3F, 0xFF, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xF0, 0x07, 0xE7, 0xFF, 0xFF,
  0xE0, 0x3F, 0x9F, 0xC1, 0xFF, 0xE1, 0xFE, 0xFE, 0x01, 0xFF, 0xFF, 0xF3,
  0xF0, 0x03, 0xFF, 0xFF, 0xCF, 0xC0, 0x07, 0xFF, 0xFE, 0x3E, 0x00, 0x07,
  0xFF, 0xF0, 0x38, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00,
};

const GFXglyph RobotoMono_MediumItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 17, 51, 41, 12, -50 },
  { 110, 21, 18, 41, 13, -53 },
  { 158, 41, 50, 41, 0, -50 },
  { 415, 37, 65, 41, 3, -58 },
  { 716, 34, 52, 41, 4, -51 },
  { 937, 38, 52, 41, 1, -51 },
  { 1184, 9, 18, 41, 18, -53 },
  { 1205, 23, 72, 41, 11, -56 },
  { 1412, 23, 72, 41, 6, -56 },
  { 1619, 33, 35, 41, 6, -50 },
  { 1764, 35, 36, 41, 3, -41 },
  { 1922, 14, 21, 41, 7, -8 },
  { 1959, 28, 6, 41, 8, -25 },
  { 1980, 12, 12, 41, 12, -11 },
  { 1998, 36, 54, 41, 3, -50 },
  { 2241, 34, 52, 41, 4, -51 },
  { 2462, 22, 50, 41, 9, -50 },
  { 2600, 37, 51, 41, 0, -51 },
  { 2836, 36, 52, 41, 2, -51 },
  { 3070, 36, 50, 41, 1, -50 },
  { 3295, 36, 51, 41, 4, -50 },
  { 3525, 33, 51, 41, 3, -50 },
  { 3736, 36, 50, 41, 5, -50 },
  { 3961, 35, 52, 41, 3, -51 },
  { 4189, 31, 51, 41, 6, -51 },
  { 4387, 17, 41, 41, 13, -40 },
  { 4475, 20, 53, 41, 10, -40 },
  { 4608, 32, 32, 41, 5, -38 },
  { 4736, 34, 21, 41, 4, -32 },
  { 4826, 33, 33, 41, 3, -38 },
  { 4963, 30, 52, 41, 9, -51 },
  { 5158, 39, 50, 41, 2, -50 },
  { 5402, 38, 50, 41, -2, -50 },
  { 5640, 39, 50, 41, 1, -50 },
  { 5884, 37, 52, 41, 3, -51 },
  { 6125, 38, 50, 41, 1, -50 },
  { 6363, 40, 50, 41, 2, -50 },
  { 6613, 40, 50, 41, 2, -50 },
  { 6863, 37, 51, 41, 3, -50 },
  { 7099, 40, 50, 41, 1, -50 },
  { 7349, 37, 50, 41, 3, -50 },
  { 7581, 39, 51, 41, 2, -50 },
  { 7830, 44, 50, 41, 1, -50 },
  { 8105, 32, 50, 41, 2, -50 },
  { 8305, 41, 50, 41, 1, -50 },
  { 8562, 40, 50, 41, 1, -50 },
  { 8812, 36, 52, 41, 3, -51 },
  { 9046, 39, 50, 41, 2, -50 },
  { 9290, 37, 60, 41, 3, -51 },
  { 9568, 39, 50, 41, 1, -50 },
  { 9812, 39, 52, 41, 2, -51 },
  { 10066, 39, 50, 41, 5, -50 },
  { 10310, 38, 51, 41, 3, -50 },
  { 10553, 38, 50, 41, 6, -50 },
  { 10791, 39, 50, 41, 5, -50 },
  { 11035, 46, 50, 41, -2, -50 },
  { 11323, 38, 50, 41, 7, -50 },
  { 11561, 41, 50, 41, 0, -50 },
  { 11818, 25, 68, 41, 9, -57 },
  { 12031, 17, 54, 41, 13, -50 },
  { 12146, 25, 68, 41, 8, -57 },
  { 12359, 26, 27, 41, 8, -50 },
  { 12447, 32, 6, 41, 0, 0 },
  { 12471, 13, 10, 41, 19, -51 },
  { 12488, 33, 39, 41, 3, -38 },
  { 12649, 35, 54, 41, 2, -53 },
  { 12886, 33, 39, 41, 4, -38 },
  { 13047, 38, 54, 41, 3, -53 },
  { 13304, 34, 39, 41, 3, -38 },
  { 13470, 37, 54, 41, 6, -54 },
  { 13720, 38, 53, 41, 1, -38 },
  { 13972, 35, 53, 41, 2, -53 },
  { 14204, 31, 51, 41, 3, -51 },
  { 14402, 32, 66, 41, 1, -51 },
  { 14666, 38, 53, 41, 2, -53 },
  { 14918, 32, 53, 41, 3, -53 },
  { 15130, 40, 38, 41, -1, -38 },
  { 15320, 35, 38, 41, 2, -38 },
  { 15487, 34, 39, 41, 3, -38 },
  { 15653, 37, 52, 41, -1, -38 },
  { 15894, 34, 52, 41, 4, -38 },
  { 16115, 32, 38, 41, 7, -38 },
  { 16267, 34, 39, 41, 3, -38 },
  { 16433, 31, 47, 41, 6, -46 },
  { 16616, 35, 38, 41, 4, -37 },
  { 16783, 36, 37, 41, 5, -37 },
  { 16950, 38, 37, 41, 4, -37 },
  { 17126, 41, 37, 41, 0, -37 },
  { 17316, 43, 52, 41, 0, -37 },
  { 17596, 38, 37, 41, 1, -37 },
  { 17772, 27, 67, 41, 10, -55 },
  { 17999, 16, 64, 41, 12, -50 },
  { 18127, 28, 68, 41, 6, -55 },
  { 18365, 38, 15, 41, 1, -28 },
};

const GFXfont RobotoMono_MediumItalic70pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic70pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic70pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _ROBOTOMONO_MEDIUMITALIC70PT7B_H_
