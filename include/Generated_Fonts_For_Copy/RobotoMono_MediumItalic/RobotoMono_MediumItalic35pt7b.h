#ifndef _ROBOTOMONO_MEDIUMITALIC35PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x38, 0xEE, 0x1D, 0xC3, 0xB8, 0x67,
  0x1C, 0xE3, 0x98, 0x77, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x00, 0x0C,
  0x38, 0x00, 0xE1, 0x80, 0x07, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x86, 0x03,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x71, 0xC0, 0x07, 0x0E,
  0x00, 0x38, 0xE0, 0x01, 0x87, 0x00, 0x1C, 0x38, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFE, 0x03, 0x8E, 0x00, 0x18, 0x70, 0x01, 0xC3, 0x00,
  0x0E, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0C, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7E, 0x3E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x3C,
  0x70, 0x0F, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x3C, 0x03,
  0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F, 0x1E, 0x0F, 0x87, 0xFF, 0xC0,
  0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1C, 0xE0, 0x0C, 0x38, 0x4E, 0x1C,
  0x77, 0x0E, 0x73, 0x86, 0x71, 0xC7, 0x38, 0x7F, 0xB8, 0x3F, 0xB8, 0x07,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x30, 0x0E, 0x7E,
  0x0E, 0x7F, 0x07, 0x71, 0xC7, 0x38, 0xE7, 0x18, 0x73, 0x1C, 0x38, 0x8E,
  0x1C, 0x03, 0x9C, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3,
  0xC0, 0x78, 0xF0, 0x0F, 0x3C, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0xC3, 0xCF, 0xF8, 0x7B, 0xE7, 0x8E, 0xF8, 0xF3,
  0xDE, 0x0F, 0x7B, 0xC1, 0xFE, 0x78, 0x1F, 0x8F, 0x03, 0xF1, 0xF0, 0xFC,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xC7, 0x80, 0x7B, 0x9C, 0xE7, 0x73,
  0x9C, 0xE0, 0x00, 0x10, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07,
  0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x20, 0x04, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0,
  0x08, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x03, 0x06, 0x19, 0xE7, 0x3D, 0xFF, 0xFF, 0x3F, 0xFF, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xFC, 0x01, 0xEF, 0x01, 0xE3, 0x81, 0xE1, 0xE0, 0xF0, 0x70,
  0x10, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1E, 0x3C, 0x78, 0xF3,
  0xC7, 0x8F, 0x3C, 0x71, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3,
  0xE1, 0xE1, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x0F,
  0xBC, 0x0F, 0xDE, 0x1F, 0xEF, 0x1E, 0xF7, 0x9E, 0xF3, 0xFE, 0x7B, 0xFC,
  0x3D, 0xFC, 0x1E, 0xF8, 0x0F, 0x78, 0x07, 0xBC, 0x07, 0x9E, 0x03, 0xC7,
  0x03, 0xC3, 0xC3, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x00,
  0x30, 0x1F, 0x07, 0xE3, 0xFE, 0x7F, 0xE7, 0xDE, 0x61, 0xE8, 0x1C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3E, 0x1F, 0x1F, 0x03,
  0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7E, 0x3E, 0x1E, 0x07, 0xCF, 0x80, 0xF3,
  0xC0, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x03, 0xF0, 0x0F,
  0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E, 0x3E, 0x0F, 0x87,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x03,
  0xDE, 0x01, 0xE7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x1E, 0x3C, 0x0F, 0x0F,
  0x07, 0x83, 0xC1, 0xC0, 0xF0, 0xF0, 0x78, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFE, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xCF, 0x01, 0xF3, 0xC0,
  0x78, 0xF0, 0x3E, 0x3E, 0x1F, 0x07, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xC0, 0x1F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7B, 0xF8, 0x7F, 0xFC, 0x7F,
  0xFE, 0xFC, 0x3E, 0xF8, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0x78, 0x7C, 0x7F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x1E,
  0x78, 0x0F, 0x3C, 0x0F, 0x8F, 0x07, 0x87, 0xEF, 0x81, 0xFF, 0x80, 0xFF,
  0x81, 0xFF, 0xE1, 0xF0, 0xF8, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x07, 0xBC,
  0x07, 0x9E, 0x03, 0xCF, 0x03, 0xE7, 0xC3, 0xE1, 0xFF, 0xF0, 0x7F, 0xF0,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3E, 0x3E, 0x7C,
  0x1E, 0x78, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF8, 0x3E, 0x7C, 0xFE, 0x7F, 0xFE, 0x3F, 0xDC, 0x0F,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x0F, 0xE0, 0x7F,
  0xC0, 0x7F, 0x00, 0x7C, 0x00, 0x1E, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF8, 0xF8,
  0x07, 0x81, 0xF0, 0xFC, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x07, 0x03, 0xC0,
  0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x03,
  0x80, 0x07, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x00, 0xFC,
  0x00, 0x78, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xE0, 0x00, 0x70, 0x00, 0x08, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0xFF,
  0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x10, 0x00, 0x0E, 0x00, 0x07, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x03, 0xF0, 0x01,
  0xE0, 0x01, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0xF8, 0xFF, 0xFB, 0xF1, 0xF7,
  0x81, 0xEF, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xC0,
  0xE0, 0xE0, 0x0C, 0x38, 0x61, 0xC6, 0x3F, 0x99, 0xCF, 0xF3, 0x31, 0xCE,
  0x6E, 0x71, 0x8D, 0x8C, 0x31, 0xB3, 0x86, 0x3E, 0x71, 0xC7, 0xCC, 0x31,
  0xB1, 0x86, 0x36, 0x30, 0xC6, 0xC6, 0x39, 0x98, 0xFF, 0xF3, 0x9F, 0x7C,
  0x70, 0xC6, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x9C, 0x00, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xBC, 0x00, 0xF7,
  0x80, 0x1C, 0xF0, 0x07, 0x8E, 0x00, 0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x87,
  0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF,
  0x0F, 0x01, 0xE3, 0xC0, 0x1E, 0x78, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F,
  0xF8, 0x01, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE1, 0xE0, 0x3E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x03,
  0xC7, 0x80, 0xF8, 0xF0, 0x7E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFE,
  0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x1E,
  0x3C, 0x03, 0xCF, 0x00, 0xF9, 0xE0, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0,
  0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xC3,
  0xE1, 0xF0, 0x3C, 0x3C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0xF1, 0xE0, 0x1E,
  0x3C, 0x07, 0xC7, 0x80, 0xF0, 0x78, 0x7E, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x80, 0xF3,
  0xFC, 0x0F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x1E,
  0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE3,
  0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C,
  0x3C, 0x07, 0xC7, 0xC0, 0xF8, 0x78, 0x1F, 0x07, 0x87, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xE3, 0xE1, 0xF0, 0x3C,
  0x3C, 0x03, 0xCF, 0x80, 0x79, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x83, 0xFC, 0xF0, 0x7F, 0x9E, 0x1F, 0xF3,
  0xC3, 0xFE, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7,
  0xC0, 0x78, 0x7C, 0x3F, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xF8, 0x00,
  0x07, 0x80, 0x78, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0,
  0x0F, 0x07, 0x80, 0x78, 0x38, 0x03, 0xC3, 0xC0, 0x3C, 0x1E, 0x01, 0xE0,
  0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0E,
  0x00, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E,
  0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x81, 0xE0, 0xF8, 0x7C, 0x1F, 0xFF,
  0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0xFC, 0x3C, 0x07, 0xC0,
  0xF0, 0x3E, 0x07, 0x81, 0xF8, 0x1E, 0x0F, 0xC0, 0x78, 0x3E, 0x01, 0xE1,
  0xF0, 0x07, 0x8F, 0x80, 0x1E, 0x7C, 0x00, 0xF3, 0xE0, 0x03, 0xDF, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F,
  0x9E, 0x00, 0x7C, 0x7C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xE0, 0x1E, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xE0,
  0xF0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0,
  0x7E, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0xC3,
  0xD9, 0xFE, 0x1E, 0xEE, 0xF0, 0xF7, 0xF7, 0x07, 0xBF, 0x38, 0x39, 0xFB,
  0xC1, 0xCF, 0x9E, 0x1E, 0x7C, 0xF0, 0xF3, 0xC7, 0x07, 0x8E, 0x38, 0x3C,
  0x63, 0xC1, 0xE0, 0x1E, 0x0E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x38,
  0x3C, 0x01, 0xC1, 0xE0, 0x1E, 0x0E, 0x00, 0xF0, 0xF0, 0x07, 0x80, 0x07,
  0x80, 0x78, 0x7C, 0x07, 0x83, 0xE0, 0x3C, 0x1F, 0x81, 0xE0, 0xFC, 0x0F,
  0x07, 0xE0, 0x78, 0x3F, 0x07, 0xC3, 0xFC, 0x3C, 0x1E, 0xE1, 0xE0, 0xF7,
  0x0F, 0x07, 0xBC, 0x78, 0x3C, 0xE3, 0xC1, 0xE7, 0x3C, 0x1E, 0x39, 0xE0,
  0xF1, 0xEF, 0x07, 0x87, 0x78, 0x3C, 0x3B, 0xC1, 0xE1, 0xFE, 0x0F, 0x07,
  0xE0, 0xF0, 0x3F, 0x07, 0x81, 0xF8, 0x3C, 0x0F, 0xC1, 0xE0, 0x3E, 0x0F,
  0x01, 0xF0, 0xF8, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE,
  0x07, 0xC7, 0xC1, 0xF0, 0x3C, 0x3C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x0F,
  0x3C, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x0F, 0xBC, 0x01, 0xE7, 0x80, 0x3C,
  0xF0, 0x07, 0x9E, 0x00, 0xF7, 0xC0, 0x1E, 0xF0, 0x07, 0x8F, 0x00, 0xF1,
  0xE0, 0x1E, 0x3C, 0x07, 0x87, 0x81, 0xF0, 0x78, 0x7C, 0x0F, 0xFF, 0x00,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0xF0, 0xFC, 0x0F, 0x03, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0,
  0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x3E, 0x03, 0xE3, 0xC0, 0x7C, 0x3F,
  0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFC, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xE0, 0x1F, 0xFE, 0x07, 0xE7, 0xE1, 0xF0, 0x3C, 0x3C, 0x07, 0x8F, 0x00,
  0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00,
  0xF7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03,
  0xDE, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0x87, 0x81, 0xF0, 0x78, 0x7C,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0x80, 0x00, 0x60, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0F, 0x0F, 0xE1, 0xE0, 0x3E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F,
  0x1E, 0x01, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x1E, 0x07, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFC, 0x0F, 0xFE, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81,
  0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE1, 0xE0, 0x3E, 0x3C, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x07, 0xC3, 0xE1, 0xF0, 0x3E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x9E, 0x00, 0xF3,
  0xC0, 0x1E, 0x7C, 0x03, 0xC7, 0x80, 0xF8, 0xF8, 0x3F, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE3, 0x80, 0x38, 0xF0, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x3C,
  0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x79,
  0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3,
  0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xE0, 0xF0, 0xF8, 0x1F, 0xFE, 0x01,
  0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xF0, 0x03, 0xFF, 0x00, 0x7B, 0xE0, 0x1F,
  0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF8,
  0x78, 0x1E, 0x0F, 0x07, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3D, 0xE0, 0x03, 0xBC, 0x00,
  0x77, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x70, 0xF7, 0x87, 0x0F, 0x78, 0xF0,
  0xE7, 0x8F, 0x1E, 0x78, 0xF1, 0xE7, 0x1F, 0x1E, 0x71, 0xF1, 0xC7, 0x1F,
  0x3C, 0x73, 0xF3, 0xC7, 0x3F, 0x3C, 0x73, 0xF3, 0x87, 0x77, 0x78, 0x77,
  0x77, 0x87, 0x77, 0x70, 0x76, 0x77, 0x07, 0xE7, 0xF0, 0x7E, 0x7F, 0x07,
  0xC7, 0xE0, 0x7C, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0x87, 0xC0,
  0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF0, 0x78, 0x00, 0x0F, 0x80, 0x3E, 0x0F,
  0x00, 0xF8, 0x1F, 0x01, 0xE0, 0x1E, 0x07, 0xC0, 0x3C, 0x1F, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0xF8, 0x00, 0xF3, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xEF, 0x00, 0x07, 0x9E, 0x00,
  0x1E, 0x3E, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xC0, 0xF8, 0x0F,
  0x80, 0xF0, 0x3E, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x03, 0xEF, 0x00,
  0x7D, 0xE0, 0x1F, 0x3C, 0x03, 0xC3, 0xC0, 0xF8, 0x78, 0x1E, 0x0F, 0x07,
  0x80, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x23, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x80, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0x80, 0xE0,
  0xE0, 0xE0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x78, 0x78, 0x78, 0x38, 0x38,
  0x38, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E,
  0x0F, 0x0F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x80, 0x01,
  0xC0, 0x0F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x39, 0xC3, 0xCE,
  0x1C, 0x71, 0xC3, 0x9E, 0x1E, 0xE0, 0x7F, 0x03, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF8, 0x70, 0xF0, 0xF0, 0x01, 0xF0, 0x03, 0xFF, 0x03,
  0xFF, 0xC3, 0xE3, 0xE3, 0xE0, 0xF9, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x07, 0xFF, 0x0F, 0xFF, 0x8F, 0xC3, 0xCF, 0x81, 0xE7, 0x80, 0xF7, 0x80,
  0x7B, 0xC0, 0x79, 0xF0, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xE7, 0x80,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC7,
  0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x38, 0x07,
  0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xF7, 0x80, 0xF3, 0xC0, 0xFB, 0xF0,
  0xF9, 0xFF, 0xFC, 0xF7, 0xFC, 0x79, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xFC,
  0x1F, 0xFE, 0x3F, 0xFE, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1E,
  0xF0, 0x1E, 0x78, 0x7C, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x1E, 0x3C, 0x0F, 0xF7, 0x83, 0xFF, 0xF0, 0xFF, 0xFE,
  0x3E, 0x0F, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78,
  0xF0, 0x0F, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1,
  0xE0, 0x7C, 0x3E, 0x1F, 0x83, 0xFF, 0xE0, 0x3F, 0xDC, 0x03, 0xF7, 0x80,
  0x01, 0xF0, 0x03, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xE0, 0xF3, 0xE0,
  0x79, 0xE0, 0x1D, 0xE0, 0x0E, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDE,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x30, 0xF8, 0x3C, 0x7F, 0xFE,
  0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0xFC, 0x20, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE1,
  0x01, 0xFE, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1E, 0x07, 0xCF, 0x01, 0xE3,
  0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0,
  0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xF1, 0xF0, 0xFC, 0x3F, 0xFF,
  0x07, 0xFB, 0x80, 0xFD, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x10, 0x0F, 0x0F,
  0x07, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x78, 0x1E, 0xFF, 0x0E, 0xFF, 0x8F, 0xFF, 0xE7, 0xC0, 0xF3, 0xC0,
  0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE,
  0x01, 0xEF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E,
  0xF0, 0x0F, 0x78, 0x0F, 0x00, 0x00, 0x10, 0x00, 0xF0, 0x01, 0xF0, 0x03,
  0xC0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x07, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFE, 0x00,
  0x10, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x01, 0x1E, 0x07, 0xC3,
  0xC1, 0xF0, 0x78, 0x7C, 0x1E, 0x3F, 0x03, 0xCF, 0xC0, 0x7B, 0xF0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFB, 0xC0, 0x3E,
  0x7C, 0x07, 0x87, 0x80, 0xF0, 0xF8, 0x3C, 0x0F, 0x87, 0x81, 0xF0, 0xF0,
  0x1F, 0x1E, 0x01, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x83, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C, 0xE3, 0x81, 0xDF, 0x7E, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x3C, 0x78, 0xE3, 0xC7, 0x8E, 0x38, 0x70, 0xE3, 0x87,
  0x1E, 0x78, 0xF1, 0xE7, 0x8F, 0x1E, 0x78, 0xF1, 0xE7, 0x8E, 0x1C, 0x70,
  0xE1, 0xC7, 0x1E, 0x3C, 0xF1, 0xE3, 0xCF, 0x1E, 0x3C, 0xF1, 0xE3, 0xCF,
  0x1C, 0x38, 0xE1, 0xC7, 0x80, 0x1E, 0x3C, 0x0E, 0x7F, 0x87, 0x7F, 0xC7,
  0xFF, 0xF3, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07,
  0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0xF3, 0xC0, 0x79, 0xE0,
  0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x07, 0x80, 0x01, 0xF0,
  0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x7C, 0x1F, 0x78, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1E, 0xF0, 0x3E, 0xF8, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0,
  0x0F, 0x3C, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x07, 0xC7,
  0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0xF9, 0xF8, 0x7C,
  0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0x9F, 0x81, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x07, 0xFB, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7, 0xC0, 0xF3, 0xC0, 0x79,
  0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x07, 0x9E, 0x03,
  0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF9, 0xF0, 0xFC, 0x7F, 0xFC, 0x1F,
  0xFE, 0x07, 0xEF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x8F, 0x3F, 0x87,
  0xBF, 0xC3, 0xFF, 0xE1, 0xFC, 0x10, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xE3, 0xE3, 0xC0, 0xF3, 0xC0,
  0x3D, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x0F, 0xC0, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xF0, 0x7C, 0x7F, 0xFC,
  0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x04, 0x1F, 0xF8, 0x0F,
  0xF8, 0x07, 0xF8, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xEF, 0x00, 0xF7,
  0x80, 0xFB, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x07,
  0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xF3, 0xE1, 0xF8, 0xFF,
  0xFC, 0x7F, 0xDC, 0x1F, 0xCE, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xFC, 0x03,
  0xDE, 0x01, 0xE7, 0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x38,
  0x78, 0x1C, 0x3C, 0x0E, 0x3C, 0x07, 0x9C, 0x03, 0xDE, 0x00, 0xEE, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0xE1, 0xFE, 0x3C, 0x3B, 0xC7, 0x87, 0x70, 0xF1, 0xEE, 0x3E, 0x39, 0xC7,
  0xC7, 0x38, 0xD9, 0xE7, 0x3B, 0x38, 0xE6, 0x67, 0x1D, 0xCD, 0xE3, 0xB9,
  0xB8, 0x76, 0x37, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3,
  0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x00, 0x1F, 0x01, 0xF8, 0x78, 0x1F, 0x01,
  0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0x3C, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7B, 0xE0, 0x07, 0x8F, 0x00, 0x7C, 0x3C, 0x07, 0xC1, 0xE0,
  0x7C, 0x07, 0x87, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0xF0, 0x07, 0x87,
  0x80, 0x7C, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x83, 0xE0, 0x3C, 0x1E,
  0x00, 0xE1, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x07,
  0x78, 0x00, 0x3B, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x00, 0x3C, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x3F, 0x00,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x70, 0x60, 0x60,
  0xE0, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x07, 0xF0, 0x3E, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x03, 0xFC, 0x07, 0x7F, 0xE0, 0xE7, 0xFF, 0x1E, 0x70, 0xFF,
  0xEE, 0x07, 0xFC, 0x00, 0x1F, 0x80,
};

const GFXglyph RobotoMono_MediumItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 9, 25, 21, 6, -25 },
  { 30, 11, 8, 21, 6, -26 },
  { 41, 21, 25, 21, 0, -25 },
  { 107, 18, 33, 21, 2, -29 },
  { 182, 17, 25, 21, 2, -25 },
  { 236, 19, 25, 21, 1, -25 },
  { 296, 5, 9, 21, 9, -26 },
  { 302, 12, 36, 21, 5, -28 },
  { 356, 12, 36, 21, 3, -28 },
  { 410, 17, 17, 21, 3, -25 },
  { 447, 17, 19, 21, 2, -21 },
  { 488, 7, 10, 21, 3, -4 },
  { 497, 14, 4, 21, 4, -13 },
  { 504, 6, 5, 21, 6, -5 },
  { 508, 18, 27, 21, 2, -25 },
  { 569, 17, 25, 21, 2, -25 },
  { 623, 12, 25, 21, 4, -25 },
  { 661, 18, 25, 21, 0, -25 },
  { 718, 18, 25, 21, 1, -25 },
  { 775, 18, 25, 21, 0, -25 },
  { 832, 18, 25, 21, 2, -25 },
  { 889, 16, 25, 21, 2, -25 },
  { 939, 17, 25, 21, 3, -25 },
  { 993, 17, 25, 21, 2, -25 },
  { 1047, 16, 25, 21, 3, -25 },
  { 1097, 8, 19, 21, 7, -19 },
  { 1116, 10, 25, 21, 5, -19 },
  { 1148, 17, 16, 21, 2, -19 },
  { 1182, 17, 11, 21, 2, -16 },
  { 1206, 17, 16, 21, 1, -19 },
  { 1240, 15, 25, 21, 4, -25 },
  { 1287, 19, 25, 21, 1, -25 },
  { 1347, 19, 25, 21, -1, -25 },
  { 1407, 19, 25, 21, 1, -25 },
  { 1467, 19, 25, 21, 1, -25 },
  { 1527, 20, 25, 21, 0, -25 },
  { 1590, 20, 25, 21, 1, -25 },
  { 1653, 20, 25, 21, 1, -25 },
  { 1716, 19, 25, 21, 1, -25 },
  { 1776, 21, 25, 21, 0, -25 },
  { 1842, 19, 25, 21, 1, -25 },
  { 1902, 19, 25, 21, 1, -25 },
  { 1962, 22, 25, 21, 1, -25 },
  { 2031, 16, 25, 21, 1, -25 },
  { 2081, 21, 25, 21, 0, -25 },
  { 2147, 21, 25, 21, 0, -25 },
  { 2213, 19, 25, 21, 1, -25 },
  { 2273, 20, 25, 21, 1, -25 },
  { 2336, 19, 29, 21, 1, -25 },
  { 2405, 19, 25, 21, 1, -25 },
  { 2465, 19, 25, 21, 1, -25 },
  { 2525, 19, 25, 21, 3, -25 },
  { 2585, 19, 25, 21, 2, -25 },
  { 2645, 19, 25, 21, 3, -25 },
  { 2705, 20, 25, 21, 2, -25 },
  { 2768, 23, 25, 21, -1, -25 },
  { 2840, 19, 25, 21, 3, -25 },
  { 2900, 21, 25, 21, 0, -25 },
  { 2966, 13, 35, 21, 4, -29 },
  { 3023, 8, 27, 21, 7, -25 },
  { 3050, 13, 35, 21, 4, -29 },
  { 3107, 13, 13, 21, 4, -25 },
  { 3129, 16, 3, 21, 0, 0 },
  { 3135, 7, 4, 21, 9, -25 },
  { 3139, 17, 19, 21, 1, -19 },
  { 3180, 17, 26, 21, 1, -26 },
  { 3236, 16, 19, 21, 2, -19 },
  { 3274, 19, 26, 21, 2, -26 },
  { 3336, 17, 19, 21, 2, -19 },
  { 3377, 19, 27, 21, 3, -27 },
  { 3442, 18, 26, 21, 1, -19 },
  { 3501, 17, 26, 21, 1, -26 },
  { 3557, 15, 26, 21, 2, -26 },
  { 3606, 16, 34, 21, 1, -26 },
  { 3674, 19, 26, 21, 1, -26 },
  { 3736, 15, 26, 21, 2, -26 },
  { 3785, 20, 19, 21, 0, -19 },
  { 3833, 17, 19, 21, 1, -19 },
  { 3874, 16, 19, 21, 2, -19 },
  { 3912, 18, 26, 21, 0, -19 },
  { 3971, 17, 26, 21, 2, -19 },
  { 4027, 17, 19, 21, 3, -19 },
  { 4068, 17, 19, 21, 2, -19 },
  { 4109, 16, 23, 21, 3, -23 },
  { 4155, 17, 18, 21, 2, -18 },
  { 4194, 17, 19, 21, 3, -19 },
  { 4235, 19, 18, 21, 2, -18 },
  { 4278, 21, 18, 21, 0, -18 },
  { 4326, 21, 26, 21, 0, -18 },
  { 4395, 18, 18, 21, 1, -18 },
  { 4436, 14, 33, 21, 5, -27 },
  { 4494, 8, 32, 21, 6, -25 },
  { 4526, 14, 33, 21, 3, -27 },
  { 4584, 20, 7, 21, 0, -14 },
};

const GFXfont RobotoMono_MediumItalic35pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic35pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOMONO_MEDIUMITALIC35PT7B_H_
