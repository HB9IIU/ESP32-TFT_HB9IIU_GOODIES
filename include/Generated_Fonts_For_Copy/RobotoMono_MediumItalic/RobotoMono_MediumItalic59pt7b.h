#ifndef _ROBOTOMONO_MEDIUMITALIC59PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFE,
  0x01, 0xF0, 0x00, 0x3E, 0x07, 0xCF, 0x81, 0xF7, 0xE0, 0xF9, 0xF0, 0x3E,
  0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3C, 0x78, 0x1F, 0x3E,
  0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF0, 0x1E, 0x3C, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x1F, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0xC1,
  0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0xF8, 0x1E, 0x01, 0x0F, 0x81, 0xF0, 0x3C, 0xF8, 0x1F,
  0x07, 0xCF, 0x81, 0xE0, 0xF8, 0xF8, 0x1E, 0x0F, 0x0F, 0x03, 0xE1, 0xF0,
  0xF8, 0x3E, 0x3E, 0x0F, 0x83, 0xE3, 0xC0, 0xFC, 0xFC, 0x7C, 0x07, 0xFF,
  0xCF, 0x80, 0x7F, 0xF9, 0xF0, 0x03, 0xFF, 0x1F, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0xF8, 0xFF, 0x80, 0x0F, 0x1F, 0xFC, 0x01, 0xF3, 0xFF, 0xE0,
  0x3E, 0x7F, 0x7E, 0x03, 0xC7, 0xC1, 0xF0, 0x7C, 0x78, 0x1F, 0x0F, 0x8F,
  0x81, 0xF0, 0xF0, 0xF8, 0x1F, 0x1F, 0x0F, 0x81, 0xF3, 0xE0, 0xF8, 0x1F,
  0x0C, 0x0F, 0x81, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xE0,
  0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x3F, 0x0F, 0xFF, 0xE0, 0x3F, 0x1F, 0xF7, 0xF0, 0x3F,
  0x1F, 0xE7, 0xF0, 0x3F, 0x3F, 0xC3, 0xF8, 0x7E, 0x7F, 0x83, 0xF8, 0x7E,
  0x7F, 0x01, 0xFC, 0xFE, 0x7F, 0x01, 0xFE, 0xFC, 0x7E, 0x00, 0xFF, 0xFC,
  0xFE, 0x00, 0x7F, 0xF8, 0xFE, 0x00, 0x7F, 0xF8, 0xFE, 0x00, 0x3F, 0xF0,
  0x7F, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE3, 0xF8, 0x03, 0xFF, 0x81, 0xFC, 0x00, 0x38, 0x00, 0x00,
  0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78,
  0xF8, 0xF8, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x30, 0x07, 0x80, 0x23, 0xC0,
  0x78, 0x1E, 0x3F, 0x07, 0x87, 0xF7, 0xFE, 0x79, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xBE,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xE1, 0xF8, 0x01,
  0xFC, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x00,
  0x7C, 0x00, 0xE0, 0x07, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x87, 0xE0,
  0x78, 0x02, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x0F, 0xE7, 0xFD, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFD, 0xFE, 0x3F, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFC, 0x1F,
  0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x1F,
  0xC0, 0x07, 0xF1, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00,
  0x3F, 0x3F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xF7,
  0xF0, 0x07, 0xFF, 0x7F, 0x01, 0xFF, 0xF7, 0xF0, 0x3F, 0xFE, 0x7F, 0x0F,
  0xF7, 0xE7, 0xE1, 0xFE, 0xFE, 0x7E, 0x3F, 0x8F, 0xEF, 0xEF, 0xF0, 0xFE,
  0xFF, 0xFC, 0x0F, 0xEF, 0xFF, 0x80, 0xFE, 0xFF, 0xE0, 0x0F, 0xCF, 0xFC,
  0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x1F,
  0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF8, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x3F,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0xE0, 0xFF,
  0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF9, 0xFC, 0x7C,
  0x1F, 0xC7, 0x01, 0xFC, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x7E, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F,
  0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x0F,
  0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7E, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0xFE, 0x07, 0xF0,
  0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF7, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xF8, 0x07, 0xF8,
  0x00, 0x20, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0xF8,
  0x01, 0xFC, 0x7F, 0xE0, 0x3F, 0xBF, 0xFE, 0x07, 0xEF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0x07, 0xFC, 0xFF, 0x80, 0x7F,
  0x9F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00,
  0x1F, 0xCF, 0xC0, 0x07, 0xF1, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x83,
  0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x3F,
  0x80, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00,
  0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0xFE,
  0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0xFF, 0x81, 0xFE, 0x01, 0xFC,
  0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFC, 0x7F,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF8, 0xFE, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x7F,
  0x8F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC1, 0xFF, 0x0F, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x9F,
  0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xF7, 0xF8, 0x0F, 0xF9, 0xFF, 0x0F, 0xFE,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC,
  0xFC, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF0, 0x7F, 0xC1, 0xFE, 0x03, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xFE, 0x07,
  0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0x3F, 0x00,
  0x30, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x03, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE3, 0xFE, 0x0F, 0xF9, 0xFF, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0xDF,
  0xC0, 0x07, 0xF7, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xC0, 0x03,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x78, 0x03, 0xF0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x0F, 0x01, 0xF0, 0x3F, 0x07, 0x81, 0xF0, 0x7F, 0xE1, 0xE0,
  0xF0, 0x7F, 0xF8, 0xF0, 0xF8, 0x7F, 0xFC, 0x78, 0x78, 0x7E, 0x1C, 0x3C,
  0x7C, 0x3E, 0x1E, 0x1E, 0x3C, 0x3E, 0x0F, 0x0F, 0x3E, 0x1E, 0x07, 0x87,
  0x9E, 0x1F, 0x03, 0x83, 0xCF, 0x0F, 0x03, 0xC1, 0xE7, 0x8F, 0x81, 0xE0,
  0xE7, 0xC7, 0xC0, 0xF0, 0x73, 0xC3, 0xC0, 0x78, 0x79, 0xE1, 0xE0, 0x78,
  0x3C, 0xF0, 0xF0, 0x3C, 0x1E, 0x78, 0x78, 0x1E, 0x0E, 0x3C, 0x3C, 0x0F,
  0x0F, 0x1E, 0x1E, 0x0F, 0x07, 0x9F, 0x0F, 0x0F, 0x87, 0x87, 0x87, 0xCF,
  0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC1, 0xE1, 0xFF, 0x7F, 0xC0, 0xF0, 0x7F,
  0x3F, 0xC0, 0x78, 0x1F, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x80, 0x00, 0xFE,
  0x03, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x01,
  0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01,
  0xFC, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xFC,
  0x07, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0x80, 0x1F, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x07, 0xFC,
  0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x7E, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x03, 0xFC,
  0x03, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE,
  0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0x83, 0xFE,
  0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8,
  0x7F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x7F, 0xFE, 0x7F, 0x00, 0xFF, 0xFC, 0xFE, 0x01, 0xFF, 0xF9, 0xFC, 0x07,
  0xFF, 0xF3, 0xF0, 0x0F, 0xFF, 0xC7, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00,
  0x7F, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xE0,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xF8,
  0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x0F, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFC, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x03, 0xF8,
  0x7F, 0xC0, 0x00, 0x1F, 0xC7, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0xC0, 0x00,
  0x07, 0xE7, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x03, 0xFB, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFD, 0xFC, 0x00, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x07, 0xFC,
  0x3F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xC0,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC,
  0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0x7E, 0xF0, 0x7D, 0xF8, 0x1F, 0xBE,
  0x3F, 0xFC, 0x07, 0xEF, 0x8F, 0xBF, 0x01, 0xFB, 0xE7, 0xEF, 0xC0, 0x7E,
  0xF9, 0xF3, 0xF0, 0x3F, 0x3E, 0xFC, 0xFC, 0x0F, 0xCF, 0xBE, 0x7F, 0x03,
  0xF3, 0xFF, 0x9F, 0x80, 0xFC, 0xFF, 0xC7, 0xE0, 0x3F, 0x1F, 0xF1, 0xF8,
  0x0F, 0xC7, 0xF8, 0x7E, 0x07, 0xF1, 0xFE, 0x3F, 0x81, 0xF8, 0x7F, 0x0F,
  0xC0, 0x7E, 0x1F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0xFC, 0x07, 0xE1, 0xF8,
  0x3F, 0x03, 0xF8, 0x7E, 0x1F, 0xC0, 0xFE, 0x0F, 0x07, 0xF0, 0x3F, 0x03,
  0xC1, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xF8, 0x0F,
  0xF8, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0x0F, 0xE0,
  0x3F, 0xE0, 0x03, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0x01, 0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0xF8, 0x07, 0xF0, 0x1F, 0xFE, 0x01,
  0xFC, 0x07, 0xFF, 0x80, 0x7F, 0x01, 0xFB, 0xE0, 0x1F, 0x80, 0xFE, 0xFC,
  0x0F, 0xE0, 0x3F, 0xBF, 0x03, 0xF8, 0x0F, 0xE7, 0xC0, 0xFE, 0x03, 0xF9,
  0xF8, 0x3F, 0x80, 0xFE, 0x7E, 0x0F, 0xE0, 0x3F, 0x1F, 0x83, 0xF0, 0x1F,
  0xC3, 0xE1, 0xFC, 0x07, 0xF0, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0x1F, 0xC0,
  0x7F, 0x07, 0xC7, 0xF0, 0x1F, 0xC1, 0xF9, 0xFC, 0x07, 0xE0, 0x7E, 0xFE,
  0x03, 0xF8, 0x1F, 0xBF, 0x80, 0xFE, 0x03, 0xEF, 0xE0, 0x3F, 0x80, 0xFF,
  0xF8, 0x0F, 0xE0, 0x3F, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0x01, 0xFC, 0x01,
  0xFF, 0xC0, 0x7F, 0x00, 0x7F, 0xF0, 0x1F, 0xC0, 0x1F, 0xFC, 0x07, 0xF0,
  0x03, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x7E, 0x00, 0x3F, 0xE0, 0x3F,
  0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xC3, 0xFE,
  0x01, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xF8,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x03, 0xF9, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x3F, 0x8F, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x3F, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFF, 0x81, 0xF8, 0x00, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xE3, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x7E,
  0x7F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x7E, 0x7F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0x9F, 0xC0,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x63, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x07,
  0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0xFF, 0x81, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03,
  0xF0, 0x0F, 0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80,
  0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80,
  0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80,
  0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0x80,
  0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xEF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0xBF, 0x01, 0xF8, 0x0F, 0xDF, 0x80,
  0xFC, 0x0F, 0xEF, 0xC0, 0xFE, 0x07, 0xE7, 0xE0, 0x7F, 0x03, 0xF3, 0xF0,
  0x3F, 0x81, 0xF9, 0xF8, 0x3F, 0xC1, 0xFC, 0xFC, 0x1F, 0xE0, 0xFC, 0x7E,
  0x0F, 0xF0, 0x7E, 0x3F, 0x07, 0xF8, 0x7F, 0x1F, 0x87, 0xFC, 0x3F, 0x0F,
  0xC3, 0xFE, 0x1F, 0x87, 0xE1, 0xFF, 0x0F, 0xC3, 0xF1, 0xFF, 0x8F, 0xE1,
  0xF8, 0xFF, 0xC7, 0xE0, 0xFC, 0x7F, 0xE3, 0xF0, 0x7E, 0x7D, 0xF1, 0xF8,
  0x3F, 0x3E, 0xF9, 0xF8, 0x1F, 0x1F, 0x7C, 0xFC, 0x0F, 0x9F, 0x3E, 0x7E,
  0x07, 0xCF, 0x9F, 0x3F, 0x03, 0xE7, 0xCF, 0xBF, 0x03, 0xF3, 0xC7, 0xDF,
  0x81, 0xFB, 0xE3, 0xEF, 0xC0, 0xFD, 0xF1, 0xFF, 0xC0, 0x7E, 0xF8, 0xFF,
  0xE0, 0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F,
  0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83,
  0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8,
  0x0F, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0x00, 0x7E, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0x9F,
  0xC0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0,
  0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80,
  0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7,
  0xC0, 0x0F, 0x8F, 0xC0, 0x3F, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF8, 0x3E,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF1,
  0xF8, 0x03, 0xE7, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFC, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xF0,
  0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xC0, 0xFE, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x00, 0xFC, 0x7F,
  0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01,
  0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0x87,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFD, 0xF8, 0x1F, 0xFF,
  0x9F, 0x80, 0x7F, 0xE1, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC7,
  0xFE, 0x00, 0x3F, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0x81, 0xFE, 0x00, 0xFE,
  0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03,
  0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x87, 0xFF, 0x07, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFB, 0xFF, 0xFC, 0x07, 0xE7,
  0xFF, 0xE0, 0x3F, 0x87, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xF8, 0x1F, 0xE1, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07,
  0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x3F, 0x87, 0xF8, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0x83, 0xF8, 0x00, 0x7F,
  0xE3, 0xF8, 0x01, 0xFF, 0xFB, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80,
  0x07, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x3F, 0x00, 0x07, 0xFE,
  0x3F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xF8, 0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xC0,
  0x07, 0xE3, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0x3F,
  0x7F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x20, 0x7F, 0x00, 0x06, 0x07, 0xF8, 0x01,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x06, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x01, 0x00, 0x1F,
  0xFC, 0x7E, 0x00, 0x7F, 0xFE, 0x7E, 0x00, 0xFF, 0xFF, 0x7E, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xF8,
  0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0,
  0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80,
  0x03, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80,
  0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xEF, 0xE0, 0x00, 0xFF,
  0x8F, 0xC0, 0x00, 0x1C, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x10, 0x00, 0x3F, 0x80, 0x38, 0x00, 0x7F, 0x80, 0x7C, 0x00,
  0xFF, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x0F, 0xC3, 0xFF, 0x00, 0x7F, 0x3F, 0xFE, 0x01, 0xFD,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0,
  0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC,
  0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x1F,
  0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x1F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x08, 0x0F, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x08, 0x1F, 0x80,
  0x0F, 0xF8, 0x0F, 0xC0, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xF0,
  0x0F, 0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x01, 0xFC, 0x0F, 0xF8, 0x00, 0xFC,
  0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F,
  0x9F, 0xF0, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xE7, 0xF0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xF0, 0x07, 0xF0,
  0x01, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0x80, 0x03,
  0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x11, 0xE0, 0x3C, 0x00, 0xF9, 0xFE,
  0x3F, 0xC0, 0x7E, 0xFF, 0xDF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x1F, 0xF1, 0xFC, 0x1F,
  0x83, 0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x03, 0xF0,
  0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x07, 0xE1, 0xFC, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE0,
  0x7E, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x03, 0xF0, 0xFE, 0x0F, 0xC0, 0xFC, 0x3F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0,
  0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0x7E, 0x1F, 0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x07, 0xE1,
  0xF8, 0x1F, 0x83, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x0F, 0xC3, 0xFF, 0x00, 0x7F, 0x3F, 0xFE, 0x01, 0xF9, 0xFF, 0xFC,
  0x07, 0xEF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0x81,
  0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x03,
  0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE,
  0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F,
  0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x3F, 0x87, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x01,
  0xFE, 0x3F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x3F,
  0x87, 0xF0, 0x07, 0xF8, 0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x7F,
  0xE0, 0x01, 0xFD, 0xFF, 0xF0, 0x01, 0xFB, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01,
  0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xF0, 0x07,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xDF, 0xFF, 0x00, 0x3F, 0x87, 0xFE,
  0x00, 0x3F, 0x80, 0x70, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0x0F, 0xC0, 0x7F, 0xFE, 0x7E,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F,
  0xE0, 0x7F, 0xC3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFC, 0x00,
  0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7E,
  0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00,
  0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F,
  0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xFC, 0x1F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFC, 0xFC, 0x00, 0xFF, 0xCF, 0xE0, 0x00, 0x60, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x07, 0xFF,
  0x03, 0xF1, 0xFF, 0xF0, 0x7F, 0x3F, 0xFE, 0x07, 0xF7, 0xFF, 0xE0, 0x7E,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x04, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xF0, 0x0F, 0xF1, 0xFC, 0x00,
  0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x1F,
  0xCF, 0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x87, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x01, 0x7F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFC, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC1, 0x80,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8,
  0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0xFE, 0x3F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8,
  0x7E, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE,
  0x00, 0xFF, 0x07, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x7E, 0x03, 0xFF, 0xF3, 0xF0, 0x0F, 0xFF, 0x3F, 0x00, 0x3F, 0xE1, 0xF8,
  0x00, 0x18, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xBF,
  0x80, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x00,
  0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x3F,
  0x81, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0,
  0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF1, 0xF8,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xE0,
  0x3F, 0xFE, 0x01, 0xF0, 0x1F, 0xBF, 0x01, 0xF8, 0x0F, 0xDF, 0x80, 0xFC,
  0x0F, 0xC7, 0xC0, 0xFE, 0x07, 0xE3, 0xE0, 0x7F, 0x03, 0xF1, 0xF0, 0x3F,
  0x83, 0xF0, 0xF8, 0x3F, 0xC1, 0xF8, 0x7C, 0x1F, 0xE0, 0xFC, 0x3E, 0x0F,
  0xF0, 0xFC, 0x1F, 0x0F, 0xF8, 0x7E, 0x0F, 0x87, 0xBC, 0x3E, 0x07, 0xC7,
  0xDE, 0x3F, 0x03, 0xE3, 0xCF, 0x1F, 0x81, 0xF1, 0xE7, 0x8F, 0x80, 0xF9,
  0xF3, 0xCF, 0xC0, 0x7C, 0xF1, 0xE7, 0xE0, 0x3E, 0xF8, 0xF3, 0xE0, 0x1F,
  0x7C, 0x7B, 0xF0, 0x0F, 0xBC, 0x3D, 0xF8, 0x07, 0xFE, 0x1E, 0xF8, 0x03,
  0xFE, 0x0F, 0x7C, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x80,
  0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x00,
  0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x01, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF8,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x08,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x03, 0xE3, 0xFF, 0xF0, 0x01, 0xF1, 0xFF, 0xFC,
  0x01, 0xF9, 0xFF, 0xFF, 0x80, 0xF9, 0xFE, 0x7F, 0xE0, 0xFC, 0xFC, 0x0F,
  0xFF, 0xFC, 0x7C, 0x01, 0xFF, 0xFE, 0x3C, 0x00, 0x7F, 0xFE, 0x3E, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoMono_MediumItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 14, 42, 35, 11, -42 },
  { 75, 18, 14, 35, 11, -44 },
  { 107, 35, 42, 35, 0, -42 },
  { 291, 30, 55, 35, 3, -49 },
  { 498, 28, 44, 35, 4, -43 },
  { 652, 32, 44, 35, 1, -43 },
  { 828, 8, 15, 35, 15, -44 },
  { 843, 20, 60, 35, 9, -47 },
  { 993, 20, 60, 35, 5, -47 },
  { 1143, 28, 29, 35, 5, -42 },
  { 1245, 29, 31, 35, 3, -35 },
  { 1358, 11, 18, 35, 6, -7 },
  { 1383, 23, 5, 35, 7, -21 },
  { 1398, 10, 10, 35, 10, -9 },
  { 1411, 30, 46, 35, 3, -42 },
  { 1584, 28, 44, 35, 4, -43 },
  { 1738, 20, 42, 35, 7, -42 },
  { 1843, 31, 43, 35, 0, -43 },
  { 2010, 31, 44, 35, 1, -43 },
  { 2181, 30, 42, 35, 1, -42 },
  { 2339, 31, 43, 35, 3, -42 },
  { 2506, 27, 43, 35, 3, -42 },
  { 2652, 30, 42, 35, 4, -42 },
  { 2810, 29, 44, 35, 3, -43 },
  { 2970, 26, 43, 35, 5, -43 },
  { 3110, 14, 34, 35, 11, -33 },
  { 3170, 18, 44, 35, 8, -33 },
  { 3269, 27, 27, 35, 4, -32 },
  { 3361, 29, 18, 35, 3, -27 },
  { 3427, 28, 27, 35, 2, -32 },
  { 3522, 26, 43, 35, 7, -43 },
  { 3662, 33, 42, 35, 1, -42 },
  { 3836, 33, 42, 35, -2, -42 },
  { 4010, 33, 42, 35, 1, -42 },
  { 4184, 32, 44, 35, 2, -43 },
  { 4360, 32, 42, 35, 1, -42 },
  { 4528, 34, 42, 35, 1, -42 },
  { 4707, 33, 42, 35, 2, -42 },
  { 4881, 31, 44, 35, 3, -43 },
  { 5052, 34, 42, 35, 1, -42 },
  { 5231, 31, 42, 35, 2, -42 },
  { 5394, 32, 43, 35, 2, -42 },
  { 5566, 37, 42, 35, 1, -42 },
  { 5761, 27, 42, 35, 2, -42 },
  { 5903, 34, 42, 35, 1, -42 },
  { 6082, 34, 42, 35, 1, -42 },
  { 6261, 31, 44, 35, 2, -43 },
  { 6432, 33, 42, 35, 2, -42 },
  { 6606, 31, 50, 35, 2, -43 },
  { 6800, 33, 42, 35, 1, -42 },
  { 6974, 32, 44, 35, 2, -43 },
  { 7150, 32, 42, 35, 5, -42 },
  { 7318, 32, 43, 35, 3, -42 },
  { 7490, 32, 42, 35, 5, -42 },
  { 7658, 33, 42, 35, 4, -42 },
  { 7832, 38, 42, 35, -1, -42 },
  { 8032, 32, 42, 35, 6, -42 },
  { 8200, 35, 42, 35, 0, -42 },
  { 8384, 21, 57, 35, 7, -48 },
  { 8534, 14, 46, 35, 11, -42 },
  { 8615, 21, 57, 35, 7, -48 },
  { 8765, 23, 22, 35, 6, -42 },
  { 8829, 27, 5, 35, 0, 0 },
  { 8846, 11, 8, 35, 16, -43 },
  { 8857, 28, 33, 35, 2, -32 },
  { 8973, 30, 45, 35, 1, -44 },
  { 9142, 28, 33, 35, 3, -32 },
  { 9258, 32, 45, 35, 3, -44 },
  { 9438, 28, 33, 35, 3, -32 },
  { 9554, 32, 46, 35, 5, -46 },
  { 9738, 32, 44, 35, 1, -32 },
  { 9914, 30, 44, 35, 1, -44 },
  { 10079, 26, 43, 35, 3, -43 },
  { 10219, 27, 56, 35, 1, -43 },
  { 10408, 33, 44, 35, 1, -44 },
  { 10590, 26, 44, 35, 3, -44 },
  { 10733, 34, 32, 35, -1, -32 },
  { 10869, 30, 32, 35, 1, -32 },
  { 10989, 28, 33, 35, 3, -32 },
  { 11105, 32, 44, 35, -1, -32 },
  { 11281, 29, 44, 35, 3, -32 },
  { 11441, 28, 32, 35, 5, -32 },
  { 11553, 28, 33, 35, 3, -32 },
  { 11669, 27, 40, 35, 5, -39 },
  { 11804, 29, 32, 35, 4, -31 },
  { 11920, 29, 31, 35, 5, -31 },
  { 12033, 33, 31, 35, 3, -31 },
  { 12161, 35, 31, 35, 0, -31 },
  { 12297, 36, 44, 35, 0, -31 },
  { 12495, 32, 31, 35, 1, -31 },
  { 12619, 22, 56, 35, 9, -46 },
  { 12773, 13, 54, 35, 10, -42 },
  { 12861, 23, 57, 35, 5, -46 },
  { 13025, 33, 13, 35, 0, -24 },
};

const GFXfont RobotoMono_MediumItalic59pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic59pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic59pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _ROBOTOMONO_MEDIUMITALIC59PT7B_H_
