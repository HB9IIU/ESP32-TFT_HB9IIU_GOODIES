#ifndef _ROBOTOMONO_MEDIUMITALIC37PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x00, 0x00, 0x00, 0x00, 0x60, 0xF0,
  0xF8, 0xF0, 0xF0, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0xFF, 0x1D, 0xC3, 0xB8,
  0x77, 0x0E, 0xE3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x03, 0x87,
  0x00, 0x0E, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x1C, 0x03,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x1C, 0x38, 0x00, 0x70,
  0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x03, 0x87, 0x00, 0x0E,
  0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0x70,
  0x00, 0xE1, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0x87, 0xC3, 0xE0, 0x78, 0x78, 0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0x1E, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE7, 0x80,
  0x3C, 0xF0, 0x07, 0x9F, 0x01, 0xF3, 0xE0, 0x3C, 0x3E, 0x1F, 0x87, 0xFF,
  0xE0, 0x7F, 0xF8, 0x03, 0xFC, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xC7,
  0x00, 0x71, 0xC3, 0x38, 0x70, 0xEE, 0x1C, 0x73, 0x87, 0x38, 0xF1, 0xCE,
  0x1F, 0xE7, 0x07, 0xF3, 0x80, 0x79, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x9F, 0x01, 0xCF, 0xE0, 0xE7, 0xBC, 0x3B,
  0xC7, 0x1C, 0xE1, 0xCE, 0x38, 0x73, 0x8E, 0x1C, 0x03, 0x87, 0x00, 0xF3,
  0x80, 0x1F, 0xE0, 0x03, 0xE0, 0x00, 0x30, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0x87, 0x80, 0x78, 0x78, 0x0F, 0x07, 0x80, 0xF0,
  0x70, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0xF3, 0xFF, 0x0F, 0x7C, 0xF0, 0xF7,
  0xCF, 0x9E, 0xF8, 0x79, 0xEF, 0x07, 0xFC, 0xF0, 0x3F, 0xCF, 0x01, 0xF8,
  0xF8, 0x1F, 0x0F, 0xC7, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xE3,
  0xE0, 0x39, 0xCE, 0xF7, 0xB9, 0xCE, 0x77, 0x00, 0x00, 0x30, 0x0F, 0x01,
  0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x04, 0x00, 0x02, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0xF8, 0x0F, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x1C,
  0x38, 0x67, 0xCE, 0x7B, 0xFF, 0xFF, 0x3F, 0xFF, 0x80, 0xFE, 0x00, 0x3E,
  0x00, 0x1D, 0xC0, 0x0F, 0x70, 0x07, 0x9E, 0x03, 0xC3, 0x81, 0xF0, 0xF0,
  0x38, 0x18, 0x04, 0x04, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0x20, 0x7F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x23, 0xEF, 0xFF, 0xFB, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x80, 0x7F, 0xF0,
  0x3F, 0xFE, 0x0F, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C,
  0x03, 0xCF, 0x01, 0xF7, 0xC0, 0xFD, 0xE0, 0xFF, 0x78, 0x7F, 0xDE, 0x7D,
  0xF7, 0xBE, 0x79, 0xFE, 0x1E, 0xFF, 0x07, 0xBF, 0x01, 0xEF, 0x80, 0xFB,
  0xC0, 0x3C, 0xF0, 0x0F, 0x1E, 0x07, 0xC7, 0x81, 0xE1, 0xF0, 0xF8, 0x3F,
  0xFC, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x60, 0x3E, 0x1F, 0xE7, 0xFE,
  0xFF, 0xEF, 0xFE, 0xE3, 0xC8, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x3F, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xF8, 0x3E, 0x3E, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFE, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1,
  0xF8, 0x7C, 0x3E, 0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xCF, 0x00, 0x79, 0xE0, 0x1F, 0x3E, 0x07, 0xC3, 0xE1, 0xF8, 0x7F,
  0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1E, 0xF0,
  0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x1E, 0x03, 0xC3, 0xC0,
  0x78, 0x78, 0x1E, 0x0F, 0x07, 0x83, 0xE1, 0xE0, 0x78, 0x78, 0x0F, 0x0F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xBF, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0x83, 0xE3, 0xF0, 0x18, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xF0,
  0x3E, 0x1F, 0x0F, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0xFE, 0x1E, 0xFF, 0x8F, 0xFF,
  0xE7, 0xE1, 0xF7, 0xE0, 0x7B, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xDE, 0x01, 0xEF, 0x81, 0xF3, 0xC0, 0xF1, 0xF1, 0xF8,
  0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x87, 0xC7, 0xC0, 0xF1, 0xE0,
  0x3C, 0x78, 0x0F, 0x3E, 0x03, 0xC7, 0x81, 0xF1, 0xE0, 0x78, 0x7C, 0x7C,
  0x0F, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0xF8, 0x7C, 0x0F, 0x3E,
  0x03, 0xCF, 0x00, 0xFB, 0xC0, 0x3E, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x81,
  0xF3, 0xF1, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xE0,
  0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xF3, 0xE0, 0x79, 0xE0,
  0x3C, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xEF,
  0x80, 0xF7, 0xC0, 0xF9, 0xF0, 0xFC, 0xFF, 0xFE, 0x3F, 0xEE, 0x0F, 0xEF,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0x00, 0x00, 0x06, 0x0F, 0x87, 0xE3,
  0xF1, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x7C, 0x7E, 0x3F, 0x1F, 0x87, 0x80, 0x01, 0x80, 0x7C, 0x1F,
  0x83, 0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC1,
  0xFF, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x04, 0x00,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF,
  0xF0, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x3F, 0xC0, 0x7F,
  0xC1, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0xFC, 0x3E,
  0xF8, 0x1E, 0xF0, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xFC, 0x03, 0xE7, 0xE0, 0x78, 0x0E, 0x0E, 0x00, 0x71, 0xC1, 0x87, 0x1C,
  0x7F, 0x33, 0x8F, 0xF3, 0x39, 0xC6, 0x37, 0x3C, 0x63, 0x73, 0x86, 0x36,
  0x30, 0xE3, 0xE7, 0x0E, 0x3E, 0x70, 0xC7, 0xE7, 0x0C, 0x6E, 0x71, 0xC6,
  0xE7, 0x1C, 0xEE, 0x73, 0xCC, 0xE7, 0xFF, 0xCE, 0x3C, 0xF8, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x08, 0x03, 0xF7, 0x80, 0x1F, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0xBC, 0x00, 0xFB, 0xC0,
  0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x3C, 0x1C,
  0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x1E, 0x01, 0xE3, 0xE0, 0x1F, 0x3C, 0x01, 0xF7, 0xC0,
  0x0F, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0xF0, 0x7F, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF1,
  0xE0, 0x0F, 0x1E, 0x01, 0xF1, 0xE0, 0x3E, 0x3E, 0x07, 0xC3, 0xFF, 0xF8,
  0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x3C, 0x07, 0xC3, 0xC0, 0x3C, 0x7C, 0x03,
  0xE7, 0x80, 0x3E, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0x78, 0x07, 0xCF, 0x80,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x00,
  0x78, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF0, 0x7C, 0x3C,
  0x07, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xCF, 0x00,
  0x79, 0xE0, 0x1E, 0x3E, 0x07, 0xC3, 0xE1, 0xF0, 0x7F, 0xFC, 0x07, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x81,
  0xF1, 0xFC, 0x1F, 0x07, 0xC1, 0xE0, 0x3E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E,
  0x1E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x1F, 0x3C, 0x01,
  0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x03, 0xE7, 0x80,
  0x3C, 0x78, 0x07, 0xC7, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x83, 0xF0, 0xFD,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF,
  0xE1, 0xF8, 0x7C, 0x3C, 0x07, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x1F, 0xF7, 0x83, 0xFE, 0xF0, 0x7F, 0xDE, 0x00, 0xFB, 0xC0, 0x1E,
  0x78, 0x03, 0xCF, 0x00, 0x79, 0xF0, 0x0F, 0x3E, 0x03, 0xE3, 0xF1, 0xFC,
  0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x1E,
  0x01, 0xF0, 0xF8, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01,
  0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x78, 0x03, 0xC1,
  0xE0, 0x0F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xE0,
  0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x3E,
  0x0F, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E,
  0x00, 0xF0, 0x78, 0x07, 0xC3, 0xE0, 0x1E, 0x00, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x3C, 0x0F, 0x81, 0xF8,
  0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x80,
  0x7E, 0x1E, 0x01, 0xF0, 0x3C, 0x07, 0xC0, 0x78, 0x1F, 0x01, 0xF0, 0x7E,
  0x03, 0xE1, 0xF8, 0x07, 0x87, 0xE0, 0x0F, 0x1F, 0x80, 0x1E, 0x7E, 0x00,
  0x3C, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xEF, 0x80, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xBE, 0x00, 0x7E, 0x3C, 0x00, 0xF8,
  0x7C, 0x01, 0xE0, 0xF8, 0x03, 0xC0, 0xF8, 0x07, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0xC1, 0xE0, 0x0F,
  0xC0, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0xFC,
  0x1F, 0x03, 0xF0, 0x7E, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F,
  0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xB9, 0xFE, 0x0E, 0xE7, 0x78, 0x7B, 0xBD,
  0xC1, 0xEE, 0xEF, 0x07, 0xBF, 0xBC, 0x1E, 0x7C, 0xF0, 0x79, 0xF3, 0xC3,
  0xC7, 0x8F, 0x0F, 0x1E, 0x78, 0x3C, 0x71, 0xE0, 0xF1, 0xC7, 0x83, 0xC0,
  0x1E, 0x0F, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x3C,
  0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x7C,
  0x1F, 0x01, 0xE0, 0xFC, 0x07, 0x83, 0xF0, 0x1E, 0x0F, 0xE0, 0x78, 0x3F,
  0x81, 0xE0, 0xFE, 0x0F, 0x83, 0xF8, 0x3C, 0x1F, 0xF0, 0xF0, 0x7F, 0xC3,
  0xC1, 0xE7, 0x0F, 0x07, 0x9E, 0x7C, 0x1E, 0x79, 0xF0, 0x78, 0xE7, 0x83,
  0xE3, 0x9E, 0x0F, 0x8F, 0x78, 0x3C, 0x3D, 0xE0, 0xF0, 0x7F, 0x83, 0xC1,
  0xFE, 0x0F, 0x07, 0xF0, 0x7C, 0x1F, 0xC1, 0xE0, 0x3F, 0x07, 0x80, 0xFC,
  0x1E, 0x03, 0xF0, 0x78, 0x07, 0x83, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xF8, 0x7C, 0x3C, 0x07, 0x8F,
  0x00, 0xF1, 0xE0, 0x1F, 0x78, 0x03, 0xEF, 0x00, 0x7D, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0,
  0x03, 0xDE, 0x00, 0xFB, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF9, 0xE0,
  0x1E, 0x3E, 0x07, 0xC3, 0xF3, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1E, 0x07,
  0xE0, 0xF0, 0x1F, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xE3, 0xC0, 0x1F, 0x1E,
  0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x7C, 0x3C, 0x07, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xC3, 0xE0,
  0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F,
  0x3C, 0x00, 0xF7, 0xC0, 0x0F, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01,
  0xE7, 0x80, 0x1E, 0x78, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x03, 0xE7, 0x80,
  0x3C, 0x78, 0x07, 0xC7, 0x80, 0x78, 0x7C, 0x0F, 0x83, 0xF3, 0xF0, 0x3F,
  0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0x00, 0x00, 0x20, 0x0F, 0xFF, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0xF0, 0x7E, 0x0F, 0x01, 0xF1, 0xF0, 0x0F, 0x1E, 0x00,
  0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x1F, 0x3E, 0x01, 0xE3, 0xE0,
  0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7C,
  0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x78, 0x0F, 0x07,
  0x80, 0xF0, 0xF8, 0x0F, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0x83,
  0xF1, 0xF0, 0x1F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xCF,
  0x00, 0x3E, 0xF8, 0x03, 0xC7, 0x80, 0x3C, 0x7C, 0x07, 0xC7, 0xE1, 0xF8,
  0x3F, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xE3, 0xE0, 0x1E, 0x3C,
  0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x3E, 0x7C, 0x03, 0xC7,
  0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x7C,
  0xF8, 0x07, 0x8F, 0x80, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F,
  0x8F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x81, 0xE0, 0x7C, 0x7E, 0x07, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0xF8, 0x01, 0xF7, 0x80, 0x1E, 0x78,
  0x03, 0xE7, 0x80, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0x7C, 0x7C, 0x0F, 0x87,
  0xC0, 0xF8, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x3C, 0x1E, 0x03, 0xC3, 0xE0,
  0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0xF8,
  0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x78,
  0x78, 0x7B, 0xC3, 0xC3, 0xDE, 0x1E, 0x1E, 0xF1, 0xF1, 0xE7, 0x8F, 0x8F,
  0x3C, 0x7C, 0x79, 0xE7, 0xE3, 0xCF, 0x3F, 0x3C, 0x79, 0xF9, 0xE3, 0xCF,
  0xCF, 0x1E, 0xEE, 0x70, 0xF7, 0x77, 0x87, 0xBB, 0xBC, 0x3B, 0x9D, 0xE1,
  0xDC, 0xFE, 0x0E, 0xE7, 0xF0, 0x7E, 0x3F, 0x83, 0xF1, 0xF8, 0x1F, 0x8F,
  0xC0, 0xFC, 0x7E, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F,
  0x07, 0xC0, 0xF8, 0x3C, 0x07, 0xC1, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x07,
  0xC0, 0x3E, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0xF8, 0x01,
  0xE1, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF3, 0xE0, 0x00, 0xF7, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xEF, 0x80, 0x03, 0xC7, 0x80, 0x07, 0xC7, 0xC0, 0x0F, 0x83, 0xC0, 0x1F,
  0x03, 0xC0, 0x1F, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x7C, 0x01, 0xF0, 0xFC,
  0x01, 0xF0, 0xF0, 0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xC7, 0x80, 0xF8,
  0x78, 0x0F, 0x87, 0xC1, 0xF0, 0x3C, 0x1E, 0x03, 0xC3, 0xE0, 0x3C, 0x7C,
  0x03, 0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0x81, 0xFC,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xFF,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0xF0, 0x78, 0x3C, 0x0E, 0x07, 0x03,
  0xC1, 0xE0, 0xF0, 0x78, 0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38,
  0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x07, 0x81,
  0xC0, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x3F, 0x00, 0xFC,
  0x07, 0xF0, 0x1D, 0xC0, 0xF7, 0x83, 0x8E, 0x1E, 0x38, 0xF0, 0xE3, 0xC3,
  0xDE, 0x0F, 0x70, 0x1F, 0xC0, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0xF0, 0xE1, 0xE1, 0xE0, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x7E, 0x7E, 0x1E, 0x07, 0xCF, 0x81, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF9, 0xF8, 0x1E, 0x78, 0x07, 0x9E,
  0x03, 0xEF, 0x80, 0xF3, 0xE0, 0x7C, 0x7C, 0x3F, 0x1F, 0xFF, 0xC3, 0xFE,
  0xF0, 0x7F, 0x3C, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x3C, 0x07,
  0xBF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x07, 0xCF, 0x80, 0xF3, 0xC0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3D, 0xF0, 0x0F,
  0x78, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xF0, 0x3E, 0xFE, 0x3F, 0x3F,
  0xFF, 0x8F, 0x7F, 0xE3, 0xCF, 0xE0, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xE3, 0xE0, 0xFB, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x3C, 0xF0, 0x3E, 0x7C, 0x3E, 0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x03, 0xE3, 0xC0,
  0xFF, 0xBC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3E, 0x0F, 0xC7, 0xC0, 0x78,
  0x78, 0x07, 0x87, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x0F,
  0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x81,
  0xF0, 0x7C, 0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xF9, 0xE0, 0x01,
  0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x3E, 0x0F, 0x9F, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x0E, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x43, 0xE0, 0x18, 0x7E,
  0x1F, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x03, 0x80, 0x01,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x10, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x87,
  0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0xE0,
  0xFF, 0xBC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xF0, 0x7E, 0x7C, 0x07, 0xCF,
  0x00, 0xF1, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x1F, 0x3C,
  0x03, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xE0, 0x7C, 0x3E,
  0x3F, 0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xF7, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x10, 0x07, 0x87, 0x83, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x3E,
  0x07, 0x9F, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0x07, 0xCF, 0x80, 0xF3,
  0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0xC0, 0x3D, 0xF0,
  0x1F, 0x78, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0xF8, 0x07,
  0xBC, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xC0, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x01, 0xF1, 0xE0, 0x3E, 0x1E, 0x0F, 0xC1, 0xE1, 0xF8, 0x1E, 0x3F,
  0x03, 0xE7, 0xE0, 0x3C, 0xFC, 0x03, 0xDF, 0x80, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x7E, 0xF8, 0x07, 0xC7, 0xC0, 0x78,
  0x3C, 0x07, 0x83, 0xE0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x0F, 0x8F,
  0x00, 0xF8, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0xF1,
  0xE0, 0xEF, 0xDF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xC7, 0xC7, 0x9E,
  0x3C, 0x3C, 0xF1, 0xE1, 0xC7, 0x8F, 0x1E, 0x38, 0x78, 0xF3, 0xC3, 0xC7,
  0x9E, 0x1C, 0x3C, 0xF1, 0xE1, 0xE7, 0x8F, 0x0E, 0x3C, 0x78, 0xF1, 0xC3,
  0xC7, 0x9E, 0x1E, 0x3C, 0xF0, 0xE1, 0xE7, 0x8F, 0x0F, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x80, 0x1E, 0x3E, 0x07, 0xBF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF,
  0x3F, 0x07, 0xCF, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF,
  0x00, 0xF7, 0xC0, 0x3D, 0xF0, 0x1F, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80,
  0x79, 0xE0, 0x1E, 0xF8, 0x07, 0xBC, 0x03, 0xEF, 0x00, 0xF3, 0xC0, 0x3C,
  0x01, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3E, 0x0F, 0x9F,
  0x01, 0xE7, 0x80, 0x7B, 0xE0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00,
  0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x00, 0xF3, 0xE0, 0x7C,
  0x7C, 0x7E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x1E, 0x01,
  0xEF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x3E, 0x3E, 0x07, 0xC7,
  0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF8, 0x07, 0x9F,
  0x00, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0x8F, 0x01, 0xF1, 0xE0, 0x3E, 0x7F,
  0x1F, 0x8F, 0xFF, 0xE1, 0xEF, 0xF8, 0x3C, 0xFE, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE3, 0xC3, 0xFE, 0xF1, 0xFF, 0xFC, 0xFF,
  0xFF, 0x3E, 0x0F, 0xDF, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0xF8, 0x07,
  0xBC, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF,
  0x00, 0xF3, 0xE0, 0x7C, 0x7C, 0x7E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x0F, 0xC3, 0xCF, 0xE1,
  0xEF, 0xF8, 0x7F, 0xFE, 0x1F, 0xE1, 0x87, 0xE0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xFE,
  0x7E, 0x3E, 0x07, 0x8F, 0x01, 0xF3, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0x80,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xCF,
  0x00, 0xF3, 0xC0, 0x3C, 0xF8, 0x1F, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x3F,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x07, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x40, 0x7F, 0xE0,
  0x1F, 0xF0, 0x07, 0xF8, 0x3E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xF7, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x07,
  0x9E, 0x01, 0xE7, 0x80, 0xF9, 0xE0, 0x3E, 0xF8, 0x0F, 0x3E, 0x03, 0xCF,
  0x80, 0xF3, 0xE0, 0x7C, 0x7C, 0x7F, 0x1F, 0xFB, 0xC3, 0xFF, 0xE0, 0x7E,
  0x78, 0xF0, 0x03, 0xFE, 0x00, 0xFB, 0xC0, 0x1E, 0x3C, 0x03, 0xC7, 0x80,
  0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x3C, 0x07, 0x87,
  0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x01, 0xCF, 0x00, 0x39, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x70, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x1E, 0xF1,
  0xF1, 0xEF, 0x1F, 0x1E, 0xF3, 0xF1, 0xCF, 0x3F, 0x3C, 0xF3, 0xF3, 0x8F,
  0x77, 0x38, 0xF7, 0x77, 0x8F, 0x67, 0x70, 0xFE, 0x77, 0x0F, 0xE7, 0xF0,
  0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF8, 0x3C,
  0x0F, 0x03, 0x80, 0x1F, 0x00, 0x7C, 0x3C, 0x03, 0xE0, 0x78, 0x1F, 0x01,
  0xE0, 0xF8, 0x03, 0xC7, 0xC0, 0x0F, 0x1E, 0x00, 0x1E, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0x79, 0xF0, 0x03, 0xE3, 0xC0, 0x1F,
  0x0F, 0x80, 0xF8, 0x1E, 0x07, 0xC0, 0x7C, 0x3E, 0x00, 0xF8, 0x1E, 0x00,
  0x3E, 0x3C, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xF8, 0x07, 0xC0, 0xF0, 0x0F,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0xF8, 0x07, 0xC1, 0xE0, 0x07, 0x87, 0xC0,
  0x0F, 0x0F, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x78, 0x00, 0x3D, 0xE0, 0x00,
  0x7B, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x9F, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x7C, 0x01,
  0xF8, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0xC0, 0x7F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x02, 0x00, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x30,
  0x70, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x03, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0xE0, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xF8, 0x01, 0xC0, 0x02, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFE,
  0x01, 0xCF, 0xF8, 0x1C, 0xFF, 0xE0, 0xE7, 0x8F, 0xFF, 0x78, 0x3F, 0xF3,
  0x80, 0x7F, 0x00, 0x01, 0xF0,
};

const GFXglyph RobotoMono_MediumItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 8, 26, 22, 7, -26 },
  { 27, 11, 9, 22, 7, -28 },
  { 40, 22, 26, 22, 0, -26 },
  { 112, 19, 35, 22, 2, -31 },
  { 196, 18, 27, 22, 2, -27 },
  { 257, 20, 27, 22, 1, -27 },
  { 325, 5, 10, 22, 9, -28 },
  { 332, 12, 37, 22, 6, -29 },
  { 388, 12, 37, 22, 3, -29 },
  { 444, 18, 18, 22, 3, -26 },
  { 485, 18, 19, 22, 2, -22 },
  { 528, 8, 11, 22, 3, -4 },
  { 539, 15, 3, 22, 4, -13 },
  { 545, 6, 6, 22, 7, -6 },
  { 550, 19, 28, 22, 2, -26 },
  { 617, 18, 27, 22, 2, -27 },
  { 678, 12, 26, 22, 5, -26 },
  { 717, 19, 27, 22, 0, -27 },
  { 782, 19, 27, 22, 1, -27 },
  { 847, 19, 26, 22, 0, -26 },
  { 909, 19, 26, 22, 2, -26 },
  { 971, 17, 26, 22, 2, -26 },
  { 1027, 19, 26, 22, 3, -26 },
  { 1089, 18, 27, 22, 2, -27 },
  { 1150, 17, 27, 22, 3, -27 },
  { 1208, 9, 21, 22, 7, -21 },
  { 1232, 11, 28, 22, 5, -21 },
  { 1271, 17, 17, 22, 3, -20 },
  { 1308, 18, 11, 22, 2, -17 },
  { 1333, 17, 17, 22, 2, -20 },
  { 1370, 16, 27, 22, 5, -27 },
  { 1424, 20, 26, 22, 1, -26 },
  { 1489, 20, 26, 22, -1, -26 },
  { 1554, 20, 26, 22, 1, -26 },
  { 1619, 19, 27, 22, 2, -27 },
  { 1684, 20, 26, 22, 1, -26 },
  { 1749, 21, 26, 22, 1, -26 },
  { 1818, 21, 26, 22, 1, -26 },
  { 1887, 19, 27, 22, 2, -27 },
  { 1952, 22, 26, 22, 0, -26 },
  { 2024, 20, 26, 22, 1, -26 },
  { 2089, 21, 26, 22, 1, -26 },
  { 2158, 23, 26, 22, 1, -26 },
  { 2233, 17, 26, 22, 1, -26 },
  { 2289, 22, 26, 22, 0, -26 },
  { 2361, 22, 26, 22, 0, -26 },
  { 2433, 19, 27, 22, 2, -27 },
  { 2498, 21, 26, 22, 1, -26 },
  { 2567, 20, 32, 22, 1, -27 },
  { 2647, 20, 26, 22, 1, -26 },
  { 2712, 20, 27, 22, 1, -27 },
  { 2780, 20, 26, 22, 3, -26 },
  { 2845, 20, 26, 22, 2, -26 },
  { 2910, 20, 26, 22, 3, -26 },
  { 2975, 21, 26, 22, 2, -26 },
  { 3044, 24, 26, 22, -1, -26 },
  { 3122, 20, 26, 22, 4, -26 },
  { 3187, 22, 26, 22, 0, -26 },
  { 3259, 13, 36, 22, 5, -30 },
  { 3318, 9, 28, 22, 7, -26 },
  { 3350, 14, 36, 22, 4, -30 },
  { 3413, 14, 14, 22, 4, -26 },
  { 3438, 17, 3, 22, 0, 0 },
  { 3445, 7, 5, 22, 10, -27 },
  { 3450, 18, 20, 22, 1, -20 },
  { 3495, 18, 28, 22, 1, -28 },
  { 3558, 17, 20, 22, 2, -20 },
  { 3601, 20, 28, 22, 2, -28 },
  { 3671, 18, 20, 22, 2, -20 },
  { 3716, 20, 29, 22, 3, -29 },
  { 3789, 19, 28, 22, 1, -20 },
  { 3856, 18, 28, 22, 1, -28 },
  { 3919, 16, 27, 22, 2, -27 },
  { 3973, 17, 35, 22, 1, -27 },
  { 4048, 20, 28, 22, 1, -28 },
  { 4118, 16, 28, 22, 2, -28 },
  { 4174, 21, 20, 22, 0, -20 },
  { 4227, 18, 20, 22, 1, -20 },
  { 4272, 18, 20, 22, 2, -20 },
  { 4317, 19, 28, 22, 0, -20 },
  { 4384, 18, 28, 22, 2, -20 },
  { 4447, 18, 20, 22, 3, -20 },
  { 4492, 18, 20, 22, 2, -20 },
  { 4537, 17, 24, 22, 3, -24 },
  { 4588, 18, 20, 22, 2, -20 },
  { 4633, 19, 20, 22, 3, -20 },
  { 4681, 20, 20, 22, 2, -20 },
  { 4731, 22, 20, 22, 0, -20 },
  { 4786, 23, 28, 22, 0, -20 },
  { 4867, 19, 20, 22, 1, -20 },
  { 4915, 15, 36, 22, 5, -29 },
  { 4983, 8, 33, 22, 7, -26 },
  { 5016, 15, 36, 22, 3, -29 },
  { 5084, 21, 8, 22, 0, -15 },
};

const GFXfont RobotoMono_MediumItalic37pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic37pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOMONO_MEDIUMITALIC37PT7B_H_
