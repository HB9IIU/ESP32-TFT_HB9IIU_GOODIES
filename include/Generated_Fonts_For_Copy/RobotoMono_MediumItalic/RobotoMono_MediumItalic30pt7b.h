#ifndef _ROBOTOMONO_MEDIUMITALIC30PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C,
  0x38, 0x38, 0x38, 0x00, 0x00, 0x00, 0x60, 0x70, 0xF0, 0x70, 0x31, 0xDC,
  0x77, 0x19, 0xC6, 0x63, 0x98, 0xE6, 0x33, 0x8C, 0x00, 0x63, 0x80, 0x38,
  0xC0, 0x0C, 0x70, 0x03, 0x1C, 0x01, 0xC6, 0x00, 0x63, 0x81, 0xFF, 0xFC,
  0xFF, 0xFE, 0x03, 0x1C, 0x01, 0xC6, 0x00, 0x61, 0x80, 0x18, 0xE0, 0x0E,
  0x30, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x71, 0x80, 0x18, 0x60, 0x06, 0x38,
  0x03, 0x8C, 0x00, 0xC7, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x1E, 0x1E, 0x0F,
  0x1C, 0x0F, 0x1C, 0x0F, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1C, 0x80, 0x1C, 0x70, 0x1C,
  0x70, 0x1C, 0x78, 0x3C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x18, 0x01, 0xF8, 0x07, 0xF0, 0x39, 0xC4, 0xC3,
  0x1B, 0x1C, 0xCC, 0x77, 0x3B, 0x98, 0x7E, 0xC0, 0xE7, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x3B, 0xE0, 0xDF, 0xC6, 0x67, 0x3B, 0x8D, 0xCE, 0x32,
  0x38, 0xC0, 0xE7, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0xC0, 0x07, 0xF0, 0x0F,
  0xF8, 0x0F, 0x38, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1E, 0x70, 0x0F,
  0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x87, 0x7B, 0xC7, 0xF1,
  0xCE, 0xF1, 0xEE, 0xE0, 0xFC, 0xE0, 0xFC, 0xF0, 0x78, 0xFF, 0xF8, 0x7F,
  0xFC, 0x3F, 0x9E, 0x76, 0x6E, 0xEE, 0xCC, 0x00, 0x80, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x3C, 0x06, 0x00, 0x80, 0x04, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x10, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x63, 0x1F, 0xED, 0xFF, 0xFF, 0xC3, 0xF0, 0x0F, 0x00, 0x76, 0x03, 0x9C,
  0x1E, 0x70, 0xF0, 0xE0, 0x83, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x3C, 0xE3, 0x8E, 0x79, 0xCF, 0x38, 0x40, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0,
  0x23, 0xFF, 0xF7, 0x80, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x1F, 0xC0, 0xFF, 0x87, 0x9F, 0x3C, 0x1C, 0xE0,
  0x77, 0x81, 0xDC, 0x07, 0x70, 0x7D, 0xC3, 0xFF, 0x3D, 0xFD, 0xEF, 0xFE,
  0x3F, 0xF0, 0xEF, 0x03, 0xB8, 0x0E, 0xE0, 0x7B, 0x81, 0xCF, 0x0F, 0x1F,
  0xF8, 0x7F, 0xC0, 0x7E, 0x00, 0x01, 0x87, 0xDF, 0xFF, 0xFF, 0x7C, 0x38,
  0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1E,
  0x0E, 0x07, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0x03, 0xFC, 0x0F, 0xFE, 0x1F,
  0x1E, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0x00, 0xC0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF1, 0xF3, 0xC1, 0xE7, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0xE0, 0x3D, 0xC0, 0x73, 0xC1,
  0xE3, 0xFF, 0x87, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xDC, 0x03, 0x9C, 0x07,
  0x1C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1C, 0x3C, 0x38, 0x38, 0x7F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1D, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0xE1, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x70, 0x3C, 0xE0, 0x79, 0xE1, 0xE3, 0xFF,
  0xC3, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0xE0, 0x7F, 0x83, 0xE0,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0xF8, 0x7F, 0xF9, 0xFF, 0xE7, 0xC3,
  0xDE, 0x0F, 0x70, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x0F, 0x70, 0x39, 0xE1,
  0xE3, 0xFF, 0x0F, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x00, 0xC0, 0x0F, 0xF0, 0x3F, 0xF0, 0x78, 0xF1, 0xE0, 0xE3, 0x81, 0xC7,
  0x03, 0x8E, 0x07, 0x1C, 0x1E, 0x3E, 0xF8, 0x3F, 0xE0, 0x7F, 0x83, 0xEF,
  0x8F, 0x07, 0x9C, 0x07, 0x38, 0x0E, 0xF0, 0x1D, 0xE0, 0x79, 0xC1, 0xE3,
  0xFF, 0xC3, 0xFF, 0x03, 0xF8, 0x00, 0x01, 0x80, 0x3F, 0x81, 0xFF, 0x0F,
  0x9E, 0x38, 0x39, 0xE0, 0xF7, 0x01, 0xDC, 0x07, 0xF0, 0x1F, 0xC0, 0xF7,
  0x03, 0xDE, 0x1E, 0x7F, 0xF8, 0xFF, 0xE0, 0xF7, 0x80, 0x1C, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x0F, 0xE0, 0x3F, 0x01, 0xF0, 0x00, 0x08, 0x78, 0xF9,
  0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x1E, 0x3E, 0x7C, 0xF0,
  0x02, 0x03, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x07,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0xF0, 0x1F, 0xC1, 0xFE, 0x3F, 0xC1, 0xF8,
  0x0F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7C, 0x00,
  0x70, 0x00, 0x40, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x10, 0x00, 0xF0, 0x03, 0xF0,
  0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF0, 0x01, 0xC0, 0x3F, 0x07, 0xF8, 0xFF,
  0x87, 0xF0, 0x1F, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x07, 0x01, 0xFF, 0x1F,
  0xFC, 0xF1, 0xEF, 0x07, 0xF0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x07, 0xC0, 0x1C, 0x00, 0x01, 0xF8, 0x07, 0xFC,
  0x0E, 0x0E, 0x1C, 0x07, 0x38, 0xE3, 0x31, 0xFB, 0x73, 0x93, 0x67, 0x33,
  0x66, 0x33, 0xCE, 0x33, 0xCC, 0x73, 0xCC, 0x63, 0xCC, 0x66, 0xCC, 0xE6,
  0xCF, 0xEC, 0xCF, 0x7C, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x40, 0x3F, 0xC0,
  0x1F, 0x80, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0x38, 0x03, 0x9C, 0x03, 0xCE, 0x01, 0xC7, 0x01,
  0xE3, 0x80, 0xE1, 0xC0, 0xF0, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE,
  0x3C, 0x07, 0x1C, 0x03, 0x9E, 0x01, 0xCE, 0x00, 0xEF, 0x00, 0x78, 0x1F,
  0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x1C, 0x0F, 0x3C, 0x07, 0x3C, 0x07, 0x3C,
  0x0F, 0x38, 0x0E, 0x38, 0x3E, 0x3F, 0xF8, 0x7F, 0xF8, 0x78, 0x7C, 0x70,
  0x1E, 0x70, 0x1E, 0x70, 0x0E, 0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0xE0, 0x03, 0xFC, 0x0F, 0xFE, 0x1F,
  0x1E, 0x1E, 0x0F, 0x3C, 0x0F, 0x38, 0x07, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x1E, 0xF0, 0x1C, 0x70, 0x3C, 0x78, 0x38, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xC1, 0xE1, 0xE0, 0xF0,
  0xF0, 0x38, 0x70, 0x1E, 0x38, 0x0F, 0x1C, 0x07, 0x9E, 0x03, 0xCF, 0x01,
  0xC7, 0x80, 0xE3, 0x80, 0x71, 0xC0, 0x78, 0xE0, 0x38, 0xF0, 0x3C, 0x78,
  0x3C, 0x3C, 0x3E, 0x1F, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xE3, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xFC, 0x0F, 0xFE, 0x0F, 0x1E,
  0x1E, 0x0F, 0x3C, 0x0F, 0x38, 0x07, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0xFE, 0xF0, 0xFE, 0xF0, 0xFE, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0x70, 0x1C, 0x78, 0x3C, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0,
  0x0E, 0x03, 0xC3, 0x80, 0xE0, 0xE0, 0x38, 0x78, 0x0E, 0x1E, 0x07, 0x87,
  0x01, 0xE1, 0xC0, 0x78, 0x70, 0x1C, 0x1C, 0x07, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0xFF, 0xFC, 0x38, 0x0E, 0x0E, 0x03, 0x87, 0x80, 0xE1, 0xE0, 0x38,
  0x70, 0x1E, 0x1C, 0x07, 0x87, 0x01, 0xC1, 0xC0, 0x70, 0xF0, 0x1C, 0x00,
  0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0xE0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0,
  0x1E, 0x07, 0xC7, 0x03, 0xE1, 0xC1, 0xF0, 0x70, 0xF8, 0x3C, 0x3C, 0x0F,
  0x1E, 0x03, 0xCF, 0x00, 0xE7, 0x80, 0x3B, 0xC0, 0x0F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x7D, 0xE0, 0x1E, 0x3C, 0x07, 0x0F, 0x01, 0xC1, 0xC0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x03, 0xC3, 0x80, 0xF0, 0xE0, 0x1E, 0x00,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xF8, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x9F,
  0x87, 0xE7, 0xE1, 0xDB, 0xB8, 0x76, 0xEE, 0x1D, 0xF7, 0x0F, 0x7D, 0xC3,
  0x9E, 0x70, 0xE7, 0x9C, 0x39, 0xC7, 0x0E, 0x73, 0xC3, 0x80, 0xE1, 0xE0,
  0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x01, 0xE1, 0xC0, 0x78, 0xF0, 0x1C,
  0x00, 0x0F, 0x03, 0xC3, 0xC0, 0xE0, 0xF0, 0x38, 0x7E, 0x0E, 0x1F, 0x87,
  0x87, 0xE1, 0xE1, 0xF8, 0x70, 0x77, 0x1C, 0x1D, 0xC7, 0x0F, 0x73, 0xC3,
  0xCE, 0xF0, 0xE3, 0xBC, 0x38, 0xEE, 0x0E, 0x3B, 0x87, 0x87, 0xE1, 0xE1,
  0xF8, 0x78, 0x7E, 0x1C, 0x0F, 0x87, 0x03, 0xC1, 0xC0, 0xF0, 0xF0, 0x3C,
  0x00, 0x00, 0xC0, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0x3E, 0x1E, 0x0E, 0x3C,
  0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0x70,
  0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0x70,
  0x3C, 0x78, 0x78, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0xF8, 0x0F,
  0xFF, 0x07, 0xFF, 0xC3, 0x81, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0xF0, 0x1C,
  0x78, 0x0E, 0x38, 0x0F, 0x1C, 0x0F, 0x0F, 0xFF, 0x8F, 0xFF, 0x07, 0xFE,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xF8, 0x0F, 0xFC,
  0x1F, 0x3E, 0x1E, 0x0E, 0x3C, 0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x70, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E,
  0xF0, 0x1E, 0xF0, 0x1C, 0x70, 0x3C, 0x78, 0x78, 0x7F, 0xF0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x10, 0x1F, 0xF8,
  0x1F, 0xFE, 0x1F, 0xFE, 0x1C, 0x0F, 0x1C, 0x07, 0x3C, 0x07, 0x3C, 0x07,
  0x38, 0x0F, 0x38, 0x0E, 0x38, 0x3E, 0x7F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF0,
  0x70, 0xF0, 0x70, 0x70, 0x70, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xE0, 0x3C,
  0xE0, 0x3C, 0xE0, 0x3C, 0x00, 0xE0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1F,
  0x1C, 0x0F, 0x3C, 0x07, 0x3C, 0x07, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x3C, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0,
  0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x1C, 0x07, 0x8E,
  0x03, 0x87, 0x01, 0xC7, 0x80, 0xE3, 0xC0, 0x71, 0xC0, 0x78, 0xE0, 0x3C,
  0x70, 0x1C, 0x38, 0x0E, 0x3C, 0x07, 0x1E, 0x07, 0x8E, 0x03, 0xC7, 0x01,
  0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x78, 0x70, 0x3C, 0x3C, 0x3C, 0x1F,
  0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0xE0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1C,
  0xF0, 0x3C, 0xF0, 0x3C, 0x70, 0x78, 0x70, 0x78, 0x70, 0x70, 0x70, 0xF0,
  0x70, 0xE0, 0x79, 0xE0, 0x79, 0xC0, 0x3B, 0xC0, 0x3B, 0x80, 0x3B, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1C, 0x00,
  0x71, 0xC3, 0xB8, 0xE3, 0x9C, 0x71, 0xCE, 0x78, 0xEF, 0x3C, 0xF7, 0x1E,
  0x73, 0x9F, 0x39, 0xCF, 0x9C, 0xE6, 0xDE, 0x77, 0x6E, 0x3B, 0xB7, 0x1D,
  0x9B, 0x8F, 0xCF, 0x87, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF0,
  0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1C, 0x0E, 0x0E, 0x00, 0x0F, 0x01, 0xF0,
  0x70, 0x1E, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x03, 0x87, 0x80, 0x3C, 0xF0,
  0x01, 0xDE, 0x00, 0x1D, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xBC, 0x00, 0xF1,
  0xC0, 0x0F, 0x1E, 0x01, 0xE0, 0xE0, 0x3C, 0x0F, 0x07, 0xC0, 0xF0, 0xF8,
  0x07, 0x80, 0xF0, 0x0F, 0xF0, 0x1E, 0x70, 0x3C, 0x78, 0x3C, 0x78, 0x78,
  0x38, 0x70, 0x38, 0xF0, 0x3C, 0xE0, 0x1D, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xC7, 0xFF,
  0xE1, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0xFC,
  0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C,
  0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xF0, 0xFC, 0x3F, 0x00, 0xE1, 0xC3,
  0x87, 0x0E, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x83, 0x80, 0x0F, 0xC3, 0xF0, 0xFC, 0x0F,
  0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0,
  0x78, 0x1C, 0x07, 0x01, 0xC3, 0xF0, 0xFC, 0x3F, 0x00, 0x03, 0x80, 0x3C,
  0x07, 0xC0, 0x6C, 0x0E, 0xC1, 0xCE, 0x1C, 0xE3, 0x8E, 0x38, 0xE7, 0x06,
  0xF0, 0x70, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0x80, 0xF1, 0xC3, 0x8F, 0x07,
  0xE0, 0x7F, 0xE3, 0xFF, 0xCF, 0x0F, 0x38, 0x1C, 0x00, 0x70, 0x3F, 0xC7,
  0xFF, 0x7F, 0xFD, 0xE0, 0xFF, 0x03, 0xBC, 0x0E, 0xF0, 0x7B, 0xFF, 0xE7,
  0xFF, 0x8F, 0xCE, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x1E, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0xF0, 0xF1,
  0xC0, 0xF3, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xB8, 0x0E, 0x70, 0x1C, 0xE0,
  0x3B, 0xC0, 0xF7, 0xC3, 0xCF, 0xFF, 0x9D, 0xFE, 0x39, 0xF8, 0x00, 0x07,
  0xE0, 0x7F, 0xC3, 0xFF, 0x9E, 0x0E, 0x70, 0x3F, 0xC0, 0xFE, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x1E, 0xF0, 0xF1, 0xFF, 0xC7,
  0xFE, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x0F, 0x9C, 0x0F, 0xEE, 0x0F, 0xFF,
  0x0F, 0x0F, 0x87, 0x03, 0xC7, 0x81, 0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xE0,
  0x38, 0x70, 0x3C, 0x38, 0x1E, 0x1C, 0x0E, 0x0F, 0x0F, 0x07, 0xFF, 0x81,
  0xFF, 0xC0, 0x7C, 0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xE0, 0xE3,
  0x81, 0xEF, 0x01, 0xDC, 0x03, 0xBF, 0xFF, 0x7F, 0xFF, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x81, 0x87, 0xFF, 0x8F, 0xFE, 0x07, 0xF0, 0x00, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x03, 0xF7, 0x83, 0xFF,
  0x83, 0xFF, 0xC3, 0xC1, 0xE1, 0xC0, 0xF1, 0xE0, 0x78, 0xE0, 0x38, 0x70,
  0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x07, 0x87, 0x03, 0xC3, 0xC3, 0xC1,
  0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xB8, 0x00, 0x3C, 0x10, 0x1C, 0x18, 0x1E,
  0x1F, 0xFE, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x7C, 0x3B, 0xFC,
  0x7F, 0xF8, 0xF0, 0x79, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0x38,
  0x0E, 0x70, 0x1C, 0xE0, 0x3B, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0x9C, 0x07,
  0x38, 0x0E, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x1F, 0xFF, 0x7F, 0xFB, 0xFF, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x86, 0xFC,
  0x3F, 0xC1, 0xF8, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x1F, 0x3C, 0x3E, 0x38, 0x7C,
  0x38, 0xF8, 0x39, 0xE0, 0x3B, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0,
  0x7F, 0xC0, 0x79, 0xE0, 0xF0, 0xE0, 0xF0, 0xF0, 0xF0, 0x78, 0xE0, 0x78,
  0xE0, 0x3C, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x3B, 0xCF, 0x1F, 0xFF, 0x8F,
  0xFF, 0xE7, 0x1C, 0xF3, 0x8E, 0x7B, 0xCF, 0x39, 0xC7, 0x1C, 0xE3, 0x8E,
  0x71, 0xC7, 0x38, 0xE3, 0x9C, 0x73, 0xDE, 0x79, 0xCE, 0x38, 0xE7, 0x1C,
  0x73, 0x8E, 0x39, 0xC7, 0x1C, 0x39, 0xF8, 0x77, 0xF8, 0xFF, 0xF1, 0xE0,
  0xF3, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0E, 0x70, 0x1C, 0xE0, 0x39,
  0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0x07,
  0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xE1, 0xE7, 0x81, 0xEF, 0x03, 0xDC, 0x07,
  0xB8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3B, 0xC0, 0x73, 0x81, 0xE7, 0x87, 0x8F,
  0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x1E, 0xF8, 0x1D, 0xFC, 0x1F, 0xFE, 0x1E,
  0x1E, 0x1C, 0x0E, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0E, 0x38,
  0x0E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x7F, 0xFC, 0x7F, 0xF8, 0x73,
  0xE0, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x0F, 0x9C, 0x7F, 0xF3, 0xFF, 0xDE, 0x0F, 0x70, 0x3F, 0xC0, 0xEE,
  0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x81, 0xEE, 0x07, 0xB8, 0x1C, 0xF0, 0xF3,
  0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0xFC, 0xFF, 0xE3, 0xBF, 0x8F, 0xC2, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x07, 0xF0, 0x1F, 0xF0,
  0x7F, 0xF1, 0xE0, 0xF3, 0x81, 0xE7, 0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x07,
  0xF8, 0x01, 0xF0, 0x00, 0xF7, 0x80, 0xE7, 0x03, 0xCF, 0x9F, 0x0F, 0xFC,
  0x0F, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE3, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x78,
  0x1E, 0xF0, 0x39, 0xE0, 0x73, 0x80, 0xE7, 0x03, 0xCE, 0x07, 0xBC, 0x0E,
  0x78, 0x1C, 0xF0, 0x39, 0xC0, 0x73, 0x81, 0xE7, 0x03, 0xCF, 0x0F, 0x1F,
  0xFE, 0x1F, 0xDC, 0x1F, 0x38, 0xF0, 0x0E, 0xE0, 0x3D, 0xC0, 0x73, 0x81,
  0xE7, 0x83, 0x87, 0x0F, 0x0E, 0x1C, 0x1C, 0x70, 0x38, 0xE0, 0x73, 0x80,
  0x77, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0xE1,
  0x87, 0xE3, 0x87, 0xE3, 0x8E, 0xE7, 0x8E, 0xE7, 0x8E, 0xE7, 0x9C, 0xEF,
  0x9C, 0xED, 0x98, 0xED, 0xB8, 0xF9, 0xB8, 0xF9, 0xB0, 0xF9, 0xF0, 0xF1,
  0xF0, 0xF1, 0xE0, 0xE1, 0xE0, 0xE1, 0xE0, 0x1E, 0x07, 0xC7, 0x83, 0xC0,
  0xF0, 0xF0, 0x1C, 0x78, 0x07, 0xBC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3D, 0xE0, 0x1E, 0x38,
  0x0F, 0x0F, 0x07, 0x81, 0xC3, 0xC0, 0x78, 0x3C, 0x03, 0xCF, 0x00, 0xF1,
  0xC0, 0x78, 0x78, 0x1C, 0x1E, 0x0F, 0x03, 0x87, 0x80, 0xE1, 0xE0, 0x38,
  0xF0, 0x0F, 0x38, 0x01, 0xDE, 0x00, 0x77, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xE0, 0x02, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFF, 0x3F,
  0xFE, 0x3F, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0x70, 0x1F, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x3E,
  0x07, 0x80, 0xF8, 0x07, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x0E,
  0x1C, 0x30, 0x60, 0xC1, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x87, 0x0E,
  0x18, 0x30, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x80, 0x0E,
  0x01, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0xF8, 0x3C, 0x0F, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x03, 0xC0,
  0x70, 0x00, 0x1E, 0x00, 0x1F, 0xC1, 0xDF, 0xF0, 0xCE, 0x3F, 0xEE, 0x0F,
  0xE1, 0x03, 0xF0,
};

const GFXglyph RobotoMono_MediumItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 8, 21, 18, 5, -21 },
  { 22, 10, 8, 18, 5, -23 },
  { 32, 18, 21, 18, 0, -21 },
  { 80, 16, 28, 18, 1, -25 },
  { 136, 14, 22, 18, 2, -22 },
  { 175, 16, 22, 18, 1, -22 },
  { 219, 4, 8, 18, 8, -23 },
  { 223, 10, 31, 18, 5, -24 },
  { 262, 11, 31, 18, 2, -24 },
  { 305, 14, 14, 18, 3, -21 },
  { 330, 15, 16, 18, 1, -18 },
  { 360, 6, 9, 18, 3, -3 },
  { 367, 12, 3, 18, 3, -11 },
  { 372, 5, 5, 18, 5, -5 },
  { 376, 16, 23, 18, 1, -21 },
  { 422, 14, 22, 18, 2, -22 },
  { 461, 9, 21, 18, 4, -21 },
  { 485, 16, 22, 18, 0, -22 },
  { 529, 15, 22, 18, 1, -22 },
  { 571, 16, 21, 18, 0, -21 },
  { 613, 15, 21, 18, 2, -21 },
  { 653, 14, 21, 18, 1, -21 },
  { 690, 16, 21, 18, 2, -21 },
  { 732, 15, 22, 18, 1, -22 },
  { 774, 14, 22, 18, 2, -22 },
  { 813, 7, 17, 18, 6, -17 },
  { 828, 9, 23, 18, 4, -17 },
  { 854, 14, 14, 18, 2, -16 },
  { 879, 14, 9, 18, 2, -14 },
  { 895, 14, 14, 18, 1, -16 },
  { 920, 13, 22, 18, 4, -22 },
  { 956, 16, 21, 18, 1, -21 },
  { 998, 17, 21, 18, -1, -21 },
  { 1043, 16, 21, 18, 1, -21 },
  { 1085, 16, 22, 18, 1, -22 },
  { 1129, 17, 21, 18, 0, -21 },
  { 1174, 17, 21, 18, 1, -21 },
  { 1219, 17, 21, 18, 1, -21 },
  { 1264, 16, 22, 18, 1, -22 },
  { 1308, 18, 21, 18, 0, -21 },
  { 1356, 16, 21, 18, 1, -21 },
  { 1398, 16, 21, 18, 1, -21 },
  { 1440, 18, 21, 18, 1, -21 },
  { 1488, 14, 21, 18, 1, -21 },
  { 1525, 18, 21, 18, 0, -21 },
  { 1573, 18, 21, 18, 0, -21 },
  { 1621, 16, 22, 18, 1, -22 },
  { 1665, 17, 21, 18, 1, -21 },
  { 1710, 16, 26, 18, 1, -22 },
  { 1762, 16, 21, 18, 1, -21 },
  { 1804, 16, 22, 18, 1, -22 },
  { 1848, 17, 21, 18, 2, -21 },
  { 1893, 17, 21, 18, 1, -21 },
  { 1938, 16, 21, 18, 3, -21 },
  { 1980, 17, 21, 18, 2, -21 },
  { 2025, 20, 21, 18, -1, -21 },
  { 2078, 16, 21, 18, 3, -21 },
  { 2120, 18, 21, 18, 0, -21 },
  { 2168, 10, 30, 18, 4, -25 },
  { 2206, 7, 23, 18, 6, -21 },
  { 2227, 10, 30, 18, 4, -25 },
  { 2265, 12, 11, 18, 3, -21 },
  { 2282, 14, 3, 18, 0, 0 },
  { 2288, 6, 4, 18, 8, -22 },
  { 2291, 14, 16, 18, 1, -16 },
  { 2319, 15, 23, 18, 1, -23 },
  { 2363, 14, 16, 18, 2, -16 },
  { 2391, 17, 23, 18, 1, -23 },
  { 2440, 15, 16, 18, 1, -16 },
  { 2470, 16, 23, 18, 3, -23 },
  { 2516, 17, 22, 18, 0, -16 },
  { 2563, 15, 23, 18, 1, -23 },
  { 2607, 14, 22, 18, 1, -22 },
  { 2646, 13, 28, 18, 1, -22 },
  { 2692, 16, 23, 18, 1, -23 },
  { 2738, 14, 23, 18, 1, -23 },
  { 2779, 17, 16, 18, 0, -16 },
  { 2813, 15, 16, 18, 1, -16 },
  { 2843, 15, 16, 18, 1, -16 },
  { 2873, 16, 22, 18, 0, -16 },
  { 2917, 14, 22, 18, 2, -16 },
  { 2956, 14, 16, 18, 3, -16 },
  { 2984, 15, 16, 18, 1, -16 },
  { 3014, 13, 20, 18, 3, -20 },
  { 3047, 15, 16, 18, 2, -16 },
  { 3077, 15, 16, 18, 2, -16 },
  { 3107, 16, 16, 18, 2, -16 },
  { 3139, 18, 16, 18, 0, -16 },
  { 3175, 18, 22, 18, 0, -16 },
  { 3225, 16, 16, 18, 1, -16 },
  { 3257, 12, 28, 18, 4, -23 },
  { 3299, 7, 27, 18, 5, -21 },
  { 3323, 11, 28, 18, 3, -23 },
  { 3362, 17, 6, 18, 0, -12 },
};

const GFXfont RobotoMono_MediumItalic30pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic30pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOMONO_MEDIUMITALIC30PT7B_H_
