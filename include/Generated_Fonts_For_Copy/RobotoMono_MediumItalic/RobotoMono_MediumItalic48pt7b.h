#ifndef _ROBOTOMONO_MEDIUMITALIC48PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x00,
  0x7C, 0x3E, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x3C,
  0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xC7, 0x07, 0x80, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78,
  0x3C, 0x00, 0x07, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0x83, 0xC0,
  0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFE, 0x1F, 0xC0, 0xFC, 0x07, 0xE0,
  0x7E, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xF8,
  0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x7F, 0x07,
  0xF0, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0x87, 0x80, 0x1E, 0x0F, 0x06,
  0x3C, 0x1E, 0x0F, 0x78, 0x3C, 0x3C, 0xF0, 0x78, 0xF1, 0xE0, 0xF1, 0xC3,
  0xC3, 0xC7, 0x87, 0xC7, 0x9E, 0x07, 0xFE, 0x78, 0x0F, 0xFC, 0xF0, 0x07,
  0xE3, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x04, 0x00, 0x3C, 0xFF, 0x00, 0xF3,
  0xFF, 0x01, 0xEF, 0xFE, 0x07, 0x9E, 0x3E, 0x1E, 0x3C, 0x3C, 0x3C, 0xF0,
  0x78, 0xF1, 0xE0, 0xF3, 0xC3, 0xC1, 0xE3, 0x07, 0x83, 0xC0, 0x0F, 0x0F,
  0x00, 0x1F, 0x1E, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE3, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x1F, 0x1F, 0xFF, 0x07, 0xCF,
  0xEF, 0xC1, 0xF7, 0xF1, 0xF8, 0xF9, 0xF8, 0x3E, 0x3E, 0x7C, 0x0F, 0xDF,
  0xBF, 0x01, 0xFF, 0xCF, 0xC0, 0x7F, 0xF3, 0xF0, 0x0F, 0xF8, 0xFC, 0x03,
  0xFC, 0x3F, 0x00, 0xFE, 0x07, 0xF0, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xCF, 0xC0, 0x7F, 0xC3, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x78, 0xF1, 0xE7, 0xCF, 0x9E, 0x3C, 0x78, 0xF1, 0xC7, 0x80, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x01, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x08, 0x07, 0x01, 0x1C, 0x1E, 0x0E, 0x7E, 0x3C, 0x7E,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xCF, 0x00, 0x1F,
  0x1E, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x3E, 0x07, 0xE0, 0x7C, 0x03, 0x80,
  0x78, 0x02, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xE1,
  0xF0, 0xF8, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xE0, 0x3E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x3E, 0x08, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFC, 0x1F, 0x83,
  0xF0, 0x1F, 0x0F, 0xC0, 0x3F, 0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xFC,
  0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xEF, 0xC0, 0x3F, 0xDF, 0x80,
  0xFF, 0xBF, 0x07, 0xFF, 0x7C, 0x1F, 0xFE, 0xF8, 0xFC, 0xF9, 0xF3, 0xF1,
  0xF3, 0xFF, 0x83, 0xEF, 0xFE, 0x0F, 0xDF, 0xF0, 0x1F, 0xBF, 0xC0, 0x3F,
  0x7F, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xE7,
  0xC0, 0x0F, 0x8F, 0xC0, 0x3F, 0x0F, 0x80, 0xFC, 0x1F, 0x83, 0xF8, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x1E, 0x00, 0xFE, 0x07, 0xFE, 0x3F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFC, 0xFE, 0x7C, 0xF8, 0x7C, 0xC0, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F,
  0xC0, 0x1F, 0x87, 0xC0, 0x07, 0xC7, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80,
  0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x1F,
  0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC1, 0xFC, 0x1F,
  0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03,
  0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xC3, 0xFC, 0x03, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F,
  0x80, 0x3F, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC1, 0x80, 0x3F, 0x3F,
  0xC0, 0xFB, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x7F, 0xC1, 0xF9,
  0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0x7C, 0x00, 0x7D, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xFD, 0xF0, 0x03,
  0xF7, 0xC0, 0x0F, 0x9F, 0x80, 0x7E, 0x7E, 0x03, 0xF0, 0xFE, 0x1F, 0xC1,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07,
  0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x3F,
  0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xFC,
  0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0x7E,
  0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xC1, 0xF8,
  0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x00, 0xFB, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xDF, 0x81, 0xFE, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFE, 0xF8, 0x3F, 0xEF, 0xC0, 0x7C, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC1, 0xF0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0x0F, 0xE1, 0xF8, 0x08, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x04, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF,
  0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFF, 0x3F, 0xC3, 0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0x3F, 0xFC,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x1F, 0x80,
  0x1F, 0x00, 0x78, 0x07, 0xC0, 0x07, 0x01, 0xE0, 0x00, 0xF0, 0x3C, 0x1F,
  0x0E, 0x0F, 0x0F, 0xF1, 0xC3, 0xC3, 0xFF, 0x38, 0x78, 0xF9, 0xE7, 0x9E,
  0x3E, 0x38, 0xF3, 0xC7, 0x87, 0x1E, 0x71, 0xE0, 0xE3, 0xDE, 0x3C, 0x3C,
  0x73, 0xC7, 0x07, 0x0E, 0x71, 0xE0, 0xE1, 0xCE, 0x3C, 0x1C, 0x3B, 0xC7,
  0x87, 0x87, 0x78, 0xE0, 0xE1, 0xCF, 0x1C, 0x1C, 0x39, 0xE3, 0x83, 0x87,
  0x3C, 0x78, 0xF1, 0xC7, 0x8F, 0xFF, 0x78, 0xF1, 0xFF, 0xFE, 0x0E, 0x1F,
  0x9F, 0x81, 0xC0, 0xC1, 0xC0, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x01, 0x00, 0x07, 0xE1, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x03,
  0xEF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3E,
  0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xF0,
  0x1F, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x3E,
  0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE7, 0xE0, 0x00, 0xF9, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0x80, 0x3F, 0x81, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x0F,
  0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x07,
  0xE0, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xC0, 0x0F, 0xE0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0x80,
  0xFC, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xCF, 0xC0,
  0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x1E, 0x7E, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC3, 0xF0, 0x0F,
  0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xC7, 0xFE,
  0x01, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x3F,
  0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xC1,
  0xF0, 0x07, 0xE0, 0x7C, 0x07, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0x80,
  0x0F, 0x8F, 0x80, 0x07, 0xCF, 0xC0, 0x03, 0xE7, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xFF, 0xDF, 0x81, 0xFF, 0xEF,
  0xC0, 0xFF, 0xF7, 0xE0, 0x7F, 0xFB, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7C,
  0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x8F, 0x80, 0x0F,
  0xC7, 0xE0, 0x07, 0xC3, 0xF8, 0x07, 0xE0, 0xFE, 0x0F, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x00, 0x1F,
  0x83, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF8,
  0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3E, 0x00,
  0x1F, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03,
  0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7E,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3E,
  0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0,
  0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x83,
  0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x03, 0xFC, 0x0F, 0x80, 0x1F, 0xE0, 0x7E, 0x00,
  0x7F, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0xFE,
  0x00, 0x7C, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xE3, 0xF8, 0x00, 0x0F,
  0x9F, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xCF, 0xC0, 0x00, 0xFE, 0x1F, 0x80,
  0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x01,
  0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8,
  0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x8F, 0xFC, 0x0F,
  0xF8, 0xF7, 0xC0, 0xFB, 0xDF, 0x7C, 0x1F, 0x3D, 0xE7, 0xC1, 0xF3, 0xFE,
  0xF8, 0x1F, 0x3F, 0xCF, 0x81, 0xF3, 0xFC, 0xF8, 0x1F, 0x3F, 0x8F, 0x81,
  0xF3, 0xF8, 0xF8, 0x3E, 0x3F, 0x1F, 0x83, 0xE3, 0xF1, 0xF0, 0x3E, 0x1E,
  0x1F, 0x03, 0xE1, 0xE1, 0xF0, 0x3E, 0x1C, 0x1F, 0x07, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x7C,
  0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x03,
  0xF0, 0x7F, 0x00, 0x7C, 0x1F, 0xE0, 0x0F, 0x83, 0xFE, 0x01, 0xF0, 0x7F,
  0xC0, 0x7E, 0x0F, 0xF8, 0x0F, 0xC1, 0xFF, 0x81, 0xF8, 0x3F, 0xF0, 0x3E,
  0x0F, 0xDE, 0x07, 0xC1, 0xFB, 0xC0, 0xF8, 0x3F, 0x7C, 0x3F, 0x07, 0xEF,
  0x87, 0xE0, 0xF8, 0xF0, 0xFC, 0x1F, 0x1F, 0x1F, 0x07, 0xE3, 0xE3, 0xE0,
  0xFC, 0x3C, 0xFC, 0x1F, 0x87, 0x9F, 0x83, 0xE0, 0xFB, 0xF0, 0x7C, 0x1F,
  0x7E, 0x0F, 0x81, 0xEF, 0x83, 0xF0, 0x3F, 0xF0, 0x7E, 0x07, 0xFE, 0x0F,
  0xC0, 0x7F, 0xC1, 0xF0, 0x0F, 0xF8, 0x3E, 0x01, 0xFE, 0x0F, 0xC0, 0x3F,
  0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0xF8,
  0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0x87,
  0xF0, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x1F, 0x0F, 0x80,
  0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xFB, 0xF0,
  0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE,
  0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x03, 0xF7,
  0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x7E,
  0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x1F,
  0x83, 0xF0, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x7E, 0x07, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x3E,
  0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x83, 0xE0,
  0x07, 0xF0, 0x7C, 0x01, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0x87,
  0xF0, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x1F, 0x8F, 0x80,
  0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xF0,
  0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF7,
  0xE0, 0x01, 0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3E,
  0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x1F,
  0x83, 0xF0, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x20, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7E, 0x0F, 0xF8, 0x0F, 0x80, 0x3F, 0x81,
  0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x00,
  0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x1F,
  0x00, 0x3F, 0x87, 0xE0, 0x07, 0xE0, 0xFC, 0x03, 0xF8, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xF0, 0x1F, 0x80,
  0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3E,
  0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x07,
  0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x0F,
  0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x7C, 0x00,
  0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xF8,
  0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07,
  0xE3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x07, 0xC0,
  0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x0F, 0xE3, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xE7, 0xC0,
  0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x87,
  0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3F,
  0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0,
  0xFC, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x07,
  0xC3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x80,
  0x07, 0xE7, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x03, 0xEF, 0x81,
  0xE0, 0x7D, 0xF0, 0x7C, 0x0F, 0xBE, 0x0F, 0x83, 0xE7, 0xC1, 0xF0, 0x7C,
  0xF8, 0x7E, 0x0F, 0x9F, 0x0F, 0xC3, 0xF3, 0xE1, 0xF8, 0x7C, 0x7C, 0x7F,
  0x0F, 0x8F, 0x8F, 0xE1, 0xF1, 0xF1, 0xFC, 0x7C, 0x3E, 0x7F, 0x8F, 0x87,
  0xCF, 0xF1, 0xF0, 0xF9, 0xFE, 0x3E, 0x1F, 0x7F, 0xCF, 0x83, 0xCF, 0x79,
  0xF0, 0x79, 0xEF, 0x3E, 0x0F, 0x3D, 0xE7, 0x81, 0xEF, 0x3D, 0xF0, 0x3D,
  0xE7, 0xBE, 0x07, 0xBC, 0xF7, 0xC0, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFE,
  0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC,
  0x3F, 0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x83, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xF1,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x1F,
  0x80, 0xF8, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0,
  0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE7, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xF8, 0x1F, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80,
  0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x1F, 0x78, 0x03, 0xCF,
  0x00, 0xF9, 0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xC1, 0xF0, 0x78, 0x3E, 0x0F,
  0x8F, 0x81, 0xF1, 0xE0, 0x1E, 0x7C, 0x03, 0xDF, 0x00, 0x7C, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFC, 0x3E, 0x1F,
  0x87, 0xC1, 0xF0, 0x78, 0x3E, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0x7F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0,
  0x1F, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xE0, 0x3E,
  0x3F, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xE7,
  0xC0, 0x0F, 0xCF, 0xC0, 0x7F, 0x1F, 0xC1, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFD, 0xF0, 0x3F, 0xE3, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC7, 0xC0, 0x0F, 0xDF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F,
  0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x83, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFD, 0xFF, 0xE0, 0xF8, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x0F, 0xDF, 0x80, 0x1F,
  0x7E, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0x3F, 0x00, 0x7C, 0xFC, 0x03, 0xF1,
  0xF8, 0x3F, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x07, 0xFE, 0xFC, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0x7E,
  0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0x7E, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0,
  0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x81, 0xFE, 0x3F,
  0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xDF, 0x00, 0x1F,
  0xE7, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC, 0x1F, 0x87,
  0xE0, 0x1F, 0x9F, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF8,
  0x00, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x01, 0x07, 0xF0, 0x0F, 0x07, 0xF0, 0x7F, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xE7, 0xC0, 0x7F, 0xFB, 0xE0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F,
  0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFE, 0xF8, 0x01, 0xFE, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x02, 0x00, 0x1F, 0x01, 0x80, 0x1F, 0x81, 0xE0,
  0x1F, 0x81, 0xFE, 0x7F, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC3, 0xE0, 0x0F, 0xCF, 0xF8, 0x0F, 0x9F, 0xFC, 0x0F, 0xBF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x43, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x0F, 0xC0, 0x7F,
  0x03, 0xF0, 0x3F, 0x80, 0xF8, 0x1F, 0xC0, 0x3E, 0x0F, 0xE0, 0x0F, 0x87,
  0xF0, 0x07, 0xE3, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0x7C, 0xFE, 0x00, 0x1F,
  0x7F, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xF7, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF0,
  0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x1F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x03, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x4F, 0x07, 0x80, 0x79, 0xF9,
  0xFC, 0x0F, 0xBF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFC, 0x7E, 0x3F, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7C, 0x1F, 0x1F, 0x87,
  0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x3E,
  0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x3E, 0x3E, 0x0F, 0x87, 0xC3, 0xE0,
  0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07,
  0xC3, 0xE1, 0xF0, 0x7C, 0x7C, 0x1F, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7C,
  0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x8F, 0xC3, 0xE1,
  0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x8F, 0xF8, 0x0F, 0x9F, 0xFC, 0x0F, 0xBF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80,
  0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3F, 0x1F, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8, 0x1F,
  0x87, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0xFC, 0x00, 0x7D,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xF0,
  0x03, 0xF3, 0xE0, 0x0F, 0xC7, 0xE0, 0x3F, 0x87, 0xE0, 0xFE, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x11, 0xF0, 0x00, 0xF9, 0xFF, 0x00, 0x3E, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x01, 0xF8,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x00,
  0xFC, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC,
  0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF8, 0x3F,
  0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0x7F, 0xF0, 0x0F, 0xCF,
  0xF8, 0x03, 0xF0, 0x30, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x01, 0xFF, 0x9F, 0x03, 0xFF, 0xDF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x3E, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03,
  0xF8, 0x7F, 0x07, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFD,
  0xF0, 0x07, 0xF9, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xFC, 0x0F, 0x8F, 0xFC, 0x1F, 0x3F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFB, 0xFF,
  0xC1, 0xFF, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0xFF, 0xBF, 0xE3, 0xF8, 0x0F, 0xC7, 0xE0, 0x0F, 0x8F, 0x80, 0x1F,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xE7, 0xC0,
  0x0F, 0xCF, 0xC0, 0x7F, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x30,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E,
  0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x7E,
  0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7C,
  0x00, 0xFC, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x07, 0xF0, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFD, 0xF0, 0x3F,
  0xFB, 0xE0, 0x1F, 0xE3, 0xE0, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x7E, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C,
  0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x1E, 0x0F, 0x80, 0x1F,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x3E, 0x00, 0x0F,
  0x7C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x1E, 0x07, 0xFE, 0x0F, 0x83, 0xEF, 0x83, 0xE0, 0xFB, 0xE1, 0xF8, 0x3E,
  0xF8, 0x7E, 0x1F, 0x3E, 0x1F, 0x87, 0xCF, 0x0F, 0xE1, 0xF3, 0xC3, 0xF8,
  0xF8, 0xF0, 0xEE, 0x3E, 0x3C, 0x7B, 0x8F, 0x0F, 0x1C, 0xE7, 0xC3, 0xCF,
  0x39, 0xF0, 0xF3, 0xCE, 0x78, 0x3C, 0xE3, 0x9E, 0x0F, 0x78, 0xEF, 0x83,
  0xDE, 0x3B, 0xC0, 0xF7, 0x0E, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0xFE,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0,
  0xFC, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x07,
  0xF0, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x01, 0xF8, 0x01,
  0xF8, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xDF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xBF, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x01, 0xF8,
  0x07, 0xC0, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xE0, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC,
  0x1F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0xF8, 0xFC, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x02, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x20, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F,
  0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x3C, 0x7F, 0xF0, 0x07, 0x9F, 0xFF, 0x01, 0xE7, 0xFF, 0xF8,
  0x7C, 0xF8, 0x3F, 0xFF, 0x9E, 0x03, 0xFF, 0xE7, 0x80, 0x3F, 0xF8, 0x10,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoMono_MediumItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 11, 34, 28, 9, -34 },
  { 48, 15, 12, 28, 9, -36 },
  { 71, 28, 34, 28, 0, -34 },
  { 190, 25, 45, 28, 2, -40 },
  { 331, 23, 36, 28, 3, -35 },
  { 435, 26, 36, 28, 1, -35 },
  { 552, 7, 12, 28, 12, -36 },
  { 563, 17, 49, 28, 7, -38 },
  { 668, 16, 49, 28, 4, -38 },
  { 766, 23, 24, 28, 4, -34 },
  { 835, 24, 25, 28, 2, -28 },
  { 910, 10, 14, 28, 4, -5 },
  { 928, 19, 4, 28, 6, -17 },
  { 938, 8, 8, 28, 8, -7 },
  { 946, 25, 37, 28, 2, -34 },
  { 1062, 23, 36, 28, 3, -35 },
  { 1166, 16, 34, 28, 6, -34 },
  { 1234, 25, 35, 28, 0, -35 },
  { 1344, 25, 36, 28, 1, -35 },
  { 1457, 24, 34, 28, 1, -34 },
  { 1559, 25, 35, 28, 2, -34 },
  { 1669, 22, 35, 28, 2, -34 },
  { 1766, 24, 34, 28, 4, -34 },
  { 1868, 24, 36, 28, 2, -35 },
  { 1976, 21, 35, 28, 4, -35 },
  { 2068, 11, 28, 28, 9, -27 },
  { 2107, 14, 36, 28, 7, -27 },
  { 2170, 23, 22, 28, 3, -26 },
  { 2234, 23, 15, 28, 3, -22 },
  { 2278, 23, 22, 28, 2, -26 },
  { 2342, 21, 35, 28, 6, -35 },
  { 2434, 27, 34, 28, 1, -34 },
  { 2549, 26, 34, 28, -1, -34 },
  { 2660, 27, 34, 28, 1, -34 },
  { 2775, 25, 36, 28, 2, -35 },
  { 2888, 26, 34, 28, 1, -34 },
  { 2999, 28, 34, 28, 1, -34 },
  { 3118, 28, 34, 28, 1, -34 },
  { 3237, 25, 36, 28, 2, -35 },
  { 3350, 27, 34, 28, 1, -34 },
  { 3465, 25, 34, 28, 2, -34 },
  { 3572, 26, 35, 28, 2, -34 },
  { 3686, 30, 34, 28, 1, -34 },
  { 3814, 23, 34, 28, 1, -34 },
  { 3912, 28, 34, 28, 1, -34 },
  { 4031, 27, 34, 28, 1, -34 },
  { 4146, 25, 36, 28, 2, -35 },
  { 4259, 27, 34, 28, 1, -34 },
  { 4374, 25, 41, 28, 2, -35 },
  { 4503, 27, 34, 28, 1, -34 },
  { 4618, 26, 36, 28, 2, -35 },
  { 4735, 26, 34, 28, 4, -34 },
  { 4846, 26, 35, 28, 2, -34 },
  { 4960, 26, 34, 28, 4, -34 },
  { 5071, 27, 34, 28, 3, -34 },
  { 5186, 31, 34, 28, -1, -34 },
  { 5318, 26, 34, 28, 5, -34 },
  { 5429, 28, 34, 28, 0, -34 },
  { 5548, 17, 47, 28, 6, -39 },
  { 5648, 11, 37, 28, 9, -34 },
  { 5699, 17, 47, 28, 6, -39 },
  { 5799, 19, 18, 28, 5, -34 },
  { 5842, 22, 4, 28, 0, 0 },
  { 5853, 9, 7, 28, 13, -35 },
  { 5861, 23, 27, 28, 2, -26 },
  { 5939, 24, 37, 28, 1, -36 },
  { 6050, 22, 27, 28, 3, -26 },
  { 6125, 26, 37, 28, 2, -36 },
  { 6246, 23, 27, 28, 2, -26 },
  { 6324, 26, 37, 28, 4, -37 },
  { 6445, 25, 36, 28, 1, -26 },
  { 6558, 24, 36, 28, 1, -36 },
  { 6666, 21, 35, 28, 2, -35 },
  { 6758, 22, 45, 28, 1, -35 },
  { 6882, 26, 36, 28, 1, -36 },
  { 6999, 22, 36, 28, 2, -36 },
  { 7098, 28, 26, 28, -1, -26 },
  { 7189, 24, 26, 28, 1, -26 },
  { 7267, 23, 27, 28, 2, -26 },
  { 7345, 26, 36, 28, -1, -26 },
  { 7462, 24, 36, 28, 2, -26 },
  { 7570, 23, 26, 28, 4, -26 },
  { 7645, 23, 27, 28, 2, -26 },
  { 7723, 22, 33, 28, 4, -32 },
  { 7814, 24, 26, 28, 3, -25 },
  { 7892, 24, 25, 28, 4, -25 },
  { 7967, 26, 25, 28, 3, -25 },
  { 8049, 28, 25, 28, 0, -25 },
  { 8137, 29, 35, 28, 0, -25 },
  { 8264, 25, 25, 28, 1, -25 },
  { 8343, 19, 46, 28, 7, -38 },
  { 8453, 11, 44, 28, 8, -34 },
  { 8514, 19, 46, 28, 4, -37 },
  { 8624, 27, 10, 28, 0, -19 },
};

const GFXfont RobotoMono_MediumItalic48pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic48pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _ROBOTOMONO_MEDIUMITALIC48PT7B_H_
