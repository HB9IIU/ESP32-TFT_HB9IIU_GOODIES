#ifndef _ROBOTOMONO_MEDIUMITALIC56PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x81, 0xFC, 0x0F,
  0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0x80, 0x3E, 0x07, 0x9F, 0x07, 0xCF, 0x83,
  0xE7, 0xC1, 0xF3, 0xC0, 0xFB, 0xE0, 0x79, 0xF0, 0x3C, 0xF8, 0x3E, 0x78,
  0x1F, 0x3C, 0x0F, 0x9E, 0x07, 0x9F, 0x03, 0xCF, 0x81, 0xE7, 0x81, 0xF0,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1E, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x03, 0xF8,
  0x1F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x7F,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8,
  0x3E, 0x06, 0x1E, 0x07, 0xC1, 0xF3, 0xC0, 0xF8, 0x3C, 0x78, 0x1E, 0x0F,
  0x0F, 0x03, 0xC3, 0xE3, 0xE0, 0x78, 0x78, 0x3C, 0x1F, 0x1E, 0x07, 0xC7,
  0xC7, 0xC0, 0xFF, 0xF9, 0xF0, 0x0F, 0xFE, 0x3C, 0x00, 0xFF, 0x8F, 0x80,
  0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x78, 0xFF, 0x80, 0x1E, 0x3F, 0xF8, 0x07, 0xCF,
  0xFF, 0x00, 0xF3, 0xF1, 0xF0, 0x3C, 0x7C, 0x3E, 0x0F, 0x8F, 0x03, 0xC3,
  0xE3, 0xE0, 0x78, 0x78, 0x7C, 0x0F, 0x1F, 0x0F, 0x81, 0xE1, 0xC1, 0xF0,
  0x7C, 0x10, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x00, 0x7E, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0,
  0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x3F, 0xC0, 0x00,
  0x7E, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0x87, 0xFF, 0xE0, 0x3E, 0x1F, 0xEF,
  0xE0, 0x7C, 0x7F, 0x8F, 0xC1, 0xF8, 0xFE, 0x1F, 0xC3, 0xF3, 0xF8, 0x1F,
  0xCF, 0xC7, 0xF0, 0x3F, 0x9F, 0x8F, 0xC0, 0x3F, 0xFE, 0x3F, 0x80, 0x7F,
  0xFC, 0x7F, 0x00, 0x7F, 0xF0, 0xFE, 0x00, 0xFF, 0xE1, 0xFC, 0x00, 0xFF,
  0x81, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xE3, 0xF8,
  0x03, 0xFF, 0x07, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0x00, 0x00,
  0x40, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x30, 0x0F, 0x01, 0xDF, 0x03, 0xC1, 0xF7, 0xF8, 0xF1, 0xFD, 0xFF, 0xBB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x78, 0x00,
  0x0F, 0x9F, 0x00, 0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0xFC, 0x07, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0x80, 0x3C, 0x00, 0xC0,
  0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87,
  0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87,
  0xE0, 0xFC, 0x3F, 0x01, 0xC0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x08, 0x1F, 0x9F, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x04, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xF8, 0x3F, 0x81,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xF8, 0x00,
  0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7F,
  0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xF9, 0xFC, 0x03, 0xFF, 0x3F, 0x00, 0xFF,
  0xE7, 0xE0, 0x7F, 0xFC, 0xFC, 0x1F, 0xFF, 0xBF, 0x8F, 0xF7, 0xF7, 0xF3,
  0xF8, 0xFC, 0xFF, 0xFE, 0x1F, 0x9F, 0xFF, 0x03, 0xF3, 0xFF, 0xC0, 0x7E,
  0x7F, 0xE0, 0x1F, 0xCF, 0xF8, 0x03, 0xFB, 0xFC, 0x00, 0x7E, 0x7F, 0x00,
  0x0F, 0xCF, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0xF0, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x87, 0xFF, 0xE7,
  0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xCF, 0xEF, 0x83, 0xF3, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01,
  0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF8, 0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00,
  0x3F, 0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1,
  0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x00,
  0x7F, 0x07, 0xE0, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x3F, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xE1, 0xFE, 0x00, 0xF8, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80,
  0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x7E, 0x7F,
  0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFC,
  0x1F, 0xE7, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFD,
  0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x7F,
  0x87, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE,
  0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF8,
  0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xC3, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xFC,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xC1, 0xFC, 0x03,
  0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xE7, 0xF0,
  0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7,
  0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07,
  0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x8F, 0xF0,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xBF, 0x01,
  0xFF, 0xDF, 0x80, 0x1F, 0xC7, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x80, 0x3F, 0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xFE, 0x07, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x7E, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFC, 0x0F, 0xC0, 0x08, 0x00, 0x00, 0x10, 0x00, 0x7E, 0x00, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7E,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x7F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F,
  0xC1, 0xFE, 0x7F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x1C, 0x07, 0xC1, 0xFE, 0x1E,
  0x07, 0x83, 0xFF, 0x1E, 0x0F, 0x07, 0xFF, 0x9E, 0x0F, 0x0F, 0xEF, 0x1E,
  0x1E, 0x1F, 0x0F, 0x0E, 0x1E, 0x1E, 0x0F, 0x0E, 0x3C, 0x3E, 0x0E, 0x0E,
  0x3C, 0x3C, 0x0E, 0x1E, 0x3C, 0x7C, 0x1E, 0x1E, 0x78, 0x78, 0x1E, 0x1E,
  0x78, 0x78, 0x1E, 0x1E, 0x78, 0x78, 0x1C, 0x1C, 0x78, 0xF8, 0x3C, 0x1C,
  0x78, 0xF0, 0x3C, 0x1C, 0x78, 0xF0, 0x3C, 0x3C, 0xF0, 0xF0, 0x78, 0x38,
  0xF0, 0xF0, 0x78, 0x78, 0xF0, 0xF8, 0xF8, 0x70, 0xF0, 0xFF, 0xF8, 0xF0,
  0x78, 0x7F, 0xFF, 0xE0, 0x78, 0x7F, 0xBF, 0xC0, 0x78, 0x3E, 0x1F, 0x80,
  0x78, 0x00, 0x04, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x60, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x3F, 0x3E, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07,
  0xF1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0,
  0x3E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x7F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFC,
  0x00, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01,
  0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF0,
  0x3F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFC, 0x1F,
  0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xC1, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0x3F,
  0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7F, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x01, 0xFF, 0x01, 0xFC,
  0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x03,
  0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC,
  0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F,
  0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x3F, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x81,
  0xF8, 0x03, 0xFC, 0x07, 0xE0, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xF1,
  0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x01, 0xFF, 0xF1, 0xF8, 0x07, 0xFF, 0xC7, 0xE0, 0x1F, 0xFF,
  0x1F, 0x80, 0x7F, 0xFC, 0xFE, 0x03, 0xFF, 0xF3, 0xF8, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC,
  0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF0,
  0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xE0,
  0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x80,
  0x03, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xE0, 0x3F, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x01, 0xFE, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x00,
  0xFC, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0x03, 0xF0, 0x1F, 0xF0,
  0x00, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03, 0xF0, 0x3F,
  0xC0, 0x00, 0x7E, 0x0F, 0xF0, 0x00, 0x0F, 0xC3, 0xFC, 0x00, 0x03, 0xF8,
  0xFF, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x01,
  0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xDF, 0xC0, 0x00, 0x1F, 0xF1, 0xFC, 0x00, 0x03, 0xFC,
  0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0xC0,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF8, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x07, 0xE0,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF,
  0x87, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFB, 0xE3, 0xEF, 0xC0, 0x7D,
  0xF1, 0xF7, 0xC0, 0x7E, 0xF9, 0xF3, 0xE0, 0x3F, 0x7C, 0xFB, 0xF0, 0x1F,
  0x9E, 0xF9, 0xF8, 0x0F, 0xCF, 0x7C, 0xFC, 0x07, 0xC7, 0xFC, 0x7E, 0x07,
  0xE3, 0xFE, 0x3E, 0x03, 0xF1, 0xFE, 0x3F, 0x01, 0xF8, 0xFF, 0x1F, 0x80,
  0xFC, 0x7F, 0x0F, 0xC0, 0x7E, 0x3F, 0x87, 0xE0, 0x3F, 0x1F, 0x83, 0xF0,
  0x3F, 0x07, 0xC3, 0xF0, 0x1F, 0x83, 0xC1, 0xF8, 0x0F, 0xC1, 0xE0, 0xFC,
  0x07, 0xE0, 0xE0, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7E, 0x03, 0xFC,
  0x00, 0x7E, 0x03, 0xFC, 0x00, 0x7E, 0x07, 0xFE, 0x00, 0xFE, 0x07, 0xFE,
  0x00, 0xFE, 0x07, 0xFE, 0x00, 0xFE, 0x07, 0xFF, 0x00, 0xFC, 0x07, 0xFF,
  0x00, 0xFC, 0x07, 0xFF, 0x00, 0xFC, 0x0F, 0xFF, 0x01, 0xFC, 0x0F, 0xFF,
  0x81, 0xFC, 0x0F, 0xEF, 0x81, 0xFC, 0x0F, 0xCF, 0x81, 0xF8, 0x0F, 0xCF,
  0x81, 0xF8, 0x0F, 0xCF, 0xC3, 0xF8, 0x1F, 0xC7, 0xC3, 0xF8, 0x1F, 0xC7,
  0xC3, 0xF8, 0x1F, 0xC7, 0xE3, 0xF0, 0x1F, 0x83, 0xE3, 0xF0, 0x1F, 0x83,
  0xE3, 0xF0, 0x3F, 0x83, 0xE7, 0xF0, 0x3F, 0x83, 0xF7, 0xF0, 0x3F, 0x81,
  0xF7, 0xF0, 0x3F, 0x01, 0xF7, 0xE0, 0x3F, 0x01, 0xFF, 0xE0, 0x3F, 0x00,
  0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xE0, 0x7F, 0x00,
  0xFF, 0xE0, 0x7E, 0x00, 0x7F, 0xC0, 0x7E, 0x00, 0x7F, 0xC0, 0x7E, 0x00,
  0x7F, 0xC0, 0xFE, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x3F, 0xC0, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0,
  0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x7E, 0xFE, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD,
  0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x03,
  0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x0F,
  0xF0, 0x7F, 0x00, 0x3F, 0xE0, 0xFF, 0xE7, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8,
  0x3F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F,
  0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x7F, 0x3F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x1F, 0x9F, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xF8, 0xFE,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x1F,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x18, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFC,
  0x00, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xF0, 0x3F, 0x00, 0x3F,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0,
  0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0x3F,
  0x81, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x07, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x3F,
  0x80, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0,
  0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0x7E, 0x1F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0x7F, 0x00,
  0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03,
  0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x0F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFE, 0x7E, 0x00, 0x07, 0xF1,
  0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xC0,
  0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x07, 0xF0,
  0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x07, 0xC0, 0x7E, 0xFC, 0x0F, 0x80, 0xFD, 0xF8, 0x1F, 0x01, 0xFB, 0xF0,
  0x3E, 0x03, 0xF7, 0xE0, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0x1F, 0x9F, 0x03,
  0xF0, 0x3F, 0x3E, 0x0F, 0xE0, 0xFC, 0x7C, 0x1F, 0xC1, 0xF8, 0xF8, 0x3F,
  0x83, 0xF1, 0xF0, 0xFF, 0x07, 0xE3, 0xE1, 0xFE, 0x1F, 0x87, 0xC3, 0xFC,
  0x3F, 0x1F, 0x8F, 0xF8, 0x7E, 0x3F, 0x1F, 0xF0, 0xF8, 0x7E, 0x3F, 0xE3,
  0xF0, 0xFC, 0xFB, 0xC7, 0xE1, 0xF9, 0xF7, 0x8F, 0xC3, 0xF3, 0xEF, 0x1F,
  0x07, 0xE7, 0x9E, 0x7E, 0x0F, 0xDF, 0x3C, 0xFC, 0x1F, 0xBE, 0x79, 0xF0,
  0x3F, 0x78, 0xF7, 0xE0, 0x7F, 0xF1, 0xEF, 0xC0, 0xFF, 0xE3, 0xDF, 0x81,
  0xFF, 0x87, 0xBE, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F,
  0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F,
  0x81, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC,
  0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0,
  0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x01, 0xFC, 0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00, 0xFC, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF8,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x3F, 0xC3, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03,
  0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xE0,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF1, 0xFC, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x10, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3E, 0xF0, 0x01, 0xFB, 0xE0, 0x07,
  0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE1, 0xF0, 0x1F, 0x07,
  0xC0, 0xFC, 0x1F, 0x07, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0xFC, 0x03, 0xE3,
  0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0xFC, 0x00, 0xFC, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFE, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7C, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0x7E,
  0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x1F, 0x8F, 0xF0, 0x03, 0xF1, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7E, 0x3F,
  0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xF8, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xDF, 0x81, 0xFF, 0xF3, 0xF0, 0x0F,
  0xF8, 0x7E, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x7F, 0xF0, 0x07, 0xEF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xE3, 0xFE, 0x0F, 0xF8, 0x0F,
  0xE0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF1, 0xFC, 0x00,
  0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xF1,
  0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xF8, 0x03, 0xFC,
  0x7F, 0xE0, 0x7F, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xEF,
  0xFF, 0xE0, 0x7E, 0x7F, 0xFC, 0x0F, 0xC3, 0xFF, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x1F, 0xE1, 0xFE, 0x01, 0xFC,
  0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xF0, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x0F,
  0xC7, 0xE0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x81, 0xFE, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xFF, 0x9F, 0x80, 0x3F,
  0xFF, 0x7E, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE1,
  0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x0F,
  0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC0,
  0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x83, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFE, 0x7E, 0x00, 0x1F, 0xF1, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x07, 0xF0,
  0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x07, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x03, 0x03, 0xF8, 0x00, 0xF0, 0x7F, 0xC0, 0x7F,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x60, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xFC, 0x01, 0xFF, 0xE3, 0xF0, 0x0F,
  0xFF, 0xDF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8,
  0x7F, 0xE0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x03,
  0xF8, 0x7F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC,
  0x1F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x3F, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F,
  0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xDF, 0x80, 0x07, 0xFC, 0x7E, 0x00, 0x03, 0x83, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x40, 0x01, 0xFC, 0x03, 0x80,
  0x0F, 0xE0, 0x1F, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x7E, 0x3F, 0xF8, 0x07, 0xE7, 0xFF, 0xC0, 0x7E, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0x0F, 0xF8, 0x07, 0xF0,
  0xFF, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xF1, 0xF8, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xE3, 0xF8,
  0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0x7F,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0xC7, 0xE0, 0x01,
  0xFC, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xC7, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x81, 0xF8,
  0x03, 0xFE, 0x03, 0xF0, 0x0F, 0xF8, 0x07, 0xE0, 0x3F, 0xE0, 0x0F, 0xC0,
  0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFC, 0x3F,
  0xC0, 0x01, 0xF8, 0xFF, 0x00, 0x03, 0xF3, 0xFC, 0x00, 0x07, 0xEF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0xFE, 0x00,
  0x0F, 0xF9, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F,
  0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x5F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xE0, 0x07, 0xE3, 0xE0, 0xF8, 0x07, 0xEF, 0xF3, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x07, 0xF3, 0xFE, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F,
  0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F,
  0x0F, 0x81, 0xF0, 0x3F, 0x1F, 0x83, 0xF0, 0x3E, 0x1F, 0x83, 0xF0, 0x7E,
  0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E,
  0x3F, 0x03, 0xE0, 0x7E, 0x3F, 0x07, 0xE0, 0x7C, 0x3F, 0x07, 0xE0, 0xFC,
  0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC,
  0x7E, 0x07, 0xC0, 0xFC, 0x7E, 0x0F, 0xC0, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7C, 0x0F, 0xC1, 0xF8,
  0xFC, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x3F, 0xF8, 0x07,
  0xE7, 0xFF, 0xC0, 0x7E, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xE1,
  0xFF, 0x0F, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0xC0,
  0x03, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF1, 0xF8, 0x00, 0x7F,
  0x1F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE3, 0xF0,
  0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xFC, 0x7E,
  0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x01,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x83, 0xFC, 0x0F, 0xE0,
  0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x83, 0xF0, 0x07,
  0xF8, 0x3F, 0x80, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE7, 0xFF, 0x00, 0x1F, 0xBF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC,
  0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0xE0, 0x1F,
  0x9F, 0xFE, 0x00, 0xFE, 0x3F, 0xF0, 0x03, 0xF8, 0x0C, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x83, 0xF0, 0x1F, 0xFE, 0x3E, 0x03, 0xFF, 0xF7, 0xE0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0x07, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0x7F,
  0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0xCF, 0xE0, 0x01,
  0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x8F,
  0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xF0,
  0x7F, 0x81, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0x7E, 0x00, 0x7F, 0xCF, 0xE0, 0x00, 0x60, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x7F, 0xC1, 0xF8, 0x7F, 0xF0, 0x7E, 0x7F, 0xFC, 0x1F, 0xBF,
  0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x78, 0x3F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0x87, 0xF0,
  0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xF8, 0xFF,
  0x00, 0x7F, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x10, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xC0,
  0x03, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0x7E,
  0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F,
  0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01,
  0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x87,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x03,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xBE, 0x03, 0xFF, 0xF7, 0xE0,
  0x1F, 0xFE, 0x7E, 0x00, 0x7F, 0x87, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xF8, 0xFC, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF8, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0xFE, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x7C, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x07, 0xC0, 0x7F, 0xF8, 0x0F, 0x80, 0xFB, 0xF0, 0x3F, 0x03, 0xF7,
  0xE0, 0x7E, 0x07, 0xEF, 0xC0, 0xFC, 0x0F, 0x9F, 0x83, 0xF8, 0x3F, 0x3F,
  0x07, 0xF0, 0x7E, 0x7E, 0x0F, 0xE0, 0xF8, 0xFC, 0x3F, 0xC3, 0xF1, 0xF8,
  0x7F, 0x87, 0xE3, 0xF1, 0xFF, 0x0F, 0x87, 0xE3, 0xDE, 0x3F, 0x0F, 0xC7,
  0xBC, 0x7C, 0x1F, 0x9F, 0x78, 0xF8, 0x3F, 0x3C, 0xF3, 0xF0, 0x7E, 0x79,
  0xE7, 0xC0, 0x7D, 0xE3, 0xCF, 0x80, 0xFB, 0xC7, 0xBF, 0x01, 0xEF, 0x8F,
  0x7C, 0x03, 0xDE, 0x1E, 0xF8, 0x07, 0xBC, 0x3D, 0xF0, 0x0F, 0xF0, 0x7F,
  0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0xFE, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0,
  0x07, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x81, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x3F, 0xC0, 0x03, 0xF8,
  0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x0F, 0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0x7E, 0x00,
  0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x7F, 0x00,
  0x07, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x3F,
  0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x4F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x01, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x3C, 0x7F, 0xFC, 0x00, 0xF9, 0xFF, 0xFE, 0x01, 0xF3,
  0xFF, 0xFE, 0x07, 0xEF, 0xE3, 0xFE, 0x1F, 0x9F, 0x01, 0xFF, 0xFF, 0x3E,
  0x01, 0xFF, 0xFC, 0x78, 0x01, 0xFF, 0xF9, 0x70, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0x00,
};

const GFXglyph RobotoMono_MediumItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 13, 40, 33, 10, -40 },
  { 66, 17, 14, 33, 10, -42 },
  { 96, 33, 40, 33, 0, -40 },
  { 261, 29, 52, 33, 3, -46 },
  { 450, 27, 41, 33, 3, -40 },
  { 589, 31, 42, 33, 1, -41 },
  { 752, 8, 14, 33, 14, -42 },
  { 766, 19, 58, 33, 9, -45 },
  { 904, 19, 58, 33, 4, -45 },
  { 1042, 26, 28, 33, 5, -40 },
  { 1133, 27, 29, 33, 3, -33 },
  { 1231, 11, 16, 33, 5, -6 },
  { 1253, 23, 5, 33, 6, -20 },
  { 1268, 9, 10, 33, 10, -9 },
  { 1280, 28, 43, 33, 3, -40 },
  { 1431, 27, 41, 33, 3, -40 },
  { 1570, 18, 40, 33, 7, -40 },
  { 1660, 29, 40, 33, 0, -40 },
  { 1805, 29, 41, 33, 1, -40 },
  { 1954, 28, 40, 33, 1, -40 },
  { 2094, 29, 41, 33, 3, -40 },
  { 2243, 25, 41, 33, 3, -40 },
  { 2372, 29, 40, 33, 4, -40 },
  { 2517, 29, 41, 33, 2, -40 },
  { 2666, 26, 40, 33, 4, -40 },
  { 2796, 13, 33, 33, 11, -32 },
  { 2850, 16, 42, 33, 8, -32 },
  { 2934, 26, 25, 33, 4, -30 },
  { 3016, 28, 17, 33, 3, -26 },
  { 3076, 27, 26, 33, 2, -30 },
  { 3164, 24, 40, 33, 7, -40 },
  { 3284, 32, 40, 33, 1, -40 },
  { 3444, 31, 40, 33, -2, -40 },
  { 3599, 31, 40, 33, 1, -40 },
  { 3754, 30, 41, 33, 2, -40 },
  { 3908, 30, 40, 33, 1, -40 },
  { 4058, 32, 40, 33, 1, -40 },
  { 4218, 32, 40, 33, 2, -40 },
  { 4378, 30, 41, 33, 2, -40 },
  { 4532, 32, 40, 33, 1, -40 },
  { 4692, 30, 40, 33, 2, -40 },
  { 4842, 31, 41, 33, 2, -40 },
  { 5001, 35, 40, 33, 1, -40 },
  { 5176, 25, 40, 33, 2, -40 },
  { 5301, 33, 40, 33, 1, -40 },
  { 5466, 32, 40, 33, 1, -40 },
  { 5626, 29, 41, 33, 2, -40 },
  { 5775, 31, 40, 33, 2, -40 },
  { 5930, 30, 47, 33, 2, -40 },
  { 6107, 31, 40, 33, 1, -40 },
  { 6262, 30, 41, 33, 2, -40 },
  { 6416, 31, 40, 33, 4, -40 },
  { 6571, 30, 41, 33, 3, -40 },
  { 6725, 30, 40, 33, 5, -40 },
  { 6875, 31, 40, 33, 4, -40 },
  { 7030, 36, 40, 33, -1, -40 },
  { 7210, 31, 40, 33, 5, -40 },
  { 7365, 33, 40, 33, 0, -40 },
  { 7530, 20, 55, 33, 7, -46 },
  { 7668, 14, 43, 33, 10, -40 },
  { 7744, 20, 55, 33, 7, -46 },
  { 7882, 22, 21, 33, 6, -40 },
  { 7940, 25, 5, 33, 0, 0 },
  { 7956, 10, 7, 33, 15, -40 },
  { 7965, 27, 31, 33, 2, -30 },
  { 8070, 28, 43, 33, 1, -42 },
  { 8221, 26, 31, 33, 3, -30 },
  { 8322, 30, 43, 33, 3, -42 },
  { 8484, 27, 31, 33, 3, -30 },
  { 8589, 30, 43, 33, 5, -43 },
  { 8751, 30, 42, 33, 1, -30 },
  { 8909, 28, 42, 33, 1, -42 },
  { 9056, 24, 41, 33, 3, -41 },
  { 9179, 26, 53, 33, 1, -41 },
  { 9352, 31, 42, 33, 1, -42 },
  { 9515, 26, 42, 33, 2, -42 },
  { 9652, 32, 30, 33, -1, -30 },
  { 9772, 28, 30, 33, 1, -30 },
  { 9877, 28, 31, 33, 2, -30 },
  { 9986, 30, 41, 33, -1, -30 },
  { 10140, 28, 41, 33, 3, -30 },
  { 10284, 26, 30, 33, 5, -30 },
  { 10382, 27, 31, 33, 3, -30 },
  { 10487, 25, 38, 33, 5, -37 },
  { 10606, 28, 31, 33, 3, -30 },
  { 10715, 29, 30, 33, 4, -30 },
  { 10824, 31, 30, 33, 3, -30 },
  { 10941, 33, 30, 33, 0, -30 },
  { 11065, 34, 42, 33, 0, -30 },
  { 11244, 30, 30, 33, 1, -30 },
  { 11357, 22, 54, 33, 8, -44 },
  { 11506, 12, 51, 33, 10, -40 },
  { 11583, 22, 54, 33, 5, -44 },
  { 11732, 31, 11, 33, 0, -22 },
};

const GFXfont RobotoMono_MediumItalic56pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic56pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic56pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _ROBOTOMONO_MEDIUMITALIC56PT7B_H_
