#ifndef _ROBOTOMONO_MEDIUMITALIC20PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x37, 0x66, 0x66, 0x68, 0x08, 0xCC, 0xCF, 0x3C, 0xA2, 0x98,
  0x03, 0x60, 0x66, 0x06, 0x40, 0x4C, 0x3F, 0xF0, 0xC8, 0x09, 0x81, 0x98,
  0xFF, 0xCF, 0xFC, 0x32, 0x02, 0x60, 0x66, 0x06, 0x40, 0x03, 0x00, 0x80,
  0x20, 0x7E, 0x3F, 0xCC, 0x33, 0x0C, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x0E,
  0x01, 0xB0, 0x6E, 0x39, 0xFC, 0x3E, 0x06, 0x01, 0x80, 0x78, 0x13, 0x2C,
  0xDB, 0x24, 0xFB, 0x1D, 0x80, 0x40, 0x20, 0x1B, 0x8D, 0xB2, 0x4D, 0xB3,
  0x04, 0x81, 0xE0, 0x0F, 0x83, 0xB0, 0x63, 0x0C, 0xC1, 0xB8, 0x3E, 0x07,
  0x01, 0xF3, 0x76, 0x6C, 0xEF, 0x8F, 0x30, 0xC7, 0xFC, 0x7D, 0xC0, 0x69,
  0x6C, 0x02, 0x1C, 0x70, 0xC3, 0x06, 0x18, 0x30, 0x61, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0x40, 0xC0, 0x81, 0x81, 0x00, 0x10, 0xC1, 0x83, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x61, 0x86, 0x31, 0x8E, 0x30, 0x80,
  0x0C, 0x06, 0x23, 0x3D, 0x77, 0xF8, 0xC0, 0xF0, 0xCC, 0xC6, 0x22, 0x00,
  0x06, 0x03, 0x80, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x70, 0x18, 0x06,
  0x01, 0x80, 0x77, 0x66, 0xC4, 0x7F, 0xFF, 0xDF, 0x80, 0x00, 0xC0, 0x60,
  0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0,
  0x70, 0x18, 0x0C, 0x00, 0x1F, 0x8E, 0xE3, 0x1D, 0x83, 0x61, 0xD8, 0xF6,
  0xFF, 0xE6, 0xF1, 0xB8, 0x6C, 0x19, 0x8C, 0x7F, 0x0F, 0x80, 0x06, 0x7D,
  0xFA, 0x68, 0xC1, 0x83, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x87, 0x00, 0x0F,
  0x8F, 0xF3, 0x0D, 0xC3, 0x00, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F, 0x83, 0xB8, 0xE3, 0x80, 0x70, 0x0C,
  0x03, 0x83, 0xE0, 0x7C, 0x01, 0xC0, 0x19, 0x87, 0x30, 0xC7, 0xF8, 0x7C,
  0x00, 0x01, 0xC0, 0x38, 0x0F, 0x03, 0x60, 0xDC, 0x3B, 0x06, 0x61, 0x8C,
  0x61, 0xBF, 0xFB, 0xFF, 0x01, 0x80, 0x30, 0x06, 0x00, 0x1F, 0xC7, 0xF3,
  0x00, 0xC0, 0x30, 0x1F, 0xC7, 0xF8, 0x06, 0x01, 0x80, 0x6C, 0x1B, 0x8E,
  0x7F, 0x0F, 0x80, 0x07, 0x8F, 0x8E, 0x06, 0x06, 0x03, 0xFB, 0xFF, 0xC3,
  0xC1, 0xE0, 0xF0, 0x7C, 0x67, 0xF1, 0xF0, 0x7F, 0xEF, 0xF8, 0x07, 0x00,
  0xC0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x07,
  0x01, 0xC0, 0x00, 0x1F, 0x8F, 0xF3, 0x1D, 0xC3, 0x71, 0xCC, 0xE1, 0xF1,
  0xFC, 0x63, 0xB0, 0x6C, 0x1B, 0x8E, 0xFF, 0x1F, 0x80, 0x3E, 0x3B, 0xB8,
  0xD8, 0x7C, 0x3E, 0x1F, 0x0D, 0xFE, 0x7F, 0x03, 0x81, 0x83, 0x8F, 0x87,
  0x80, 0x33, 0xDC, 0x00, 0x00, 0x00, 0xE7, 0x38, 0x18, 0xF1, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xC7, 0x18, 0x63, 0x04, 0x00, 0x00, 0x40, 0xE0, 0xF8,
  0xF8, 0x70, 0x3C, 0x03, 0xE0, 0x3C, 0x03, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x00, 0xFF, 0xBF, 0xE0, 0x40, 0x38, 0x1F, 0x01, 0xE0, 0x38, 0x3C, 0xF9,
  0xF0, 0xC0, 0x00, 0x7E, 0xFF, 0xC3, 0x03, 0x07, 0x0E, 0x1C, 0x38, 0x30,
  0x30, 0x00, 0x20, 0x60, 0x60, 0x0F, 0x83, 0x18, 0x81, 0x37, 0xA5, 0x95,
  0xA6, 0xA4, 0x95, 0x92, 0xB2, 0x56, 0xD2, 0x6C, 0x60, 0x0E, 0x40, 0x78,
  0x00, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x6C, 0x0D, 0x83, 0x30, 0x66,
  0x18, 0xE3, 0xFC, 0xFF, 0x98, 0x37, 0x07, 0xC0, 0xC0, 0x1F, 0xC3, 0xFC,
  0xE1, 0x9C, 0x33, 0x06, 0x61, 0xCF, 0xE1, 0xFE, 0x70, 0xCC, 0x1D, 0x83,
  0xB0, 0xE7, 0xF9, 0xFE, 0x00, 0x1F, 0x8F, 0xF7, 0x0D, 0x83, 0x60, 0x38,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x1B, 0x8E, 0x7F, 0x0F, 0x80, 0x1F,
  0x87, 0xF8, 0xE3, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x1B, 0x83, 0x70, 0xEC,
  0x19, 0x87, 0x31, 0xC7, 0xF1, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x1F, 0xE3, 0xFC, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0F,
  0xF9, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x1F,
  0xE3, 0xFC, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x1F,
  0x8F, 0xF7, 0x0D, 0x83, 0x60, 0x38, 0x0C, 0x03, 0x1F, 0xC7, 0xF0, 0x6C,
  0x1B, 0x86, 0x7F, 0x8F, 0x80, 0x18, 0x73, 0x86, 0x30, 0x63, 0x06, 0x30,
  0x63, 0x06, 0x3F, 0xE7, 0xFC, 0x60, 0xC6, 0x0C, 0x60, 0xC6, 0x0C, 0xE1,
  0xCE, 0x18, 0x3F, 0xCF, 0xF0, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x07, 0x01, 0xC0, 0x60, 0xFF, 0x3F, 0xC0, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x33, 0x0E, 0x61,
  0x8F, 0xF0, 0xF8, 0x00, 0x18, 0x78, 0xC7, 0x0E, 0x30, 0x73, 0x03, 0x38,
  0x1B, 0x80, 0xF8, 0x07, 0xE0, 0x7B, 0x03, 0x9C, 0x18, 0xE0, 0xC3, 0x06,
  0x1C, 0x70, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x70, 0x30, 0x18, 0x0F, 0xFF, 0xFC, 0x1C, 0x73, 0xCF, 0x3C, 0xF3,
  0xDE, 0x3D, 0xE3, 0x76, 0x37, 0x67, 0x66, 0x66, 0xC6, 0x4C, 0x60, 0xC6,
  0x0C, 0x60, 0xCC, 0x1C, 0x18, 0x73, 0x86, 0x3C, 0x63, 0xC6, 0x3C, 0x63,
  0x6E, 0x36, 0xE7, 0x6C, 0x72, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0xE1, 0xCE,
  0x18, 0x1F, 0x8F, 0xE7, 0x1D, 0x83, 0x60, 0xF8, 0x3C, 0x0F, 0x03, 0xC1,
  0xF0, 0x6C, 0x1B, 0x8E, 0x7F, 0x0F, 0x80, 0x3F, 0x87, 0xF8, 0xC3, 0x38,
  0x76, 0x0E, 0xC1, 0x98, 0xF3, 0xFC, 0x7C, 0x1C, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x00, 0x1F, 0x8F, 0xE7, 0x0D, 0x83, 0x60, 0xF8, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x7C, 0x1B, 0x8E, 0x7F, 0x0F, 0xC0, 0x38, 0x06, 0x1F,
  0xC1, 0xFE, 0x38, 0x63, 0x86, 0x30, 0x63, 0x06, 0x31, 0xC3, 0xF8, 0x73,
  0x06, 0x38, 0x61, 0x86, 0x18, 0x61, 0xCE, 0x0C, 0x1F, 0x87, 0xF9, 0xC3,
  0x30, 0x77, 0x00, 0x70, 0x0F, 0x80, 0x7C, 0x03, 0x80, 0x3B, 0x07, 0x70,
  0xC7, 0xF8, 0x7C, 0x00, 0xFF, 0xFF, 0xF8, 0x30, 0x0E, 0x01, 0xC0, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x00,
  0x30, 0xEE, 0x1D, 0xC3, 0x30, 0x66, 0x0C, 0xC1, 0x98, 0x77, 0x0E, 0xE1,
  0x98, 0x33, 0x06, 0x71, 0x87, 0xF0, 0x7C, 0x00, 0xC0, 0xF8, 0x3B, 0x86,
  0x71, 0xCE, 0x30, 0xC6, 0x19, 0x83, 0x30, 0x6E, 0x0D, 0x81, 0xF0, 0x3C,
  0x03, 0x80, 0x60, 0x00, 0x66, 0x76, 0x66, 0x6E, 0x66, 0xE6, 0x6E, 0xC7,
  0xEC, 0x7E, 0xC5, 0xF8, 0xD7, 0x8F, 0x78, 0xF7, 0x8E, 0x70, 0xE7, 0x0E,
  0x70, 0x38, 0x78, 0xC3, 0x06, 0x38, 0x3B, 0x80, 0xD8, 0x07, 0xC0, 0x1C,
  0x01, 0xE0, 0x1F, 0x00, 0xDC, 0x0E, 0x60, 0xE3, 0x06, 0x1C, 0x70, 0x60,
  0xE0, 0xFC, 0x39, 0x86, 0x31, 0x87, 0x70, 0x6C, 0x0F, 0x01, 0xE0, 0x18,
  0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x00, 0x3F, 0xF3, 0xFE, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30,
  0x07, 0x00, 0xFF, 0xCF, 0xFC, 0x1F, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38,
  0x38, 0x30, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x78, 0xF8,
  0xCC, 0xCC, 0x66, 0x66, 0x66, 0x33, 0x33, 0x30, 0x1F, 0x06, 0x06, 0x06,
  0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x78, 0xF8, 0x0C, 0x0E, 0x1E, 0x36, 0x36, 0x62, 0xE3, 0xFF, 0xFF,
  0xC0, 0xE3, 0x1E, 0x1F, 0x9C, 0xE0, 0x30, 0x1B, 0xFF, 0x8F, 0x87, 0xC3,
  0x7F, 0x9E, 0xC0, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x3B, 0x0F, 0xF3, 0x9C,
  0xC3, 0x30, 0xDC, 0x37, 0x0D, 0x83, 0x71, 0xDF, 0xEE, 0xF0, 0x0E, 0x1F,
  0xDC, 0x6C, 0x3E, 0x06, 0x03, 0x01, 0x81, 0xE3, 0xBF, 0x8F, 0x80, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0x61, 0xCC, 0x7F, 0x9C, 0xF3, 0x0C, 0xE1, 0x98,
  0x33, 0x06, 0x61, 0xCE, 0x38, 0xFE, 0x1F, 0xC0, 0x0E, 0x0F, 0xE7, 0x19,
  0x86, 0xE1, 0xFF, 0xEC, 0x03, 0x00, 0xE1, 0x1F, 0xE3, 0xE0, 0x07, 0xC3,
  0xD1, 0xC0, 0x60, 0xFF, 0xBF, 0xE3, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x70, 0x1C, 0x06, 0x00, 0x0E, 0x63, 0xFC, 0xE3, 0x98, 0x77, 0x0C,
  0xC1, 0x98, 0x33, 0x06, 0x71, 0xC7, 0xF0, 0xFE, 0x00, 0xC4, 0x39, 0xFE,
  0x0F, 0x80, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x38, 0x6F, 0x8E, 0x31,
  0x86, 0x30, 0xCE, 0x19, 0xC3, 0x30, 0x66, 0x1C, 0xC3, 0xB8, 0x60, 0x02,
  0x03, 0x81, 0xC0, 0x03, 0xE1, 0xF1, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01,
  0x80, 0xC7, 0xFF, 0xFE, 0x00, 0x80, 0x70, 0x18, 0x00, 0x0F, 0x87, 0xE0,
  0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18,
  0x0E, 0x1F, 0x0F, 0x80, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x8E, 0x63,
  0x8C, 0xE1, 0xB8, 0x3E, 0x0F, 0xC1, 0xF8, 0x3B, 0x86, 0x38, 0xC3, 0x38,
  0x70, 0x3F, 0x1F, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06,
  0x03, 0x01, 0x80, 0xC7, 0xFF, 0xFE, 0x3E, 0xCF, 0xFD, 0xD9, 0xB3, 0x36,
  0x66, 0xCC, 0xD9, 0xBE, 0x66, 0xCC, 0xD9, 0x9B, 0x33, 0x00, 0x33, 0x86,
  0xF8, 0xE3, 0x18, 0x63, 0x0C, 0xE1, 0x9C, 0x33, 0x06, 0x61, 0xCC, 0x3B,
  0x86, 0x00, 0x0E, 0x0F, 0xC7, 0x39, 0x86, 0xE1, 0xF0, 0x6C, 0x1B, 0x06,
  0xE3, 0x9F, 0xC3, 0xE0, 0x33, 0x0F, 0xF3, 0x9C, 0xC3, 0x30, 0xDC, 0x37,
  0x0D, 0x83, 0x61, 0xDF, 0xE7, 0xF3, 0x80, 0xE0, 0x30, 0x0C, 0x00, 0x1C,
  0xCF, 0xF7, 0x1D, 0x86, 0xE1, 0xB0, 0x6C, 0x1B, 0x0E, 0xE3, 0x9F, 0xC7,
  0xF0, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x33, 0x9F, 0xDF, 0xEE, 0x06, 0x03,
  0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x00, 0x0E, 0x0F, 0xE7, 0x19, 0x87,
  0x70, 0x0F, 0x80, 0xF8, 0x06, 0xC1, 0xBF, 0xC3, 0xE0, 0x18, 0x0C, 0x3F,
  0xFF, 0xF3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x07, 0xC3, 0xE0,
  0x70, 0xD8, 0x36, 0x1D, 0x87, 0x61, 0x98, 0x6E, 0x1B, 0x86, 0xE3, 0x9F,
  0xC7, 0xB0, 0xC1, 0xF0, 0x6C, 0x3B, 0x0C, 0xE6, 0x19, 0x86, 0xC1, 0xB0,
  0x78, 0x0E, 0x03, 0x00, 0xC4, 0x79, 0x8F, 0x33, 0x66, 0x6D, 0xCD, 0xAF,
  0x35, 0xE7, 0xBC, 0xE7, 0x1C, 0xE3, 0x18, 0x00, 0x30, 0x73, 0x8E, 0x19,
  0xC1, 0xF8, 0x0F, 0x00, 0x60, 0x0F, 0x01, 0xF0, 0x3B, 0x87, 0x18, 0xE1,
  0xC0, 0x70, 0x33, 0x07, 0x30, 0xE3, 0x8C, 0x39, 0xC1, 0x98, 0x1B, 0x81,
  0xB0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x0F, 0x00, 0xE0, 0x00,
  0x3F, 0xE7, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x0F, 0xFB, 0xFF, 0x00, 0x01, 0x07, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18,
  0x30, 0xE0, 0xE0, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x18, 0x08,
  0x33, 0x32, 0x26, 0x66, 0x64, 0x44, 0xCC, 0xC8, 0x88, 0x10, 0x38, 0x0C,
  0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x0C, 0x0F, 0x0E, 0x18, 0x38, 0x30, 0x30,
  0x30, 0x30, 0x60, 0xE0, 0x80, 0x38, 0x0F, 0x8F, 0x1F, 0xE1, 0xE0,
};

const GFXglyph RobotoMono_MediumItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 14, 12, 4, -14 },
  { 8, 6, 5, 12, 4, -15 },
  { 12, 12, 14, 12, 0, -14 },
  { 33, 10, 19, 12, 1, -17 },
  { 57, 10, 14, 12, 1, -14 },
  { 75, 11, 14, 12, 0, -14 },
  { 95, 3, 5, 12, 5, -15 },
  { 97, 7, 21, 12, 3, -16 },
  { 116, 6, 21, 12, 2, -16 },
  { 132, 9, 10, 12, 2, -14 },
  { 144, 10, 11, 12, 1, -12 },
  { 158, 4, 6, 12, 2, -2 },
  { 161, 8, 2, 12, 2, -7 },
  { 163, 3, 3, 12, 4, -3 },
  { 165, 10, 15, 12, 1, -14 },
  { 184, 10, 14, 12, 1, -14 },
  { 202, 7, 14, 12, 2, -14 },
  { 215, 10, 14, 12, 0, -14 },
  { 233, 11, 14, 12, 0, -14 },
  { 253, 11, 14, 12, 0, -14 },
  { 273, 10, 14, 12, 1, -14 },
  { 291, 9, 14, 12, 1, -14 },
  { 307, 11, 14, 12, 1, -14 },
  { 327, 10, 14, 12, 1, -14 },
  { 345, 9, 14, 12, 2, -14 },
  { 361, 5, 11, 12, 4, -11 },
  { 368, 6, 15, 12, 3, -11 },
  { 380, 10, 9, 12, 1, -11 },
  { 392, 10, 6, 12, 1, -9 },
  { 400, 9, 9, 12, 1, -11 },
  { 411, 8, 14, 12, 3, -14 },
  { 425, 11, 14, 12, 1, -14 },
  { 445, 11, 14, 12, -1, -14 },
  { 465, 11, 14, 12, 0, -14 },
  { 485, 10, 14, 12, 1, -14 },
  { 503, 11, 14, 12, 0, -14 },
  { 523, 11, 14, 12, 1, -14 },
  { 543, 11, 14, 12, 1, -14 },
  { 563, 10, 14, 12, 1, -14 },
  { 581, 12, 14, 12, 0, -14 },
  { 602, 10, 14, 12, 1, -14 },
  { 620, 11, 14, 12, 1, -14 },
  { 640, 13, 14, 12, 0, -14 },
  { 663, 9, 14, 12, 1, -14 },
  { 679, 12, 14, 12, 0, -14 },
  { 700, 12, 14, 12, 0, -14 },
  { 721, 10, 14, 12, 1, -14 },
  { 739, 11, 14, 12, 1, -14 },
  { 759, 10, 16, 12, 1, -14 },
  { 779, 12, 14, 12, 0, -14 },
  { 800, 11, 14, 12, 1, -14 },
  { 820, 11, 14, 12, 2, -14 },
  { 840, 11, 14, 12, 1, -14 },
  { 860, 11, 14, 12, 2, -14 },
  { 880, 12, 14, 12, 1, -14 },
  { 901, 13, 14, 12, 0, -14 },
  { 924, 11, 14, 12, 2, -14 },
  { 944, 12, 14, 12, 0, -14 },
  { 965, 8, 19, 12, 2, -16 },
  { 984, 4, 15, 12, 4, -14 },
  { 992, 8, 19, 12, 2, -16 },
  { 1011, 8, 7, 12, 2, -14 },
  { 1018, 9, 2, 12, 0, 0 },
  { 1021, 4, 2, 12, 5, -14 },
  { 1022, 9, 11, 12, 1, -11 },
  { 1035, 10, 15, 12, 0, -15 },
  { 1054, 9, 11, 12, 1, -11 },
  { 1067, 11, 15, 12, 1, -15 },
  { 1088, 10, 11, 12, 1, -11 },
  { 1102, 10, 15, 12, 2, -15 },
  { 1121, 11, 15, 12, 0, -11 },
  { 1142, 11, 15, 12, 0, -15 },
  { 1163, 9, 15, 12, 1, -15 },
  { 1180, 10, 19, 12, 0, -15 },
  { 1204, 11, 15, 12, 0, -15 },
  { 1225, 9, 15, 12, 1, -15 },
  { 1242, 11, 11, 12, 0, -11 },
  { 1258, 11, 11, 12, 0, -11 },
  { 1274, 10, 11, 12, 1, -11 },
  { 1288, 10, 15, 12, 0, -11 },
  { 1307, 10, 15, 12, 1, -11 },
  { 1326, 9, 11, 12, 2, -11 },
  { 1339, 10, 11, 12, 1, -11 },
  { 1353, 9, 13, 12, 2, -13 },
  { 1368, 10, 11, 12, 1, -11 },
  { 1382, 10, 11, 12, 2, -11 },
  { 1396, 11, 11, 12, 1, -11 },
  { 1412, 12, 11, 12, 0, -11 },
  { 1429, 12, 15, 12, 0, -11 },
  { 1452, 11, 11, 12, 0, -11 },
  { 1468, 8, 20, 12, 3, -16 },
  { 1488, 4, 18, 12, 4, -14 },
  { 1497, 8, 20, 12, 2, -16 },
  { 1517, 11, 4, 12, 0, -8 },
};

const GFXfont RobotoMono_MediumItalic20pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic20pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOMONO_MEDIUMITALIC20PT7B_H_
