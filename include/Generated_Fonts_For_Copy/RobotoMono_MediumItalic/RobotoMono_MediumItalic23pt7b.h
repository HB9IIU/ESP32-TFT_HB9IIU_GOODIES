#ifndef _ROBOTOMONO_MEDIUMITALIC23PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x63, 0x8E, 0x38, 0xE3, 0x0C, 0x71, 0xC0, 0x00, 0x01, 0x8E,
  0x38, 0x66, 0xCD, 0x9E, 0x3C, 0xC0, 0x01, 0x98, 0x0C, 0xC0, 0x33, 0x01,
  0x8C, 0x3F, 0xFC, 0xFF, 0xE0, 0xC6, 0x03, 0x30, 0x0C, 0xC0, 0x62, 0x0F,
  0xFF, 0x04, 0x60, 0x31, 0x00, 0xCC, 0x02, 0x30, 0x19, 0x80, 0x01, 0x80,
  0x18, 0x03, 0x80, 0xFE, 0x1F, 0xE3, 0x87, 0x38, 0x73, 0x87, 0x38, 0x01,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xC0, 0x0E, 0xE0, 0xEE, 0x0E, 0x71, 0xC7,
  0xFC, 0x3F, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x0F, 0x81, 0x98, 0x23, 0x3C,
  0x6C, 0x9B, 0x1F, 0x61, 0x98, 0x06, 0x00, 0x80, 0x37, 0x0D, 0xF3, 0x62,
  0x6C, 0x59, 0x98, 0x3B, 0x03, 0xC0, 0x01, 0x80, 0x3E, 0x03, 0xF8, 0x38,
  0xC1, 0xC6, 0x0E, 0x70, 0x37, 0x01, 0xF0, 0x0E, 0x01, 0xF8, 0xDE, 0xCE,
  0xE7, 0x66, 0x1F, 0x30, 0xF1, 0xC7, 0x8F, 0xFC, 0x3F, 0x70, 0x6F, 0x6D,
  0x80, 0x06, 0x1C, 0x70, 0xC3, 0x06, 0x18, 0x30, 0xE1, 0xC3, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x03, 0x06, 0x06, 0x04, 0x00, 0x18, 0x1C,
  0x0C, 0x06, 0x06, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07, 0x06, 0x06, 0x06,
  0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x30, 0x70, 0xE0, 0x80, 0x06, 0x00, 0xC0,
  0x18, 0x33, 0x3F, 0xFE, 0x3F, 0x07, 0x81, 0xF0, 0x33, 0x0C, 0x70, 0x84,
  0x00, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x61, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0E, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x39, 0xCC, 0x67, 0x33, 0x00, 0xFF,
  0xFF, 0xC0, 0x4F, 0xFE, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x30, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xFC, 0x1F, 0xE3, 0x86,
  0x30, 0x67, 0x06, 0x70, 0xE7, 0x3E, 0x67, 0x66, 0xCE, 0x78, 0xEF, 0x0E,
  0xE0, 0xC6, 0x1C, 0x71, 0xC7, 0xF8, 0x3F, 0x00, 0x06, 0x7F, 0xFF, 0x78,
  0xE1, 0x83, 0x0E, 0x1C, 0x38, 0x70, 0xC1, 0x87, 0x0E, 0x1C, 0x01, 0x00,
  0xFE, 0x1F, 0xE3, 0x87, 0x38, 0x73, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFE, 0xFF, 0xE0,
  0x03, 0x03, 0xF8, 0xFF, 0x98, 0x77, 0x06, 0x00, 0xC0, 0x38, 0x1E, 0x0F,
  0x81, 0xF0, 0x07, 0x00, 0x60, 0x0D, 0x83, 0xB8, 0xF7, 0xFC, 0x3E, 0x00,
  0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0x60, 0x6E, 0x0C, 0xE1, 0x8E,
  0x38, 0xC7, 0x0C, 0x7F, 0xFF, 0xFF, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38,
  0x1F, 0xF1, 0xFF, 0x18, 0x01, 0x80, 0x38, 0x03, 0x70, 0x3F, 0xC7, 0xBC,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0xE0, 0xC6, 0x1C, 0x7F, 0x83, 0xF0,
  0x03, 0xC1, 0xF8, 0x78, 0x1C, 0x03, 0x00, 0xEE, 0x1B, 0xF3, 0xCE, 0xE0,
  0xDC, 0x1F, 0x83, 0xF0, 0x6E, 0x1C, 0xE3, 0x9F, 0xE1, 0xF8, 0xFF, 0xFF,
  0xFC, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x00, 0x03, 0x00, 0xFC, 0x1F,
  0xE3, 0x86, 0x38, 0x73, 0x06, 0x38, 0xE3, 0xDC, 0x1F, 0x83, 0xFC, 0x70,
  0xCE, 0x0C, 0xE0, 0xEE, 0x0C, 0xE1, 0xC7, 0xF8, 0x3F, 0x00, 0x06, 0x0F,
  0xE7, 0xF9, 0xC7, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xFD, 0xF7, 0xF8,
  0x66, 0x03, 0x81, 0xC1, 0xE1, 0xF0, 0x70, 0x00, 0x10, 0xF3, 0xCE, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x1C, 0xF1, 0xC0, 0x04, 0x3C, 0x78, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x86, 0x0C, 0x38, 0x61, 0x80, 0x00,
  0xC0, 0xF1, 0xF9, 0xF0, 0xF0, 0x3C, 0x07, 0xC0, 0x7E, 0x07, 0x80, 0x60,
  0x7F, 0xF7, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x30,
  0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x1E, 0x07, 0xC7, 0xE7, 0xF0, 0xF0, 0x18,
  0x00, 0x0C, 0x0F, 0xE7, 0xFB, 0x87, 0xE1, 0xC0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x70, 0x00, 0x07,
  0xC1, 0xC6, 0x30, 0x32, 0x39, 0x6F, 0x94, 0xC9, 0xD9, 0x9D, 0x99, 0x99,
  0x39, 0x12, 0x9B, 0x29, 0xDC, 0xC8, 0x8C, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x36, 0x03, 0xB0, 0x1D, 0xC1, 0xCE,
  0x0E, 0x70, 0x61, 0x87, 0xFC, 0x3F, 0xE3, 0x83, 0x18, 0x1D, 0xC0, 0xFC,
  0x07, 0x1F, 0xE0, 0xFF, 0x86, 0x0E, 0x30, 0x73, 0x83, 0x9C, 0x1C, 0xE3,
  0xC7, 0xF8, 0x3F, 0xE1, 0x83, 0x9C, 0x0C, 0xE0, 0x67, 0x07, 0x38, 0x71,
  0xFF, 0x9F, 0xF0, 0x03, 0x00, 0xFC, 0x1F, 0xE3, 0x87, 0x70, 0x77, 0x03,
  0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xEE, 0x0E,
  0x61, 0xC7, 0xF8, 0x3F, 0x00, 0x1F, 0xC0, 0xFF, 0x06, 0x1C, 0x70, 0x63,
  0x83, 0x9C, 0x1C, 0xE0, 0xE6, 0x07, 0x30, 0x3B, 0x81, 0x9C, 0x1C, 0xE0,
  0xE7, 0x0E, 0x31, 0xE1, 0xFE, 0x1F, 0xC0, 0x3F, 0xF9, 0xFF, 0x8E, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0x00, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0x1F, 0xF8, 0x3F, 0xF9, 0xFF,
  0x8E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xFC, 0x7F, 0xC3,
  0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0x03,
  0x00, 0xFC, 0x1F, 0xE3, 0x87, 0x70, 0x77, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x1E, 0x3E, 0xE3, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0x71, 0xE7, 0xFC, 0x3F,
  0x00, 0x1C, 0x1C, 0x60, 0x61, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xE3,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF1, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x60, 0x61,
  0x81, 0x86, 0x0E, 0x38, 0x38, 0x1F, 0xF3, 0xFF, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0xFF, 0xCF, 0xF8, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xEC, 0x0C, 0xE1,
  0xCE, 0x3C, 0x7F, 0x83, 0xE0, 0x1C, 0x1E, 0x38, 0x70, 0x61, 0xC0, 0xC7,
  0x03, 0x9C, 0x07, 0x70, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x01,
  0xC7, 0x03, 0x8E, 0x07, 0x0E, 0x0E, 0x1C, 0x18, 0x18, 0x70, 0x38, 0x38,
  0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06,
  0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0x1C, 0x3C, 0x78, 0xE1, 0xE7,
  0x8F, 0x9E, 0x3E, 0xD8, 0xFB, 0xE3, 0x7B, 0x8D, 0xEC, 0x37, 0x31, 0xCC,
  0xC7, 0x27, 0x1C, 0x1C, 0x60, 0x71, 0x81, 0x86, 0x06, 0x38, 0x38, 0x1C,
  0x1C, 0x70, 0x61, 0xC3, 0x8F, 0x8E, 0x3E, 0x38, 0xF8, 0xE3, 0xF3, 0x0C,
  0xCC, 0x33, 0x71, 0xCD, 0xC7, 0x1F, 0x1C, 0x78, 0x71, 0xE1, 0x87, 0x86,
  0x0E, 0x38, 0x38, 0x03, 0x00, 0xFC, 0x1F, 0xE3, 0x86, 0x70, 0x77, 0x07,
  0x60, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0xE0, 0xEE, 0x0C,
  0x71, 0xC7, 0xF8, 0x3F, 0x00, 0x3F, 0xE3, 0xFF, 0x38, 0x73, 0x03, 0x30,
  0x37, 0x03, 0x70, 0x77, 0x1E, 0x7F, 0xC7, 0xF0, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x00, 0xFC, 0x1F, 0xE3, 0x86, 0x70,
  0x77, 0x07, 0x60, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x06, 0xE0,
  0xEE, 0x0C, 0x71, 0xC7, 0xF8, 0x3F, 0x80, 0x1C, 0x00, 0xE0, 0x08, 0x1F,
  0xE0, 0xFF, 0x86, 0x0E, 0x30, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0xFE,
  0x3F, 0xE1, 0xFE, 0x1C, 0x70, 0xE1, 0x87, 0x0E, 0x38, 0x71, 0x83, 0x9C,
  0x0E, 0x03, 0x00, 0xFE, 0x3F, 0xE3, 0x87, 0x70, 0x37, 0x00, 0x38, 0x03,
  0xC0, 0x1F, 0x80, 0x7C, 0x01, 0xE0, 0x0E, 0xC0, 0x6E, 0x0E, 0xE1, 0xE7,
  0xFC, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0x81, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x39, 0x81, 0x8C, 0x0C, 0xE0, 0xE7,
  0x07, 0x38, 0x39, 0xC1, 0x8C, 0x0C, 0x60, 0xE7, 0x07, 0x38, 0x39, 0xC1,
  0xCE, 0x1C, 0x38, 0xE1, 0xFE, 0x07, 0xE0, 0xE0, 0x7E, 0x07, 0xE0, 0xE6,
  0x0E, 0x61, 0xC7, 0x1C, 0x71, 0x87, 0x38, 0x73, 0x07, 0x70, 0x36, 0x03,
  0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0xC6, 0x3E, 0x31, 0xB3, 0x9D,
  0x9C, 0xCC, 0xE6, 0x6F, 0x33, 0x7B, 0x9B, 0xD8, 0xF6, 0xC7, 0xBE, 0x3D,
  0xE1, 0xCF, 0x0E, 0x78, 0x73, 0xC3, 0x9C, 0x18, 0xE0, 0x1E, 0x0F, 0x0E,
  0x1C, 0x0E, 0x38, 0x07, 0x38, 0x07, 0x70, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0x70, 0x38,
  0x70, 0x38, 0x70, 0xF0, 0x38, 0xE0, 0x7B, 0x03, 0x9C, 0x38, 0xE3, 0x83,
  0x1C, 0x19, 0xC0, 0xEC, 0x03, 0xE0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x0B, 0xFF, 0x9F, 0xFC, 0x1F, 0x1F, 0x1C,
  0x18, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70, 0x70,
  0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xF8, 0xF8, 0xE1, 0x86, 0x18, 0x61,
  0xC7, 0x0C, 0x30, 0xC3, 0x8E, 0x18, 0x61, 0x86, 0x1C, 0x1F, 0x1F, 0x07,
  0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x18, 0x18, 0x38, 0x38, 0x38, 0xF8, 0xF0, 0x07, 0x07, 0x83, 0xC3,
  0x61, 0xB1, 0x8C, 0xC7, 0xC3, 0xFF, 0xFF, 0xF0, 0xE6, 0x30, 0x1F, 0x87,
  0xF9, 0xC3, 0x80, 0x70, 0x0E, 0x7F, 0x9C, 0x37, 0x0E, 0xE1, 0xDC, 0x7B,
  0xFF, 0x3E, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x6F, 0x9F,
  0xF3, 0x87, 0x70, 0xEC, 0x1D, 0x83, 0xB0, 0x7E, 0x0F, 0xC1, 0xB8, 0x77,
  0xFC, 0xDF, 0x00, 0x1F, 0x87, 0xF9, 0xC3, 0xB8, 0x76, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0xCE, 0x39, 0xFE, 0x1F, 0x80, 0x00, 0x30, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x71, 0xF6, 0x3F, 0xE7, 0x0E, 0x70, 0xE6, 0x0E, 0xE0,
  0xEE, 0x0C, 0xE0, 0xCE, 0x1C, 0x73, 0xC7, 0xFC, 0x3D, 0xC0, 0x1F, 0x87,
  0xF9, 0xE3, 0xB8, 0x36, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x0E, 0x19,
  0xFF, 0x0F, 0x80, 0x01, 0xF0, 0x3F, 0x07, 0xB0, 0xE0, 0x0C, 0x00, 0xC0,
  0xFF, 0xEF, 0xFC, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x0F, 0xB8, 0xFF, 0x8E, 0x1C, 0x70,
  0xE3, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x0C, 0x70, 0x61, 0xC7, 0x0F, 0xF8,
  0x3F, 0xC0, 0x0E, 0x20, 0xE3, 0xCF, 0x0F, 0xF0, 0x1E, 0x00, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0xBE, 0x3F, 0xF3, 0x87, 0x38, 0x73,
  0x07, 0x30, 0x77, 0x07, 0x70, 0x77, 0x06, 0x70, 0x66, 0x0E, 0xE0, 0xE0,
  0x01, 0x80, 0xE0, 0x38, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE3, 0xFF, 0xFF, 0xC0, 0x00, 0x40,
  0x1C, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x0E, 0x01, 0xC0, 0x30,
  0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C,
  0x07, 0x07, 0xE1, 0xF0, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30,
  0x03, 0x0F, 0x71, 0xC7, 0x38, 0x77, 0x06, 0xE0, 0x7E, 0x0F, 0xE0, 0xF7,
  0x0E, 0x30, 0xE3, 0x8C, 0x1C, 0xC1, 0xC0, 0x1F, 0x87, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03,
  0x80, 0xE3, 0xFF, 0xFF, 0xC0, 0x3F, 0x71, 0xFF, 0xDC, 0xCE, 0xE6, 0x76,
  0x33, 0xB3, 0x99, 0x9C, 0xCC, 0xC6, 0xE6, 0x77, 0x33, 0xB1, 0x9D, 0x9C,
  0xC0, 0x3B, 0xE3, 0xFF, 0x38, 0x73, 0x87, 0x30, 0x73, 0x07, 0x70, 0x77,
  0x06, 0x70, 0x67, 0x06, 0x60, 0xEE, 0x0E, 0x1F, 0x87, 0xF9, 0xC3, 0xB8,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xCC, 0x39, 0xFE, 0x1F, 0x80,
  0x1F, 0xE3, 0xFE, 0x38, 0x73, 0x87, 0x30, 0x73, 0x07, 0x70, 0x77, 0x07,
  0x70, 0xE7, 0x0E, 0x7F, 0xC6, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x00, 0x1F, 0x73, 0xFE, 0x70, 0xE7, 0x0E, 0x60, 0xEE, 0x0E, 0xE0,
  0xCE, 0x0C, 0xE1, 0xC7, 0x1C, 0x7F, 0xC3, 0xDC, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x3B, 0xE6, 0xF8, 0xF0, 0x9C, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x00, 0x1F, 0xC7, 0xFD,
  0xC3, 0xB8, 0x17, 0x80, 0x7E, 0x03, 0xF0, 0x0E, 0xE0, 0xDC, 0x39, 0xFF,
  0x1F, 0x80, 0x0C, 0x07, 0x01, 0xC3, 0xFF, 0xFF, 0xC6, 0x01, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xE1, 0xF8, 0x30, 0x77, 0x06,
  0x70, 0x67, 0x0E, 0x70, 0xE6, 0x0E, 0x60, 0xEE, 0x0C, 0xE0, 0xC6, 0x1C,
  0x7F, 0xC3, 0xDC, 0xC0, 0xFC, 0x1B, 0x87, 0x30, 0xC6, 0x38, 0xC6, 0x1D,
  0xC1, 0xB0, 0x3E, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0xE6, 0x3F, 0x31, 0xB9,
  0xCD, 0xDE, 0xEE, 0xF6, 0x75, 0xB3, 0xEF, 0x1B, 0x78, 0xF3, 0xC7, 0x9C,
  0x18, 0xE0, 0xC7, 0x00, 0x38, 0x3C, 0x71, 0xC0, 0xCE, 0x03, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x1D, 0xC0, 0xE7, 0x07, 0x0E, 0x38,
  0x1C, 0x38, 0x1C, 0xE0, 0xE3, 0x83, 0x06, 0x1C, 0x18, 0xE0, 0x73, 0x81,
  0xDC, 0x03, 0x60, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1F,
  0xF9, 0xFF, 0xC0, 0x01, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x18,
  0x0C, 0x0C, 0x1C, 0x1E, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0E,
  0x03, 0x01, 0xC0, 0x60, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x31, 0x88, 0xC6,
  0x31, 0x8C, 0x42, 0x31, 0x8C, 0x00, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x60,
  0x70, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0xE0, 0xF0, 0xE0, 0xE0, 0x70, 0x30,
  0x18, 0x0C, 0x0E, 0x06, 0x0F, 0x06, 0x00, 0x3C, 0x13, 0xF0, 0xF9, 0xFD,
  0x87, 0xE0, 0x0C, 0x00,
};

const GFXglyph RobotoMono_MediumItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 16, 14, 4, -16 },
  { 13, 7, 5, 14, 4, -17 },
  { 18, 14, 16, 14, 0, -16 },
  { 46, 12, 21, 14, 1, -19 },
  { 78, 11, 17, 14, 1, -17 },
  { 102, 13, 17, 14, 0, -17 },
  { 130, 3, 6, 14, 6, -17 },
  { 133, 7, 23, 14, 4, -18 },
  { 154, 8, 23, 14, 2, -18 },
  { 177, 11, 11, 14, 2, -16 },
  { 193, 11, 12, 14, 1, -14 },
  { 210, 5, 7, 14, 2, -3 },
  { 215, 9, 2, 14, 3, -8 },
  { 218, 4, 4, 14, 4, -4 },
  { 220, 12, 17, 14, 1, -16 },
  { 246, 12, 17, 14, 1, -17 },
  { 272, 7, 16, 14, 3, -16 },
  { 286, 12, 17, 14, 0, -17 },
  { 312, 11, 17, 14, 1, -17 },
  { 336, 12, 16, 14, 0, -16 },
  { 360, 12, 16, 14, 1, -16 },
  { 384, 11, 16, 14, 1, -16 },
  { 406, 11, 16, 14, 2, -16 },
  { 428, 12, 17, 14, 1, -17 },
  { 454, 10, 17, 14, 2, -17 },
  { 476, 6, 14, 14, 4, -14 },
  { 487, 7, 18, 14, 3, -14 },
  { 503, 10, 10, 14, 2, -12 },
  { 516, 12, 7, 14, 1, -11 },
  { 527, 11, 10, 14, 1, -12 },
  { 541, 10, 17, 14, 3, -17 },
  { 563, 12, 16, 14, 1, -16 },
  { 587, 13, 16, 14, -1, -16 },
  { 613, 13, 16, 14, 0, -16 },
  { 639, 12, 17, 14, 1, -17 },
  { 665, 13, 16, 14, 0, -16 },
  { 691, 13, 16, 14, 1, -16 },
  { 717, 13, 16, 14, 1, -16 },
  { 743, 12, 17, 14, 1, -17 },
  { 769, 14, 16, 14, 0, -16 },
  { 797, 12, 16, 14, 1, -16 },
  { 821, 12, 16, 14, 1, -16 },
  { 845, 15, 16, 14, 0, -16 },
  { 875, 10, 16, 14, 1, -16 },
  { 895, 14, 16, 14, 0, -16 },
  { 923, 14, 16, 14, 0, -16 },
  { 951, 12, 17, 14, 1, -17 },
  { 977, 12, 16, 14, 1, -16 },
  { 1001, 12, 20, 14, 1, -17 },
  { 1031, 13, 16, 14, 0, -16 },
  { 1057, 12, 17, 14, 1, -17 },
  { 1083, 13, 16, 14, 2, -16 },
  { 1109, 13, 16, 14, 1, -16 },
  { 1135, 12, 16, 14, 2, -16 },
  { 1159, 13, 16, 14, 2, -16 },
  { 1185, 16, 16, 14, -1, -16 },
  { 1217, 13, 16, 14, 2, -16 },
  { 1243, 13, 16, 14, 0, -16 },
  { 1269, 8, 23, 14, 3, -19 },
  { 1292, 6, 17, 14, 4, -16 },
  { 1305, 8, 23, 14, 3, -19 },
  { 1328, 9, 8, 14, 2, -16 },
  { 1337, 10, 2, 14, 0, 0 },
  { 1340, 4, 3, 14, 6, -17 },
  { 1342, 11, 12, 14, 1, -12 },
  { 1359, 11, 17, 14, 1, -17 },
  { 1383, 11, 12, 14, 1, -12 },
  { 1400, 12, 17, 14, 1, -17 },
  { 1426, 11, 12, 14, 1, -12 },
  { 1443, 12, 18, 14, 2, -18 },
  { 1470, 13, 17, 14, 0, -12 },
  { 1498, 12, 17, 14, 0, -17 },
  { 1524, 10, 17, 14, 1, -17 },
  { 1546, 11, 22, 14, 0, -17 },
  { 1577, 12, 17, 14, 1, -17 },
  { 1603, 10, 17, 14, 1, -17 },
  { 1625, 13, 12, 14, 0, -12 },
  { 1645, 12, 12, 14, 0, -12 },
  { 1663, 11, 12, 14, 1, -12 },
  { 1680, 12, 17, 14, 0, -12 },
  { 1706, 12, 17, 14, 1, -12 },
  { 1732, 11, 12, 14, 2, -12 },
  { 1749, 11, 12, 14, 1, -12 },
  { 1766, 10, 15, 14, 2, -15 },
  { 1785, 12, 12, 14, 1, -12 },
  { 1803, 11, 12, 14, 2, -12 },
  { 1820, 13, 12, 14, 1, -12 },
  { 1840, 14, 12, 14, 0, -12 },
  { 1861, 14, 17, 14, 0, -12 },
  { 1891, 13, 12, 14, 0, -12 },
  { 1911, 9, 22, 14, 3, -18 },
  { 1936, 5, 21, 14, 4, -16 },
  { 1950, 9, 22, 14, 2, -18 },
  { 1975, 13, 5, 14, 0, -9 },
};

const GFXfont RobotoMono_MediumItalic23pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic23pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOMONO_MEDIUMITALIC23PT7B_H_
