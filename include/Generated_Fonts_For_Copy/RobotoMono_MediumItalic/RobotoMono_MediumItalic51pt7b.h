#ifndef _ROBOTOMONO_MEDIUMITALIC51PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C,
  0x1F, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x7F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x07, 0xC1, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x1E, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78,
  0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0x87, 0xF8, 0x1F, 0x80,
  0xFE, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3E,
  0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x1F, 0xF3,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xC1,
  0xE0, 0x41, 0xE0, 0xF0, 0x79, 0xE0, 0x78, 0x7C, 0xF0, 0x3C, 0x3C, 0x78,
  0x1E, 0x3C, 0x3C, 0x1E, 0x3C, 0x1F, 0x0F, 0x1E, 0x07, 0xDF, 0x9E, 0x03,
  0xFF, 0x9E, 0x00, 0xFF, 0x8F, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC7, 0xF0, 0x03, 0xCF, 0xFC, 0x03, 0xE7,
  0xFF, 0x01, 0xE7, 0xCF, 0x81, 0xE7, 0xC3, 0xC1, 0xE3, 0xC1, 0xF0, 0xF1,
  0xE0, 0xF8, 0xF0, 0xF0, 0x78, 0xF0, 0x78, 0x3C, 0x18, 0x3C, 0x1E, 0x00,
  0x1E, 0x0F, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x02, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xC7, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xF0,
  0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xC0,
  0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x3F, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x01, 0xF1, 0xFF, 0xF8, 0x3E, 0x3F,
  0x9F, 0x83, 0xE3, 0xF0, 0xFC, 0x3E, 0x7F, 0x0F, 0xC7, 0xE7, 0xE0, 0x7E,
  0x7C, 0xFC, 0x07, 0xFF, 0xCF, 0xC0, 0x3F, 0xF8, 0xFC, 0x03, 0xFF, 0x8F,
  0xC0, 0x1F, 0xF0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xE0, 0x7F, 0x8F,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xF9, 0xF8,
  0x07, 0xFE, 0x1F, 0xC0, 0x06, 0x00, 0x00, 0x3E, 0x78, 0xF3, 0xE7, 0xCF,
  0x9E, 0x3C, 0x78, 0xF3, 0xE7, 0x8F, 0x00, 0x00, 0x00, 0x80, 0x01, 0x80,
  0x01, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x40,
  0x1C, 0x00, 0x70, 0x3C, 0x0E, 0x7C, 0x3C, 0x3E, 0xFF, 0x3C, 0xFE, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xCF, 0x00, 0x0F,
  0x8F, 0x80, 0x1F, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3C,
  0x03, 0xC0, 0x18, 0x03, 0x80, 0x08, 0x02, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8,
  0xFC, 0x3E, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x3F, 0x83, 0xF0, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0xC7, 0xC0, 0x07, 0xE7, 0xE0, 0x03,
  0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x03, 0xFC, 0xFC, 0x03, 0xFE, 0x7C, 0x07,
  0xFE, 0x7E, 0x07, 0xFF, 0x3F, 0x0F, 0xFF, 0x9F, 0x8F, 0xCF, 0xCF, 0xDF,
  0xC7, 0xE7, 0xFF, 0x83, 0xF3, 0xFF, 0x81, 0xF3, 0xFF, 0x01, 0xF9, 0xFF,
  0x00, 0xFC, 0xFF, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x1F,
  0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0,
  0xFC, 0x07, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0xE1, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF,
  0xFC, 0xFF, 0x7E, 0x7C, 0x3E, 0x38, 0x1F, 0x20, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xF8, 0x7F, 0x81,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x81, 0xFE, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x0F,
  0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0xC7, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xEF, 0xC0, 0x01, 0xF3, 0xF0,
  0x00, 0xFC, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x87,
  0xE0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x00, 0xFC,
  0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x07,
  0xE0, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x8F, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0xF0, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x07,
  0xE3, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xE0,
  0x3F, 0x81, 0xFE, 0x3F, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x8F,
  0xC0, 0x1F, 0x3F, 0xF0, 0x3F, 0x7F, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x7F, 0xC0, 0xFE, 0x7F, 0x80, 0x7E, 0x7F, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0xFE, 0x7E, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0xC7, 0xF8, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0x80, 0x7F,
  0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x3E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F,
  0xC3, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC7, 0xC0,
  0x03, 0xF3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x87,
  0xE0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0xC7, 0xFC, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFC, 0x3F, 0x8F, 0xE0, 0x3F, 0x1F, 0x80,
  0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFD, 0xF8, 0x07, 0xF3, 0xF8, 0x1F, 0xE3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x07, 0xFE, 0x7C, 0x03,
  0xF9, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0xFE, 0x0F, 0xE1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xE0,
  0x7C, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x7E, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7E, 0x01, 0x00, 0x00, 0x38,
  0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0x7E, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x07,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0x0F, 0xF7, 0xF0, 0x1F, 0xDF, 0x80,
  0x3F, 0x7E, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x3F, 0x80,
  0x0F, 0x80, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0x80, 0xF0,
  0x18, 0x1E, 0x07, 0x87, 0xF8, 0x70, 0x78, 0x7F, 0xE3, 0x87, 0x87, 0xFF,
  0x1C, 0x3C, 0x7C, 0x38, 0xE3, 0xC3, 0xC3, 0xC7, 0x1E, 0x3C, 0x1C, 0x38,
  0xE1, 0xE0, 0xE1, 0xCF, 0x1E, 0x0F, 0x0E, 0x78, 0xF0, 0x78, 0x73, 0xC7,
  0x83, 0x83, 0x9C, 0x38, 0x1C, 0x3C, 0xE3, 0xC1, 0xE1, 0xCF, 0x1E, 0x0F,
  0x0E, 0x78, 0xF0, 0x70, 0x73, 0xC7, 0x83, 0x87, 0x1E, 0x3C, 0x3C, 0x38,
  0xF1, 0xF7, 0xE3, 0x87, 0x87, 0xFF, 0xFC, 0x1C, 0x3F, 0xBF, 0xC0, 0xE0,
  0xF8, 0xFC, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x08, 0x00, 0x1F, 0xC7, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0xFC, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x8F,
  0x80, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0x7E, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0x80,
  0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xC0,
  0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0x07,
  0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7E,
  0x00, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0x3F, 0xC7, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7E,
  0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00,
  0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1,
  0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xE0,
  0x1F, 0xE0, 0x7E, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xF8, 0x7F, 0x81, 0xFC, 0x03,
  0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xFF, 0xE7, 0xC0, 0x7F, 0xF9,
  0xF8, 0x0F, 0xFF, 0x3F, 0x01, 0xFF, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00,
  0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC1, 0xFC, 0x03,
  0xF8, 0x3F, 0xE7, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xF0, 0x7E, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xF0,
  0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x03,
  0xF0, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xC0,
  0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x07,
  0xF8, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0x03, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xE0, 0x07,
  0xF8, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x3F,
  0xC0, 0x07, 0xE0, 0x7F, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xC0, 0xFE,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x0F, 0xBF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xF7, 0xE0, 0x00, 0x3F, 0xE7, 0xE0,
  0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x1F,
  0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x0F,
  0xFC, 0x3F, 0xF0, 0x3E, 0xF1, 0xF7, 0xC0, 0xFB, 0xC7, 0xFF, 0x03, 0xEF,
  0x1E, 0xFC, 0x0F, 0xBC, 0xFB, 0xE0, 0x3E, 0xFB, 0xCF, 0x81, 0xF9, 0xFF,
  0x3E, 0x07, 0xE7, 0xF8, 0xF8, 0x1F, 0x1F, 0xE7, 0xE0, 0x7C, 0x7F, 0x1F,
  0x81, 0xF1, 0xFC, 0x7C, 0x07, 0xC7, 0xE1, 0xF0, 0x3F, 0x1F, 0x87, 0xC0,
  0xFC, 0x7C, 0x3F, 0x03, 0xE1, 0xF0, 0xFC, 0x0F, 0x83, 0x83, 0xE0, 0x3E,
  0x0E, 0x0F, 0x81, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01,
  0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC,
  0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xF8,
  0x1F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xF0, 0x07, 0xE0, 0x7F,
  0x80, 0x3F, 0x03, 0xFC, 0x01, 0xF8, 0x1F, 0xF0, 0x0F, 0xC1, 0xFF, 0x80,
  0x7E, 0x0F, 0xFC, 0x03, 0xF0, 0x7F, 0xE0, 0x3F, 0x03, 0xFF, 0x81, 0xF8,
  0x1F, 0xFC, 0x0F, 0xC0, 0xFF, 0xE0, 0x7E, 0x0F, 0xCF, 0x83, 0xF0, 0x7E,
  0x7C, 0x1F, 0x03, 0xF3, 0xE1, 0xF8, 0x1F, 0x9F, 0x0F, 0xC0, 0xFC, 0x7C,
  0x7E, 0x07, 0xE3, 0xE3, 0xF0, 0x7E, 0x1F, 0x1F, 0x83, 0xF0, 0x7D, 0xF8,
  0x1F, 0x83, 0xEF, 0xC0, 0xFC, 0x1F, 0x7E, 0x07, 0xE0, 0xFB, 0xF0, 0x3E,
  0x03, 0xFF, 0x83, 0xF0, 0x1F, 0xFC, 0x1F, 0x80, 0xFF, 0xC0, 0xFC, 0x03,
  0xFE, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0x00, 0xFF, 0x81, 0xF0, 0x07, 0xFC,
  0x1F, 0x80, 0x1F, 0xE0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x3F,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xE3,
  0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xFB, 0xF0, 0x00,
  0x3E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xF8,
  0x03, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x01,
  0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8,
  0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xF8, 0xFF, 0x01,
  0xFC, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x00,
  0xF8, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E,
  0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7C,
  0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x01,
  0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7E,
  0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x01,
  0xFE, 0x1F, 0x80, 0x3F, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0x01,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFE, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x3F,
  0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xC3, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xE1, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x07,
  0xF0, 0x0F, 0xF0, 0x3F, 0xE7, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xC1, 0xF8, 0x00, 0xFC,
  0x1F, 0x80, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0x83, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF0, 0x7E,
  0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFB, 0xF0,
  0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x7E,
  0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0x80,
  0x7C, 0x07, 0xF0, 0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x07,
  0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03,
  0xF0, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF9, 0xF8,
  0x00, 0x1F, 0xBF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0x80, 0xFB, 0xF0, 0x7C,
  0x0F, 0xDF, 0x83, 0xE0, 0x7E, 0xFC, 0x1F, 0x03, 0xE7, 0xE0, 0xF8, 0x1F,
  0x3F, 0x0F, 0xC1, 0xF9, 0xF0, 0x7E, 0x0F, 0x8F, 0x83, 0xF0, 0x7C, 0x7C,
  0x3F, 0x87, 0xE3, 0xE1, 0xFC, 0x3F, 0x1F, 0x0F, 0xE1, 0xF0, 0xF8, 0xFF,
  0x0F, 0x87, 0xC7, 0xF8, 0xFC, 0x3E, 0x3F, 0xC7, 0xC1, 0xF3, 0xFE, 0x3E,
  0x0F, 0x9E, 0xF1, 0xF0, 0x7C, 0xF7, 0x9F, 0x83, 0xEF, 0xBC, 0xF8, 0x1F,
  0x79, 0xE7, 0xC0, 0xFB, 0xCF, 0x3E, 0x07, 0xDE, 0x7B, 0xE0, 0x3F, 0xF3,
  0xDF, 0x01, 0xFF, 0x1E, 0xF8, 0x0F, 0xF8, 0xFF, 0xC0, 0x7F, 0xC7, 0xFC,
  0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07,
  0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xC0,
  0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x01, 0xF8,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFE, 0x7E, 0x00,
  0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x07,
  0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0,
  0x0F, 0xE0, 0x1F, 0x00, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x00,
  0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0x7B, 0xC0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x3E, 0x1E, 0x07,
  0xC3, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x1E, 0x7C,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0x80, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x3E,
  0x1F, 0x87, 0xC1, 0xF0, 0x78, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE,
  0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x3F, 0xF0, 0x7E, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC,
  0xFC, 0x03, 0xFC, 0xFF, 0x0F, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFC, 0xFC, 0x0F, 0xF8, 0xFC, 0x00, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x1F, 0xE0,
  0x07, 0xDF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x03, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0xFE, 0x1F, 0xF9, 0xFF, 0x07,
  0xFF, 0xFF, 0xC1, 0xF7, 0xFF, 0xE0, 0xFC, 0xFF, 0xF0, 0x3F, 0x1F, 0xF0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xF3, 0xFC, 0x1F, 0xC0,
  0xFE, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0x7E, 0x03,
  0xF8, 0x7F, 0x8F, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x8F, 0xC0,
  0x3F, 0xF9, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0x9F,
  0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x83, 0xE0,
  0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xF3,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xDF, 0x80,
  0x1F, 0xE3, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F,
  0xCF, 0xF0, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0x3E, 0x1F, 0x80, 0x1F, 0x9F,
  0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x01,
  0x03, 0xF8, 0x00, 0xC0, 0xFE, 0x01, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x7C, 0x03, 0xFF, 0xDF,
  0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFD, 0xFF, 0x83, 0xFC,
  0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x87,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0xBF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFD, 0xF8, 0x01, 0xFF, 0x3F,
  0x00, 0x02, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0x80,
  0x0F, 0xC0, 0x78, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x0F, 0xF0, 0x07, 0xCF, 0xFE, 0x03, 0xF7, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xF0, 0x1F, 0x83, 0xF0, 0x07,
  0xF0, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x0F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0x07, 0xC0, 0x1F, 0xE0, 0xFC, 0x03, 0xF8,
  0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC1, 0xFC, 0x00, 0xFC,
  0x3F, 0x80, 0x0F, 0x8F, 0xF0, 0x01, 0xF9, 0xFE, 0x00, 0x1F, 0xBF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFC, 0xFE,
  0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x3E, 0x03, 0xF0, 0x07,
  0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x00,
  0xFE, 0x07, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xCF, 0xC7, 0xE0, 0x3E, 0xFF, 0x7F, 0x81, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xE1, 0xF8, 0x7C,
  0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0xFC,
  0x1F, 0x07, 0xC7, 0xE1, 0xF8, 0x7E, 0x3E, 0x0F, 0xC3, 0xF1, 0xF0, 0x7C,
  0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC7, 0xE0, 0xF8, 0x3E,
  0x3F, 0x0F, 0xC3, 0xF1, 0xF0, 0x7C, 0x1F, 0x8F, 0x83, 0xE0, 0xF8, 0x7C,
  0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x3F, 0x0F, 0xC1, 0xF1, 0xF8, 0x7E,
  0x1F, 0x8F, 0x83, 0xE0, 0xFC, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E,
  0x3F, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xFC, 0x01, 0xF3, 0xFF, 0x80, 0xFD,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFE, 0xFF, 0x83, 0xFC, 0x07, 0xE0,
  0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03,
  0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x7F, 0xCF, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01,
  0xFB, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xCF, 0x80, 0x0F, 0xC7, 0xE0,
  0x07, 0xE3, 0xF0, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xF1, 0xFE, 0x00, 0x1F, 0x7F, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0xFE,
  0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x3E, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC1, 0xF8, 0x00,
  0xFC, 0x1F, 0xC0, 0x1F, 0x81, 0xFE, 0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xF3, 0xFF, 0x80, 0x3F, 0x1F,
  0xF0, 0x03, 0xF0, 0x18, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x87, 0xC0, 0xFF, 0xF7, 0xE0, 0xFF,
  0xFB, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0x9F, 0xF8, 0xFF, 0x03, 0xFC, 0x7E,
  0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x9F,
  0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF9,
  0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x3F,
  0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF8, 0x0F,
  0xE0, 0xFF, 0x1F, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0x7E, 0x01, 0xFF, 0x3E, 0x00, 0x08, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x20, 0x0F, 0xC3, 0xFF, 0x0F, 0xCF, 0xFE, 0x0F, 0x9F, 0xFE,
  0x0F, 0xBF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0x3C, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xFF, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x9F,
  0x80, 0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xFE, 0x07, 0xF0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0xBE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01,
  0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3E, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x1F, 0xC3, 0xF0, 0x1F, 0xC1, 0xFE, 0x7F, 0xE0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFE, 0xF8, 0x0F, 0xFE, 0xFC, 0x03, 0xFC, 0x7E, 0x00, 0x10, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF1, 0xF0,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xC0,
  0xF8, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x3F,
  0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0,
  0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xE7, 0xC0, 0x00,
  0xFB, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x03, 0xFF, 0x81, 0xF0, 0x3E,
  0xF8, 0x1F, 0x03, 0xEF, 0x81, 0xF0, 0x7E, 0xF8, 0x3F, 0x07, 0xCF, 0x83,
  0xF0, 0x7C, 0xF8, 0x7F, 0x0F, 0x8F, 0x87, 0xF0, 0xF8, 0xF8, 0x7F, 0x0F,
  0x8F, 0x8F, 0xF1, 0xF0, 0xF8, 0xFF, 0x1F, 0x0F, 0x9E, 0xF1, 0xF0, 0xF9,
  0xEF, 0x3E, 0x0F, 0x9E, 0xF3, 0xE0, 0xFB, 0xC7, 0x3E, 0x0F, 0xBC, 0x73,
  0xC0, 0xFB, 0x87, 0x7C, 0x0F, 0xF8, 0x77, 0xC0, 0xFF, 0x87, 0x78, 0x0F,
  0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00,
  0xFC, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0,
  0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x03,
  0xF0, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80,
  0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x3F,
  0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7C, 0x7E, 0x00,
  0x00, 0xF9, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x78, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0x1F, 0xFE, 0x00,
  0xF3, 0xFF, 0xF0, 0x1F, 0x7F, 0xFF, 0xC1, 0xF7, 0xC1, 0xFF, 0xFE, 0x78,
  0x0F, 0xFF, 0xE7, 0x80, 0x3F, 0xFC, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xF0,
};

const GFXglyph RobotoMono_MediumItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 12, 36, 30, 9, -36 },
  { 55, 16, 12, 30, 9, -38 },
  { 79, 30, 36, 30, 0, -36 },
  { 214, 26, 47, 30, 3, -42 },
  { 367, 25, 38, 30, 3, -37 },
  { 486, 28, 38, 30, 1, -37 },
  { 619, 7, 13, 30, 13, -38 },
  { 631, 17, 53, 30, 8, -41 },
  { 744, 17, 53, 30, 4, -41 },
  { 857, 24, 25, 30, 5, -36 },
  { 932, 26, 26, 30, 2, -30 },
  { 1017, 10, 15, 30, 5, -6 },
  { 1036, 20, 4, 30, 6, -18 },
  { 1046, 8, 9, 30, 9, -8 },
  { 1055, 27, 39, 30, 2, -36 },
  { 1187, 25, 38, 30, 3, -37 },
  { 1306, 17, 36, 30, 6, -36 },
  { 1383, 27, 37, 30, 0, -37 },
  { 1508, 26, 38, 30, 1, -37 },
  { 1632, 26, 36, 30, 1, -36 },
  { 1749, 26, 37, 30, 3, -36 },
  { 1870, 24, 37, 30, 2, -36 },
  { 1981, 26, 36, 30, 4, -36 },
  { 2098, 26, 38, 30, 2, -37 },
  { 2222, 23, 37, 30, 4, -37 },
  { 2329, 12, 30, 30, 10, -29 },
  { 2374, 15, 38, 30, 7, -29 },
  { 2446, 23, 24, 30, 4, -28 },
  { 2515, 25, 15, 30, 3, -23 },
  { 2562, 24, 23, 30, 2, -27 },
  { 2631, 22, 37, 30, 6, -37 },
  { 2733, 29, 36, 30, 1, -36 },
  { 2864, 28, 36, 30, -2, -36 },
  { 2990, 28, 36, 30, 1, -36 },
  { 3116, 27, 38, 30, 2, -37 },
  { 3245, 28, 36, 30, 1, -36 },
  { 3371, 29, 36, 30, 1, -36 },
  { 3502, 30, 36, 30, 1, -36 },
  { 3637, 27, 38, 30, 2, -37 },
  { 3766, 29, 36, 30, 1, -36 },
  { 3897, 27, 36, 30, 2, -36 },
  { 4019, 28, 37, 30, 2, -36 },
  { 4149, 32, 36, 30, 1, -36 },
  { 4293, 23, 36, 30, 2, -36 },
  { 4397, 30, 36, 30, 1, -36 },
  { 4532, 29, 36, 30, 1, -36 },
  { 4663, 27, 38, 30, 2, -37 },
  { 4792, 29, 36, 30, 1, -36 },
  { 4923, 27, 43, 30, 2, -37 },
  { 5069, 28, 36, 30, 1, -36 },
  { 5195, 28, 38, 30, 2, -37 },
  { 5328, 28, 36, 30, 4, -36 },
  { 5454, 28, 37, 30, 2, -36 },
  { 5584, 27, 36, 30, 5, -36 },
  { 5706, 29, 36, 30, 3, -36 },
  { 5837, 33, 36, 30, -1, -36 },
  { 5986, 28, 36, 30, 5, -36 },
  { 6112, 30, 36, 30, 0, -36 },
  { 6247, 18, 50, 30, 6, -42 },
  { 6360, 13, 39, 30, 9, -36 },
  { 6424, 18, 50, 30, 6, -42 },
  { 6537, 19, 19, 30, 6, -36 },
  { 6583, 23, 5, 30, 0, 0 },
  { 6598, 9, 7, 30, 14, -37 },
  { 6606, 24, 29, 30, 2, -28 },
  { 6693, 26, 39, 30, 1, -38 },
  { 6820, 24, 29, 30, 3, -28 },
  { 6907, 27, 39, 30, 3, -38 },
  { 7039, 25, 29, 30, 2, -28 },
  { 7130, 27, 39, 30, 5, -39 },
  { 7262, 27, 39, 30, 1, -28 },
  { 7394, 26, 38, 30, 1, -38 },
  { 7518, 23, 37, 30, 2, -37 },
  { 7625, 23, 48, 30, 1, -37 },
  { 7763, 28, 38, 30, 1, -38 },
  { 7896, 23, 38, 30, 2, -38 },
  { 8006, 29, 27, 30, -1, -27 },
  { 8104, 26, 27, 30, 1, -27 },
  { 8192, 25, 29, 30, 2, -28 },
  { 8283, 28, 37, 30, -1, -27 },
  { 8413, 25, 38, 30, 3, -28 },
  { 8532, 24, 28, 30, 5, -28 },
  { 8616, 25, 28, 30, 2, -27 },
  { 8704, 23, 35, 30, 4, -34 },
  { 8805, 25, 28, 30, 3, -27 },
  { 8893, 26, 27, 30, 4, -27 },
  { 8981, 28, 27, 30, 3, -27 },
  { 9076, 30, 27, 30, 0, -27 },
  { 9178, 31, 38, 30, 0, -27 },
  { 9326, 27, 27, 30, 1, -27 },
  { 9418, 20, 49, 30, 7, -40 },
  { 9541, 11, 46, 30, 9, -36 },
  { 9605, 19, 49, 30, 5, -40 },
  { 9722, 28, 10, 30, 0, -20 },
};

const GFXfont RobotoMono_MediumItalic51pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic51pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOMONO_MEDIUMITALIC51PT7B_H_
