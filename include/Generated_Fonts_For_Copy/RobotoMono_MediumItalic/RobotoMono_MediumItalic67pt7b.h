#ifndef _ROBOTOMONO_MEDIUMITALIC67PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x7E,
  0x00, 0x1F, 0x81, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x7E, 0x07, 0xE3,
  0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x7E, 0x03,
  0xE3, 0xF0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E,
  0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x30, 0x7C, 0x07, 0xC0, 0x7C, 0xFC,
  0x07, 0xC0, 0x7C, 0xFC, 0x07, 0xC0, 0xF8, 0xFC, 0x07, 0xC1, 0xF8, 0xFC,
  0x07, 0xC1, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC,
  0x1F, 0x87, 0xC0, 0x7E, 0x3F, 0x8F, 0x80, 0x7F, 0xFF, 0x1F, 0x00, 0x3F,
  0xFE, 0x3F, 0x00, 0x1F, 0xFC, 0x3E, 0x00, 0x0F, 0xF8, 0x7C, 0x00, 0x01,
  0xC0, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x0F, 0xF0, 0x00,
  0x3E, 0x3F, 0xF8, 0x00, 0x7E, 0x7F, 0xFC, 0x00, 0x7C, 0xFF, 0xFE, 0x00,
  0xF8, 0xFF, 0xFF, 0x01, 0xF9, 0xF8, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x03,
  0xE1, 0xF0, 0x1F, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0xC3, 0xF0, 0x1F, 0x0F,
  0x83, 0xF0, 0x1F, 0x1F, 0x03, 0xF0, 0x1F, 0x07, 0x03, 0xF0, 0x3F, 0x02,
  0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x0F,
  0xF0, 0x00, 0x03, 0xF9, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0x00, 0xFE,
  0x0F, 0xFF, 0xF8, 0x07, 0xE0, 0xFF, 0x9F, 0xE0, 0x7F, 0x0F, 0xF8, 0xFF,
  0x03, 0xF8, 0xFF, 0x83, 0xFC, 0x1F, 0xC7, 0xF8, 0x1F, 0xF1, 0xFC, 0x7F,
  0xC0, 0x7F, 0x8F, 0xE3, 0xFC, 0x03, 0xFE, 0xFF, 0x1F, 0xE0, 0x0F, 0xFF,
  0xF0, 0xFE, 0x00, 0x3F, 0xFF, 0x87, 0xF0, 0x01, 0xFF, 0xF8, 0x3F, 0x80,
  0x07, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0xC0,
  0x7F, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x3F, 0xC0, 0x1F, 0xFF, 0xF1, 0xFF, 0x00, 0x3F, 0xFC, 0x07,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xCF, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xC3, 0xE3, 0xF1, 0xF8,
  0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x10, 0x03,
  0xE0, 0x02, 0x3C, 0x03, 0xE0, 0x0E, 0x3F, 0x03, 0xE0, 0x7E, 0x7F, 0xC3,
  0xE1, 0xFE, 0x7F, 0xF3, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x07, 0xE0, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0x0F, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xC7, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFC,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0,
  0x01, 0xFF, 0x3F, 0xC0, 0x03, 0xFF, 0x3F, 0xC0, 0x0F, 0xFF, 0x3F, 0xC0,
  0x1F, 0xFF, 0x3F, 0x80, 0x3F, 0xFF, 0x3F, 0x80, 0xFF, 0xFF, 0x3F, 0x81,
  0xFE, 0xFF, 0x7F, 0x87, 0xFC, 0xFE, 0x7F, 0x8F, 0xF0, 0xFE, 0x7F, 0xBF,
  0xE1, 0xFE, 0x7F, 0xFF, 0x81, 0xFE, 0x7F, 0xFF, 0x01, 0xFE, 0x7F, 0xFC,
  0x01, 0xFE, 0xFF, 0xF8, 0x01, 0xFC, 0xFF, 0xE0, 0x01, 0xFC, 0xFF, 0xC0,
  0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x03, 0xF8, 0xFF, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE7, 0xFF, 0x7F, 0x1F, 0xE1, 0xFC, 0x7E, 0x07, 0xF1, 0xC0, 0x3F,
  0xC8, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x3F, 0xCF,
  0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x07,
  0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8,
  0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0x1F, 0xDF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xF0, 0x07, 0xFC, 0x00, 0x08,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x30, 0x00, 0x3F, 0xC7, 0xFE, 0x00, 0x7F, 0x1F, 0xFF, 0x00, 0xFE, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x7F, 0xF0, 0x07, 0xFC, 0xFF, 0xC0, 0x07,
  0xF9, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x1F,
  0xEF, 0xE0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F,
  0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF0,
  0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F,
  0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0x87, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0,
  0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0xFE, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x7F,
  0x9F, 0xE0, 0x01, 0xFF, 0x3F, 0xC0, 0x07, 0xFE, 0x7F, 0xC0, 0x1F, 0xFC,
  0x7F, 0xC0, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0xFE, 0x00, 0xFF, 0xF9, 0xFC, 0x00,
  0x7F, 0xC7, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x07, 0xF0,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFE,
  0x07, 0xFC, 0x07, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x04, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xE0, 0xFF, 0xC7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xFB, 0xFC, 0x00,
  0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x01,
  0xE0, 0x1F, 0x80, 0x30, 0x0F, 0x80, 0xF8, 0x0F, 0xF0, 0x3C, 0x0F, 0x81,
  0xFF, 0xE1, 0xE0, 0xFC, 0x1F, 0xFF, 0x8F, 0x07, 0xC1, 0xFF, 0xF8, 0x78,
  0x7C, 0x1F, 0xC3, 0xC3, 0xC3, 0xE1, 0xF8, 0x3E, 0x1E, 0x3E, 0x0F, 0x81,
  0xF0, 0xF1, 0xF0, 0xFC, 0x0F, 0x07, 0x8F, 0x87, 0xC0, 0x78, 0x3C, 0xF8,
  0x3E, 0x07, 0xC1, 0xE7, 0xC3, 0xE0, 0x3E, 0x0F, 0x3E, 0x1F, 0x01, 0xE0,
  0x79, 0xE0, 0xF8, 0x0F, 0x03, 0xDF, 0x0F, 0x80, 0xF8, 0x3E, 0xF8, 0x7C,
  0x07, 0xC1, 0xE7, 0xC3, 0xE0, 0x3C, 0x0F, 0x3E, 0x1F, 0x01, 0xE0, 0x79,
  0xF0, 0xF8, 0x1F, 0x03, 0xCF, 0x07, 0xC0, 0xF8, 0x3C, 0x78, 0x3E, 0x07,
  0xC1, 0xE3, 0xC1, 0xF0, 0x7C, 0x1E, 0x1E, 0x0F, 0xC7, 0xF1, 0xF0, 0xF8,
  0x7F, 0xFF, 0xDF, 0x07, 0xC1, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0xF9, 0xFF,
  0x81, 0xF0, 0x3F, 0x8F, 0xF0, 0x0F, 0x80, 0xF0, 0x1F, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x60, 0x00, 0x07, 0xFF, 0x7F,
  0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x01, 0xFE, 0x3F, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0xFF, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xC0, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x01, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x03, 0xFF,
  0x83, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x0F, 0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xF8,
  0x07, 0xF8, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x9F, 0xE0, 0x0F,
  0xFF, 0xF3, 0xFC, 0x01, 0xFF, 0xFE, 0x7F, 0x80, 0x3F, 0xFF, 0xCF, 0xF0,
  0x07, 0xFF, 0xF9, 0xFE, 0x01, 0xFF, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xC7,
  0xF8, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF0, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x80,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x00, 0x1F,
  0xE0, 0x1F, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0xE0, 0x00, 0x00,
  0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x8F, 0xFC, 0x00, 0x00, 0x1F, 0xE7,
  0xFE, 0x00, 0x00, 0x07, 0xFB, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x7F,
  0xC0, 0x00, 0x07, 0xFF, 0x8F, 0xF0, 0x00, 0x01, 0xFF, 0xC3, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xFC,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0x7F, 0x00, 0xFF, 0xF8, 0x7E,
  0xFE, 0x01, 0xF9, 0xF1, 0xF9, 0xFC, 0x07, 0xF3, 0xE3, 0xF7, 0xF0, 0x0F,
  0xE7, 0xCF, 0xCF, 0xE0, 0x1F, 0xCF, 0x9F, 0x9F, 0xC0, 0x3F, 0x9F, 0xFE,
  0x3F, 0x80, 0x7F, 0x3F, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0xF8, 0xFE, 0x03,
  0xF8, 0xFF, 0xE3, 0xF8, 0x07, 0xF0, 0xFF, 0xC7, 0xF0, 0x0F, 0xE1, 0xFF,
  0x0F, 0xE0, 0x1F, 0xC3, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x3F, 0x80,
  0xFF, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F,
  0x83, 0xF8, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0,
  0x1F, 0xC0, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00,
  0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x1F,
  0xF8, 0x00, 0x3F, 0x80, 0x7F, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x07,
  0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0x80, 0xFF,
  0xF8, 0x01, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xF0, 0x0F, 0xFF, 0x80, 0x3F,
  0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFC, 0x07, 0xFB,
  0xF0, 0x0F, 0xF0, 0x1F, 0xEF, 0xC0, 0x3F, 0x80, 0x7F, 0xBF, 0x80, 0xFE,
  0x01, 0xFE, 0x7E, 0x07, 0xF8, 0x07, 0xF1, 0xF8, 0x1F, 0xE0, 0x3F, 0xC7,
  0xF0, 0x7F, 0x80, 0xFF, 0x1F, 0xC1, 0xFE, 0x03, 0xFC, 0x3F, 0x07, 0xF0,
  0x0F, 0xF0, 0xFC, 0x3F, 0xC0, 0x3F, 0x83, 0xF8, 0xFF, 0x01, 0xFE, 0x07,
  0xE3, 0xFC, 0x07, 0xF8, 0x1F, 0x8F, 0xF0, 0x1F, 0xE0, 0x7F, 0x3F, 0xC0,
  0x7F, 0x81, 0xFC, 0xFE, 0x01, 0xFE, 0x03, 0xF7, 0xF8, 0x07, 0xF0, 0x0F,
  0xDF, 0xE0, 0x3F, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xFE, 0x03,
  0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F,
  0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x1F,
  0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0x80, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x1F,
  0xF8, 0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0xFF,
  0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF1, 0xFF,
  0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xF1,
  0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03,
  0xFC, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x01, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xF3, 0xF8,
  0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x3F,
  0xC7, 0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0x80,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFF,
  0x80, 0x7F, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xFC, 0x7F,
  0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x00, 0x7F, 0x7F, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x01,
  0xFC, 0xFE, 0x01, 0xF8, 0x07, 0xF3, 0xF8, 0x0F, 0xE0, 0x1F, 0xCF, 0xE0,
  0x3F, 0x80, 0xFF, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0x0F,
  0xE3, 0xF8, 0x1F, 0xE0, 0x3F, 0x8F, 0xE0, 0x7F, 0x81, 0xFC, 0x3F, 0x83,
  0xFE, 0x07, 0xF0, 0xFC, 0x0F, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0xE0, 0xFF,
  0x0F, 0xC0, 0xFF, 0x83, 0xF8, 0x3F, 0x07, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F,
  0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0xE1, 0xFC, 0x1F, 0xC3, 0xFF, 0x87, 0xF0,
  0x7F, 0x0F, 0xFE, 0x1F, 0xC1, 0xFC, 0x3E, 0xF8, 0x7F, 0x07, 0xF1, 0xFB,
  0xE3, 0xF8, 0x1F, 0xC7, 0xEF, 0x8F, 0xE0, 0x7F, 0x1F, 0x3E, 0x3F, 0x81,
  0xFC, 0xFC, 0xF8, 0xFC, 0x07, 0xF3, 0xF3, 0xE7, 0xF0, 0x1F, 0xCF, 0x8F,
  0x9F, 0xC0, 0x7F, 0x3E, 0x3E, 0x7F, 0x01, 0xFD, 0xF8, 0xFB, 0xF8, 0x07,
  0xF7, 0xE3, 0xEF, 0xE0, 0x1F, 0xDF, 0x0F, 0xBF, 0x80, 0x7F, 0xFC, 0x3E,
  0xFC, 0x01, 0xFB, 0xF0, 0xFF, 0xF0, 0x07, 0xEF, 0x83, 0xFF, 0xC0, 0x1F,
  0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC3, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC7, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xBF, 0xC0, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x0F,
  0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF,
  0x00, 0x07, 0xE7, 0xE0, 0x03, 0xF9, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7F,
  0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x01,
  0xFC, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F,
  0x87, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x7F, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0x81, 0xFE, 0x3F, 0xF0, 0x01, 0xFE, 0x3F, 0xE0, 0x01, 0xFC, 0x7F, 0xC0,
  0x01, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x00,
  0x03, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0xF7, 0xF8, 0x0F, 0xFF,
  0xE7, 0xF8, 0x03, 0xFF, 0x83, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x07, 0xF1, 0xFF, 0xC0, 0x07, 0xFB, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0xFF,
  0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xF8, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x1F, 0xC0,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFE, 0x3F,
  0xE0, 0x01, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x81,
  0xFC, 0xFF, 0xFF, 0x80, 0xFE, 0x3F, 0xFF, 0x80, 0x7F, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFC, 0x03,
  0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x03,
  0xFC, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFF, 0xC3, 0xFC, 0x00, 0xFF, 0xFF,
  0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x1F, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFE,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x7F, 0x00, 0x07, 0xFF, 0xE7,
  0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFE, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFE,
  0x0F, 0xF8, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xC7, 0xFC, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x01,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x10, 0x0F, 0xF8, 0x00, 0x1C, 0x03, 0xFE, 0x00, 0x1F, 0x01, 0xFF,
  0x80, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x04, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x7F, 0x00,
  0x1F, 0xFF, 0xCF, 0xF0, 0x07, 0xFF, 0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x3F, 0xF0,
  0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF8, 0x1F,
  0xC0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xDF, 0xC0, 0x01,
  0xFF, 0xF9, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x80, 0x00,
  0x7F, 0x80, 0x18, 0x00, 0x0F, 0xF8, 0x03, 0xC0, 0x01, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0xE0, 0x03, 0xFC, 0xFF, 0xFE, 0x00,
  0xFE, 0x7F, 0xFF, 0xC0, 0x3F, 0xBF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xF3, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x07,
  0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F,
  0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00,
  0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x40, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x10, 0x3F, 0x80, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0x80,
  0x1F, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x07,
  0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xF0,
  0x00, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0xC0, 0x00, 0xFE, 0x1F,
  0xF0, 0x00, 0x0F, 0xE7, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x9F, 0xE0, 0x00, 0x3F,
  0xF1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x80,
  0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x10, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x0F, 0xE7, 0xFC, 0x7F, 0xC0, 0x3F, 0xBF, 0xF3, 0xFF,
  0x80, 0xFD, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xEF, 0xFF, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x81, 0xFC,
  0x3F, 0x81, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x0F, 0xE1,
  0xFC, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF0,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F,
  0x81, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0x80,
  0xFE, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x07,
  0xF0, 0x00, 0x04, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0x8F,
  0xFF, 0xE0, 0x0F, 0xE7, 0xFF, 0xFC, 0x03, 0xFB, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x0F,
  0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC,
  0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0,
  0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0x80,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF3, 0xFF, 0xC0, 0x00,
  0xFE, 0x7F, 0xFF, 0x00, 0x0F, 0xEF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF9, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0xFF, 0x80, 0x1F,
  0xE7, 0xFF, 0xE0, 0x01, 0xFE, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x3E, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x8F, 0xF0, 0x0F, 0xFF, 0xF3, 0xF8,
  0x07, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xF0, 0xFF, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F,
  0xC0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFD, 0xFC, 0x00,
  0x7F, 0xFE, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xC0, 0x00, 0x3C, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x04, 0x07, 0xFD,
  0x03, 0xF8, 0x3F, 0xFE, 0x03, 0xF8, 0x7F, 0xFE, 0x03, 0xF9, 0xFF, 0xFE,
  0x03, 0xFB, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x04, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x1F,
  0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0xC0,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x02, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xE1, 0xFE,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x03, 0xFC, 0x3F,
  0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x0F,
  0xF0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x07,
  0xFE, 0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xDF, 0xC0, 0x7F, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0xCF, 0xE0, 0x07, 0xFF,
  0xC7, 0xF0, 0x01, 0xFF, 0xC3, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xDF, 0xC0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x0F, 0xF1,
  0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x07,
  0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x80,
  0x7F, 0xFE, 0x03, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0x80, 0xFE, 0xFE, 0x03,
  0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0x80, 0xFC, 0xFE, 0x07, 0xF8, 0x1F, 0xCF,
  0xC0, 0xFF, 0x81, 0xFC, 0xFC, 0x0F, 0xF8, 0x1F, 0x8F, 0xC0, 0xFF, 0x83,
  0xF8, 0xFC, 0x1F, 0xF8, 0x3F, 0x8F, 0xC1, 0xFF, 0x83, 0xF0, 0xFC, 0x1F,
  0xF8, 0x7F, 0x0F, 0xC3, 0xEF, 0x87, 0xE0, 0xFC, 0x3E, 0xF8, 0x7E, 0x0F,
  0xC7, 0xEF, 0x8F, 0xE0, 0xFC, 0x7C, 0xF8, 0xFC, 0x0F, 0xC7, 0xCF, 0x8F,
  0xC0, 0xFC, 0xF8, 0xF9, 0xFC, 0x0F, 0xCF, 0x8F, 0x9F, 0x80, 0xFC, 0xF8,
  0xF9, 0xF8, 0x0F, 0xDF, 0x07, 0xBF, 0x80, 0xFD, 0xF0, 0x7B, 0xF0, 0x0F,
  0xDE, 0x07, 0xBF, 0x00, 0xFF, 0xE0, 0x7B, 0xE0, 0x0F, 0xFE, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xE1,
  0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xF1, 0xFF, 0xFC, 0x00, 0x1F, 0x3F, 0xFF, 0xF0, 0x03,
  0xF7, 0xFF, 0xFF, 0x80, 0x3F, 0x7F, 0xFF, 0xFC, 0x07, 0xE7, 0xF0, 0x7F,
  0xF1, 0xFE, 0xFE, 0x03, 0xFF, 0xFF, 0xEF, 0xC0, 0x0F, 0xFF, 0xFC, 0xF8,
  0x00, 0x7F, 0xFF, 0x8F, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0,
};

const GFXglyph RobotoMono_MediumItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 16, 48, 39, 12, -48 },
  { 97, 21, 16, 39, 12, -50 },
  { 139, 40, 48, 39, 0, -48 },
  { 379, 35, 62, 39, 3, -55 },
  { 651, 32, 49, 39, 4, -48 },
  { 847, 37, 49, 39, 1, -48 },
  { 1074, 9, 17, 39, 17, -50 },
  { 1094, 23, 68, 39, 10, -53 },
  { 1290, 23, 68, 39, 5, -53 },
  { 1486, 32, 33, 39, 6, -48 },
  { 1618, 33, 34, 39, 3, -39 },
  { 1759, 14, 20, 39, 6, -8 },
  { 1794, 26, 6, 39, 8, -24 },
  { 1814, 11, 11, 39, 12, -10 },
  { 1830, 35, 52, 39, 3, -48 },
  { 2058, 32, 49, 39, 4, -48 },
  { 2254, 22, 48, 39, 8, -48 },
  { 2386, 35, 48, 39, 0, -48 },
  { 2596, 34, 49, 39, 2, -48 },
  { 2805, 34, 48, 39, 1, -48 },
  { 3009, 35, 49, 39, 3, -48 },
  { 3224, 31, 49, 39, 3, -48 },
  { 3414, 34, 48, 39, 5, -48 },
  { 3618, 34, 49, 39, 3, -48 },
  { 3827, 31, 48, 39, 5, -48 },
  { 4013, 15, 39, 39, 13, -38 },
  { 4087, 20, 50, 39, 9, -38 },
  { 4212, 31, 30, 39, 5, -36 },
  { 4329, 33, 21, 39, 4, -31 },
  { 4416, 31, 31, 39, 3, -36 },
  { 4537, 29, 48, 39, 8, -48 },
  { 4711, 37, 47, 39, 2, -47 },
  { 4929, 37, 48, 39, -2, -48 },
  { 5151, 37, 48, 39, 1, -48 },
  { 5373, 35, 49, 39, 3, -48 },
  { 5588, 36, 48, 39, 1, -48 },
  { 5804, 38, 48, 39, 2, -48 },
  { 6032, 38, 48, 39, 2, -48 },
  { 6260, 35, 49, 39, 3, -48 },
  { 6475, 38, 48, 39, 1, -48 },
  { 6703, 36, 48, 39, 2, -48 },
  { 6919, 37, 49, 39, 2, -48 },
  { 7146, 42, 48, 39, 1, -48 },
  { 7398, 31, 48, 39, 2, -48 },
  { 7584, 39, 48, 39, 1, -48 },
  { 7818, 38, 48, 39, 1, -48 },
  { 8046, 35, 49, 39, 3, -48 },
  { 8261, 37, 48, 39, 2, -48 },
  { 8483, 35, 56, 39, 3, -48 },
  { 8728, 38, 48, 39, 1, -48 },
  { 8956, 37, 49, 39, 2, -48 },
  { 9183, 37, 48, 39, 5, -48 },
  { 9405, 37, 49, 39, 3, -48 },
  { 9632, 36, 48, 39, 6, -48 },
  { 9848, 38, 48, 39, 4, -48 },
  { 10076, 44, 48, 39, -2, -48 },
  { 10340, 37, 48, 39, 6, -48 },
  { 10562, 39, 48, 39, 0, -48 },
  { 10796, 24, 66, 39, 8, -55 },
  { 10994, 16, 52, 39, 12, -48 },
  { 11098, 24, 66, 39, 8, -55 },
  { 11296, 26, 26, 39, 7, -48 },
  { 11381, 30, 6, 39, 0, 0 },
  { 11404, 12, 9, 39, 18, -48 },
  { 11418, 32, 37, 39, 2, -36 },
  { 11566, 33, 51, 39, 2, -50 },
  { 11777, 32, 37, 39, 3, -36 },
  { 11925, 36, 51, 39, 3, -50 },
  { 12155, 33, 37, 39, 3, -36 },
  { 12308, 36, 52, 39, 6, -52 },
  { 12542, 36, 50, 39, 1, -36 },
  { 12767, 34, 50, 39, 1, -50 },
  { 12980, 30, 49, 39, 3, -49 },
  { 13164, 31, 63, 39, 1, -49 },
  { 13409, 36, 50, 39, 2, -50 },
  { 13634, 30, 50, 39, 3, -50 },
  { 13822, 38, 36, 39, -1, -36 },
  { 13993, 34, 36, 39, 1, -36 },
  { 14146, 32, 37, 39, 3, -36 },
  { 14294, 36, 50, 39, -1, -36 },
  { 14519, 34, 50, 39, 3, -36 },
  { 14732, 32, 36, 39, 6, -36 },
  { 14876, 33, 37, 39, 3, -36 },
  { 15029, 30, 45, 39, 6, -44 },
  { 15198, 33, 36, 39, 4, -35 },
  { 15347, 34, 35, 39, 5, -35 },
  { 15496, 36, 35, 39, 4, -35 },
  { 15654, 39, 35, 39, 0, -35 },
  { 15825, 41, 49, 39, 0, -35 },
  { 16077, 36, 35, 39, 1, -35 },
  { 16235, 26, 64, 39, 10, -52 },
  { 16443, 15, 61, 39, 12, -48 },
  { 16558, 26, 64, 39, 6, -52 },
  { 16766, 36, 14, 39, 1, -27 },
};

const GFXfont RobotoMono_MediumItalic67pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic67pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic67pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _ROBOTOMONO_MEDIUMITALIC67PT7B_H_
