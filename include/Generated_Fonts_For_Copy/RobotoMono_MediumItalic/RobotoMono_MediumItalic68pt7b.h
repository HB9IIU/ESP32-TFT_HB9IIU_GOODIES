#ifndef _ROBOTOMONO_MEDIUMITALIC68PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x3F, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E,
  0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x7E,
  0x3E, 0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xC0,
  0x7E, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x0F,
  0xE0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x01, 0xF8, 0x1F, 0x00, 0x40, 0xF8, 0x0F, 0xC0, 0x70, 0x7C, 0x07, 0xE0,
  0x7E, 0x7E, 0x03, 0xF0, 0x3E, 0x3F, 0x01, 0xF0, 0x3E, 0x1F, 0x80, 0xF8,
  0x3F, 0x0F, 0xC0, 0x7C, 0x1F, 0x07, 0xE0, 0x7E, 0x1F, 0x03, 0xF0, 0x3F,
  0x1F, 0x80, 0xFC, 0x3F, 0x0F, 0x80, 0x7F, 0xFF, 0x8F, 0x80, 0x3F, 0xFF,
  0x8F, 0xC0, 0x0F, 0xFF, 0x8F, 0xC0, 0x03, 0xFF, 0x87, 0xC0, 0x00, 0x7F,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x0C, 0x00,
  0x00, 0xF8, 0x7F, 0xC0, 0x00, 0xF8, 0xFF, 0xF0, 0x00, 0xFC, 0xFF, 0xFC,
  0x00, 0x7C, 0x7F, 0xFF, 0x00, 0x7C, 0x7F, 0x3F, 0x80, 0x7E, 0x3E, 0x07,
  0xC0, 0x7E, 0x3F, 0x03, 0xF0, 0x3E, 0x1F, 0x01, 0xF8, 0x3F, 0x0F, 0x80,
  0xFC, 0x3F, 0x07, 0xC0, 0x7E, 0x1F, 0x03, 0xE0, 0x3F, 0x1F, 0x03, 0xF0,
  0x1F, 0x03, 0x81, 0xF8, 0x0F, 0x80, 0x80, 0xFC, 0x0F, 0xC0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00,
  0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0xFF, 0x80, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7E, 0x0F, 0xFF, 0xF8, 0x07,
  0xF0, 0xFF, 0xDF, 0xE0, 0x3F, 0x87, 0xFC, 0xFF, 0x01, 0xFC, 0x7F, 0xC3,
  0xFC, 0x1F, 0xC7, 0xFC, 0x1F, 0xE0, 0xFE, 0x3F, 0xC0, 0x7F, 0x87, 0xF3,
  0xFE, 0x03, 0xFE, 0x7F, 0x1F, 0xE0, 0x0F, 0xF7, 0xF8, 0xFF, 0x00, 0x7F,
  0xFF, 0xC7, 0xF8, 0x01, 0xFF, 0xFC, 0x3F, 0x80, 0x07, 0xFF, 0xC1, 0xFE,
  0x00, 0x3F, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0x80, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x87, 0xF8, 0x01, 0xFF, 0xF0,
  0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3,
  0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0,
  0xF8, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x18, 0x01, 0xF0, 0x06,
  0x3E, 0x01, 0xE0, 0x1E, 0x3F, 0x83, 0xE0, 0xFF, 0x7F, 0xE3, 0xE3, 0xFF,
  0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0x7E, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x1E, 0x00, 0x02, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0,
  0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x07, 0x00,
  0x08, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0x8F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xC7,
  0xF0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xF8, 0x07, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xC0, 0x00,
  0x7F, 0x8F, 0xE0, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0xFF, 0xE7, 0xF8, 0x01,
  0xFF, 0xF3, 0xFC, 0x01, 0xFF, 0xF9, 0xFE, 0x03, 0xFF, 0xF8, 0xFE, 0x03,
  0xFF, 0xFC, 0x7F, 0x07, 0xFD, 0xFE, 0x7F, 0x87, 0xFC, 0xFF, 0x3F, 0xCF,
  0xF8, 0x7F, 0x9F, 0xEF, 0xF8, 0x3F, 0xCF, 0xFF, 0xF0, 0x1F, 0xC7, 0xFF,
  0xF0, 0x1F, 0xE3, 0xFF, 0xE0, 0x0F, 0xF3, 0xFF, 0xE0, 0x07, 0xF9, 0xFF,
  0xC0, 0x03, 0xFC, 0xFF, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x3F,
  0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF,
  0x9F, 0xE3, 0xF8, 0x3F, 0xC7, 0x80, 0x7F, 0x08, 0x00, 0xFE, 0x20, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F,
  0xC2, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x4F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x1F,
  0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0,
  0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x0F,
  0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x3C, 0x00,
  0x00, 0x3F, 0xBF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xFE,
  0x00, 0x02, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x1F, 0xE3, 0xFF, 0xC0, 0x1F, 0xCF, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x3F,
  0xFC, 0x3F, 0xF8, 0x07, 0xFC, 0x7F, 0xF0, 0x03, 0xFE, 0x7F, 0xE0, 0x01,
  0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03,
  0xFC, 0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xF8, 0x07, 0xFE, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xC0,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFC,
  0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x1F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x03,
  0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xCF, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x3F,
  0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0xFF, 0x7F, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xFC, 0x00,
  0x07, 0xFB, 0xF8, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F,
  0xFC, 0x7F, 0xC0, 0x3F, 0xF8, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x7F, 0x01, 0xFF, 0xFD, 0xFE,
  0x01, 0xFF, 0xF3, 0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0,
  0x3F, 0x80, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x06, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xCF, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x0F,
  0xF7, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0xF8, 0x07, 0xF0, 0x3C, 0x0F, 0xC0, 0xFF,
  0xE1, 0xF0, 0x7C, 0x0F, 0xFF, 0x8F, 0x87, 0xC0, 0xFF, 0xFC, 0x3C, 0x3E,
  0x0F, 0xFF, 0xE1, 0xE3, 0xE0, 0xFC, 0x1E, 0x0F, 0x1F, 0x0F, 0xC0, 0xF0,
  0x79, 0xF0, 0x7C, 0x0F, 0x83, 0xCF, 0x87, 0xE0, 0x7C, 0x1E, 0x7C, 0x3E,
  0x03, 0xC0, 0xF7, 0xC1, 0xF0, 0x1E, 0x0F, 0xBE, 0x1F, 0x01, 0xF0, 0x7D,
  0xF0, 0xF8, 0x0F, 0x83, 0xEF, 0x07, 0xC0, 0x78, 0x1E, 0xF8, 0x3E, 0x03,
  0xC0, 0xF7, 0xC3, 0xE0, 0x3E, 0x07, 0xBE, 0x1F, 0x01, 0xF0, 0x7D, 0xF0,
  0xF8, 0x0F, 0x83, 0xCF, 0x87, 0xC0, 0x78, 0x1E, 0x7C, 0x3E, 0x07, 0xC0,
  0xF3, 0xE1, 0xF0, 0x3E, 0x0F, 0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0xF8, 0x7E,
  0x7F, 0x87, 0x87, 0xC1, 0xFF, 0xFF, 0xFC, 0x3E, 0x0F, 0xFD, 0xFF, 0xC1,
  0xF0, 0x7F, 0xCF, 0xFC, 0x0F, 0x81, 0xFC, 0x3F, 0xC0, 0x3E, 0x03, 0x00,
  0x70, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x03, 0x80,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFB, 0xF0,
  0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00,
  0x00, 0x3F, 0x87, 0xF8, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00,
  0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0x80, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xF7,
  0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x0F, 0xF1, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFC,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x1F, 0xFE, 0x00,
  0x3F, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xFE,
  0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xF8,
  0x03, 0xFC, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0x0F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xFC,
  0xFF, 0x00, 0x7F, 0xFF, 0xCF, 0xF0, 0x07, 0xFF, 0xFC, 0xFF, 0x00, 0x7F,
  0xFF, 0x8F, 0xF0, 0x07, 0xFF, 0xF8, 0xFF, 0x00, 0x7F, 0xFF, 0x8F, 0xF0,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF8,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xE0, 0x1F,
  0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x00, 0x07,
  0xF8, 0x07, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE3, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xBF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x7F, 0xC0, 0x00, 0x07, 0xFF,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xFB, 0xE0, 0xFD, 0xFC, 0x03, 0xFB,
  0xE1, 0xFF, 0xF8, 0x03, 0xFB, 0xE1, 0xFB, 0xF8, 0x03, 0xFB, 0xF3, 0xFB,
  0xF8, 0x07, 0xF3, 0xF3, 0xF3, 0xF8, 0x07, 0xF3, 0xF7, 0xF3, 0xF8, 0x07,
  0xF3, 0xF7, 0xE7, 0xF8, 0x07, 0xF3, 0xFF, 0xE7, 0xF0, 0x07, 0xF3, 0xFF,
  0xC7, 0xF0, 0x07, 0xF1, 0xFF, 0xC7, 0xF0, 0x0F, 0xE1, 0xFF, 0x87, 0xF0,
  0x0F, 0xE1, 0xFF, 0x8F, 0xF0, 0x0F, 0xE1, 0xFF, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFF, 0x0F, 0xE0, 0x0F, 0xE1, 0xFE, 0x0F, 0xE0, 0x1F, 0xE1, 0xFE, 0x0F,
  0xE0, 0x1F, 0xE1, 0xFC, 0x1F, 0xE0, 0x1F, 0xC0, 0xFC, 0x1F, 0xE0, 0x1F,
  0xC0, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xF0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xFC, 0x00, 0x0F,
  0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0x80, 0x7F,
  0xF0, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x03,
  0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xE0, 0x1F,
  0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFC, 0x03, 0xFD, 0xF8, 0x07, 0xF8, 0x07,
  0xFB, 0xF8, 0x0F, 0xF0, 0x0F, 0xF7, 0xF0, 0x1F, 0xE0, 0x1F, 0xE7, 0xE0,
  0x3F, 0xC0, 0x3F, 0xCF, 0xC0, 0x7F, 0x80, 0x7F, 0x1F, 0xC0, 0xFE, 0x01,
  0xFE, 0x3F, 0x83, 0xFC, 0x03, 0xFC, 0x3F, 0x07, 0xF8, 0x07, 0xF8, 0x7F,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0xFC, 0x3F, 0xC0,
  0x7F, 0x81, 0xF8, 0xFF, 0x00, 0xFF, 0x03, 0xF9, 0xFE, 0x01, 0xFE, 0x07,
  0xF3, 0xFC, 0x03, 0xFC, 0x07, 0xE7, 0xF8, 0x07, 0xF8, 0x0F, 0xEF, 0xF0,
  0x0F, 0xF0, 0x1F, 0xDF, 0xE0, 0x3F, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0x80,
  0x3F, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFC,
  0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0xE0,
  0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFF,
  0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xF8,
  0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xC0,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8,
  0x03, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFF, 0x00,
  0x7F, 0x80, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x03,
  0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0xFF,
  0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFC, 0xFF, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07,
  0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xE3, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0x80,
  0x07, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0x03, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFF,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x0F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0x80,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F,
  0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xF8, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x7F,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xC7,
  0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0xFC,
  0x01, 0xFD, 0xFC, 0x03, 0xF0, 0x0F, 0xF7, 0xF0, 0x1F, 0xC0, 0x3F, 0x9F,
  0xC0, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFC, 0x07, 0xF9, 0xFC, 0x0F, 0xF0,
  0x1F, 0xC7, 0xF0, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x7F,
  0x03, 0xFC, 0x0F, 0xF1, 0xFC, 0x1F, 0xF0, 0x3F, 0x87, 0xF0, 0x7F, 0xC0,
  0xFE, 0x1F, 0xC1, 0xFF, 0x03, 0xF8, 0x7E, 0x0F, 0xFC, 0x1F, 0xC1, 0xF8,
  0x3F, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0xC1, 0xFC, 0x3F, 0x87, 0xFF, 0x07,
  0xF0, 0xFE, 0x1F, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0xF0, 0xFE, 0x0F, 0xE3,
  0xF7, 0xC3, 0xF8, 0x3F, 0x8F, 0xDF, 0x1F, 0xC0, 0xFE, 0x3F, 0x7C, 0x7F,
  0x03, 0xF8, 0xF9, 0xF1, 0xFC, 0x0F, 0xE7, 0xE7, 0xC7, 0xF0, 0x3F, 0x9F,
  0x9F, 0x3F, 0x80, 0xFE, 0x7C, 0x7C, 0xFE, 0x03, 0xFB, 0xF1, 0xF3, 0xF8,
  0x0F, 0xEF, 0xC7, 0xCF, 0xC0, 0x3F, 0xBE, 0x1F, 0x7F, 0x00, 0xFF, 0xF8,
  0x7D, 0xFC, 0x03, 0xFF, 0xE1, 0xF7, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xCF, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00,
  0x3F, 0x9F, 0xE0, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF9, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC,
  0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x00,
  0x7E, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFD, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0x7F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE1,
  0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x80, 0x03, 0xFC,
  0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0xFF,
  0xE1, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0xFF, 0x01, 0xFF, 0xFC,
  0x7F, 0x80, 0x3F, 0xF8, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0xF0, 0x00, 0x0F, 0xE1, 0xFF, 0x80, 0x03, 0xF9, 0xFF, 0xF8, 0x01, 0xFE,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8,
  0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F,
  0xE1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x7F,
  0xFF, 0xC0, 0x3F, 0x8F, 0xFF, 0xE0, 0x0F, 0xE0, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x1F,
  0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFE, 0x3F,
  0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0xFF,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F,
  0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x87,
  0xF8, 0x00, 0x7F, 0xFF, 0x3F, 0xC0, 0x07, 0xFF, 0xFD, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x1F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x7F, 0x00, 0x0F, 0xFF, 0xF7, 0xF0, 0x00, 0x3F, 0xFF,
  0x3F, 0x80, 0x00, 0x7F, 0xE1, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0C, 0x07, 0xFC, 0x00, 0x0F, 0x01,
  0xFF, 0x00, 0x0F, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x06, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0xC0, 0x03, 0xFF,
  0xF1, 0xFC, 0x00, 0x7F, 0xFF, 0xCF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xF8,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF3, 0xFC, 0x00, 0x07,
  0xFF, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x08, 0x00, 0x07, 0xF8, 0x00, 0xC0, 0x00,
  0x7F, 0xC0, 0x0F, 0x00, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0xC0, 0x03, 0xFC, 0x7F, 0xFE, 0x00, 0x7F,
  0x9F, 0xFF, 0xE0, 0x0F, 0xF7, 0xFF, 0xFE, 0x01, 0xFD, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x07, 0xFE, 0x01,
  0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x7F,
  0xE0, 0x03, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0xE0, 0x01, 0xFE,
  0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0x8F, 0xFE, 0x00,
  0x03, 0xFC, 0xFF, 0xC0, 0x00, 0x1F, 0xCF, 0xFC, 0x00, 0x01, 0xFE, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFB, 0xFC, 0x00, 0x03, 0xFF,
  0x9F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x18, 0x01, 0x80, 0x07, 0xF1, 0xFE, 0x1F, 0xE0,
  0x0F, 0xEF, 0xFC, 0x7F, 0xE0, 0x1F, 0xFF, 0xFD, 0xFF, 0xE0, 0x3F, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xFE, 0x3F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0,
  0x7F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F,
  0xF0, 0xFF, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xF8,
  0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE,
  0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0,
  0x7F, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x3F,
  0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF8,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0x7F, 0x0F,
  0xF0, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0xFE,
  0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x3F, 0x87, 0xF8, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0, 0x3F,
  0x81, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3F, 0x83, 0xFF, 0x00,
  0x0F, 0xF1, 0xFF, 0xF8, 0x01, 0xFC, 0x7F, 0xFF, 0x80, 0x3F, 0x9F, 0xFF,
  0xF8, 0x07, 0xF7, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE,
  0x07, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01,
  0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0xFF,
  0x8F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0x3F, 0xFF, 0x00,
  0x0F, 0xE7, 0xFF, 0xF8, 0x00, 0xFE, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x0F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xEF, 0xFF, 0xF8, 0x01,
  0xFE, 0x7F, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0xC0, 0x03, 0xFC, 0x03, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xF0, 0x07, 0xFF, 0xF1,
  0xFC, 0x03, 0xFF, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xF8,
  0x01, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xC0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x7F, 0x00, 0x1F, 0xFF, 0x9F, 0xC0, 0x01, 0xFF, 0x87,
  0xF0, 0x00, 0x0F, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x0F, 0xFF, 0x03, 0xFC, 0x3F,
  0xFF, 0x03, 0xF8, 0xFF, 0xFF, 0x03, 0xF9, 0xFF, 0xFE, 0x03, 0xFB, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3C, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F, 0xFC, 0x0F, 0xF8,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x1F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x1C, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF7, 0xF0, 0x07, 0xFF, 0xF9, 0xFC, 0x00,
  0xFF, 0xF8, 0x7F, 0x00, 0x1F, 0xFC, 0x3F, 0x80, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xE0, 0x00, 0x07, 0xF9, 0xFC, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xF0,
  0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x03, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F,
  0xFF, 0x80, 0x7E, 0x01, 0xFD, 0xFC, 0x03, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F,
  0x80, 0xFE, 0x7F, 0x01, 0xFC, 0x07, 0xF3, 0xF8, 0x1F, 0xE0, 0x3F, 0x9F,
  0xC0, 0xFF, 0x01, 0xF8, 0xFE, 0x07, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0xC0,
  0xFE, 0x3F, 0x83, 0xFE, 0x07, 0xE1, 0xFC, 0x3E, 0xF0, 0x7F, 0x0F, 0xE1,
  0xF7, 0x83, 0xF8, 0x7F, 0x0F, 0xBC, 0x1F, 0x83, 0xF0, 0xF9, 0xE1, 0xFC,
  0x1F, 0x87, 0xCF, 0x0F, 0xE0, 0xFC, 0x3E, 0x78, 0x7E, 0x07, 0xE3, 0xE3,
  0xE7, 0xF0, 0x3F, 0x1F, 0x1F, 0x3F, 0x01, 0xF9, 0xF8, 0xF9, 0xF8, 0x0F,
  0xCF, 0x87, 0xDF, 0xC0, 0x7E, 0x7C, 0x3E, 0xFC, 0x03, 0xF7, 0xC1, 0xF7,
  0xE0, 0x1F, 0xBE, 0x0F, 0xFF, 0x00, 0xFD, 0xF0, 0x7F, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x0F, 0xF7,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x00, 0x7F, 0xC7, 0xF8, 0x00,
  0x00, 0xFF, 0x87, 0xF8, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFE,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7E, 0x3F, 0xFF, 0xC0,
  0x03, 0xF3, 0xFF, 0xFF, 0x00, 0x1F, 0xBF, 0xFF, 0xFC, 0x01, 0xF9, 0xFF,
  0xFF, 0xF8, 0x1F, 0xDF, 0xE0, 0x7F, 0xFF, 0xFE, 0xFC, 0x01, 0xFF, 0xFF,
  0xE7, 0xE0, 0x07, 0xFF, 0xFE, 0x3E, 0x00, 0x1F, 0xFF, 0xF1, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
};

const GFXglyph RobotoMono_MediumItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 16, 49, 40, 12, -48 },
  { 99, 21, 17, 40, 12, -51 },
  { 144, 40, 48, 40, 0, -48 },
  { 384, 35, 63, 40, 3, -56 },
  { 660, 33, 50, 40, 4, -49 },
  { 867, 37, 50, 40, 1, -49 },
  { 1099, 9, 17, 40, 17, -51 },
  { 1119, 22, 69, 40, 11, -54 },
  { 1309, 23, 69, 40, 5, -54 },
  { 1508, 32, 33, 40, 6, -48 },
  { 1640, 34, 35, 40, 3, -40 },
  { 1789, 14, 21, 40, 6, -8 },
  { 1826, 27, 6, 40, 8, -24 },
  { 1847, 11, 11, 40, 12, -10 },
  { 1863, 35, 52, 40, 3, -48 },
  { 2091, 33, 50, 40, 4, -49 },
  { 2298, 23, 48, 40, 8, -48 },
  { 2436, 36, 49, 40, 0, -49 },
  { 2657, 34, 50, 40, 2, -49 },
  { 2870, 35, 48, 40, 1, -48 },
  { 3080, 36, 49, 40, 3, -48 },
  { 3301, 32, 50, 40, 3, -49 },
  { 3501, 35, 48, 40, 5, -48 },
  { 3711, 34, 50, 40, 3, -49 },
  { 3924, 31, 49, 40, 5, -49 },
  { 4114, 16, 39, 40, 13, -38 },
  { 4192, 20, 51, 40, 10, -38 },
  { 4320, 31, 31, 40, 5, -37 },
  { 4441, 33, 20, 40, 4, -31 },
  { 4524, 32, 31, 40, 3, -36 },
  { 4648, 29, 50, 40, 9, -49 },
  { 4830, 37, 48, 40, 2, -48 },
  { 5052, 37, 48, 40, -2, -48 },
  { 5274, 38, 48, 40, 1, -48 },
  { 5502, 36, 50, 40, 3, -49 },
  { 5727, 37, 48, 40, 1, -48 },
  { 5949, 38, 48, 40, 2, -48 },
  { 6177, 39, 48, 40, 2, -48 },
  { 6411, 36, 50, 40, 3, -49 },
  { 6636, 39, 48, 40, 1, -48 },
  { 6870, 37, 48, 40, 2, -48 },
  { 7092, 38, 49, 40, 2, -48 },
  { 7325, 43, 48, 40, 1, -48 },
  { 7583, 31, 48, 40, 2, -48 },
  { 7769, 40, 48, 40, 1, -48 },
  { 8009, 39, 48, 40, 1, -48 },
  { 8243, 35, 50, 40, 3, -49 },
  { 8462, 38, 48, 40, 2, -48 },
  { 8690, 35, 57, 40, 3, -49 },
  { 8940, 38, 48, 40, 1, -48 },
  { 9168, 37, 50, 40, 2, -49 },
  { 9400, 38, 48, 40, 5, -48 },
  { 9628, 37, 49, 40, 3, -48 },
  { 9855, 37, 48, 40, 6, -48 },
  { 10077, 38, 48, 40, 5, -48 },
  { 10305, 45, 48, 40, -2, -48 },
  { 10575, 37, 48, 40, 7, -48 },
  { 10797, 40, 48, 40, 0, -48 },
  { 11037, 25, 67, 40, 8, -56 },
  { 11247, 16, 52, 40, 13, -48 },
  { 11351, 24, 67, 40, 8, -56 },
  { 11552, 26, 25, 40, 7, -48 },
  { 11634, 31, 6, 40, 0, 0 },
  { 11658, 13, 9, 40, 18, -49 },
  { 11673, 33, 38, 40, 2, -37 },
  { 11830, 34, 52, 40, 2, -51 },
  { 12051, 32, 38, 40, 4, -37 },
  { 12203, 37, 52, 40, 3, -51 },
  { 12444, 33, 38, 40, 3, -37 },
  { 12601, 36, 53, 40, 6, -53 },
  { 12840, 37, 51, 40, 1, -37 },
  { 13076, 35, 51, 40, 1, -51 },
  { 13300, 30, 50, 40, 3, -50 },
  { 13488, 31, 65, 40, 1, -50 },
  { 13740, 37, 51, 40, 2, -51 },
  { 13976, 31, 51, 40, 3, -51 },
  { 14174, 39, 37, 40, -1, -37 },
  { 14355, 35, 37, 40, 1, -37 },
  { 14517, 33, 38, 40, 3, -37 },
  { 14674, 36, 51, 40, -1, -37 },
  { 14904, 34, 51, 40, 3, -37 },
  { 15121, 32, 37, 40, 6, -37 },
  { 15269, 33, 38, 40, 3, -37 },
  { 15426, 30, 46, 40, 6, -45 },
  { 15599, 34, 37, 40, 4, -36 },
  { 15757, 35, 36, 40, 5, -36 },
  { 15915, 37, 36, 40, 4, -36 },
  { 16082, 40, 36, 40, 0, -36 },
  { 16262, 42, 51, 40, 0, -36 },
  { 16530, 36, 36, 40, 1, -36 },
  { 16692, 26, 65, 40, 10, -53 },
  { 16904, 15, 61, 40, 12, -48 },
  { 17019, 27, 65, 40, 6, -53 },
  { 17239, 37, 14, 40, 1, -27 },
};

const GFXfont RobotoMono_MediumItalic68pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic68pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic68pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _ROBOTOMONO_MEDIUMITALIC68PT7B_H_
