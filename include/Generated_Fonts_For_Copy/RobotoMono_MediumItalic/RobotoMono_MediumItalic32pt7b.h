#ifndef _ROBOTOMONO_MEDIUMITALIC32PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x3C, 0x78, 0xF1, 0xE3, 0x87, 0x1E, 0x3C, 0x78, 0xE1, 0xC3,
  0x8F, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x0F, 0x1E, 0x38, 0x00, 0x71, 0xDC,
  0x66, 0x3B, 0x8E, 0xE3, 0xB8, 0xEC, 0x33, 0x0C, 0x00, 0x71, 0xC0, 0x0E,
  0x38, 0x01, 0x86, 0x00, 0x71, 0xC0, 0x0E, 0x30, 0x01, 0x86, 0x00, 0x71,
  0xC0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x71, 0xC0, 0x0C, 0x30, 0x01, 0x8E,
  0x00, 0x71, 0xC0, 0x0C, 0x30, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF,
  0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0C, 0x30, 0x03, 0x8E, 0x00, 0x71, 0xC0,
  0x1C, 0x70, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x01, 0xF8, 0x07,
  0xFC, 0x0F, 0xFE, 0x1F, 0x1E, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3C, 0x00, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xF0, 0x3C, 0xF0,
  0x7C, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x3E, 0x00, 0xFE, 0x01, 0xCC, 0x07, 0x1C, 0x6E, 0x39, 0xDC, 0x63,
  0x38, 0xCE, 0x73, 0xB8, 0x7E, 0x60, 0x79, 0xC0, 0x07, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xE6, 0x03, 0xBF, 0x06, 0x7F, 0x1D, 0xC6, 0x73, 0x0D, 0xC6,
  0x19, 0x0C, 0x70, 0x1C, 0xE0, 0x3F, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x01,
  0xFC, 0x01, 0xFF, 0x01, 0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0xF0,
  0x1C, 0xF0, 0x0E, 0xF0, 0x07, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xFC,
  0x3B, 0xFE, 0x1D, 0xE7, 0x9F, 0xE3, 0xCE, 0xF0, 0xFF, 0x70, 0x3F, 0x3C,
  0x1F, 0x9E, 0x0F, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFE, 0x3C, 0x77, 0x77,
  0x76, 0xEE, 0x00, 0xC0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x80,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03,
  0x81, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x0E,
  0x02, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x04, 0x18, 0x0C,
  0x31, 0xFF, 0x6F, 0xFF, 0xFF, 0x0F, 0xE0, 0x0F, 0x00, 0x3F, 0x00, 0xEE,
  0x03, 0x8E, 0x0F, 0x1E, 0x1C, 0x1C, 0x10, 0x20, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x73, 0xCF, 0x3C, 0xE7, 0x9C, 0xE1, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xF3,
  0xC1, 0xE7, 0x01, 0xDE, 0x03, 0xBC, 0x07, 0x78, 0x3E, 0xE0, 0xFD, 0xC7,
  0xFB, 0x9E, 0xFF, 0xF9, 0xFF, 0xC3, 0xFF, 0x07, 0x78, 0x0E, 0xE0, 0x3D,
  0xE0, 0x7B, 0xC0, 0xE3, 0x83, 0xC7, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x00,
  0x00, 0x40, 0x70, 0xFD, 0xFF, 0xFF, 0xFE, 0xEC, 0x38, 0x0E, 0x07, 0x81,
  0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC1,
  0xE1, 0xE1, 0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFE,
  0x1E, 0x1F, 0x3C, 0x0F, 0x3C, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF8, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x1E, 0xE0, 0x1C, 0xF0, 0x3C, 0xF0, 0x7C, 0x7F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xBC, 0x03, 0x9C, 0x03, 0xCE, 0x03,
  0xCF, 0x01, 0xC7, 0x81, 0xC3, 0xC1, 0xE1, 0xC1, 0xE0, 0xE1, 0xE0, 0xF0,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F,
  0xFF, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3B, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF8, 0x7C, 0x7C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0xE0, 0x3C, 0xE0, 0x3C, 0xF0, 0x78, 0x7F, 0xF0, 0x7F,
  0xE0, 0x1F, 0xC0, 0x00, 0x38, 0x07, 0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0x7B, 0xE1, 0xDF, 0xCF, 0xFF, 0xBF, 0x1F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFF, 0x07,
  0xBC, 0x1E, 0x7F, 0xF0, 0xFF, 0x81, 0xFC, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0x9F, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x07,
  0xFE, 0x0F, 0xFF, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x07, 0x1C, 0x07, 0x1E,
  0x0F, 0x1E, 0x0F, 0x0F, 0x1E, 0x0F, 0xFC, 0x07, 0xF8, 0x1F, 0xFC, 0x3C,
  0x3C, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1E, 0xF0, 0x1E, 0x70, 0x1E, 0x78,
  0x3C, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xE0, 0x07, 0xC0, 0x7F, 0xC3, 0xFF,
  0x9F, 0x1E, 0x78, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFF, 0x03, 0xFC, 0x1F, 0xFD, 0xF9, 0xFF, 0xE3, 0xFF, 0x81, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x3E, 0x03, 0xF0, 0x7F, 0x81, 0xF8, 0x07, 0x80, 0x00,
  0x0C, 0x1E, 0x3F, 0x3E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0xF8, 0xF8, 0xF8, 0x78, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x78,
  0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x07, 0x83, 0x80, 0x80, 0x00, 0x06, 0x00,
  0x3C, 0x03, 0xF8, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0x1F, 0x00, 0x7C, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x03, 0x00,
  0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x10, 0x00, 0x38, 0x00, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0x80, 0x1F, 0x01, 0xFE,
  0x1F, 0xF1, 0xFF, 0x03, 0xF8, 0x07, 0x80, 0x0C, 0x00, 0x20, 0x00, 0x00,
  0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F, 0xC0, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x07, 0x80, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x7F, 0x80, 0x7F, 0xF0,
  0x38, 0x0C, 0x1C, 0x01, 0x86, 0x1C, 0x63, 0x9F, 0xD8, 0xCE, 0x66, 0x63,
  0x19, 0x99, 0xC6, 0x6E, 0x61, 0x9B, 0x18, 0xC6, 0xCE, 0x31, 0xB3, 0x8C,
  0x6C, 0xE7, 0x33, 0x3B, 0xCC, 0xC7, 0xFE, 0x31, 0xEF, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x78, 0x60, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xB8, 0x01, 0xEF, 0x00, 0x73, 0xC0, 0x3C, 0x70, 0x0E, 0x1C,
  0x07, 0x87, 0x01, 0xC1, 0xC0, 0xF0, 0x70, 0x3F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x78, 0x03, 0x9E, 0x00, 0xEF, 0x00,
  0x3C, 0x1F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xC3, 0xF1, 0xC0, 0x78,
  0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x0F, 0x8F, 0xFF,
  0x87, 0xFF, 0x87, 0xFF, 0xE3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x70,
  0x0F, 0x38, 0x07, 0xBC, 0x07, 0x9E, 0x07, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3,
  0xFF, 0x80, 0x01, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xE1, 0xE1, 0xE0,
  0x79, 0xE0, 0x3C, 0xF0, 0x0E, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x0F, 0x38, 0x07, 0x1E, 0x07, 0x8F, 0x07, 0x83, 0xFF, 0xC0, 0xFF,
  0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3C, 0xFC,
  0x0E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7,
  0x80, 0xF1, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0x8F, 0x00, 0xE3, 0xC0,
  0x78, 0xE0, 0x1E, 0x38, 0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xE1, 0xE1, 0xF0,
  0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1,
  0xFF, 0xFC, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xE1, 0xE1,
  0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x0E, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x0F, 0xE7, 0x07, 0xF7, 0x87, 0xFB, 0xC0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x0F, 0x38, 0x07, 0x1E, 0x03, 0x8F, 0x83, 0xC3, 0xFF, 0xE0,
  0xFF, 0xE0, 0x3F, 0xC0, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x38, 0x07, 0x07,
  0x00, 0xE0, 0xE0, 0x1C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1C,
  0x03, 0x83, 0x80, 0x70, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x78,
  0x0F, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0,
  0x3C, 0x3C, 0x07, 0x87, 0x00, 0xE0, 0xE0, 0x1C, 0x3C, 0x07, 0x80, 0x0F,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78,
  0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xC1, 0xE1, 0xF0, 0x7F, 0xF8, 0x0F,
  0xFC, 0x01, 0xFC, 0x00, 0x1E, 0x01, 0xF1, 0xE0, 0x3E, 0x1E, 0x07, 0xC1,
  0xE0, 0xF8, 0x1E, 0x1F, 0x01, 0xC3, 0xE0, 0x3C, 0x7C, 0x03, 0xCF, 0x80,
  0x3D, 0xF0, 0x03, 0xDE, 0x00, 0x3B, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xEF, 0x00, 0x7C, 0xF0, 0x07, 0x8F, 0x80, 0x70, 0x78, 0x07, 0x07,
  0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xE0,
  0x0F, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0x00, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x87, 0xC3, 0xF0, 0xF8, 0x7C, 0x3F, 0x1F,
  0x87, 0xF3, 0xF0, 0xEE, 0xEE, 0x1D, 0xDF, 0xC3, 0xBF, 0x78, 0x77, 0xEE,
  0x1E, 0xF9, 0xC3, 0xCF, 0x38, 0x71, 0xCF, 0x0E, 0x39, 0xE1, 0xC6, 0x3C,
  0x38, 0x07, 0x0F, 0x00, 0xE1, 0xE0, 0x1C, 0x38, 0x07, 0x87, 0x00, 0xF0,
  0xE0, 0x1E, 0x3C, 0x03, 0x80, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3E, 0x07,
  0x07, 0xC0, 0xE0, 0xF8, 0x3C, 0x3F, 0x07, 0x87, 0xF0, 0xF0, 0xFE, 0x1E,
  0x1F, 0xC3, 0x83, 0xBC, 0x70, 0x73, 0x9E, 0x1E, 0x73, 0xC3, 0xCE, 0x78,
  0x78, 0xEF, 0x0F, 0x1D, 0xC1, 0xC3, 0xF8, 0x78, 0x7F, 0x0F, 0x07, 0xE1,
  0xE0, 0xFC, 0x3C, 0x1F, 0x87, 0x81, 0xE0, 0xE0, 0x3C, 0x3C, 0x07, 0x80,
  0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x81, 0xE3, 0xE1, 0xE0, 0xF1, 0xE0,
  0x3C, 0xF0, 0x1E, 0x70, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEE,
  0x00, 0xF7, 0x00, 0x77, 0x80, 0x3B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0E,
  0x38, 0x0F, 0x1E, 0x07, 0x8F, 0x0F, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F,
  0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x78, 0x3E, 0x1E, 0x07,
  0x87, 0x80, 0xF1, 0xC0, 0x3C, 0x70, 0x0F, 0x3C, 0x03, 0x8F, 0x01, 0xE3,
  0xC0, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x81,
  0xE1, 0xE1, 0xE0, 0x71, 0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x0F, 0x78, 0x07,
  0xBC, 0x03, 0xDE, 0x01, 0xEE, 0x00, 0xF7, 0x00, 0x7F, 0x80, 0x3B, 0xC0,
  0x1D, 0xE0, 0x1E, 0xF0, 0x0F, 0x38, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0x83,
  0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0E,
  0x00, 0x02, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xC3, 0xF1,
  0xE0, 0x78, 0xE0, 0x3C, 0x70, 0x0E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03,
  0xCF, 0x07, 0xC7, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0x81, 0xE1, 0xE0, 0xF0,
  0xF0, 0x70, 0x78, 0x38, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x01, 0xE7,
  0x80, 0xF3, 0x80, 0x78, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7C,
  0x3E, 0x1E, 0x07, 0x8F, 0x00, 0xE3, 0xC0, 0x38, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF1, 0xE0,
  0x78, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFE, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x00, 0xE3, 0x80, 0x73, 0xC0,
  0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x38, 0x07, 0x1C, 0x03, 0x9E,
  0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xC0, 0x38, 0xE0, 0x3C,
  0x70, 0x1E, 0x3C, 0x0E, 0x1E, 0x0F, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F,
  0x00, 0xF0, 0x07, 0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xE3,
  0x80, 0xF1, 0xC0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1C,
  0x0F, 0x1E, 0x03, 0x8E, 0x01, 0xCF, 0x00, 0xE7, 0x80, 0x77, 0x80, 0x3F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x70, 0xE1, 0xDC, 0x38, 0xF7, 0x1E, 0x3D, 0xC7, 0x8E, 0x71,
  0xE3, 0x9C, 0xF9, 0xE7, 0x3E, 0x71, 0xCF, 0x9C, 0x77, 0xE7, 0x1D, 0xFB,
  0xC7, 0x7E, 0xE3, 0xDB, 0xB8, 0xFE, 0xEE, 0x3F, 0xBF, 0x8E, 0xCF, 0xC3,
  0xF3, 0xF0, 0xFC, 0xFC, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF0,
  0xF8, 0x3C, 0x3C, 0x0F, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x3C, 0x07, 0x81,
  0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x3C, 0x3C, 0x01, 0xE3, 0xC0, 0x07, 0x1E,
  0x00, 0x3D, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0xC0,
  0x07, 0x9E, 0x00, 0x78, 0x70, 0x07, 0xC3, 0xC0, 0x3C, 0x1E, 0x03, 0xC0,
  0x78, 0x3E, 0x03, 0xC3, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0xF8, 0x07, 0xDE,
  0x03, 0xCF, 0x03, 0xC7, 0x81, 0xE1, 0xC1, 0xE0, 0xF1, 0xE0, 0x78, 0xF0,
  0x1C, 0xF0, 0x0E, 0x78, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC0, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0xE1, 0xFC, 0x3F, 0x80, 0xE0, 0xE0,
  0xF0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x78, 0x38, 0x38, 0x38, 0x38, 0x3C,
  0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x07,
  0xE1, 0xFC, 0x3F, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78,
  0x0F, 0x0F, 0xE1, 0xFC, 0x3F, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0xF8, 0x07,
  0xC0, 0x7E, 0x07, 0x70, 0x39, 0x83, 0x8E, 0x1C, 0x71, 0xC3, 0x8E, 0x1D,
  0xE0, 0x70, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0xF3, 0x9E, 0x70, 0x07,
  0xF0, 0x1F, 0xF8, 0x7F, 0xF9, 0xE0, 0xF3, 0xC0, 0xE0, 0x01, 0xC0, 0x07,
  0x87, 0xFF, 0x3F, 0xFE, 0xF8, 0x3D, 0xE0, 0x77, 0x80, 0xEF, 0x03, 0xDE,
  0x0F, 0x9F, 0xFF, 0x3F, 0xFE, 0x3F, 0xBC, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1D, 0xF8, 0x3F,
  0xFC, 0x3F, 0xFE, 0x3E, 0x1E, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x70, 0x1E, 0x70, 0x1E, 0xF8,
  0x3C, 0xFF, 0xF8, 0xFF, 0xF8, 0xE7, 0xE0, 0x07, 0xF0, 0x3F, 0xF0, 0xFF,
  0xF1, 0xE1, 0xE7, 0x81, 0xEE, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x01, 0xEF, 0x03, 0x9E, 0x0F, 0x1F, 0xFC, 0x1F,
  0xF0, 0x1F, 0xC0, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x1F, 0x9C, 0x1F, 0xEE, 0x1F, 0xFF,
  0x1F, 0x0F, 0x8F, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xE3, 0xC0, 0x71, 0xC0,
  0x78, 0xE0, 0x3C, 0x70, 0x1E, 0x38, 0x0F, 0x1E, 0x0F, 0x0F, 0x0F, 0x83,
  0xFF, 0xC1, 0xFE, 0xE0, 0x7E, 0xF0, 0x03, 0xF8, 0x07, 0xFC, 0x1F, 0xFE,
  0x1E, 0x1E, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x70, 0x00, 0x70, 0x00, 0x78, 0x08, 0x7C, 0x1C, 0x3F, 0xFE,
  0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x7E,
  0x20, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0xFF, 0xFE, 0x7F,
  0xFE, 0x3F, 0xFF, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE7,
  0x87, 0xFF, 0x87, 0xFF, 0xC7, 0xC3, 0xE3, 0xC0, 0xF3, 0xC0, 0x79, 0xE0,
  0x3C, 0xF0, 0x1C, 0x70, 0x0E, 0x38, 0x0F, 0x1C, 0x07, 0x8E, 0x03, 0xC7,
  0x81, 0xE3, 0xC1, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xBC, 0x00, 0x1E,
  0x00, 0x0E, 0x08, 0x0F, 0x0F, 0x1F, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0xFC, 0x3D, 0xFE, 0x3F, 0xFE, 0x3E, 0x1F, 0x3C,
  0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x78, 0x0E, 0x78,
  0x1E, 0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x1C, 0xE0,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x3F, 0xE0, 0xFE, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x1F, 0x3C, 0x1F, 0x1E, 0x1F, 0x0F, 0x1F, 0x07, 0x9F,
  0x03, 0x9E, 0x01, 0xDE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3E,
  0xF0, 0x1E, 0x3C, 0x0E, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xE3, 0xC0, 0xF1,
  0xE0, 0x7C, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x0F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x3D,
  0xE7, 0x8E, 0xFF, 0xE3, 0xFF, 0xFC, 0xF3, 0xCF, 0x38, 0xE3, 0xCE, 0x38,
  0xF7, 0x8E, 0x39, 0xE3, 0x8E, 0x71, 0xE3, 0x9C, 0x78, 0xE7, 0x1C, 0x79,
  0xC7, 0x1E, 0xF1, 0xC7, 0x3C, 0x71, 0xCE, 0x3C, 0x73, 0x8F, 0x1C, 0xE3,
  0x8F, 0x00, 0x1C, 0xFC, 0x3D, 0xFE, 0x3F, 0xFE, 0x3E, 0x1F, 0x3C, 0x0F,
  0x38, 0x0F, 0x38, 0x0F, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x1E,
  0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x1C, 0xE0, 0x3C,
  0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3E, 0x1E, 0x3C, 0x0E, 0x78, 0x0F,
  0x78, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0x70, 0x1E,
  0x78, 0x1E, 0x78, 0x3C, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xE0, 0x0E, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xE1, 0xE1, 0xE0, 0x70, 0xE0, 0x3C, 0x70,
  0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0x8F, 0x03, 0xC7, 0x01, 0xE3,
  0x80, 0xF3, 0xE0, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7B, 0xF0, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x0F, 0xCF, 0x1F, 0xEE, 0x3F, 0xFE, 0x7C, 0x3E, 0x78, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1C, 0xF0, 0x1C, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0,
  0x3C, 0xF0, 0x38, 0xF0, 0x78, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x1C, 0x7E, 0x3B, 0xFC, 0xFF, 0xF1, 0xFE, 0xE3, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x0F,
  0xFC, 0x1F, 0xFE, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x3E, 0x80, 0x1E, 0x70, 0x1E, 0x78,
  0x1E, 0x7E, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x38, 0x0F, 0x38, 0x0E,
  0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1E, 0x70, 0x1C,
  0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78,
  0xFF, 0xF8, 0x7F, 0xB8, 0x3F, 0x78, 0xF0, 0x0F, 0xB8, 0x07, 0x9E, 0x03,
  0x8F, 0x03, 0xC7, 0x81, 0xC1, 0xC1, 0xE0, 0xE0, 0xE0, 0x70, 0xF0, 0x3C,
  0x70, 0x0E, 0x78, 0x07, 0x38, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8,
  0xF1, 0xDC, 0x78, 0xEE, 0x3C, 0x77, 0x3E, 0x73, 0x9B, 0x39, 0xDD, 0x9C,
  0xEE, 0xDC, 0x76, 0x6E, 0x3F, 0x37, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7,
  0xC3, 0xC3, 0xC1, 0xE1, 0xE0, 0xE0, 0xE0, 0x00, 0x1E, 0x03, 0xE1, 0xE0,
  0xF8, 0x3C, 0x3E, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0xF3, 0xC0, 0x3C, 0x78, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0xF8, 0x0F,
  0x00, 0x3C, 0x01, 0xF1, 0xC0, 0x1E, 0x1E, 0x03, 0xC1, 0xE0, 0x7C, 0x1E,
  0x07, 0x80, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00,
  0x73, 0xC0, 0x07, 0x38, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF,
  0xFE, 0x00, 0x00, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x03, 0xE0, 0xF8,
  0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x02,
  0x00, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0x61, 0xC3,
  0x87, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0xC3,
  0x86, 0x0C, 0x00, 0x06, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C,
  0x01, 0xF0, 0x0F, 0x03, 0xF0, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0xF8, 0x0F, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x77, 0xFC, 0x1D, 0xEF, 0xCE, 0xE0,
  0xFF, 0xB8, 0x1F, 0xC0, 0x01, 0xE0,
};

const GFXglyph RobotoMono_MediumItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 7, 23, 19, 6, -23 },
  { 22, 10, 8, 19, 6, -24 },
  { 32, 19, 23, 19, 0, -23 },
  { 87, 16, 29, 19, 2, -26 },
  { 145, 15, 23, 19, 2, -23 },
  { 189, 17, 23, 19, 1, -23 },
  { 238, 4, 8, 19, 8, -24 },
  { 242, 11, 32, 19, 5, -25 },
  { 286, 10, 32, 19, 3, -25 },
  { 326, 15, 16, 19, 3, -23 },
  { 356, 15, 17, 19, 2, -19 },
  { 388, 6, 10, 19, 3, -4 },
  { 396, 12, 4, 19, 4, -12 },
  { 402, 5, 5, 19, 6, -5 },
  { 406, 17, 25, 19, 1, -23 },
  { 460, 15, 23, 19, 2, -23 },
  { 504, 10, 23, 19, 4, -23 },
  { 533, 17, 23, 19, 0, -23 },
  { 582, 16, 23, 19, 1, -23 },
  { 628, 17, 23, 19, 0, -23 },
  { 677, 16, 23, 19, 2, -23 },
  { 723, 14, 23, 19, 2, -23 },
  { 764, 17, 23, 19, 2, -23 },
  { 813, 16, 23, 19, 1, -23 },
  { 859, 14, 23, 19, 3, -23 },
  { 900, 8, 18, 19, 6, -18 },
  { 918, 9, 24, 19, 5, -18 },
  { 945, 15, 14, 19, 2, -17 },
  { 972, 15, 10, 19, 2, -15 },
  { 991, 15, 15, 19, 1, -17 },
  { 1020, 14, 23, 19, 4, -23 },
  { 1061, 18, 23, 19, 1, -23 },
  { 1113, 18, 23, 19, -1, -23 },
  { 1165, 17, 23, 19, 1, -23 },
  { 1214, 17, 23, 19, 1, -23 },
  { 1263, 18, 23, 19, 0, -23 },
  { 1315, 18, 23, 19, 1, -23 },
  { 1367, 18, 23, 19, 1, -23 },
  { 1419, 17, 23, 19, 1, -23 },
  { 1468, 19, 23, 19, 0, -23 },
  { 1523, 17, 23, 19, 1, -23 },
  { 1572, 18, 23, 19, 1, -23 },
  { 1624, 20, 23, 19, 1, -23 },
  { 1682, 15, 23, 19, 1, -23 },
  { 1726, 19, 23, 19, 0, -23 },
  { 1781, 19, 23, 19, 0, -23 },
  { 1836, 17, 23, 19, 1, -23 },
  { 1885, 18, 23, 19, 1, -23 },
  { 1937, 17, 27, 19, 1, -23 },
  { 1995, 17, 23, 19, 1, -23 },
  { 2044, 18, 23, 19, 1, -23 },
  { 2096, 18, 23, 19, 2, -23 },
  { 2148, 17, 23, 19, 2, -23 },
  { 2197, 17, 23, 19, 3, -23 },
  { 2246, 18, 23, 19, 2, -23 },
  { 2298, 21, 23, 19, -1, -23 },
  { 2359, 17, 23, 19, 3, -23 },
  { 2408, 19, 23, 19, 0, -23 },
  { 2463, 11, 31, 19, 4, -26 },
  { 2506, 8, 25, 19, 6, -23 },
  { 2531, 11, 31, 19, 4, -26 },
  { 2574, 13, 12, 19, 3, -23 },
  { 2594, 15, 3, 19, 0, 0 },
  { 2600, 5, 4, 19, 9, -23 },
  { 2603, 15, 17, 19, 1, -17 },
  { 2635, 16, 24, 19, 1, -24 },
  { 2683, 15, 17, 19, 2, -17 },
  { 2715, 17, 24, 19, 2, -24 },
  { 2766, 16, 17, 19, 1, -17 },
  { 2800, 17, 25, 19, 3, -25 },
  { 2854, 17, 24, 19, 1, -17 },
  { 2905, 16, 24, 19, 1, -24 },
  { 2953, 14, 23, 19, 2, -23 },
  { 2994, 14, 30, 19, 1, -23 },
  { 3047, 17, 24, 19, 1, -24 },
  { 3098, 15, 24, 19, 1, -24 },
  { 3143, 18, 17, 19, 0, -17 },
  { 3182, 16, 17, 19, 1, -17 },
  { 3216, 16, 17, 19, 1, -17 },
  { 3250, 17, 24, 19, 0, -17 },
  { 3301, 16, 24, 19, 2, -17 },
  { 3349, 15, 17, 19, 3, -17 },
  { 3381, 16, 17, 19, 1, -17 },
  { 3415, 14, 21, 19, 3, -21 },
  { 3452, 16, 17, 19, 2, -17 },
  { 3486, 17, 17, 19, 2, -17 },
  { 3523, 17, 17, 19, 2, -17 },
  { 3560, 19, 17, 19, 0, -17 },
  { 3601, 20, 24, 19, 0, -17 },
  { 3661, 17, 17, 19, 1, -17 },
  { 3698, 12, 31, 19, 5, -25 },
  { 3745, 7, 29, 19, 6, -23 },
  { 3771, 12, 31, 19, 3, -25 },
  { 3818, 18, 7, 19, 0, -13 },
};

const GFXfont RobotoMono_MediumItalic32pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic32pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOMONO_MEDIUMITALIC32PT7B_H_
