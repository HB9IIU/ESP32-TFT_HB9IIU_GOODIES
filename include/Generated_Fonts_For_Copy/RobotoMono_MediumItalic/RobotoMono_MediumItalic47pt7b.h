#ifndef _ROBOTOMONO_MEDIUMITALIC47PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x7C, 0x0F, 0xE0, 0xFE, 0x07,
  0xC0, 0x7C, 0x00, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE1, 0xE3, 0xC3,
  0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x38, 0xE0, 0xF3, 0xC1, 0xE0,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x70, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x0F,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0x83,
  0xC0, 0x00, 0x70, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x70, 0x00,
  0x0E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0x83, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x01,
  0xF0, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC7, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x0F, 0xC1, 0xFE, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0x7C,
  0x00, 0x78, 0xF0, 0x23, 0xC1, 0xE0, 0xCF, 0x07, 0x87, 0xBC, 0x1C, 0x3C,
  0xF0, 0x70, 0xE3, 0xC3, 0xC7, 0x8F, 0x0F, 0x3C, 0x3F, 0xF9, 0xE0, 0x7F,
  0xE7, 0x80, 0xFF, 0x3C, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE3, 0xF0,
  0x0F, 0x3F, 0xE0, 0x3D, 0xFF, 0xC1, 0xE7, 0x8F, 0x0F, 0x3C, 0x3C, 0x38,
  0xF0, 0x71, 0xE3, 0xC1, 0xCF, 0x0F, 0x0F, 0x18, 0x3C, 0x3C, 0x20, 0xF0,
  0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x10, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0x81,
  0xE0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8,
  0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x81, 0xE3, 0xFF, 0xC0, 0xF3, 0xFB, 0xF0, 0xFB, 0xF8, 0xF8, 0x7D,
  0xF8, 0x7E, 0x7E, 0xF8, 0x1F, 0xBE, 0xFC, 0x0F, 0xFF, 0x7E, 0x03, 0xFF,
  0x3F, 0x01, 0xFF, 0x1F, 0x80, 0x7F, 0x8F, 0xC0, 0x3F, 0x83, 0xF0, 0x7F,
  0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0x7E, 0x03, 0xFE,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0x73,
  0xCF, 0x3C, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x01, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x03, 0x03, 0xC0, 0xDF, 0x0E, 0x0F,
  0x7F, 0x39, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xF7, 0x80, 0x0F, 0x8F,
  0x00, 0x7C, 0x3C, 0x03, 0xF0, 0xF8, 0x1F, 0x81, 0xF0, 0x3C, 0x07, 0xC0,
  0x20, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F,
  0x87, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F, 0x87, 0xC3, 0xF0, 0x78, 0x04, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xF8, 0x1F,
  0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xF7, 0xE0, 0x1F, 0xCF, 0xC0, 0x7F, 0x9F,
  0x03, 0xFF, 0x3E, 0x0F, 0xFE, 0x7C, 0x3E, 0x7C, 0xF9, 0xF9, 0xF9, 0xF7,
  0xE3, 0xF7, 0xFF, 0x07, 0xCF, 0xFC, 0x0F, 0x9F, 0xE0, 0x1F, 0x3F, 0x80,
  0x3E, 0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x0F,
  0xC7, 0xE0, 0x1F, 0x07, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0xFC, 0x0F, 0xF8, 0x7F, 0xE7, 0xFF, 0xCF, 0xFF, 0xBF,
  0xFF, 0x7E, 0x3E, 0xE0, 0xFD, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0x00, 0xFC,
  0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0x87, 0xE0, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xE0, 0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x1F, 0x10, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01,
  0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xBE, 0x00, 0x0F, 0xBF, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0x8F, 0x80,
  0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF8,
  0x07, 0xC0, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F,
  0x03, 0xE0, 0x1F, 0x83, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x7F,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x3F, 0x80, 0xF9, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x7F, 0xE7, 0xF9, 0xFE, 0x07, 0xE7, 0xE0, 0x0F, 0x9F, 0x80, 0x3F,
  0x7C, 0x00, 0xFD, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x9F, 0x00, 0x7C, 0x7E, 0x03,
  0xF0, 0xFC, 0x3F, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x0F,
  0xC0, 0x3E, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0xFC, 0x07,
  0xF3, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xC3, 0xF0, 0x3F, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC,
  0x00, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x1F, 0xC1, 0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0x7C,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xF3, 0xF0,
  0x3F, 0x9F, 0xC7, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFD, 0xF0,
  0x1F, 0x8F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x2F, 0xFE, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x81, 0xF8, 0x7F,
  0x8F, 0xF1, 0xFE, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07,
  0xE1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFE, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x03, 0x80, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x40, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x00, 0x08,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xF0, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xE0, 0x7C, 0x03,
  0xE0, 0x07, 0x80, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x3C, 0x1F, 0x87,
  0x0E, 0x1F, 0xF1, 0xC7, 0x8F, 0xFC, 0x71, 0xC7, 0xC7, 0x1C, 0xF1, 0xE1,
  0xC7, 0x38, 0xF0, 0xF1, 0xDE, 0x3C, 0x38, 0x77, 0x8E, 0x0E, 0x1D, 0xC7,
  0x83, 0x87, 0x71, 0xE1, 0xE3, 0x9C, 0x70, 0x70, 0xEF, 0x1C, 0x1C, 0x3B,
  0xC7, 0x07, 0x0E, 0xF1, 0xC3, 0xC7, 0x3C, 0x70, 0xF1, 0xCF, 0x1F, 0xFC,
  0xE3, 0xC7, 0xFF, 0xF8, 0xF0, 0xFD, 0xFC, 0x1C, 0x1C, 0x3C, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC1, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xC7, 0x80,
  0x03, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7E, 0x07,
  0xE0, 0x3E, 0x01, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xE0,
  0x03, 0xF3, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xC0, 0x3F, 0x81, 0xF0,
  0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x3F,
  0x07, 0xE0, 0x7F, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x3E,
  0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xE1, 0xF0, 0x03,
  0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0x03,
  0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x9F, 0x80,
  0x0F, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x7C,
  0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x1F,
  0x81, 0xF8, 0x3F, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7C, 0x1F, 0xE0,
  0x7E, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x1F,
  0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x00,
  0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xC0, 0x03, 0xE3, 0xE0,
  0x01, 0xF1, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0xFE, 0x0F,
  0xC7, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0x3E, 0x1F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xFF, 0xBF, 0x03, 0xFF, 0x9F,
  0x81, 0xFF, 0xCF, 0xC0, 0xFF, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xF9,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x1F,
  0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03,
  0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00,
  0x7C, 0x0F, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x80,
  0xF8, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0,
  0x1F, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xE0,
  0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E,
  0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0x7C,
  0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8,
  0x7C, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0xFE,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x3F,
  0x81, 0xF8, 0x03, 0xF8, 0x0F, 0x80, 0x3F, 0x80, 0x7C, 0x03, 0xF8, 0x03,
  0xE0, 0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC3,
  0xF8, 0x00, 0x7C, 0x3F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x1F, 0x80,
  0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xDF, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0xC0, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0xF7, 0xC1, 0xFF, 0x1E, 0xF0, 0x3D, 0xE7,
  0xBE, 0x0F, 0xBC, 0xF7, 0xC1, 0xF3, 0xBE, 0xF8, 0x3E, 0x7F, 0x9F, 0x07,
  0xCF, 0xF3, 0xE0, 0xF9, 0xFC, 0xF8, 0x3E, 0x3F, 0x9F, 0x07, 0xC7, 0xE3,
  0xE0, 0xF8, 0xFC, 0x7C, 0x1F, 0x1F, 0x0F, 0x83, 0xE3, 0xE1, 0xF0, 0x7C,
  0x38, 0x7C, 0x1F, 0x07, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x1F,
  0x80, 0x1F, 0x03, 0xF8, 0x03, 0xE0, 0xFF, 0x00, 0xFC, 0x1F, 0xE0, 0x1F,
  0x83, 0xFE, 0x03, 0xE0, 0x7F, 0xC0, 0x7C, 0x0F, 0xF8, 0x0F, 0x81, 0xFF,
  0x01, 0xF0, 0x7F, 0xF0, 0x7E, 0x0F, 0xDE, 0x0F, 0xC1, 0xFB, 0xC1, 0xF0,
  0x3E, 0x7C, 0x3E, 0x07, 0xCF, 0x87, 0xC0, 0xF8, 0xF1, 0xF8, 0x3F, 0x1E,
  0x3F, 0x07, 0xE3, 0xE7, 0xE0, 0xFC, 0x7C, 0xF8, 0x1F, 0x07, 0x9F, 0x03,
  0xE0, 0xFB, 0xE0, 0x7C, 0x1F, 0xFC, 0x1F, 0x81, 0xFF, 0x83, 0xF0, 0x3F,
  0xF0, 0x7C, 0x07, 0xFC, 0x0F, 0x80, 0xFF, 0x81, 0xF0, 0x0F, 0xF0, 0x7E,
  0x01, 0xFE, 0x0F, 0xC0, 0x3F, 0xC1, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x7E,
  0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07,
  0xE0, 0x7E, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x1F, 0x3F,
  0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7E,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x3F,
  0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0x80,
  0x1F, 0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC1,
  0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0xFC, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x0F, 0xE0, 0xFC, 0x07, 0xF8, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x00,
  0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xF7, 0xE0,
  0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF,
  0x80, 0x03, 0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xFC,
  0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x3F,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x07, 0xC0, 0x7F, 0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xF8,
  0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1,
  0xF8, 0x07, 0xF0, 0x7C, 0x0F, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0x80,
  0xF8, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x1F,
  0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x00, 0xFC,
  0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xF8, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x3E,
  0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x8F, 0xE0, 0x0F, 0xC3, 0xF8, 0x1F, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8,
  0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xF0, 0x01,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83, 0xE0,
  0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x87,
  0xE0, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F,
  0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x1F, 0x00,
  0x7E, 0x07, 0xC0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x00,
  0x0F, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8,
  0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xC0,
  0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x1F, 0x07, 0xEF, 0x83, 0xE0, 0xF9, 0xF0, 0x7C, 0x1F, 0x3E, 0x0F,
  0x83, 0xE7, 0xC3, 0xF0, 0xF8, 0xF8, 0x7E, 0x1F, 0x1F, 0x0F, 0xC3, 0xE3,
  0xE3, 0xF8, 0x7C, 0x7C, 0x7F, 0x1F, 0x0F, 0x8F, 0xE3, 0xE1, 0xF3, 0xFC,
  0x7C, 0x3C, 0x7F, 0x8F, 0x07, 0x8F, 0xF3, 0xE0, 0xF3, 0xDE, 0x7C, 0x1E,
  0x7B, 0xCF, 0x83, 0xCF, 0x7B, 0xE0, 0x7B, 0xCF, 0x7C, 0x0F, 0x79, 0xEF,
  0x81, 0xEF, 0x3D, 0xE0, 0x3D, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF,
  0x1F, 0xF0, 0x3F, 0xE3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0,
  0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0,
  0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x01, 0xFE, 0x07, 0xE0, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x7E, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0x3E, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x7E, 0x03, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x07, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x8F, 0x80, 0x1F,
  0xC7, 0xC0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x7C, 0x07,
  0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xC3, 0xF0, 0x03, 0xE1,
  0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07,
  0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x7B, 0x80, 0x3E, 0xF0, 0x0F, 0x3C, 0x07, 0xCF,
  0x01, 0xE3, 0xC0, 0xF8, 0xF8, 0x7C, 0x1E, 0x1F, 0x07, 0x8F, 0x81, 0xE3,
  0xC0, 0x7D, 0xF0, 0x1F, 0xF8, 0x03, 0xC0, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0x0F, 0x83, 0xE0, 0xF0,
  0x3C, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE,
  0x1F, 0xC1, 0xF8, 0x7C, 0x03, 0xF3, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0xFF, 0x03, 0xE7, 0xE0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xF3,
  0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x3F, 0x01, 0xFC, 0xFC, 0x0F, 0xF3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFE, 0xFC, 0x1F, 0xF1, 0xF0, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xCF, 0xE0, 0x0F, 0xBF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xF1, 0xFE, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x1F, 0x00,
  0x3F, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7E, 0x00,
  0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFD, 0xFF, 0xC0, 0xF8, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F,
  0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7C,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xF0, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xE3,
  0xF0, 0x0F, 0xFE, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFE,
  0x1F, 0xE0, 0x7E, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x07,
  0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3F,
  0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3F, 0x00,
  0x3E, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xF0, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0x7C, 0x00, 0x7F, 0x1F, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0xC3, 0xF0, 0x1F,
  0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x1F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x7D,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x83, 0xF0, 0x07, 0x83, 0xF8, 0x3F, 0x87, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xF8, 0x10, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x8F, 0x80, 0xFF, 0xE7, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0x0F, 0xF0, 0x7E, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0,
  0x07, 0xC3, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC,
  0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x07,
  0xE0, 0x3F, 0x83, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFD, 0xF0, 0x03, 0xFD, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x04, 0x00, 0x7E, 0x03, 0x00, 0x7F, 0x03, 0xC0, 0x7F, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x87, 0xF0, 0x0F,
  0x9F, 0xF8, 0x0F, 0xBF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xF1, 0xFE, 0x1F,
  0xC0, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x1F,
  0x00, 0x3F, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x7E,
  0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C,
  0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x0E,
  0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x01,
  0xFC, 0x3F, 0x01, 0xFC, 0x0F, 0x80, 0xFE, 0x03, 0xE0, 0x7F, 0x00, 0xF8,
  0x3F, 0x80, 0x3E, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x07, 0xC7, 0xF0, 0x01,
  0xF3, 0xF8, 0x00, 0x7D, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xDF, 0x80, 0x0F, 0xE7,
  0xE0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x1F,
  0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0xE0, 0x7C, 0x01, 0xF8,
  0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x9F, 0x8F, 0x81, 0xF7, 0xF3, 0xF8, 0x3F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFC, 0xFE, 0x7E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0xF8, 0x3E, 0x1F, 0x1F, 0x07, 0xC3, 0xE3, 0xE1, 0xF0,
  0x7C, 0x7C, 0x3E, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7C,
  0x1F, 0x0F, 0x8F, 0x83, 0xC1, 0xF1, 0xF0, 0xF8, 0x3E, 0x3E, 0x1F, 0x07,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3E, 0x0F, 0x87, 0xC7, 0xC1,
  0xE0, 0xF8, 0xF8, 0x7C, 0x1F, 0x1F, 0x0F, 0x83, 0xC3, 0xE1, 0xF0, 0xF8,
  0xF8, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xF0, 0x0F, 0x9F, 0xF8, 0x0F, 0xBF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xF1, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80,
  0x3E, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00,
  0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7E, 0x00,
  0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0xFC, 0x00,
  0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFE, 0x1F, 0x83, 0xF0, 0x1F,
  0x8F, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0xF8, 0x00, 0xFD,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xBE,
  0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xF1, 0xF0,
  0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xF0, 0x7F, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x03, 0xE3,
  0xF8, 0x01, 0xF7, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F,
  0xC7, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x1F, 0x07,
  0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0,
  0xFC, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3F,
  0x0F, 0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F,
  0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7E, 0xFF,
  0xE0, 0x3F, 0x3F, 0xE0, 0x1F, 0x01, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x1F, 0x03, 0xFF, 0xBE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0xE1, 0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C,
  0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC,
  0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8,
  0xFC, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x03, 0xF0,
  0x7F, 0x0F, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFD, 0xF0,
  0x07, 0xF3, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x07, 0xC3, 0xFC,
  0x3E, 0x3F, 0xF0, 0xF9, 0xFF, 0xC3, 0xEF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xE0, 0x20, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFC, 0x0F, 0xC3, 0xF0, 0x0F, 0xC7,
  0xC0, 0x1F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xF0, 0x03,
  0xE7, 0xE0, 0x07, 0xC7, 0xE0, 0x3F, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x30, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3E,
  0x7E, 0x00, 0xFC, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7,
  0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0xFC, 0xF8,
  0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0xC0, 0x1F, 0x9F, 0x80,
  0x3F, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03,
  0xE3, 0xE0, 0x0F, 0xC7, 0xE0, 0x3F, 0x8F, 0xE1, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x1F, 0xF9, 0xF0, 0x1F, 0xE3, 0xE0, 0x02, 0x00, 0x00,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x07, 0xE7,
  0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x3C,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0xF8, 0x03, 0xC3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x3E,
  0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x1C, 0x0F, 0xF8, 0x1E, 0x07, 0xFC, 0x0F, 0x03, 0xFE, 0x0F, 0x83,
  0xEF, 0x07, 0xC1, 0xF7, 0x83, 0xE0, 0xF3, 0xC3, 0xF0, 0xF9, 0xE1, 0xF8,
  0x7C, 0xF0, 0xFE, 0x3C, 0x78, 0xFF, 0x3E, 0x3C, 0x77, 0x9F, 0x1E, 0x7B,
  0xCF, 0x0F, 0x3D, 0xE7, 0x87, 0x9C, 0xF7, 0xC3, 0xDE, 0x7B, 0xC1, 0xEE,
  0x3D, 0xE0, 0xF7, 0x1F, 0xF0, 0x7F, 0x87, 0xF0, 0x3F, 0x83, 0xF8, 0x1F,
  0xC1, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x7E,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0xC0, 0x3F, 0x01, 0xF8, 0x01, 0xF0, 0x3F,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xF1,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x1F, 0x80,
  0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0xF8, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8,
  0xFC, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x07, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0x70, 0x1E, 0x00, 0x01, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x01, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFA, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x81, 0xFF,
  0xC0, 0x3C, 0xFF, 0xF8, 0x0F, 0x7F, 0xFF, 0x07, 0xDF, 0x0F, 0xFF, 0xE7,
  0x81, 0xFF, 0xFB, 0xC0, 0x1F, 0xFC, 0x30, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0x00,
};

const GFXglyph RobotoMono_MediumItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 12, 33, 28, 8, -33 },
  { 51, 15, 11, 28, 8, -35 },
  { 72, 28, 33, 28, 0, -33 },
  { 188, 25, 44, 28, 2, -39 },
  { 326, 22, 35, 28, 3, -34 },
  { 423, 25, 35, 28, 1, -34 },
  { 533, 6, 12, 28, 12, -35 },
  { 542, 16, 48, 28, 7, -37 },
  { 638, 16, 48, 28, 4, -37 },
  { 734, 22, 23, 28, 4, -33 },
  { 798, 23, 25, 28, 2, -28 },
  { 870, 10, 14, 28, 4, -5 },
  { 888, 19, 5, 28, 5, -17 },
  { 900, 8, 7, 28, 8, -7 },
  { 907, 24, 36, 28, 2, -33 },
  { 1015, 23, 35, 28, 3, -34 },
  { 1116, 15, 33, 28, 6, -33 },
  { 1178, 25, 34, 28, 0, -34 },
  { 1285, 24, 35, 28, 1, -34 },
  { 1390, 25, 33, 28, 0, -33 },
  { 1494, 25, 34, 28, 2, -33 },
  { 1601, 22, 35, 28, 2, -34 },
  { 1698, 23, 33, 28, 4, -33 },
  { 1793, 24, 35, 28, 2, -34 },
  { 1898, 21, 34, 28, 4, -34 },
  { 1988, 11, 26, 28, 9, -26 },
  { 2024, 13, 35, 28, 7, -26 },
  { 2081, 22, 21, 28, 3, -25 },
  { 2139, 23, 15, 28, 3, -22 },
  { 2183, 22, 21, 28, 2, -25 },
  { 2241, 20, 34, 28, 6, -34 },
  { 2326, 26, 33, 28, 1, -33 },
  { 2434, 25, 33, 28, -1, -33 },
  { 2538, 26, 33, 28, 1, -33 },
  { 2646, 25, 35, 28, 2, -34 },
  { 2756, 25, 33, 28, 1, -33 },
  { 2860, 27, 33, 28, 1, -33 },
  { 2972, 27, 33, 28, 1, -33 },
  { 3084, 25, 35, 28, 2, -34 },
  { 3194, 28, 33, 28, 0, -33 },
  { 3310, 25, 33, 28, 2, -33 },
  { 3414, 25, 34, 28, 2, -33 },
  { 3521, 29, 33, 28, 1, -33 },
  { 3641, 22, 33, 28, 1, -33 },
  { 3732, 27, 33, 28, 1, -33 },
  { 3844, 27, 33, 28, 1, -33 },
  { 3956, 24, 35, 28, 2, -34 },
  { 4061, 27, 33, 28, 1, -33 },
  { 4173, 25, 40, 28, 2, -34 },
  { 4298, 26, 33, 28, 1, -33 },
  { 4406, 25, 34, 28, 2, -34 },
  { 4513, 26, 33, 28, 4, -33 },
  { 4621, 26, 34, 28, 2, -33 },
  { 4732, 25, 33, 28, 4, -33 },
  { 4836, 27, 33, 28, 3, -33 },
  { 4948, 31, 33, 28, -1, -33 },
  { 5076, 25, 33, 28, 5, -33 },
  { 5180, 28, 33, 28, 0, -33 },
  { 5296, 17, 46, 28, 6, -39 },
  { 5394, 11, 36, 28, 9, -33 },
  { 5444, 16, 46, 28, 6, -39 },
  { 5536, 18, 17, 28, 5, -33 },
  { 5575, 21, 4, 28, 0, 0 },
  { 5586, 9, 6, 28, 12, -34 },
  { 5593, 22, 25, 28, 2, -25 },
  { 5662, 24, 36, 28, 1, -35 },
  { 5770, 23, 26, 28, 2, -25 },
  { 5845, 26, 35, 28, 2, -35 },
  { 5959, 23, 25, 28, 2, -25 },
  { 6031, 25, 36, 28, 4, -36 },
  { 6144, 25, 35, 28, 1, -25 },
  { 6254, 24, 35, 28, 1, -35 },
  { 6359, 21, 34, 28, 2, -34 },
  { 6449, 21, 44, 28, 1, -34 },
  { 6565, 26, 35, 28, 1, -35 },
  { 6679, 21, 35, 28, 2, -35 },
  { 6771, 27, 25, 28, -1, -25 },
  { 6856, 24, 25, 28, 1, -25 },
  { 6931, 23, 26, 28, 2, -25 },
  { 7006, 25, 35, 28, -1, -25 },
  { 7116, 24, 35, 28, 2, -25 },
  { 7221, 22, 25, 28, 4, -25 },
  { 7290, 23, 26, 28, 2, -25 },
  { 7365, 21, 32, 28, 4, -31 },
  { 7449, 23, 26, 28, 3, -25 },
  { 7524, 23, 25, 28, 4, -25 },
  { 7596, 25, 25, 28, 3, -25 },
  { 7675, 28, 25, 28, 0, -25 },
  { 7763, 29, 35, 28, 0, -25 },
  { 7890, 25, 25, 28, 1, -25 },
  { 7969, 18, 45, 28, 7, -37 },
  { 8071, 11, 42, 28, 8, -33 },
  { 8129, 19, 45, 28, 4, -37 },
  { 8236, 26, 10, 28, 0, -19 },
};

const GFXfont RobotoMono_MediumItalic47pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic47pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOMONO_MEDIUMITALIC47PT7B_H_
