#ifndef _ROBOTOMONO_MEDIUMITALIC43PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x80, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xE7, 0x07,
  0x38, 0x7B, 0xC3, 0xDE, 0x1E, 0xE0, 0xE7, 0x07, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x78, 0x00, 0x38,
  0x38, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x0F,
  0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x03, 0x87, 0x80, 0x03, 0xC3, 0xC0,
  0x01, 0xC1, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xF1, 0xF8, 0x3F,
  0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0x7C, 0x3C, 0x01,
  0xF0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x1F,
  0x3E, 0x00, 0x7C, 0xFC, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xE0, 0x7E, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80,
  0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0x9E, 0x00, 0xF0, 0xE0, 0xCE, 0x0E,
  0x0E, 0xE0, 0xE1, 0xCE, 0x0E, 0x3C, 0xE1, 0xE7, 0x8F, 0x1E, 0x70, 0xFF,
  0xCE, 0x07, 0xF9, 0xE0, 0x3F, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x39, 0xFE,
  0x07, 0x3F, 0xF0, 0xF3, 0xCF, 0x0E, 0x78, 0x71, 0xC7, 0x07, 0x3C, 0x70,
  0x77, 0x87, 0x07, 0x10, 0x70, 0xF0, 0x07, 0x0F, 0x00, 0x7F, 0xE0, 0x03,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0x3E, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x00,
  0x1E, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x1E, 0x3F, 0xF8, 0x3C, 0xFD, 0xF0, 0x7B, 0xF1,
  0xF1, 0xF7, 0xC3, 0xE3, 0xDF, 0x83, 0xEF, 0xBE, 0x07, 0xFE, 0x7C, 0x07,
  0xFC, 0xF8, 0x0F, 0xF1, 0xF0, 0x0F, 0xC3, 0xF0, 0x3F, 0x83, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFE, 0x3F, 0x00, 0x3D, 0xE7,
  0x9E, 0x79, 0xE7, 0x3C, 0xF3, 0xCE, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0x80, 0x02, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x60, 0x70, 0x17, 0x87, 0x0F, 0x7E, 0x73, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF0, 0x7F, 0xE0, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xB8,
  0x00, 0xF3, 0xC0, 0x1F, 0x3C, 0x03, 0xE1, 0xE0, 0x7C, 0x1F, 0x03, 0x80,
  0xF0, 0x18, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x87, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8,
  0x7C, 0x3C, 0x3E, 0x1E, 0x1E, 0x02, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x10, 0xFB, 0xF7, 0xFF, 0xFF, 0x9E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xC3, 0xE1, 0xF0, 0x1F,
  0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x00, 0xF7, 0xC0, 0x0F, 0x7C, 0x01,
  0xF7, 0xC0, 0x3F, 0x7C, 0x0F, 0xF7, 0xC1, 0xFF, 0x78, 0x7F, 0xFF, 0x8F,
  0x9F, 0xFB, 0xF1, 0xFF, 0xFC, 0x3E, 0xFF, 0x83, 0xEF, 0xE0, 0x3E, 0xFC,
  0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF8, 0x07, 0xCF,
  0x80, 0xF8, 0x7C, 0x1F, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x70, 0x0F, 0xC1, 0xFF, 0x3F, 0xFD,
  0xFF, 0xE7, 0xFF, 0x9F, 0x3E, 0x70, 0xFA, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0x1F,
  0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF,
  0x01, 0xFF, 0xFE, 0x0F, 0xE1, 0xF8, 0x3E, 0x03, 0xF1, 0xF8, 0x07, 0xC7,
  0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xC0, 0x04, 0x7F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x03,
  0xF3, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1E, 0xF8, 0x00, 0x7D, 0xF0, 0x01,
  0xF3, 0xE0, 0x07, 0xC7, 0x80, 0x0F, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0xF8,
  0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x1E, 0x07, 0xC0, 0x78, 0x0F,
  0x81, 0xF0, 0x1F, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0x80, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFB, 0xF0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0x83, 0xF0, 0x06, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE0,
  0xF8, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xFC, 0x00,
  0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE7, 0xF0,
  0x3D, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF0, 0x7E, 0x7E, 0x03,
  0xE7, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0x7E,
  0x0F, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x00,
  0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xFC, 0x0F, 0xE1, 0xF8, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x3E,
  0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x0F,
  0x83, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x7E, 0x7F, 0x03, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xE3,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xF0,
  0x1F, 0x87, 0xC0, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80,
  0xFF, 0xFC, 0x1F, 0x87, 0xE3, 0xF0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x1F,
  0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01,
  0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x7E, 0x0F, 0xE3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xBC, 0x07, 0xE7, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x02, 0x03,
  0xE0, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0xF0, 0x7E,
  0x3F, 0x8F, 0xE3, 0xF8, 0x7C, 0x00, 0x00, 0x40, 0x0F, 0x80, 0xFC, 0x07,
  0xF0, 0x3F, 0x81, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x01, 0x80,
  0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x00, 0x10,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0x00, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00,
  0x00, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xF0,
  0xFC, 0xFC, 0x0F, 0xDF, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC,
  0x03, 0xE0, 0x3C, 0x07, 0x80, 0x1E, 0x07, 0x00, 0x0E, 0x0E, 0x0F, 0x86,
  0x1E, 0x3F, 0xE7, 0x1C, 0x7F, 0xC7, 0x38, 0xF1, 0xC7, 0x38, 0xE1, 0xC7,
  0x79, 0xE1, 0xC7, 0x71, 0xC1, 0x87, 0x71, 0xC3, 0x86, 0x73, 0xC3, 0x86,
  0xF3, 0x83, 0x8E, 0xE3, 0x83, 0x8E, 0xE3, 0x87, 0x0C, 0xE3, 0x87, 0x1C,
  0xE3, 0x8F, 0x1C, 0xE3, 0xFF, 0x38, 0xE1, 0xFF, 0xF0, 0xE1, 0xF3, 0xE0,
  0x70, 0x00, 0x80, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x06, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0xF0, 0x00,
  0x7D, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x1F,
  0x1F, 0x00, 0x3E, 0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x78, 0x07, 0xC0,
  0xF0, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0x00, 0x3C, 0x7E, 0x00, 0x7C,
  0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x0F, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x7E, 0x1F, 0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3E, 0x03, 0xF8, 0x3E, 0x00, 0xF8,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x07, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0xFE, 0x1F, 0x81, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3E,
  0x00, 0x3C, 0x7C, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE0,
  0xF8, 0x07, 0xC1, 0xF8, 0x3F, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xF0,
  0x3F, 0x03, 0xE0, 0x3F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07,
  0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0xF8,
  0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x1F,
  0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0x81, 0xF0, 0x1F, 0x87, 0xC0, 0x1F,
  0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x05, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x1F, 0xF9, 0xF0, 0x3F, 0xF3, 0xE0, 0x7F, 0xE7, 0xC1,
  0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0xFC, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF8, 0x1F, 0xC1, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xE0,
  0x07, 0x81, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0x78, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xC0,
  0xF0, 0x03, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x0F, 0x80, 0x1E, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x0F,
  0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0xF0, 0x3C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7E, 0x0F, 0xE0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xC0,
  0x0F, 0xE0, 0xF8, 0x03, 0xF8, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x1F, 0x80,
  0xF8, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x1F,
  0x80, 0x0F, 0x87, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x7F, 0x00, 0x0F,
  0x9F, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0x7C, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x1F, 0x00,
  0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x81,
  0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xC1, 0xFC,
  0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F,
  0xE3, 0xFE, 0x1F, 0xF1, 0xFE, 0x0F, 0xF9, 0xEF, 0x07, 0xFC, 0xF7, 0x83,
  0xCE, 0xF7, 0xC1, 0xE7, 0x7B, 0xE0, 0xF3, 0xF9, 0xF0, 0xF9, 0xFC, 0xF0,
  0x7C, 0xFC, 0x78, 0x3E, 0x7E, 0x7C, 0x1E, 0x3E, 0x3E, 0x0F, 0x1F, 0x1F,
  0x07, 0x8F, 0x0F, 0x07, 0xC3, 0x87, 0x83, 0xE1, 0x87, 0xC1, 0xF0, 0x03,
  0xE0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x3E, 0x00,
  0x3C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0x80, 0x0F, 0x83, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0,
  0xFE, 0x01, 0xF0, 0x7F, 0x00, 0xF8, 0x3F, 0x80, 0xF8, 0x1F, 0xC0, 0x7C,
  0x0F, 0xF0, 0x3E, 0x0F, 0xF8, 0x1F, 0x07, 0xFC, 0x0F, 0x83, 0xFF, 0x07,
  0xC1, 0xF7, 0x87, 0xC0, 0xFB, 0xC3, 0xE0, 0x7D, 0xE1, 0xF0, 0x7C, 0xF8,
  0xF8, 0x3E, 0x3C, 0x7C, 0x1F, 0x1E, 0x3E, 0x0F, 0x8F, 0x3E, 0x07, 0xC3,
  0xDF, 0x07, 0xC1, 0xEF, 0x83, 0xE0, 0xF7, 0xC1, 0xF0, 0x7F, 0xE0, 0xF8,
  0x1F, 0xE0, 0x7C, 0x0F, 0xF0, 0x3E, 0x07, 0xF8, 0x3E, 0x01, 0xFC, 0x1F,
  0x00, 0xFE, 0x0F, 0x80, 0x7F, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0x83,
  0xF0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xE3, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0xC0,
  0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F,
  0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7B, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00,
  0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xE1,
  0xF0, 0x1F, 0x87, 0xE0, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xC0, 0x3E, 0x0F,
  0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F,
  0x00, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xFC, 0x0F, 0xE3, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C,
  0x00, 0x7D, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB,
  0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xE1, 0xF0,
  0x1F, 0x87, 0xE0, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0x80, 0x7E, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7C, 0x1F,
  0x01, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x3C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C,
  0x03, 0xE0, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3F, 0x0F,
  0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x3F, 0x03, 0xF8, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1E, 0x1E,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0,
  0x07, 0xC7, 0xC0, 0x0F, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0x87, 0x80, 0x1F,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1,
  0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xFC, 0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xF8,
  0x3F, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0,
  0x07, 0xCF, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x01,
  0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF3, 0xE0, 0x01,
  0xE7, 0xC0, 0x03, 0xDF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x0F, 0x78,
  0x3C, 0x1F, 0x78, 0x3C, 0x1F, 0x78, 0x3C, 0x1E, 0x78, 0x7C, 0x3E, 0x78,
  0x7C, 0x3E, 0x78, 0x7C, 0x3E, 0x78, 0xFC, 0x3C, 0x78, 0xFC, 0x7C, 0xF8,
  0xFC, 0x7C, 0xF9, 0xFC, 0x78, 0xF9, 0xFC, 0x78, 0xF9, 0xDC, 0xF8, 0xFB,
  0xDC, 0xF8, 0xFB, 0xDC, 0xF0, 0xFB, 0x9C, 0xF0, 0xFF, 0x9D, 0xF0, 0xF7,
  0x9D, 0xE0, 0xF7, 0x1D, 0xE0, 0xF7, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x7E,
  0x03, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x1F,
  0x81, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xFC, 0x7C,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x07, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0x3E, 0x01, 0xF0,
  0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x1F, 0x0F, 0xC0,
  0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0xBE, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x7F, 0x80,
  0x7F, 0x80, 0xFF, 0x80, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x83,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x01,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xBC, 0x0F, 0x9C,
  0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x1E, 0x7C, 0x0E, 0x78, 0x0F,
  0xF8, 0x0F, 0xF0, 0x0F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFC, 0x3C, 0x3E, 0x1E, 0x0F, 0x07, 0x01, 0xFE, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0x03, 0xE3, 0xE0, 0x1F, 0x3E,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x7F, 0x83, 0xE7, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3C,
  0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x1F, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xFF, 0x7C, 0x1F, 0xE7, 0xC0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0xFC, 0x03, 0xDF, 0xF8, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xE0, 0xFC, 0x7E, 0x03, 0xE3, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x80, 0x1E, 0x7C, 0x01, 0xF3, 0xE0,
  0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0x80, 0x1F, 0x7C, 0x01, 0xF3,
  0xE0, 0x0F, 0x9F, 0x80, 0xFC, 0xFE, 0x0F, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE3, 0xEF, 0xFE, 0x1F, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x83, 0xF3, 0xF0, 0x1F, 0x3E, 0x00, 0xF7,
  0xC0, 0x0F, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x78, 0x03,
  0xE7, 0xC0, 0x7E, 0x7E, 0x0F, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xF9, 0xF8, 0x1F, 0xFB, 0xE0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xF0, 0x7F, 0x0F, 0xC0, 0x7E, 0x1F,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xC0,
  0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01,
  0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC1, 0xF0, 0x1F, 0x83, 0xF0, 0x7E,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xF3, 0xE0,
  0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xF8,
  0x3F, 0x1F, 0x80, 0xF8, 0xF8, 0x03, 0xCF, 0xC0, 0x1F, 0x7C, 0x00, 0xFB,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x0C, 0x1F,
  0x80, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x0F, 0xE0, 0x40, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x3E, 0x07, 0xFF, 0x7C, 0x1F, 0xFE, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFC, 0x1F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0,
  0x0F, 0x8F, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01,
  0xF0, 0x7C, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x01, 0xFC, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x40, 0x0F, 0x81, 0xC0, 0x3F, 0x07, 0xC1, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x3F, 0x00,
  0xF3, 0xFE, 0x07, 0xDF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0x87, 0xE1, 0xF8,
  0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0xF8, 0x01, 0xE3, 0xE0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x9F,
  0x00, 0x3E, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00,
  0x7C, 0x78, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7F,
  0x0F, 0x80, 0xFC, 0x0F, 0x01, 0xF8, 0x1F, 0x03, 0xF0, 0x1F, 0x07, 0xE0,
  0x1F, 0x0F, 0xC0, 0x1F, 0x3F, 0x80, 0x1F, 0x7F, 0x00, 0x1E, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xBE, 0x00, 0x7F, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x80,
  0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0xF8, 0x07, 0xE0,
  0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xBE,
  0x3E, 0x07, 0xBF, 0xBF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xF8,
  0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x7C, 0x3C, 0x3E, 0x3E, 0x1E, 0x1F, 0x1F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x87, 0x87, 0x87, 0xC3, 0xC7, 0xC3, 0xC3, 0xE3,
  0xE1, 0xE1, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0xF8, 0x78, 0x78, 0x7C, 0x3C,
  0x3C, 0x3E, 0x1E, 0x3E, 0x1E, 0x1F, 0x1F, 0x0F, 0x0F, 0x8F, 0x87, 0x87,
  0xC7, 0x87, 0xC3, 0xC3, 0xC3, 0xE1, 0xE3, 0xE1, 0xF0, 0xF0, 0x0F, 0x0F,
  0xC0, 0x3C, 0xFF, 0x80, 0xF7, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xC1, 0xF8,
  0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x1E, 0x3E, 0x00, 0x78, 0xF8,
  0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03,
  0xE7, 0xC0, 0x0F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0xF8, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x3E, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC1, 0xF8, 0x3F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x1E, 0x7C,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F,
  0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x03, 0xE3, 0xE0,
  0x3F, 0x1F, 0x03, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC7, 0xE0, 0x07, 0xBF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xF0,
  0x0F, 0x83, 0xE0, 0x1F, 0x07, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7E, 0x07, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xDF, 0xFC, 0x0F, 0x9F, 0xE0, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xFC, 0x7C, 0x1F, 0xF9, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x1F, 0x83, 0xF8, 0xFC, 0x07, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0x7C, 0x7C,
  0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01,
  0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE1,
  0xF0, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0xFE, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x8F, 0xF0, 0xF1, 0xFF, 0x0F, 0x7F,
  0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE1, 0xF8, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0xF8, 0x01, 0xE7,
  0xC0, 0x1F, 0x3F, 0x01, 0xF8, 0xFE, 0x3F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3E,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x78, 0x03, 0xE7, 0xC0, 0x1F,
  0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xE3, 0xC0,
  0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xE3,
  0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x07,
  0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0x78, 0x1F, 0xF3, 0xC0, 0x7F, 0x3E, 0x00,
  0xF8, 0x00, 0x7D, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0x7C,
  0x01, 0xF0, 0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x3E, 0x01, 0xE0, 0xF8, 0x07, 0x87, 0xC0, 0x1E, 0x1E, 0x00,
  0x7C, 0xF8, 0x00, 0xF3, 0xC0, 0x03, 0xDF, 0x00, 0x0F, 0x78, 0x00, 0x3D,
  0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x78, 0x3F, 0xE0, 0xF0, 0x7F, 0xC1, 0xE0,
  0xF7, 0x87, 0xC3, 0xEF, 0x0F, 0x87, 0x9E, 0x1F, 0x0F, 0x3C, 0x7E, 0x3E,
  0x78, 0xFC, 0x78, 0xF3, 0xF8, 0xF1, 0xE7, 0x71, 0xE3, 0xCE, 0xE7, 0x87,
  0xB9, 0xCF, 0x0F, 0x73, 0x9E, 0x1F, 0xE7, 0x78, 0x3B, 0x8E, 0xF0, 0x77,
  0x1D, 0xC0, 0xFE, 0x3F, 0x81, 0xF8, 0x7F, 0x03, 0xF0, 0xFC, 0x07, 0xC1,
  0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0xC0,
  0x3E, 0x0F, 0xC0, 0x0F, 0x8F, 0xC0, 0x07, 0xCF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xEF,
  0x80, 0x07, 0xE7, 0xC0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xF0,
  0x3E, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0x1F,
  0x00, 0x07, 0xC7, 0xE0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x01,
  0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x8F, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x1E, 0x7C, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x10, 0x00, 0x03, 0x81, 0xC1, 0xE0,
  0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70,
  0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38,
  0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1E,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0x02, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xF0, 0x07, 0x3F, 0xF8, 0x0F, 0x7F, 0xFC, 0x1F, 0x7C,
  0x7F, 0x3E, 0x78, 0x3F, 0xFE, 0xF0, 0x0F, 0xFC, 0x30, 0x07, 0xF8, 0x00,
  0x01, 0xE0,
};

const GFXglyph RobotoMono_MediumItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 10, 31, 25, 8, -31 },
  { 40, 13, 10, 25, 8, -32 },
  { 57, 25, 31, 25, 0, -31 },
  { 154, 22, 39, 25, 2, -35 },
  { 262, 20, 31, 25, 3, -31 },
  { 340, 23, 31, 25, 1, -31 },
  { 430, 6, 11, 25, 11, -32 },
  { 439, 14, 44, 25, 7, -34 },
  { 516, 15, 44, 25, 3, -34 },
  { 599, 20, 22, 25, 4, -31 },
  { 654, 21, 22, 25, 2, -25 },
  { 712, 9, 13, 25, 4, -5 },
  { 727, 17, 4, 25, 5, -15 },
  { 736, 7, 7, 25, 8, -7 },
  { 743, 22, 34, 25, 2, -31 },
  { 837, 20, 31, 25, 3, -31 },
  { 915, 14, 31, 25, 5, -31 },
  { 970, 23, 31, 25, 0, -31 },
  { 1060, 22, 31, 25, 1, -31 },
  { 1146, 23, 31, 25, 0, -31 },
  { 1236, 23, 31, 25, 2, -31 },
  { 1326, 20, 31, 25, 2, -31 },
  { 1404, 22, 31, 25, 3, -31 },
  { 1490, 22, 31, 25, 2, -31 },
  { 1576, 20, 31, 25, 3, -31 },
  { 1654, 10, 25, 25, 8, -25 },
  { 1686, 13, 33, 25, 6, -25 },
  { 1740, 20, 19, 25, 3, -23 },
  { 1788, 21, 13, 25, 2, -20 },
  { 1823, 20, 20, 25, 2, -23 },
  { 1873, 19, 31, 25, 5, -31 },
  { 1947, 24, 30, 25, 1, -30 },
  { 2037, 23, 31, 25, -1, -31 },
  { 2127, 24, 31, 25, 1, -31 },
  { 2220, 23, 32, 25, 2, -31 },
  { 2312, 23, 31, 25, 1, -31 },
  { 2402, 25, 31, 25, 1, -31 },
  { 2499, 25, 31, 25, 1, -31 },
  { 2596, 23, 31, 25, 2, -31 },
  { 2686, 25, 31, 25, 0, -31 },
  { 2783, 22, 31, 25, 2, -31 },
  { 2869, 24, 31, 25, 1, -31 },
  { 2962, 27, 31, 25, 1, -31 },
  { 3067, 20, 31, 25, 1, -31 },
  { 3145, 25, 31, 25, 1, -31 },
  { 3242, 25, 31, 25, 0, -31 },
  { 3339, 22, 31, 25, 2, -31 },
  { 3425, 24, 31, 25, 1, -31 },
  { 3518, 22, 36, 25, 2, -31 },
  { 3617, 24, 31, 25, 1, -31 },
  { 3710, 24, 31, 25, 1, -31 },
  { 3803, 24, 31, 25, 3, -31 },
  { 3896, 23, 31, 25, 2, -31 },
  { 3986, 23, 31, 25, 4, -31 },
  { 4076, 24, 31, 25, 3, -31 },
  { 4169, 28, 31, 25, -1, -31 },
  { 4278, 24, 31, 25, 4, -31 },
  { 4371, 25, 31, 25, 0, -31 },
  { 4468, 16, 42, 25, 5, -35 },
  { 4552, 10, 34, 25, 8, -31 },
  { 4595, 15, 42, 25, 5, -35 },
  { 4674, 16, 17, 25, 5, -31 },
  { 4708, 20, 4, 25, 0, 0 },
  { 4718, 8, 6, 25, 11, -31 },
  { 4724, 20, 23, 25, 2, -23 },
  { 4782, 21, 32, 25, 1, -32 },
  { 4866, 20, 23, 25, 2, -23 },
  { 4924, 23, 32, 25, 2, -32 },
  { 5016, 21, 23, 25, 2, -23 },
  { 5077, 23, 33, 25, 4, -33 },
  { 5172, 23, 32, 25, 1, -23 },
  { 5264, 22, 32, 25, 1, -32 },
  { 5352, 19, 31, 25, 2, -31 },
  { 5426, 20, 40, 25, 1, -31 },
  { 5526, 24, 32, 25, 1, -32 },
  { 5622, 19, 32, 25, 2, -32 },
  { 5698, 25, 23, 25, -1, -23 },
  { 5770, 22, 23, 25, 1, -23 },
  { 5834, 21, 24, 25, 2, -23 },
  { 5897, 23, 32, 25, -1, -23 },
  { 5989, 22, 32, 25, 2, -23 },
  { 6077, 20, 23, 25, 4, -23 },
  { 6135, 21, 23, 25, 2, -23 },
  { 6196, 19, 28, 25, 4, -28 },
  { 6263, 21, 23, 25, 3, -23 },
  { 6324, 22, 23, 25, 3, -23 },
  { 6388, 23, 23, 25, 3, -23 },
  { 6455, 25, 23, 25, 0, -23 },
  { 6527, 26, 32, 25, 0, -23 },
  { 6631, 23, 23, 25, 1, -23 },
  { 6698, 17, 42, 25, 6, -34 },
  { 6788, 9, 40, 25, 8, -31 },
  { 6833, 17, 42, 25, 4, -34 },
  { 6923, 24, 9, 25, 0, -17 },
};

const GFXfont RobotoMono_MediumItalic43pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic43pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOMONO_MEDIUMITALIC43PT7B_H_
