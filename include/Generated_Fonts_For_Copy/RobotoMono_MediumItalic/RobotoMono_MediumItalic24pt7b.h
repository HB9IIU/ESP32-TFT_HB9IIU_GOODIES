#ifndef _ROBOTOMONO_MEDIUMITALIC24PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC6, 0x38, 0xE3, 0x8E, 0x30, 0xC7, 0x00, 0x00, 0x06,
  0x3C, 0x60, 0x63, 0x67, 0x66, 0x66, 0x46, 0xC6, 0x01, 0x9C, 0x06, 0x60,
  0x31, 0x80, 0xCC, 0x06, 0x30, 0xFF, 0xF3, 0xFF, 0xC3, 0x18, 0x0C, 0x40,
  0x33, 0x0F, 0xFF, 0x3F, 0xFC, 0x19, 0x80, 0xC6, 0x03, 0x30, 0x0C, 0xC0,
  0x63, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x0F, 0xC1, 0xFF, 0x0E, 0x38,
  0xE1, 0xC7, 0x06, 0x38, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x70, 0x01, 0x9C, 0x0C, 0xE0, 0xE3, 0x8F, 0x1F, 0xF0, 0x7F, 0x00, 0xC0,
  0x06, 0x00, 0x3C, 0x06, 0xE0, 0x66, 0x26, 0x66, 0xE6, 0xC7, 0xD8, 0x79,
  0x80, 0x30, 0x06, 0x00, 0x60, 0x0D, 0xE1, 0xBF, 0x33, 0x37, 0x33, 0x26,
  0x30, 0x36, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x80, 0xE6, 0x07, 0x18, 0x1C,
  0x60, 0x73, 0x80, 0xFC, 0x03, 0xC0, 0x1F, 0x04, 0xFC, 0x67, 0xB9, 0x9C,
  0xEE, 0x61, 0xF1, 0x83, 0xC7, 0x1E, 0x1F, 0xFC, 0x3F, 0x78, 0x6D, 0xBD,
  0x80, 0x03, 0x07, 0x0E, 0x1C, 0x18, 0x30, 0x30, 0x70, 0x60, 0xE0, 0xE0,
  0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x30,
  0x10, 0x08, 0x1C, 0x0C, 0x06, 0x06, 0x07, 0x07, 0x03, 0x03, 0x03, 0x07,
  0x07, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x70, 0xE0,
  0xC0, 0x03, 0x00, 0xE0, 0x18, 0x23, 0x1F, 0x6E, 0xFF, 0xC3, 0x80, 0xD0,
  0x3B, 0x0E, 0x71, 0x86, 0x10, 0x80, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x07, 0x0F, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x39, 0xCE, 0x67, 0x33, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x6F, 0xF7, 0x00,
  0x30, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70,
  0x0E, 0x00, 0x0F, 0xC1, 0xFE, 0x1C, 0x73, 0x87, 0x30, 0x77, 0x07, 0x70,
  0xF7, 0x3F, 0x77, 0x77, 0xC6, 0x78, 0x6E, 0x0E, 0xE0, 0xE6, 0x0C, 0x71,
  0xC3, 0xF8, 0x1F, 0x00, 0x03, 0x1F, 0xFE, 0xFE, 0xCE, 0x0E, 0x0E, 0x0E,
  0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x07, 0xE0, 0xFF,
  0x87, 0x1C, 0x70, 0x63, 0x83, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x5F, 0xFC, 0xFF,
  0xE0, 0x0F, 0xC1, 0xFE, 0x38, 0xF7, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0xFC, 0x0F, 0x80, 0x3C, 0x00, 0xE0, 0x0E, 0xC0, 0xEC, 0x0C, 0xE1, 0xC7,
  0xF8, 0x3F, 0x00, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x3F, 0x03,
  0xB0, 0x39, 0x81, 0x9C, 0x18, 0xE1, 0xC7, 0x1C, 0x39, 0xFF, 0xFF, 0xFF,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xF8, 0xFF, 0x87, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xFE, 0x07, 0xF8, 0x79, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xCE, 0x0E, 0x70, 0x71, 0xC7, 0x0F, 0xF0, 0x3F, 0x00, 0x01,
  0xC0, 0xF8, 0x3C, 0x0E, 0x03, 0x80, 0x60, 0x1F, 0xE3, 0xFE, 0x78, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xDC, 0x73, 0xFC, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0,
  0x00, 0x0F, 0xC1, 0xFE, 0x3C, 0x73, 0x87, 0x38, 0x73, 0x87, 0x38, 0xE1,
  0xFC, 0x1F, 0x83, 0x9C, 0x70, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xF1, 0xC7,
  0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xF9, 0xC7, 0x30, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE1, 0xCF, 0xF8, 0xFF, 0x00, 0xC0, 0x38, 0x0E, 0x07, 0xC3,
  0xE0, 0x70, 0x00, 0x33, 0xDE, 0x70, 0x00, 0x00, 0x00, 0x11, 0xCF, 0x70,
  0x04, 0x1C, 0x78, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x87,
  0x0E, 0x18, 0x71, 0xC0, 0x00, 0x20, 0x3C, 0x1F, 0x1F, 0xCF, 0xC1, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x70, 0x02, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x20, 0x07, 0x01, 0xF8, 0x0F,
  0xC0, 0x3E, 0x01, 0xC0, 0xF8, 0xFC, 0xFE, 0x1E, 0x03, 0x00, 0x00, 0x3F,
  0x9F, 0xFF, 0x1F, 0x87, 0x01, 0xC0, 0x70, 0x38, 0x1E, 0x0E, 0x07, 0x01,
  0x80, 0xE0, 0x00, 0x00, 0x03, 0x01, 0xE0, 0x30, 0x00, 0x03, 0xC0, 0x7F,
  0x06, 0x0C, 0x60, 0x26, 0x7D, 0xB7, 0x6F, 0x33, 0x7B, 0x13, 0xD9, 0x94,
  0xCC, 0xA6, 0x6D, 0x37, 0x49, 0xFE, 0x60, 0x03, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x1C,
  0xC0, 0xE6, 0x0E, 0x30, 0x71, 0x87, 0x0E, 0x3F, 0xF3, 0xFF, 0x9C, 0x1C,
  0xC0, 0xEE, 0x07, 0xE0, 0x18, 0x1F, 0xE0, 0x7F, 0xE1, 0xC3, 0x87, 0x07,
  0x18, 0x1C, 0xE0, 0x63, 0x83, 0x8F, 0xFC, 0x3F, 0xE0, 0xE1, 0xC3, 0x03,
  0x9C, 0x0E, 0x70, 0x39, 0xC1, 0xC7, 0x0F, 0x1F, 0xF8, 0xFF, 0x80, 0x0F,
  0xC0, 0xFF, 0x8F, 0x1C, 0x70, 0x67, 0x03, 0xB8, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x06, 0x70, 0x71, 0xC7, 0x0F,
  0xF8, 0x3F, 0x00, 0x1F, 0xC0, 0xFF, 0x07, 0x3C, 0x30, 0x71, 0x83, 0x9C,
  0x1C, 0xE0, 0x67, 0x03, 0x38, 0x39, 0x81, 0xDC, 0x0E, 0xE0, 0x67, 0x07,
  0x38, 0x71, 0xCF, 0x8F, 0xF0, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xCE, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0F, 0xFC, 0x7F, 0xE3, 0x80, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xFC, 0xFF, 0xC0, 0x1F,
  0xF9, 0xFF, 0xCE, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0F, 0xFC,
  0x7F, 0xE3, 0xFF, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x00, 0x07, 0xC0, 0xFF, 0x8F, 0x1C, 0x70, 0x67, 0x03, 0xB8,
  0x01, 0x80, 0x1C, 0x00, 0xE3, 0xF7, 0x1F, 0xB8, 0xFD, 0xC0, 0xEE, 0x06,
  0x70, 0x71, 0xC3, 0x8F, 0xF8, 0x1F, 0x80, 0x1C, 0x1C, 0x70, 0x71, 0x81,
  0xC6, 0x07, 0x38, 0x18, 0xE0, 0xE3, 0x83, 0x8F, 0xFE, 0x3F, 0xF8, 0xC0,
  0xC7, 0x03, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC6, 0x07, 0x18, 0x18, 0xE0,
  0xE0, 0x1F, 0xF8, 0xFF, 0x88, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0xCE, 0x0E, 0x70, 0xE3, 0x8F, 0x0F, 0xF0, 0x3F, 0x00, 0x1C, 0x1F, 0x1C,
  0x1C, 0x1C, 0x38, 0x1C, 0x70, 0x18, 0xE0, 0x39, 0xC0, 0x3B, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x39, 0xC0, 0x71, 0xC0, 0x70, 0xE0, 0x70,
  0xE0, 0x70, 0xF0, 0x60, 0x70, 0xE0, 0x78, 0x18, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06,
  0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xC0, 0x1E, 0x1C, 0x78, 0xF1, 0xE3,
  0xC7, 0x9F, 0x3E, 0x7C, 0xFB, 0x63, 0xED, 0x8D, 0xF6, 0x33, 0xB8, 0xCE,
  0xE7, 0x33, 0x9C, 0xCC, 0x70, 0x31, 0xC1, 0xC6, 0x07, 0x18, 0x1C, 0xE0,
  0x70, 0x1C, 0x1C, 0x70, 0x71, 0xE1, 0xC7, 0x87, 0x3E, 0x18, 0xFC, 0xE3,
  0xF3, 0x8E, 0xCE, 0x3B, 0x38, 0xCE, 0xC7, 0x1B, 0x1C, 0x7C, 0x71, 0xF1,
  0xC7, 0xC6, 0x0F, 0x18, 0x38, 0xE0, 0xE0, 0x0F, 0xC1, 0xFE, 0x3C, 0x73,
  0x87, 0x70, 0x37, 0x03, 0x60, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0xEE, 0x0E, 0x71, 0xC7, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xFF,
  0x8E, 0x1C, 0x70, 0x73, 0x83, 0x98, 0x1D, 0xC0, 0xEE, 0x0E, 0x7F, 0xF3,
  0xFE, 0x1F, 0x80, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x00, 0x0F, 0xC0, 0xFF, 0x0F, 0x1C, 0x70, 0xE7, 0x03, 0x38, 0x1D, 0x80,
  0xFC, 0x06, 0xE0, 0x37, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x0E, 0x70, 0x71,
  0xC7, 0x0F, 0xF0, 0x3F, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x80, 0x1F, 0xE0,
  0x7F, 0xE1, 0xC3, 0x87, 0x07, 0x18, 0x1C, 0xE0, 0x73, 0x83, 0x8E, 0x1E,
  0x3F, 0xF0, 0xFF, 0x03, 0x1C, 0x1C, 0x30, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x1C, 0xE0, 0x70, 0x0F, 0xE0, 0xFF, 0x8F, 0x1C, 0x70, 0x73, 0x03,
  0xB8, 0x00, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0xEE,
  0x07, 0x70, 0x33, 0xC7, 0x8F, 0xF8, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xC1,
  0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x00,
  0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x60, 0x77, 0x03, 0x38, 0x19, 0xC1, 0xCE,
  0x0E, 0x70, 0x73, 0x03, 0xB8, 0x19, 0xC1, 0xCE, 0x0E, 0x70, 0x71, 0xC7,
  0x0F, 0xF0, 0x3F, 0x00, 0xE0, 0x3F, 0x03, 0xB8, 0x1C, 0xC1, 0xC7, 0x0E,
  0x38, 0x61, 0xC7, 0x0E, 0x38, 0x73, 0x83, 0x9C, 0x0D, 0xC0, 0x6E, 0x03,
  0x60, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x00, 0xE7, 0x3F, 0x39, 0xF9,
  0xCD, 0x9E, 0x6C, 0xF7, 0x67, 0xBB, 0x7D, 0x9B, 0x6C, 0xDB, 0xE6, 0xDE,
  0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0x71, 0xC3, 0x8E, 0x1C, 0x70, 0xC3, 0x80,
  0x1E, 0x0F, 0x0E, 0x0E, 0x0E, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x03, 0x70,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x0E, 0xE0,
  0x0E, 0x70, 0x1C, 0x70, 0x38, 0x30, 0x78, 0x38, 0xF0, 0x38, 0xE0, 0x3B,
  0x83, 0x9C, 0x1C, 0xE1, 0xC3, 0x1C, 0x1C, 0xE0, 0xEE, 0x03, 0x60, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x0F, 0x8F, 0x87, 0xC3,
  0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0xE1, 0xF0, 0xE1,
  0x86, 0x1C, 0x71, 0xC3, 0x0C, 0x30, 0xE3, 0x86, 0x18, 0x61, 0x87, 0x1C,
  0x30, 0x0F, 0x1F, 0x1F, 0x07, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0xF8,
  0xF8, 0x0E, 0x07, 0x07, 0x83, 0xE3, 0xB1, 0x99, 0x8D, 0xC6, 0xC1, 0x80,
  0xFF, 0xFF, 0xFC, 0xF1, 0x86, 0x0F, 0x87, 0xF8, 0xE7, 0xB8, 0x70, 0x0E,
  0x1F, 0xCF, 0xFB, 0x87, 0xE0, 0xDC, 0x1B, 0x8F, 0x7F, 0xE7, 0xDC, 0x18,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x38, 0x3F, 0xC7, 0xDE, 0x70,
  0xE7, 0x06, 0x70, 0x76, 0x06, 0x60, 0x6E, 0x0E, 0xE0, 0xEF, 0x1C, 0xFF,
  0xCD, 0xF0, 0x07, 0x81, 0xFC, 0x3D, 0xE7, 0x06, 0x70, 0x76, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x0E, 0x71, 0xC7, 0xF8, 0x3F, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x07, 0xB8, 0x7F, 0xC7, 0xBE, 0x70,
  0x73, 0x83, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x8E, 0x38,
  0x7F, 0xC1, 0xFE, 0x00, 0x07, 0x81, 0xFC, 0x3D, 0xE7, 0x06, 0x70, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x0E, 0x04, 0x70, 0xE7, 0xFC, 0x1F, 0x80,
  0x00, 0x40, 0x1F, 0xC1, 0xFE, 0x0E, 0x00, 0xE0, 0x07, 0x03, 0xFF, 0x9F,
  0xFC, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x07, 0x98, 0x7F, 0xC7, 0xBE,
  0x70, 0x73, 0x83, 0x98, 0x19, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x8E,
  0x3C, 0x7F, 0xC1, 0xFE, 0x00, 0x71, 0x03, 0x9E, 0x78, 0x7F, 0x81, 0xF0,
  0x00, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x3C, 0x37, 0xE7,
  0xDE, 0x70, 0x77, 0x07, 0x70, 0x66, 0x06, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE,
  0x0E, 0xE0, 0xCC, 0x1C, 0x00, 0x80, 0x38, 0x0F, 0x00, 0x80, 0x00, 0x7F,
  0x0F, 0xE1, 0xFC, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x70, 0xFF, 0xFF, 0xF8, 0x00, 0x40, 0x1C, 0x03, 0x80, 0x20, 0x00,
  0x1F, 0xC3, 0xF8, 0x7E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0xF0, 0xFC, 0x3F,
  0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x3C, 0xC3,
  0x8E, 0x38, 0x73, 0x83, 0xB8, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x7B, 0x83,
  0x8E, 0x1C, 0x78, 0xE1, 0xC6, 0x0F, 0x00, 0x1F, 0xC3, 0xF8, 0x06, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x70, 0xFF, 0xFF, 0xFC, 0x37, 0x31, 0xFF, 0xCE,
  0xEE, 0xE7, 0x37, 0x31, 0xB9, 0x8D, 0x8C, 0xEC, 0xE7, 0xE7, 0x3F, 0x39,
  0xB9, 0x8D, 0xCC, 0x6C, 0xE7, 0x00, 0x33, 0xC3, 0x7E, 0x7D, 0xE7, 0x07,
  0x70, 0x77, 0x06, 0x60, 0x6E, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0C,
  0xC1, 0xC0, 0x0F, 0x81, 0xFC, 0x3D, 0xE7, 0x0E, 0x70, 0x7E, 0x07, 0xE0,
  0x7E, 0x06, 0xE0, 0xEE, 0x0E, 0x71, 0xC7, 0xF8, 0x3F, 0x00, 0x19, 0xC0,
  0xFF, 0x0F, 0xBC, 0x70, 0xE3, 0x83, 0x1C, 0x18, 0xC0, 0xCE, 0x0E, 0x70,
  0x73, 0x83, 0x9E, 0x38, 0xFF, 0xC6, 0xF8, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x0F, 0x31, 0xFF, 0x3D, 0xF7, 0x07, 0x70, 0x66,
  0x06, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0x71, 0xC7, 0xFC, 0x3F, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x39, 0xE7, 0xFC, 0xFF, 0x9E,
  0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E,
  0x00, 0x0F, 0x81, 0xFE, 0x38, 0xE7, 0x07, 0x70, 0x03, 0xC0, 0x1F, 0x80,
  0x7C, 0x00, 0xEE, 0x0E, 0xE0, 0xE7, 0xFC, 0x3F, 0x80, 0x0E, 0x01, 0xC0,
  0x30, 0x7F, 0xFF, 0xFE, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x07, 0xE0, 0xFC, 0x38, 0x73, 0x07, 0x70, 0x77,
  0x07, 0x70, 0x77, 0x06, 0x70, 0xE6, 0x0E, 0x60, 0xE6, 0x0E, 0x71, 0xE7,
  0xFC, 0x3E, 0xC0, 0xE0, 0x7E, 0x0E, 0xE0, 0xE6, 0x1C, 0x61, 0xC7, 0x18,
  0x73, 0x87, 0x30, 0x37, 0x03, 0x60, 0x3C, 0x03, 0xC0, 0x18, 0x00, 0xE3,
  0x1F, 0x8C, 0x6E, 0x73, 0xB9, 0xCC, 0xEF, 0x33, 0xBD, 0xCE, 0xB6, 0x3E,
  0xD8, 0x7B, 0xE1, 0xCF, 0x07, 0x3C, 0x18, 0x60, 0x61, 0x80, 0x38, 0x1C,
  0x70, 0xE1, 0xC7, 0x03, 0xB8, 0x0F, 0xE0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0xC0, 0x77, 0x03, 0x8E, 0x1C, 0x38, 0xF0, 0x70, 0x38, 0x1E, 0x70,
  0x38, 0xE0, 0xE0, 0xC1, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x38, 0x06, 0x60,
  0x0D, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0xCF, 0xFE,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0xC0, 0xF0, 0x30, 0x1C, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x03, 0xC1, 0xC0, 0xF0, 0x0E, 0x01, 0x80,
  0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x80, 0xC0, 0x0C, 0x61,
  0x86, 0x18, 0x61, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x86,
  0x10, 0xC3, 0x00, 0x08, 0x07, 0x00, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x0E, 0x01, 0x80, 0x74, 0x0E, 0x07, 0x83, 0x81, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x38, 0x1C, 0x0E, 0x00, 0x10, 0x03, 0xF0, 0xDF,
  0xC7, 0xC7, 0xFC, 0x1F, 0x00,
};

const GFXglyph RobotoMono_MediumItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 17, 14, 4, -17 },
  { 14, 8, 6, 14, 4, -18 },
  { 20, 14, 17, 14, 0, -17 },
  { 50, 13, 22, 14, 1, -20 },
  { 86, 12, 17, 14, 1, -17 },
  { 112, 14, 17, 14, 0, -17 },
  { 142, 3, 6, 14, 6, -18 },
  { 145, 8, 24, 14, 4, -19 },
  { 169, 8, 24, 14, 2, -19 },
  { 193, 11, 12, 14, 2, -17 },
  { 210, 12, 12, 14, 1, -14 },
  { 228, 5, 7, 14, 2, -3 },
  { 233, 9, 3, 14, 3, -9 },
  { 237, 4, 4, 14, 4, -4 },
  { 239, 12, 18, 14, 1, -17 },
  { 266, 12, 17, 14, 1, -17 },
  { 292, 8, 17, 14, 3, -17 },
  { 309, 13, 17, 14, 0, -17 },
  { 337, 12, 17, 14, 1, -17 },
  { 363, 13, 17, 14, 0, -17 },
  { 391, 13, 17, 14, 1, -17 },
  { 419, 11, 17, 14, 1, -17 },
  { 443, 12, 17, 14, 2, -17 },
  { 469, 12, 17, 14, 1, -17 },
  { 495, 11, 17, 14, 2, -17 },
  { 519, 5, 14, 14, 5, -14 },
  { 528, 7, 18, 14, 3, -14 },
  { 544, 11, 11, 14, 2, -13 },
  { 560, 12, 7, 14, 1, -11 },
  { 571, 11, 11, 14, 1, -13 },
  { 587, 10, 17, 14, 3, -17 },
  { 609, 13, 17, 14, 1, -17 },
  { 637, 13, 17, 14, -1, -17 },
  { 665, 14, 17, 14, 0, -17 },
  { 695, 13, 17, 14, 1, -17 },
  { 723, 13, 17, 14, 0, -17 },
  { 751, 13, 17, 14, 1, -17 },
  { 779, 13, 17, 14, 1, -17 },
  { 807, 13, 17, 14, 1, -17 },
  { 835, 14, 17, 14, 0, -17 },
  { 865, 13, 17, 14, 1, -17 },
  { 893, 13, 17, 14, 1, -17 },
  { 921, 16, 17, 14, 0, -17 },
  { 955, 11, 17, 14, 1, -17 },
  { 979, 14, 17, 14, 0, -17 },
  { 1009, 14, 17, 14, 0, -17 },
  { 1039, 12, 17, 14, 1, -17 },
  { 1065, 13, 17, 14, 1, -17 },
  { 1093, 13, 20, 14, 1, -17 },
  { 1126, 14, 17, 14, 0, -17 },
  { 1156, 13, 17, 14, 1, -17 },
  { 1184, 13, 17, 14, 2, -17 },
  { 1212, 13, 17, 14, 1, -17 },
  { 1240, 13, 17, 14, 2, -17 },
  { 1268, 13, 17, 14, 2, -17 },
  { 1296, 16, 17, 14, -1, -17 },
  { 1330, 13, 17, 14, 2, -17 },
  { 1358, 14, 17, 14, 0, -17 },
  { 1388, 9, 24, 14, 3, -20 },
  { 1415, 6, 18, 14, 4, -17 },
  { 1429, 8, 24, 14, 3, -20 },
  { 1453, 9, 9, 14, 3, -17 },
  { 1464, 11, 2, 14, 0, 0 },
  { 1467, 5, 3, 14, 6, -17 },
  { 1469, 11, 13, 14, 1, -13 },
  { 1487, 12, 18, 14, 1, -18 },
  { 1514, 12, 13, 14, 1, -13 },
  { 1534, 13, 18, 14, 1, -18 },
  { 1564, 12, 13, 14, 1, -13 },
  { 1584, 13, 19, 14, 2, -19 },
  { 1615, 13, 18, 14, 0, -13 },
  { 1645, 12, 18, 14, 1, -18 },
  { 1672, 11, 18, 14, 1, -18 },
  { 1697, 11, 23, 14, 0, -18 },
  { 1729, 13, 18, 14, 1, -18 },
  { 1759, 11, 18, 14, 1, -18 },
  { 1784, 13, 13, 14, 0, -13 },
  { 1806, 12, 13, 14, 1, -13 },
  { 1826, 12, 13, 14, 1, -13 },
  { 1846, 13, 18, 14, 0, -13 },
  { 1876, 12, 18, 14, 1, -13 },
  { 1903, 11, 13, 14, 2, -13 },
  { 1921, 12, 13, 14, 1, -13 },
  { 1941, 11, 16, 14, 2, -16 },
  { 1963, 12, 13, 14, 1, -13 },
  { 1983, 12, 13, 14, 2, -13 },
  { 2003, 14, 13, 14, 1, -13 },
  { 2026, 14, 13, 14, 0, -13 },
  { 2049, 15, 18, 14, 0, -13 },
  { 2083, 13, 13, 14, 0, -13 },
  { 2105, 10, 23, 14, 3, -19 },
  { 2134, 6, 22, 14, 4, -17 },
  { 2151, 10, 23, 14, 2, -19 },
  { 2180, 13, 5, 14, 0, -10 },
};

const GFXfont RobotoMono_MediumItalic24pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic24pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOMONO_MEDIUMITALIC24PT7B_H_
