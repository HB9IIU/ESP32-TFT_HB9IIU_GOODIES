#ifndef _ROBOTOMONO_MEDIUMITALIC33PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x38, 0x38, 0x78, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xF0,
  0x71, 0xDC, 0x77, 0x1D, 0xC7, 0x61, 0xB8, 0xEE, 0x3B, 0x8E, 0x00, 0x70,
  0xE0, 0x0E, 0x38, 0x01, 0x87, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0x86,
  0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x71, 0xC0, 0x0E, 0x38,
  0x01, 0x86, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC,
  0x0C, 0x38, 0x03, 0x86, 0x00, 0x71, 0xC0, 0x0C, 0x38, 0x03, 0x86, 0x00,
  0x71, 0xC0, 0x1C, 0x30, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x7E, 0xFC, 0x3C, 0x1E, 0x3C, 0x0F,
  0x1E, 0x03, 0x8F, 0x01, 0xE7, 0x80, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x03, 0xCF,
  0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xF0, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC,
  0x07, 0xF8, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x3F,
  0x00, 0x7F, 0x80, 0xE3, 0x84, 0xE3, 0x8E, 0xE3, 0x9C, 0xE3, 0x98, 0xE3,
  0x38, 0x7F, 0x70, 0x7E, 0x60, 0x08, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x07, 0x3C, 0x0E, 0xFE, 0x0C, 0xEF, 0x1D, 0xC7, 0x39, 0xC7, 0x71,
  0xC7, 0x11, 0xC7, 0x01, 0xCE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0xFE, 0x00, 0x7F, 0xC0, 0x3E, 0x78, 0x0F, 0x1E, 0x03, 0x87, 0x80, 0xE1,
  0xE0, 0x38, 0xF0, 0x0E, 0x78, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0xF7, 0xDE, 0x39, 0xE7, 0x8E, 0xF0, 0xF7, 0xBC,
  0x3F, 0xCF, 0x07, 0xF3, 0xC0, 0xF8, 0xF0, 0x7C, 0x3F, 0xFF, 0x87, 0xFF,
  0xF0, 0x7F, 0x3C, 0x39, 0xDC, 0xE7, 0x39, 0xCC, 0xE0, 0x00, 0x60, 0x1C,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0,
  0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xF0, 0x0C, 0x00, 0x04, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70,
  0x1C, 0x07, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x61, 0x82, 0x79, 0x9E, 0xFF, 0xFE, 0x3F, 0xFD, 0x03, 0xC0, 0x07,
  0xC0, 0x0E, 0xC0, 0x1C, 0xE0, 0x38, 0xF0, 0x78, 0x70, 0x30, 0x70, 0x10,
  0x40, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x1E,
  0x38, 0x71, 0xE3, 0xC7, 0x9E, 0x3C, 0xF0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0x3E, 0x1E, 0x0E, 0x3C, 0x0F, 0x38,
  0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x78, 0x3F, 0x78, 0x7F, 0x71, 0xEF, 0x73,
  0xCE, 0xFF, 0x1E, 0xFE, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0,
  0x3C, 0xF0, 0x3C, 0x78, 0x78, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x00,
  0xE0, 0xFC, 0xFF, 0x3F, 0xEF, 0xFD, 0xC7, 0xA0, 0xF0, 0x1C, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x01, 0xFF, 0x01,
  0xFF, 0xC1, 0xF3, 0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x00, 0xF0,
  0x03, 0xFE, 0x03, 0xFF, 0x83, 0xF3, 0xE1, 0xE0, 0xF1, 0xE0, 0x3C, 0xF0,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x3C, 0x07, 0x9E, 0x07, 0xCF, 0x87, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F,
  0xC0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xBC, 0x03, 0x9E, 0x03, 0xCF, 0x03, 0xC7, 0x03, 0xC7,
  0x81, 0xC3, 0xC1, 0xC1, 0xE1, 0xE0, 0xF1, 0xE0, 0x78, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC3, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3B, 0xF0, 0x1F, 0xFC, 0x1F,
  0xFF, 0x07, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x70, 0x1E, 0x3C, 0x0F, 0x1F, 0x0F, 0x07, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0x00, 0x00, 0x0C, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0xC0, 0xF7, 0xE1, 0xFF, 0xE7,
  0xFF, 0xEF, 0x83, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0,
  0x3B, 0xC0, 0xF7, 0x81, 0xE7, 0x87, 0x8F, 0xFE, 0x0F, 0xFC, 0x0F, 0xE0,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xF3, 0xE0, 0xF0, 0x78,
  0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x0F, 0x07, 0x83, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xE0, 0xF0, 0x78, 0xF0, 0x1C, 0x78,
  0x0F, 0x38, 0x07, 0x1C, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE3, 0xFF, 0xE0,
  0xFF, 0xE0, 0x1F, 0xC0, 0x03, 0xC0, 0x1F, 0xE0, 0xFF, 0xE1, 0xF3, 0xC7,
  0x83, 0xCE, 0x07, 0xBC, 0x07, 0x78, 0x0E, 0xF0, 0x1D, 0xC0, 0x3B, 0xC0,
  0x77, 0x81, 0xEF, 0x87, 0xCF, 0xFF, 0x9F, 0xFE, 0x0F, 0xDC, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3C,
  0x00, 0x0E, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x7C, 0xFC, 0xFC, 0x78, 0x07, 0x07, 0xC3, 0xE1,
  0xF0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC1, 0xC1, 0xC0, 0x40,
  0x00, 0x00, 0x01, 0x00, 0x0E, 0x00, 0x3E, 0x01, 0xFE, 0x07, 0xFC, 0x1F,
  0xE0, 0x7F, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07,
  0xFC, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x18, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xFC, 0x10, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x3F, 0x01, 0xFE, 0x0F,
  0xF8, 0x7F, 0xC0, 0x7F, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x7F,
  0xC3, 0xFF, 0x9F, 0xBF, 0x78, 0x3F, 0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x78, 0x38, 0x38, 0x06,
  0x1C, 0x01, 0xCE, 0x3F, 0x33, 0x1F, 0xCD, 0xCE, 0x33, 0x63, 0x18, 0xD9,
  0xC6, 0x3E, 0x61, 0x8F, 0x98, 0x67, 0xCE, 0x31, 0xB3, 0x8C, 0x6C, 0xE3,
  0x1B, 0x3B, 0xCC, 0xC7, 0xFE, 0x38, 0xE7, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x60, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03,
  0x9C, 0x01, 0xE7, 0x00, 0x71, 0xC0, 0x3C, 0x70, 0x0E, 0x1E, 0x07, 0x87,
  0x81, 0xC1, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE3,
  0xC0, 0x38, 0xF0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xFF, 0x00, 0x3C, 0x0F,
  0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x78, 0x1F, 0x1E, 0x03, 0xC7, 0x00,
  0xF3, 0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0,
  0xFF, 0xF8, 0x78, 0x3F, 0x1E, 0x03, 0xC7, 0x80, 0x71, 0xE0, 0x1E, 0x78,
  0x07, 0x1C, 0x03, 0xCF, 0x01, 0xF3, 0xC0, 0xF8, 0xFF, 0xFE, 0x3F, 0xFE,
  0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3E, 0x7E,
  0x1F, 0x07, 0x87, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC7, 0x00, 0xF1, 0xE0, 0x78,
  0x7C, 0x3E, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x3C, 0x3E, 0x0E, 0x07, 0xC7, 0x80, 0xF1, 0xE0,
  0x3C, 0x78, 0x0F, 0x1E, 0x01, 0xC7, 0x80, 0x71, 0xC0, 0x3C, 0xF0, 0x0F,
  0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x38, 0xF0, 0x1E, 0x38, 0x07, 0x9E,
  0x03, 0xC7, 0x81, 0xE1, 0xE1, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFF, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFC, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0x7E,
  0x1F, 0x07, 0x87, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x7F, 0x9C, 0x1F, 0xEF, 0x07,
  0xFB, 0xC0, 0x1C, 0xF0, 0x0F, 0x1C, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C,
  0x7C, 0x1F, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0x00, 0xE1,
  0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x00, 0xF0, 0xE0, 0x1E, 0x3C, 0x03, 0x87,
  0x80, 0x70, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xC0, 0x3C, 0x78,
  0x07, 0x8F, 0x00, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x00, 0xF0, 0xE0,
  0x1E, 0x3C, 0x03, 0x80, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0xF0, 0x1E, 0x3C, 0x07,
  0x8F, 0x03, 0xE1, 0xE1, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00,
  0x0F, 0x01, 0xF1, 0xE0, 0x3E, 0x1E, 0x07, 0xC1, 0xE0, 0xF8, 0x1E, 0x1F,
  0x01, 0xC3, 0xE0, 0x3C, 0x7C, 0x03, 0xCF, 0x80, 0x3D, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xEF, 0x00, 0x7C,
  0xF8, 0x07, 0x87, 0x80, 0x78, 0x7C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x00, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1,
  0xFD, 0xDC, 0x1D, 0xDD, 0xC1, 0xDF, 0x9C, 0x1C, 0xFB, 0xC3, 0xCF, 0x3C,
  0x3C, 0xF3, 0xC3, 0xCE, 0x38, 0x38, 0xE3, 0x83, 0x8C, 0x78, 0x38, 0x07,
  0x87, 0x80, 0x78, 0x78, 0x07, 0x07, 0x80, 0x70, 0x70, 0x07, 0x07, 0x00,
  0xF0, 0xF0, 0x0F, 0x00, 0x0F, 0x01, 0xE1, 0xF0, 0x3C, 0x3E, 0x07, 0x87,
  0xC0, 0xF0, 0xFC, 0x1E, 0x3F, 0x83, 0x87, 0xF0, 0xF0, 0xFE, 0x1E, 0x1E,
  0xE3, 0xC3, 0xDC, 0x78, 0x73, 0x8F, 0x1E, 0x79, 0xC3, 0xC7, 0x78, 0x78,
  0xEF, 0x0F, 0x1D, 0xE1, 0xE1, 0xFC, 0x78, 0x3F, 0x0F, 0x07, 0xE1, 0xE0,
  0xFC, 0x3C, 0x0F, 0x87, 0x81, 0xF0, 0xE0, 0x3E, 0x3C, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0x07, 0x87, 0x81,
  0xE3, 0xC0, 0x38, 0xF0, 0x0E, 0x78, 0x03, 0x9E, 0x00, 0xE7, 0x80, 0x39,
  0xE0, 0x1E, 0x78, 0x07, 0x9C, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0,
  0x0F, 0x3C, 0x03, 0xC7, 0x00, 0xE1, 0xE0, 0x78, 0x7C, 0x3C, 0x0F, 0xFF,
  0x01, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF8,
  0x78, 0x1F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x0F, 0x3C,
  0x03, 0xCF, 0x01, 0xE3, 0xC0, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0x7C, 0x1F, 0x07, 0x87, 0x81, 0xE3, 0xC0,
  0x38, 0xF0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0E,
  0x78, 0x07, 0x9C, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0x3C,
  0x03, 0xC7, 0x00, 0xF1, 0xE0, 0x78, 0x7C, 0x3C, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x30,
  0x0F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x78, 0x1E, 0x1E, 0x03, 0xC7,
  0x80, 0xF1, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC1,
  0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0x87, 0x81, 0xE1, 0xE0,
  0x78, 0x3C, 0x1C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C,
  0x07, 0x8F, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0x7E, 0x1E, 0x07, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x3C, 0x01, 0xCF, 0x00, 0xF3, 0xE0,
  0x3C, 0x7C, 0x1F, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x38,
  0x07, 0x9E, 0x01, 0xE7, 0x80, 0x71, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03,
  0xC7, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0E, 0x3C, 0x07, 0x8F, 0x01, 0xE3,
  0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xE1, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00,
  0xF1, 0xC0, 0x3C, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x1E, 0x07, 0x87, 0x80, 0xE3, 0xC0, 0x38, 0xF0, 0x0F,
  0x78, 0x03, 0xDE, 0x00, 0xF7, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0xE1,
  0xEE, 0x1C, 0x39, 0xC7, 0x87, 0x38, 0xF1, 0xE7, 0x1E, 0x3C, 0xE7, 0xC7,
  0x1C, 0xF9, 0xE3, 0x9F, 0x3C, 0x73, 0x67, 0x0E, 0xEC, 0xE1, 0xDD, 0xBC,
  0x3B, 0x37, 0x8F, 0xE6, 0xE1, 0xFC, 0xDC, 0x3F, 0x1F, 0x87, 0xE3, 0xE0,
  0xFC, 0x7C, 0x1F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x87, 0x81,
  0xE0, 0xF0, 0x3C, 0x1C, 0x00, 0x0F, 0x80, 0x7C, 0x1E, 0x03, 0xC0, 0x7C,
  0x1F, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xC0, 0x07, 0x9F, 0x00, 0x1E, 0x78,
  0x00, 0x7B, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xF7,
  0x80, 0x07, 0x8F, 0x00, 0x3E, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0x81, 0xE0,
  0x3E, 0x07, 0x81, 0xF0, 0x1F, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xDE,
  0x01, 0xE7, 0x80, 0xF1, 0xE0, 0x7C, 0x38, 0x1E, 0x0F, 0x0F, 0x03, 0xC3,
  0xC0, 0x71, 0xE0, 0x1C, 0xF0, 0x07, 0xBC, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x4F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x70, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xF0, 0xF0, 0x70, 0x70,
  0x70, 0x78, 0x78, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x07, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x0E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0xEC, 0x0E, 0xE1, 0xEE, 0x1C, 0xE3, 0x8E, 0x38, 0xE7, 0x07,
  0xF0, 0x7E, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF1, 0xC3, 0x8E,
  0x1C, 0x01, 0xE0, 0x07, 0xFC, 0x1F, 0xFE, 0x1F, 0x1E, 0x3C, 0x0F, 0x3C,
  0x0F, 0x00, 0x0F, 0x01, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x7C, 0x1E, 0x78,
  0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF8, 0x7C, 0x7F, 0xFC, 0x7F, 0xDC, 0x3F,
  0x9C, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x70, 0x1D, 0xFC, 0x3F, 0xFE, 0x3F, 0xBF, 0x3E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0xFC, 0x3C, 0xFF, 0xFC, 0xFF,
  0xF8, 0xE7, 0xF0, 0x01, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xF3, 0xF7, 0xC1,
  0xEF, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x80, 0x0F, 0x01, 0xDE, 0x07, 0xBE, 0x1E, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F,
  0x80, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x07, 0x1E, 0x0F, 0xEF, 0x0F, 0xFF, 0x8F, 0x9F,
  0xCF, 0x83, 0xC7, 0x81, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0,
  0x1E, 0x70, 0x0E, 0x38, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0xC3, 0xE1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0x38, 0x00, 0x01, 0xE0, 0x0F, 0xF8, 0x1F,
  0xFC, 0x3F, 0x7E, 0x7C, 0x1E, 0x78, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xFF,
  0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x08, 0xF8,
  0x38, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x7F, 0xE0, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0xFF, 0xFE, 0x7F, 0xFF, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x03, 0xFB, 0xC3, 0xFF, 0xE3, 0xF7, 0xF3, 0xE0, 0xF9,
  0xE0, 0x39, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9C, 0x03,
  0xCE, 0x01, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xF0, 0xF8, 0x7F, 0xFC, 0x3F,
  0xFE, 0x0F, 0xCE, 0x00, 0x0F, 0x00, 0x07, 0x84, 0x07, 0x87, 0x87, 0xC3,
  0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x78, 0x1C,
  0xFE, 0x3F, 0xFE, 0x3F, 0xBF, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x70, 0x0E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0x00, 0x70, 0x03,
  0xE0, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3E, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F,
  0x00, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x01, 0x1C, 0x0F, 0x8F, 0x07,
  0xC3, 0xC3, 0xE0, 0xF1, 0xF0, 0x3C, 0xF8, 0x0F, 0x78, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0x70,
  0x78, 0x3C, 0x1F, 0x0F, 0x03, 0xC3, 0xC0, 0xF8, 0xF0, 0x1E, 0x00, 0x07,
  0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x00, 0xC3,
  0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFB, 0xEF, 0x38, 0xF1, 0xCE, 0x3C, 0x73,
  0x8F, 0x1D, 0xE3, 0x8F, 0x78, 0xE3, 0xDE, 0x38, 0xF7, 0x1E, 0x39, 0xC7,
  0x8E, 0x71, 0xE3, 0xBC, 0x71, 0xEF, 0x1C, 0x7B, 0xC7, 0x1E, 0xE3, 0xC7,
  0x38, 0xF1, 0xC0, 0x00, 0x78, 0x1D, 0xFE, 0x3F, 0xFE, 0x3F, 0xBF, 0x3E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x78, 0x0E, 0x70, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1C, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x3E, 0x3C,
  0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x07, 0x70, 0x07, 0x70, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x78, 0x3C, 0x3F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xE0, 0x00, 0x38, 0x07, 0x7F, 0x07, 0xFF, 0xC3, 0xFB, 0xE1,
  0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x38, 0x0F, 0x3C, 0x07, 0x9E, 0x03,
  0xCF, 0x01, 0xE7, 0x80, 0xF3, 0x80, 0xF1, 0xE0, 0x79, 0xF0, 0x78, 0xFF,
  0xFC, 0x7F, 0xFC, 0x3D, 0xFC, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x0F,
  0xEF, 0x1F, 0xFF, 0x3E, 0x7F, 0x7C, 0x1E, 0x78, 0x1E, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF8, 0x7C, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x02,
  0x3E, 0x39, 0xFC, 0x77, 0xF8, 0xFF, 0xF3, 0xF8, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x1F,
  0xF0, 0x7F, 0xF1, 0xF1, 0xF7, 0x81, 0xEF, 0x01, 0xDE, 0x00, 0x1F, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xE0, 0x01, 0xDC, 0x03, 0xBC,
  0x0F, 0x7F, 0xFE, 0x7F, 0xF8, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xBF, 0xFF, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0x3C, 0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x78,
  0x1E, 0x70, 0x1E, 0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0x7F, 0xFC, 0x7F, 0xBC, 0x3F, 0x38, 0xE0,
  0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0x70, 0x3C, 0x70, 0x78, 0x78,
  0x70, 0x78, 0xF0, 0x38, 0xE0, 0x39, 0xE0, 0x39, 0xC0, 0x3B, 0xC0, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0xE1, 0xC3, 0xF8,
  0x70, 0xEE, 0x3C, 0x3B, 0x8F, 0x1E, 0xE3, 0xC7, 0x39, 0xF1, 0xCE, 0x6C,
  0xE3, 0x9B, 0x38, 0xEE, 0xCE, 0x3B, 0x37, 0x0F, 0xCD, 0xC3, 0xF3, 0x70,
  0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x0F, 0x83, 0xC3, 0xC0, 0xF0, 0xF0, 0x00,
  0x1E, 0x03, 0xE1, 0xE0, 0xF8, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0x3D, 0xE0,
  0x07, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x3C, 0x3C, 0x0F, 0x07, 0x83,
  0xE0, 0x78, 0xF8, 0x0F, 0x80, 0x3E, 0x01, 0xF1, 0xE0, 0x1E, 0x1E, 0x03,
  0xC1, 0xE0, 0x3C, 0x0E, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF1,
  0xE0, 0x07, 0x1E, 0x00, 0x7B, 0xC0, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xFF,
  0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x00, 0x10, 0x03, 0xC0, 0x7E, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x01, 0xF8, 0x1F, 0x00, 0xF0, 0x07, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x60, 0x0E, 0x1C,
  0x38, 0x60, 0xC1, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0E, 0x1C,
  0x30, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0E, 0x18,
  0x00, 0x04, 0x00, 0x38, 0x03, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x1F, 0x81, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x18, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x37, 0xFE, 0x1D,
  0xC7, 0xFF, 0xE0, 0xFF, 0xB8, 0x0F, 0xC0, 0x00, 0xE0,
};

const GFXglyph RobotoMono_MediumItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 8, 23, 19, 6, -23 },
  { 24, 10, 8, 19, 6, -25 },
  { 34, 19, 23, 19, 0, -23 },
  { 89, 17, 30, 19, 2, -27 },
  { 153, 16, 24, 19, 2, -24 },
  { 201, 18, 24, 19, 1, -24 },
  { 255, 5, 9, 19, 8, -25 },
  { 261, 11, 33, 19, 5, -26 },
  { 307, 11, 33, 19, 3, -26 },
  { 353, 16, 16, 19, 3, -23 },
  { 385, 16, 17, 19, 2, -19 },
  { 419, 7, 10, 19, 3, -4 },
  { 428, 13, 3, 19, 4, -12 },
  { 433, 5, 5, 19, 6, -5 },
  { 437, 17, 25, 19, 2, -23 },
  { 491, 16, 24, 19, 2, -24 },
  { 539, 11, 23, 19, 4, -23 },
  { 571, 17, 24, 19, 0, -24 },
  { 622, 17, 24, 19, 1, -24 },
  { 673, 17, 23, 19, 0, -23 },
  { 722, 17, 23, 19, 2, -23 },
  { 771, 15, 24, 19, 2, -24 },
  { 816, 17, 23, 19, 2, -23 },
  { 865, 17, 24, 19, 1, -24 },
  { 916, 15, 24, 19, 3, -24 },
  { 961, 8, 19, 19, 6, -19 },
  { 980, 9, 25, 19, 5, -19 },
  { 1009, 16, 15, 19, 2, -18 },
  { 1039, 16, 10, 19, 2, -15 },
  { 1059, 16, 15, 19, 1, -18 },
  { 1089, 14, 24, 19, 4, -24 },
  { 1131, 18, 23, 19, 1, -23 },
  { 1183, 18, 23, 19, -1, -23 },
  { 1235, 18, 23, 19, 1, -23 },
  { 1287, 18, 24, 19, 1, -24 },
  { 1341, 18, 23, 19, 0, -23 },
  { 1393, 19, 23, 19, 1, -23 },
  { 1448, 19, 23, 19, 1, -23 },
  { 1503, 18, 24, 19, 1, -24 },
  { 1557, 19, 23, 19, 0, -23 },
  { 1612, 18, 23, 19, 1, -23 },
  { 1664, 18, 23, 19, 1, -23 },
  { 1716, 20, 23, 19, 1, -23 },
  { 1774, 15, 23, 19, 1, -23 },
  { 1818, 20, 23, 19, 0, -23 },
  { 1876, 19, 23, 19, 0, -23 },
  { 1931, 18, 24, 19, 1, -24 },
  { 1985, 18, 23, 19, 1, -23 },
  { 2037, 18, 28, 19, 1, -24 },
  { 2100, 18, 23, 19, 1, -23 },
  { 2152, 18, 24, 19, 1, -24 },
  { 2206, 18, 23, 19, 3, -23 },
  { 2258, 18, 23, 19, 2, -23 },
  { 2310, 18, 23, 19, 3, -23 },
  { 2362, 19, 23, 19, 2, -23 },
  { 2417, 22, 23, 19, -1, -23 },
  { 2481, 18, 23, 19, 3, -23 },
  { 2533, 19, 23, 19, 0, -23 },
  { 2588, 12, 32, 19, 4, -27 },
  { 2636, 8, 25, 19, 6, -23 },
  { 2661, 12, 32, 19, 4, -27 },
  { 2709, 12, 12, 19, 4, -23 },
  { 2727, 15, 3, 19, 0, 0 },
  { 2733, 6, 5, 19, 9, -24 },
  { 2737, 16, 18, 19, 1, -18 },
  { 2773, 16, 25, 19, 1, -25 },
  { 2823, 15, 18, 19, 2, -18 },
  { 2857, 17, 25, 19, 2, -25 },
  { 2911, 16, 18, 19, 2, -18 },
  { 2947, 17, 25, 19, 3, -25 },
  { 3001, 17, 25, 19, 1, -18 },
  { 3055, 16, 25, 19, 1, -25 },
  { 3105, 14, 24, 19, 2, -24 },
  { 3147, 15, 31, 19, 1, -24 },
  { 3206, 18, 25, 19, 1, -25 },
  { 3263, 15, 25, 19, 1, -25 },
  { 3310, 18, 18, 19, 0, -18 },
  { 3351, 16, 18, 19, 1, -18 },
  { 3387, 16, 18, 19, 1, -18 },
  { 3423, 17, 25, 19, 0, -18 },
  { 3477, 16, 25, 19, 2, -18 },
  { 3527, 15, 18, 19, 3, -18 },
  { 3561, 15, 18, 19, 2, -18 },
  { 3595, 15, 22, 19, 3, -22 },
  { 3637, 16, 17, 19, 2, -17 },
  { 3671, 16, 17, 19, 3, -17 },
  { 3705, 18, 17, 19, 2, -17 },
  { 3744, 19, 17, 19, 0, -17 },
  { 3785, 20, 24, 19, 0, -17 },
  { 3845, 17, 17, 19, 1, -17 },
  { 3882, 13, 32, 19, 5, -26 },
  { 3934, 7, 30, 19, 6, -23 },
  { 3961, 13, 32, 19, 3, -26 },
  { 4013, 18, 7, 19, 0, -13 },
};

const GFXfont RobotoMono_MediumItalic33pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic33pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _ROBOTOMONO_MEDIUMITALIC33PT7B_H_
