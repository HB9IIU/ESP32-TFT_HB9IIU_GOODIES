#ifndef _ROBOTOMONO_MEDIUMITALIC21PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x63, 0x39, 0xCC, 0x63, 0x00, 0x04, 0x73, 0x00, 0x4F,
  0x3C, 0xF3, 0xC8, 0x03, 0x30, 0x22, 0x06, 0x60, 0x66, 0x3F, 0xF3, 0xFF,
  0x0C, 0xC0, 0x98, 0x19, 0x8F, 0xFE, 0xFF, 0xE3, 0x30, 0x32, 0x06, 0x60,
  0x66, 0x00, 0x03, 0x00, 0x60, 0x3E, 0x0F, 0xE3, 0x8E, 0x61, 0xCC, 0x39,
  0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xEE, 0x1D, 0xC3, 0xB8, 0x63, 0xFC,
  0x3F, 0x01, 0x00, 0x60, 0x00, 0x38, 0x1B, 0x0C, 0xCF, 0x36, 0xCD, 0x1E,
  0xC0, 0x60, 0x10, 0x0C, 0x06, 0xF3, 0x6C, 0x91, 0x64, 0x41, 0xB0, 0x78,
  0x07, 0x80, 0xFC, 0x1C, 0xC1, 0x8C, 0x19, 0xC1, 0xF8, 0x0F, 0x01, 0xE0,
  0x3E, 0x37, 0x77, 0x63, 0x66, 0x3E, 0x61, 0xC7, 0xFC, 0x3E, 0xE0, 0x6D,
  0xA5, 0x80, 0x02, 0x0C, 0x30, 0xE1, 0x86, 0x0C, 0x30, 0x60, 0xC1, 0x87,
  0x0C, 0x18, 0x30, 0x60, 0x60, 0xC1, 0x81, 0x83, 0x02, 0x00, 0x10, 0x30,
  0x60, 0x60, 0xC1, 0x81, 0x83, 0x06, 0x0C, 0x38, 0x70, 0xC1, 0x83, 0x0C,
  0x18, 0x60, 0xC3, 0x0C, 0x10, 0x00, 0x06, 0x01, 0x00, 0xC3, 0x33, 0xFF,
  0xC7, 0x81, 0xC0, 0xD8, 0x66, 0x30, 0xC0, 0x06, 0x01, 0x80, 0xE0, 0x38,
  0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x37, 0x76, 0xE4,
  0x7F, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0x0F, 0x87, 0xF3, 0x8C, 0xC3, 0x70, 0xD8, 0x76, 0x3D,
  0xBB, 0x78, 0xFC, 0x7E, 0x1F, 0x86, 0x63, 0x9F, 0xC3, 0xE0, 0x04, 0xFF,
  0xFB, 0x9C, 0x71, 0x86, 0x18, 0xE3, 0x8E, 0x30, 0xC3, 0x00, 0x0F, 0x83,
  0xF8, 0xE3, 0x98, 0x37, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xFF, 0xBF, 0xF0, 0x1F, 0x8F, 0xF7, 0x1D, 0x83,
  0x00, 0xC0, 0x71, 0xF8, 0x7C, 0x03, 0x80, 0x60, 0x1B, 0x06, 0xC3, 0xBF,
  0xC7, 0xE0, 0x00, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x6C, 0x19, 0x87, 0x71,
  0xCE, 0x31, 0x8C, 0x33, 0xFF, 0xFF, 0xF0, 0x38, 0x07, 0x00, 0xC0, 0x1F,
  0xE3, 0xFC, 0x60, 0x18, 0x03, 0x00, 0x7C, 0x1F, 0xE3, 0x9C, 0x01, 0xC0,
  0x38, 0x07, 0x60, 0xCE, 0x38, 0xFE, 0x0F, 0x80, 0x03, 0x83, 0xE1, 0xC0,
  0xE0, 0x70, 0x1B, 0xC7, 0xFB, 0xCE, 0xE1, 0xF8, 0x7C, 0x1F, 0x86, 0xE3,
  0x9F, 0xC3, 0xE0, 0xFF, 0xFF, 0xF0, 0x18, 0x06, 0x03, 0x01, 0xC0, 0x60,
  0x38, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x00, 0x0F, 0x87,
  0xF3, 0x8C, 0xC3, 0x30, 0xCC, 0x73, 0xF8, 0x7C, 0x73, 0xB8, 0x6E, 0x1F,
  0x06, 0xE3, 0x9F, 0xC3, 0xE0, 0x1E, 0x3F, 0x98, 0xFC, 0x3C, 0x1E, 0x0F,
  0x07, 0xC7, 0xFF, 0xBF, 0x80, 0xC0, 0xC1, 0xE3, 0xE3, 0xC0, 0x3B, 0xCE,
  0x00, 0x00, 0x00, 0x07, 0x39, 0xC0, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x1C, 0x71, 0x8E, 0x10, 0x00, 0xC0, 0xF1, 0xF9, 0xF0, 0x60,
  0x3E, 0x01, 0xF0, 0x1E, 0x01, 0x80, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x60, 0x1E, 0x03, 0xE0, 0x1F, 0x01, 0xC3, 0xE7, 0xE3,
  0xE0, 0xC0, 0x00, 0x3E, 0x3F, 0xB8, 0xF8, 0x70, 0x30, 0x38, 0x38, 0x38,
  0x38, 0x18, 0x0C, 0x00, 0x02, 0x03, 0x81, 0x80, 0x07, 0x83, 0xF8, 0xC1,
  0xB3, 0x94, 0xFB, 0xB2, 0x74, 0x4C, 0x99, 0xB3, 0x76, 0x4A, 0x7F, 0x4D,
  0xCC, 0x00, 0xCC, 0x0F, 0x80, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x6E, 0x06, 0x60, 0xC6, 0x0C, 0x61, 0xFE, 0x1F, 0xE3, 0xFE, 0x30,
  0x77, 0x07, 0xE0, 0x70, 0x1F, 0xC1, 0xFE, 0x18, 0x73, 0x83, 0x38, 0x73,
  0x06, 0x3F, 0xE3, 0xFC, 0x30, 0xE7, 0x06, 0x70, 0x66, 0x0E, 0x61, 0xE7,
  0xFC, 0xFF, 0x00, 0x0F, 0x83, 0xF8, 0xE3, 0xB8, 0x76, 0x07, 0xC0, 0x38,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x03, 0x60, 0xEE, 0x38, 0xFE, 0x0F, 0x80,
  0x1F, 0x01, 0xFC, 0x38, 0xE3, 0x86, 0x38, 0x73, 0x07, 0x30, 0x73, 0x07,
  0x70, 0x67, 0x06, 0x70, 0xE6, 0x0C, 0x63, 0xC7, 0xF8, 0xFE, 0x00, 0x3F,
  0xE7, 0xFC, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1F, 0xE3, 0xFC, 0x60, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xF3, 0xFE, 0x30,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x47, 0xF8, 0x7F, 0x86, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x0F, 0x83, 0xF8, 0xE3, 0xB8,
  0x76, 0x00, 0xC0, 0x38, 0x07, 0x3E, 0xC7, 0xD8, 0x1B, 0x03, 0x70, 0xEE,
  0x1C, 0xFF, 0x0F, 0xC0, 0x18, 0x31, 0x83, 0x38, 0x33, 0x87, 0x30, 0x73,
  0x06, 0x3F, 0xE3, 0xFE, 0x70, 0x67, 0x0E, 0x60, 0xE6, 0x0C, 0x60, 0xCE,
  0x0C, 0xE1, 0xC0, 0x3F, 0xE7, 0xFC, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC1, 0xFF, 0x3F, 0xC0,
  0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0xC0, 0x38, 0x06, 0x60, 0xCE, 0x39, 0xFE, 0x1F, 0x80, 0x18, 0x3C, 0x61,
  0xC1, 0x8E, 0x0E, 0x70, 0x3B, 0x80, 0xCE, 0x03, 0x70, 0x0F, 0xC0, 0x3F,
  0x01, 0xEE, 0x07, 0x38, 0x18, 0x70, 0x61, 0xC1, 0x83, 0x0E, 0x0E, 0x00,
  0x38, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38,
  0x1C, 0x0C, 0x07, 0xFF, 0xFE, 0x1C, 0x78, 0xE3, 0x8F, 0x3C, 0x79, 0xE3,
  0x5B, 0x1A, 0xF8, 0xDD, 0x86, 0xEC, 0x76, 0x63, 0x33, 0x18, 0x18, 0xC1,
  0xC6, 0x0C, 0x30, 0x63, 0x83, 0x00, 0x18, 0x31, 0xC3, 0x3C, 0x33, 0xC7,
  0x3C, 0x73, 0x66, 0x36, 0x63, 0x66, 0x73, 0xE7, 0x3E, 0x63, 0xE6, 0x3C,
  0x61, 0xCE, 0x1C, 0xE1, 0xC0, 0x0F, 0x83, 0xF8, 0xE3, 0x38, 0x76, 0x0E,
  0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xD8, 0x1B, 0x07, 0x60, 0xCE, 0x38, 0xFE,
  0x0F, 0x80, 0x3F, 0x87, 0xF8, 0xC3, 0x98, 0x37, 0x06, 0xE0, 0xD8, 0x3B,
  0xFE, 0x7F, 0x8C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x0F,
  0x83, 0xF8, 0xE3, 0x38, 0x76, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xD8,
  0x1B, 0x03, 0x60, 0xEE, 0x38, 0xFE, 0x0F, 0xC0, 0x1C, 0x01, 0xC0, 0x20,
  0x1F, 0xC1, 0xFE, 0x18, 0x73, 0x87, 0x38, 0x33, 0x07, 0x30, 0x63, 0xFE,
  0x3F, 0x87, 0x38, 0x71, 0x86, 0x1C, 0x61, 0xC6, 0x0C, 0xE0, 0xE0, 0x0F,
  0x87, 0xF8, 0xC3, 0xB8, 0x37, 0x00, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80,
  0x3B, 0x03, 0x60, 0x6E, 0x1C, 0xFF, 0x0F, 0xC0, 0xFF, 0xFF, 0xFC, 0x30,
  0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0x80, 0x60, 0x0C, 0x00, 0x30, 0x66, 0x0D, 0xC1, 0xB8, 0x76, 0x0E,
  0xC1, 0xD8, 0x33, 0x06, 0xE0, 0xDC, 0x3B, 0x07, 0x70, 0xCE, 0x38, 0xFE,
  0x0F, 0x80, 0xC0, 0xFC, 0x1B, 0x87, 0x70, 0xE6, 0x18, 0xC7, 0x18, 0xC3,
  0x38, 0x66, 0x0D, 0xC1, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x66,
  0x36, 0x63, 0x66, 0x76, 0x66, 0x6E, 0x66, 0xE6, 0x6A, 0xC7, 0xAC, 0x7A,
  0xC7, 0x2C, 0x73, 0x8F, 0x38, 0xE3, 0x8E, 0x30, 0xE3, 0x00, 0x1C, 0x1C,
  0x30, 0xE0, 0xE3, 0x83, 0x9C, 0x06, 0xE0, 0x1F, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x3F, 0x00, 0xCC, 0x07, 0x30, 0x38, 0xE0, 0xC1, 0x8F, 0x07,
  0x00, 0xE0, 0xFC, 0x1D, 0x87, 0x30, 0xC7, 0x38, 0x6E, 0x0D, 0x81, 0xF0,
  0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x00, 0x3F, 0xF3,
  0xFF, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x03, 0x00, 0x70, 0x0F, 0xFE, 0xFF, 0xC0, 0x1E, 0x3C, 0xE1,
  0xC3, 0x06, 0x0C, 0x18, 0x70, 0xE1, 0x83, 0x06, 0x0C, 0x18, 0x70, 0xE1,
  0x83, 0xC7, 0x80, 0xC6, 0x30, 0xC6, 0x31, 0x8C, 0x71, 0x8C, 0x63, 0x18,
  0xE3, 0x1E, 0x7C, 0x38, 0x60, 0xC1, 0x83, 0x0E, 0x1C, 0x30, 0x60, 0xC1,
  0x87, 0x0E, 0x1C, 0x30, 0x63, 0xC7, 0x80, 0x06, 0x0E, 0x1E, 0x1E, 0x33,
  0x33, 0x63, 0xE3, 0xFF, 0xFF, 0xE0, 0xCC, 0x80, 0x1F, 0x1F, 0xE7, 0x1C,
  0x07, 0x1F, 0x9F, 0xEE, 0x1B, 0x06, 0xC3, 0xBF, 0xE7, 0xF8, 0x1C, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x80, 0x7F, 0x8F, 0xF1, 0xC7, 0x30, 0x66, 0x0D,
  0xC3, 0xB8, 0x77, 0x0C, 0xE3, 0x9F, 0xE7, 0x78, 0x1F, 0x0F, 0xE7, 0x1D,
  0x83, 0xE0, 0x38, 0x0C, 0x03, 0x86, 0xE3, 0x9F, 0xC3, 0xE0, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x70, 0x0E, 0x3D, 0x8F, 0xF3, 0x8E, 0x61, 0xDC, 0x3B,
  0x87, 0x60, 0xCE, 0x19, 0xC7, 0x1F, 0xE1, 0xFC, 0x1F, 0x0F, 0xE7, 0x1D,
  0x83, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0xE1, 0x9F, 0xE3, 0xF0, 0x03, 0xE1,
  0xFC, 0x30, 0x0E, 0x01, 0xC5, 0xFF, 0x3F, 0xE0, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x0F, 0xF1, 0xFE, 0x38,
  0xE3, 0x06, 0x70, 0xE7, 0x0E, 0x60, 0xC7, 0x0C, 0x71, 0xC3, 0xFC, 0x1F,
  0xC0, 0x1C, 0x41, 0x8F, 0xF8, 0x7E, 0x00, 0x1C, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x80, 0x7F, 0x8F, 0xF9, 0xC7, 0x30, 0x66, 0x0D, 0xC3, 0xB8, 0x76,
  0x0C, 0xC1, 0x98, 0x37, 0x0E, 0x03, 0x01, 0x80, 0x00, 0x03, 0xF1, 0xF0,
  0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC7, 0xFF, 0xFE, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30,
  0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x1F, 0x87, 0xC2, 0x80, 0x1C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x8F, 0x39, 0xC3, 0x38, 0x37,
  0x03, 0xE0, 0x7E, 0x07, 0xF0, 0x73, 0x86, 0x38, 0x61, 0xCE, 0x1C, 0x1F,
  0x1F, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81,
  0xC0, 0xC0, 0x63, 0xFF, 0xFF, 0x3E, 0xE7, 0xFF, 0x67, 0x76, 0x67, 0x66,
  0x66, 0x66, 0x66, 0x6E, 0x66, 0xCE, 0x6C, 0xCE, 0xCC, 0xC0, 0x3F, 0xC7,
  0xFC, 0xE3, 0x98, 0x33, 0x0E, 0xE1, 0xDC, 0x3B, 0x06, 0x60, 0xCC, 0x1B,
  0x87, 0x00, 0x1F, 0x0F, 0xE7, 0x1F, 0x83, 0xE0, 0xF0, 0x3C, 0x1F, 0x06,
  0xE3, 0x9F, 0xC3, 0xE0, 0x3F, 0xC7, 0xF8, 0xE3, 0x98, 0x73, 0x06, 0xE1,
  0xDC, 0x3B, 0x06, 0x71, 0xCF, 0xF1, 0xBC, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x00, 0x1E, 0xE7, 0xF9, 0xC7, 0x30, 0xEE, 0x1D, 0xC3, 0xB0, 0x67, 0x0C,
  0xE3, 0x8F, 0xF0, 0xFE, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x37, 0xCF,
  0xE7, 0x81, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x00,
  0x1F, 0x8F, 0xF7, 0x0D, 0x80, 0x78, 0x0F, 0xC0, 0x78, 0x06, 0xE1, 0x9F,
  0xE3, 0xF0, 0x1C, 0x0C, 0x06, 0x1F, 0xFF, 0xF9, 0xC0, 0xE0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0xF0, 0xF8, 0x70, 0xEE, 0x19, 0x83, 0x30, 0x66,
  0x1C, 0xC3, 0xB8, 0x67, 0x0C, 0xE3, 0x8F, 0xF1, 0xF6, 0x00, 0xC1, 0xF0,
  0x6C, 0x3B, 0x8C, 0x67, 0x19, 0x86, 0xE1, 0xB0, 0x2C, 0x0E, 0x03, 0x80,
  0xC6, 0x7C, 0x66, 0xCE, 0x6C, 0xEC, 0xDE, 0xCD, 0xEC, 0xD7, 0x8F, 0x78,
  0xE3, 0x8E, 0x30, 0xE3, 0x00, 0x38, 0x71, 0x8E, 0x1D, 0xC0, 0xF8, 0x0F,
  0x00, 0x70, 0x0F, 0x01, 0xF8, 0x39, 0x87, 0x1C, 0xE0, 0xE0, 0x70, 0x39,
  0x83, 0x8E, 0x18, 0x71, 0xC1, 0x8C, 0x0C, 0xC0, 0x6E, 0x03, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x7C, 0x03, 0xC0, 0x08, 0x00,
  0x3F, 0xF3, 0xFE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x07, 0xFC, 0xFF, 0xC0, 0x03, 0x06, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C,
  0x18, 0x38, 0xE0, 0xF0, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x18,
  0x08, 0x13, 0x33, 0x32, 0x22, 0x66, 0x66, 0x44, 0xCC, 0xCC, 0x80, 0x18,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0E, 0x07, 0x0F, 0x18, 0x18,
  0x38, 0x38, 0x30, 0x30, 0x70, 0xE0, 0x80, 0x7C, 0x37, 0xE6, 0xC7, 0xE0,
  0x1C,
};

const GFXglyph RobotoMono_MediumItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 5, 15, 12, 4, -15 },
  { 11, 6, 5, 12, 4, -16 },
  { 15, 12, 15, 12, 0, -15 },
  { 38, 11, 19, 12, 1, -17 },
  { 65, 10, 15, 12, 1, -15 },
  { 84, 12, 15, 12, 0, -15 },
  { 107, 3, 6, 12, 5, -16 },
  { 110, 7, 22, 12, 3, -17 },
  { 130, 7, 22, 12, 2, -17 },
  { 150, 10, 10, 12, 2, -15 },
  { 163, 10, 11, 12, 1, -12 },
  { 177, 4, 6, 12, 2, -2 },
  { 180, 9, 2, 12, 2, -8 },
  { 183, 3, 3, 12, 4, -3 },
  { 185, 11, 16, 12, 1, -15 },
  { 207, 10, 15, 12, 1, -15 },
  { 226, 6, 15, 12, 3, -15 },
  { 238, 11, 15, 12, 0, -15 },
  { 259, 10, 15, 12, 1, -15 },
  { 278, 11, 15, 12, 0, -15 },
  { 299, 11, 15, 12, 1, -15 },
  { 320, 10, 15, 12, 1, -15 },
  { 339, 10, 15, 12, 2, -15 },
  { 358, 10, 15, 12, 1, -15 },
  { 377, 9, 15, 12, 2, -15 },
  { 394, 5, 12, 12, 4, -12 },
  { 402, 6, 16, 12, 3, -12 },
  { 414, 10, 9, 12, 1, -11 },
  { 426, 10, 7, 12, 1, -10 },
  { 435, 10, 9, 12, 1, -11 },
  { 447, 9, 15, 12, 3, -15 },
  { 464, 11, 15, 12, 1, -15 },
  { 485, 12, 15, 12, -1, -15 },
  { 508, 12, 15, 12, 0, -15 },
  { 531, 11, 15, 12, 1, -15 },
  { 552, 12, 15, 12, 0, -15 },
  { 575, 11, 15, 12, 1, -15 },
  { 596, 12, 15, 12, 1, -15 },
  { 619, 11, 15, 12, 1, -15 },
  { 640, 12, 15, 12, 0, -15 },
  { 663, 11, 15, 12, 1, -15 },
  { 684, 11, 15, 12, 1, -15 },
  { 705, 14, 15, 12, 0, -15 },
  { 732, 9, 15, 12, 1, -15 },
  { 749, 13, 15, 12, 0, -15 },
  { 774, 12, 15, 12, 0, -15 },
  { 797, 11, 15, 12, 1, -15 },
  { 818, 11, 15, 12, 1, -15 },
  { 839, 11, 18, 12, 1, -15 },
  { 864, 12, 15, 12, 0, -15 },
  { 887, 11, 15, 12, 1, -15 },
  { 908, 11, 15, 12, 2, -15 },
  { 929, 11, 15, 12, 1, -15 },
  { 950, 11, 15, 12, 2, -15 },
  { 971, 12, 15, 12, 1, -15 },
  { 994, 14, 15, 12, -1, -15 },
  { 1021, 11, 15, 12, 2, -15 },
  { 1042, 12, 15, 12, 0, -15 },
  { 1065, 7, 20, 12, 3, -17 },
  { 1083, 5, 16, 12, 4, -15 },
  { 1093, 7, 20, 12, 3, -17 },
  { 1111, 8, 8, 12, 2, -15 },
  { 1119, 10, 2, 12, 0, 0 },
  { 1122, 3, 3, 12, 6, -15 },
  { 1124, 10, 11, 12, 1, -11 },
  { 1138, 11, 16, 12, 0, -16 },
  { 1160, 10, 11, 12, 1, -11 },
  { 1174, 11, 16, 12, 1, -16 },
  { 1196, 10, 11, 12, 1, -11 },
  { 1210, 11, 16, 12, 2, -16 },
  { 1232, 12, 15, 12, 0, -11 },
  { 1255, 11, 16, 12, 0, -16 },
  { 1277, 9, 15, 12, 1, -15 },
  { 1294, 10, 20, 12, 0, -15 },
  { 1319, 12, 16, 12, 0, -16 },
  { 1343, 9, 16, 12, 1, -16 },
  { 1361, 12, 11, 12, 0, -11 },
  { 1378, 11, 11, 12, 0, -11 },
  { 1394, 10, 11, 12, 1, -11 },
  { 1408, 11, 15, 12, 0, -11 },
  { 1429, 11, 15, 12, 1, -11 },
  { 1450, 10, 11, 12, 2, -11 },
  { 1464, 10, 11, 12, 1, -11 },
  { 1478, 9, 14, 12, 2, -14 },
  { 1494, 11, 11, 12, 1, -11 },
  { 1510, 10, 11, 12, 2, -11 },
  { 1524, 12, 11, 12, 1, -11 },
  { 1541, 12, 11, 12, 0, -11 },
  { 1558, 13, 16, 12, 0, -11 },
  { 1584, 12, 11, 12, 0, -11 },
  { 1601, 8, 20, 12, 3, -16 },
  { 1621, 4, 19, 12, 4, -15 },
  { 1631, 8, 20, 12, 2, -16 },
  { 1651, 12, 4, 12, 0, -8 },
};

const GFXfont RobotoMono_MediumItalic21pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic21pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOMONO_MEDIUMITALIC21PT7B_H_
