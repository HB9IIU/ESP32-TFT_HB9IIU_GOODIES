#ifndef _ROBOTOMONO_MEDIUMITALIC34PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xF8,
  0x70, 0x70, 0xEE, 0x1D, 0xC7, 0x38, 0xE7, 0x1C, 0xC3, 0xB8, 0x67, 0x0C,
  0xE3, 0x80, 0x00, 0x38, 0xE0, 0x03, 0x0E, 0x00, 0x71, 0xC0, 0x07, 0x1C,
  0x00, 0xE1, 0x80, 0x0E, 0x38, 0x00, 0xC3, 0x81, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0x18, 0x70, 0x03, 0x86, 0x00, 0x38, 0xE0, 0x03, 0x0E, 0x00, 0x70,
  0xC0, 0x07, 0x1C, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0xE3, 0x80, 0x1C,
  0x38, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03, 0x86, 0x00, 0x38, 0xE0, 0x03,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x3F,
  0xC0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3E, 0x1F, 0x1E, 0x07, 0x9E, 0x03, 0xCF,
  0x01, 0xE7, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xE7, 0x80,
  0x73, 0xC0, 0x79, 0xE0, 0x3C, 0xF8, 0x3E, 0x3F, 0xFE, 0x0F, 0xFE, 0x03,
  0xFC, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x04, 0x00,
  0x3F, 0x00, 0x7F, 0x80, 0x73, 0x80, 0xE3, 0x86, 0xE3, 0x8E, 0xE3, 0x9C,
  0xE3, 0x9C, 0xF7, 0xB8, 0x7F, 0x70, 0x3E, 0x60, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x07, 0x3E, 0x0E, 0x7F, 0x0E, 0xE7, 0x1C, 0xC3,
  0x39, 0xC3, 0x31, 0xC3, 0x11, 0xC7, 0x01, 0xC7, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0x20, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0x0E, 0x03,
  0xC3, 0x80, 0xE0, 0xE0, 0x38, 0x78, 0x0F, 0x3C, 0x03, 0xDE, 0x00, 0xFF,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x07, 0xF0, 0x73, 0xFE, 0x1D, 0xF7, 0x8F,
  0x78, 0xF3, 0xFC, 0x3D, 0xEF, 0x07, 0xFB, 0xC1, 0xFC, 0xF0, 0x3E, 0x3E,
  0x1F, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xCF, 0x80, 0x77, 0x77, 0xEE,
  0xEE, 0xE0, 0x00, 0x20, 0x07, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x04, 0x00, 0x04, 0x00, 0xC0, 0x3C, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x38,
  0x0F, 0x03, 0xC0, 0xF0, 0x18, 0x02, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x41, 0xC1, 0x71, 0xC7, 0xFD, 0xBF, 0xFF, 0xFF,
  0x0F, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x0E, 0xE0, 0x1C, 0xF0, 0x38, 0x70,
  0x78, 0x78, 0x30, 0x30, 0x00, 0x20, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x8E,
  0x3C, 0xF0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7B, 0xEF, 0xFE, 0x78,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x40, 0x03, 0xFC,
  0x07, 0xFE, 0x0F, 0xFE, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x07, 0x38, 0x07,
  0x78, 0x07, 0x78, 0x1F, 0x78, 0x3F, 0x78, 0xFF, 0x79, 0xEF, 0x77, 0xCF,
  0xFF, 0x0F, 0xFE, 0x0F, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C,
  0xF0, 0x3C, 0x78, 0x78, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x60,
  0x7C, 0x7F, 0xBF, 0xF7, 0xFD, 0xF3, 0xB0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x00, 0x10, 0x00, 0x7F, 0x80,
  0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x3C, 0xF0,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x00, 0x00, 0x20, 0x01, 0xFE, 0x01, 0xFF, 0xC1, 0xFF,
  0xE1, 0xF0, 0xF8, 0xF0, 0x3C, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x01, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xB0, 0x03, 0x9E, 0x03, 0xCF, 0x01,
  0xE7, 0xC1, 0xE1, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x0F, 0x70, 0x07, 0x9C, 0x01, 0xCF, 0x00, 0xF3, 0xC0, 0x78, 0xF0, 0x3C,
  0x3C, 0x1E, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE1, 0xFF, 0xFF, 0x7F, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3D, 0xE0, 0x1F,
  0xFC, 0x0F, 0xFF, 0x0F, 0xCF, 0xC0, 0x81, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x70, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x8F, 0x87,
  0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x7C, 0x03, 0xF8, 0x1F,
  0xF0, 0x7F, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x79, 0xF0,
  0xFF, 0xF1, 0xFF, 0xF7, 0xF3, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xE7, 0x87, 0xCF, 0xFF,
  0x0F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x7F, 0x80,
  0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0x87, 0x87, 0xC1, 0xE1, 0xE0, 0x38, 0x78,
  0x0E, 0x1E, 0x07, 0x87, 0x81, 0xE0, 0xF0, 0xF0, 0x3F, 0xF8, 0x07, 0xFC,
  0x03, 0xFF, 0x03, 0xE3, 0xE0, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x1F, 0x1F, 0x0F, 0x83, 0xFF, 0xC0, 0xFF,
  0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x80, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE7,
  0xC3, 0xCF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x03, 0xFF, 0x0F, 0x9F, 0xFF, 0x1F, 0xFE, 0x1F, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x01, 0xF8, 0x1F, 0xE0, 0x3F,
  0x80, 0x7C, 0x00, 0x0F, 0x1F, 0x1F, 0x1F, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x7C, 0xFC, 0x7C, 0x78, 0x07, 0x83,
  0xF0, 0xFC, 0x3F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38,
  0x1E, 0x07, 0x03, 0xC0, 0x60, 0x00, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x7F,
  0x01, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x00, 0x78, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x0C,
  0x3F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x80,
  0x18, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0x00, 0x7F, 0x03, 0xFE, 0x1F, 0xF8, 0x7F, 0xC0,
  0x7F, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x1F, 0xE0, 0xFF, 0xF3,
  0xFF, 0xE7, 0xC3, 0xEF, 0x03, 0xFC, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x1C, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x1F, 0x1E,
  0x07, 0x80, 0xE1, 0xC0, 0x0C, 0x38, 0xF1, 0x8E, 0x3F, 0xB1, 0x8E, 0x67,
  0x73, 0x8C, 0xEC, 0x61, 0x99, 0x9C, 0x73, 0x73, 0x0C, 0x6E, 0x61, 0x8D,
  0x8C, 0x31, 0xB3, 0x8E, 0x66, 0x31, 0x8C, 0xC7, 0xFB, 0x18, 0xFF, 0xE3,
  0x8C, 0x70, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0xC0, 0x0F, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1D, 0xC0, 0x07, 0xB8, 0x00, 0xE7, 0x80,
  0x3C, 0xF0, 0x07, 0x1E, 0x01, 0xE3, 0xC0, 0x38, 0x78, 0x0F, 0x07, 0x01,
  0xE0, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x78, 0x0F, 0x1E,
  0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0x77, 0x80, 0x0F, 0x0F,
  0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x78, 0x1F, 0x1E, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x3C, 0x70, 0x0F, 0x3C, 0x07, 0xCF, 0x03, 0xE3, 0xFF, 0xF0,
  0xFF, 0xF0, 0x3F, 0xFF, 0x1E, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x1E, 0x78,
  0x07, 0x9E, 0x01, 0xE7, 0x00, 0x7B, 0xC0, 0x3C, 0xF0, 0x3F, 0x3F, 0xFF,
  0x8F, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x7F, 0x80, 0x7F, 0xF0,
  0x3F, 0xFE, 0x0F, 0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x27, 0x00, 0x71,
  0xE0, 0x3C, 0x78, 0x1F, 0x1F, 0x0F, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0x87, 0xC0,
  0xF0, 0x3C, 0x1E, 0x07, 0x83, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3,
  0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0x8F,
  0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x3E, 0x3C,
  0x0F, 0x87, 0x87, 0xE0, 0xFF, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x8F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x10, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x1F, 0xFE, 0x0F, 0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x07, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x5E, 0x1F,
  0xE7, 0x87, 0xF9, 0xC1, 0xFE, 0xF0, 0x07, 0x9C, 0x01, 0xE7, 0x80, 0x79,
  0xE0, 0x3C, 0x78, 0x0F, 0x0F, 0x07, 0xC3, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F,
  0xF0, 0x00, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0E,
  0x0F, 0x01, 0xE0, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01,
  0xE1, 0xE0, 0x1C, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xC0,
  0x3C, 0x3C, 0x03, 0x83, 0xC0, 0x38, 0x38, 0x07, 0x87, 0x80, 0x78, 0x78,
  0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x0F,
  0x00, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x1F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x78, 0x7C, 0x0F, 0x07, 0x87, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x01, 0xF8, 0x70, 0x1F, 0x07, 0x80,
  0xF8, 0x3C, 0x0F, 0x81, 0xE0, 0xF8, 0x0F, 0x0F, 0x80, 0x78, 0xF8, 0x03,
  0x8F, 0x80, 0x3C, 0xF8, 0x01, 0xEF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFB, 0xE0, 0x0F, 0x8F, 0x00, 0x78,
  0x7C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0,
  0x78, 0x0F, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0x81, 0xF0, 0xFC,
  0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F,
  0xCE, 0xE1, 0xFC, 0xEE, 0x1E, 0xDD, 0xE1, 0xED, 0xDE, 0x1C, 0xF9, 0xE1,
  0xCF, 0x9C, 0x3C, 0xF1, 0xC3, 0xCF, 0x3C, 0x3C, 0xF3, 0xC3, 0xCE, 0x3C,
  0x38, 0xE3, 0x83, 0x80, 0x38, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07,
  0x87, 0x80, 0x78, 0x70, 0x07, 0x0F, 0x00, 0x70, 0x0F, 0x80, 0xF0, 0xF8,
  0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0x1E, 0x0F, 0xC1, 0xE0, 0xFC, 0x1E, 0x1F,
  0xC1, 0xE1, 0xFE, 0x1E, 0x1E, 0xE1, 0xE1, 0xEE, 0x3C, 0x1E, 0xE3, 0xC1,
  0xEF, 0x3C, 0x3C, 0x73, 0xC3, 0xC7, 0x3C, 0x3C, 0x7B, 0x83, 0xC3, 0xF8,
  0x3C, 0x3F, 0x87, 0x83, 0xF8, 0x78, 0x3F, 0x87, 0x81, 0xF8, 0x78, 0x1F,
  0x07, 0x81, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF0, 0x00, 0x10, 0x00, 0x7F,
  0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x78,
  0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01,
  0xE7, 0x00, 0xF1, 0xE0, 0x3C, 0x78, 0x1E, 0x1F, 0x0F, 0x83, 0xFF, 0xC0,
  0x7F, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF,
  0x0F, 0x03, 0xE1, 0xE0, 0x3E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F,
  0x1E, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x1F, 0xC3, 0xFF, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFC, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F,
  0x07, 0x87, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xDE, 0x00,
  0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x00, 0x3F,
  0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x71, 0xE0, 0x3C, 0x78,
  0x1E, 0x1F, 0x0F, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x04, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0x03, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80,
  0xF0, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x3E, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xC1, 0xE0, 0x78, 0x3C,
  0x0F, 0x07, 0x81, 0xE0, 0xF8, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3E,
  0x3C, 0x03, 0xC7, 0x80, 0x78, 0x00, 0x10, 0x00, 0x3F, 0xC0, 0x1F, 0xFE,
  0x07, 0xFF, 0xC1, 0xF0, 0x7C, 0x3C, 0x07, 0x87, 0x80, 0x78, 0xE0, 0x0F,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF3,
  0xC0, 0x1E, 0x78, 0x03, 0xC7, 0x80, 0xF8, 0xF8, 0x3E, 0x0F, 0xFF, 0x80,
  0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C,
  0x07, 0x8E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01,
  0xC7, 0x80, 0xF1, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x38, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF0, 0xF8,
  0x7C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x79, 0xE0, 0x3E, 0x78, 0x0F, 0x1E, 0x07, 0xC7, 0x81, 0xE1,
  0xE0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x87, 0x80, 0xE1, 0xE0, 0x3C,
  0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x78, 0xF0, 0xF7, 0x0F, 0x1E, 0x70, 0xF1, 0xE7, 0x0F, 0x1C,
  0x71, 0xF1, 0xC7, 0x1F, 0x3C, 0x71, 0xF3, 0xC7, 0x3F, 0x38, 0x73, 0xF3,
  0x87, 0x3F, 0x78, 0x77, 0x77, 0x87, 0x77, 0x70, 0x77, 0x7F, 0x07, 0xE7,
  0xF0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC,
  0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0x80, 0xF0, 0x78, 0x0F,
  0x07, 0x80, 0x0F, 0x80, 0x7C, 0x1E, 0x01, 0xE0, 0x7C, 0x0F, 0x80, 0xF0,
  0x7C, 0x03, 0xC1, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x7C, 0x00, 0x79, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xCF,
  0x00, 0x1E, 0x3C, 0x00, 0xF8, 0xF0, 0x07, 0xC1, 0xE0, 0x1E, 0x07, 0x80,
  0xF8, 0x1F, 0x07, 0xC0, 0x3C, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xEF, 0x00,
  0xF9, 0xE0, 0x1E, 0x3C, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x0F, 0x0F,
  0x00, 0xE1, 0xE0, 0x1E, 0x78, 0x03, 0xDF, 0x00, 0x7B, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x78, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x7F, 0x0F, 0xE0, 0xFE, 0x00, 0xF0, 0x70, 0x70, 0x70, 0x78,
  0x78, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1E,
  0x1E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x07, 0x07, 0x07, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x00, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0x70, 0x7B, 0x83, 0x8E,
  0x38, 0x73, 0xC3, 0x9C, 0x1D, 0xE0, 0xEE, 0x03, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0x8F, 0x1C, 0x03, 0xF8, 0x0F, 0xFE, 0x1F,
  0xFF, 0x3E, 0x0F, 0x3C, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x03, 0xFF, 0x1F,
  0xFF, 0x3F, 0xFF, 0x7C, 0x0E, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF8,
  0x7E, 0x7F, 0xFE, 0x7F, 0xFE, 0x1F, 0x9E, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0xFC, 0x0E, 0xFF, 0x07, 0xFF, 0xC7, 0xE1, 0xE3, 0xE0, 0xF1, 0xE0,
  0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xCF,
  0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF3, 0xF0, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8,
  0x79, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3E, 0x1E, 0x78,
  0x0F, 0x78, 0x0F, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x1E, 0xF0, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x07, 0xE7, 0x87,
  0xFF, 0xC3, 0xFF, 0xF0, 0xF8, 0x7C, 0x78, 0x1F, 0x1E, 0x03, 0xCF, 0x00,
  0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78,
  0xF0, 0x1C, 0x3C, 0x0F, 0x0F, 0x87, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x07,
  0xEF, 0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x3E, 0x1E, 0x7C, 0x0F,
  0x78, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x08, 0x78, 0x3C, 0x7F, 0xFC, 0x3F, 0xF8,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xC0, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xF3, 0xC3, 0xFE, 0xF1, 0xFF, 0xF8, 0x7C, 0x3E, 0x3E, 0x07,
  0x8F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1C, 0x78, 0x0F, 0x1E, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0x87, 0xC3, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x03, 0xF7, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x40, 0x7C,
  0x3C, 0x3E, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x7C, 0x0E, 0xFF, 0x8F, 0xFF, 0xC7, 0xE1, 0xF3,
  0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x0F, 0x78, 0x07, 0x3C, 0x07,
  0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0x80, 0x7B, 0xC0, 0x39, 0xE0,
  0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x00, 0x00, 0x30, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x1F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x07, 0xC7, 0x83, 0xE3, 0xC1, 0xF0, 0xF0, 0xF8, 0x3C, 0x7C, 0x0F, 0x7E,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01,
  0xF3, 0xC0, 0x78, 0xF8, 0x1C, 0x1E, 0x0F, 0x03, 0xC3, 0xC0, 0xF8, 0xF0,
  0x1E, 0x3C, 0x07, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0x1D, 0xF7, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x9E, 0x7C, 0xF3, 0xC7, 0x1E, 0x71, 0xE3, 0xCE, 0x3C,
  0x7B, 0xC7, 0x8E, 0x78, 0xF1, 0xCF, 0x1C, 0x39, 0xC3, 0x8F, 0x38, 0xF1,
  0xE7, 0x1E, 0x3D, 0xE3, 0xC7, 0x3C, 0x70, 0xE7, 0x8E, 0x1C, 0xE1, 0xC7,
  0x9C, 0x78, 0xF0, 0x1C, 0xFE, 0x0E, 0xFF, 0x8F, 0xFF, 0xC7, 0xE1, 0xF3,
  0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x0F, 0x78, 0x07, 0x3C, 0x07,
  0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0x80, 0x7B, 0xC0, 0x39, 0xE0,
  0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x07, 0xFF,
  0x83, 0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78,
  0x07, 0xB8, 0x03, 0xDC, 0x01, 0xEE, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF1,
  0xF0, 0xF8, 0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0x0E, 0x7E, 0x03,
  0xFF, 0xC1, 0xFF, 0xF8, 0x7E, 0x3E, 0x1E, 0x07, 0x87, 0x80, 0xF1, 0xE0,
  0x3C, 0x70, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x1E,
  0x3C, 0x07, 0x8F, 0x03, 0xC7, 0xE1, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1E,
  0xFE, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xE7, 0x8F, 0xFB, 0x8F, 0xFF,
  0xC7, 0xC3, 0xE7, 0x80, 0xF3, 0xC0, 0x7B, 0xC0, 0x39, 0xE0, 0x3C, 0xF0,
  0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xC7, 0x81, 0xE3,
  0xE1, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xDE, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x1E, 0x7F, 0x1E, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x07, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x3C, 0x1F, 0x78, 0x0F, 0x78, 0x00,
  0x7C, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3E,
  0xE0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0x7F, 0xFC, 0x7F, 0xF8, 0x1F, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x87, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x3C, 0x07, 0x9E, 0x03, 0xCE, 0x03,
  0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x70,
  0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE3,
  0xE1, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0x9E, 0x00, 0xF0, 0x0F, 0xF8,
  0x07, 0xBC, 0x07, 0x9E, 0x03, 0xC7, 0x03, 0xC3, 0x81, 0xE1, 0xE1, 0xE0,
  0xF0, 0xF0, 0x38, 0x70, 0x1C, 0x78, 0x0E, 0x38, 0x07, 0xBC, 0x03, 0xDC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0xC1, 0xFC, 0x3C, 0x7B, 0x87, 0x8F, 0x70, 0xF1, 0xCE, 0x3E, 0x39,
  0xC7, 0xCF, 0x39, 0xF9, 0xC7, 0x3F, 0x38, 0xE6, 0xEE, 0x1D, 0xDD, 0xC3,
  0xB3, 0xB8, 0x76, 0x7E, 0x0F, 0xCF, 0xC1, 0xF0, 0xF8, 0x3E, 0x1E, 0x07,
  0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x0E, 0x00, 0x1E, 0x01, 0xF0, 0xF0, 0x3E,
  0x0F, 0x07, 0xC0, 0x78, 0xF8, 0x03, 0xCF, 0x00, 0x3D, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xBC, 0x00, 0xF1, 0xE0, 0x1E, 0x1E, 0x03, 0xE0, 0xF0, 0x7C,
  0x0F, 0x0F, 0x80, 0x78, 0x3E, 0x00, 0xF8, 0xF0, 0x07, 0x87, 0x80, 0x78,
  0x3C, 0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x83, 0xE0, 0x3C, 0x1E, 0x01, 0xE1,
  0xE0, 0x07, 0x0F, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x78, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xFC, 0xFF, 0xFF,
  0x3F, 0xFF, 0x80, 0x00, 0x08, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0x7C, 0x1F, 0xC0, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x00, 0x07, 0x06, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x18,
  0x38, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x70, 0x60, 0x60,
  0x60, 0xE0, 0xE0, 0xE0, 0x04, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3F, 0x00, 0x78, 0x0F, 0xC0, 0xF8, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1E, 0x00, 0xE0, 0x00, 0x04, 0x00,
  0x03, 0xF0, 0x18, 0xFF, 0x03, 0xBF, 0xF8, 0xF7, 0x0F, 0xFD, 0xC0, 0xFF,
  0x88, 0x0F, 0xE0, 0x00, 0x20,
};

const GFXglyph RobotoMono_MediumItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 8, 24, 20, 6, -24 },
  { 25, 11, 9, 20, 6, -26 },
  { 38, 20, 24, 20, 0, -24 },
  { 98, 17, 32, 20, 2, -28 },
  { 166, 16, 25, 20, 2, -25 },
  { 216, 18, 25, 20, 1, -25 },
  { 273, 4, 9, 20, 9, -26 },
  { 278, 12, 35, 20, 5, -27 },
  { 331, 11, 35, 20, 3, -27 },
  { 380, 16, 17, 20, 3, -24 },
  { 414, 16, 18, 20, 2, -20 },
  { 450, 7, 10, 20, 3, -4 },
  { 459, 13, 3, 20, 4, -12 },
  { 464, 6, 5, 20, 6, -5 },
  { 468, 17, 26, 20, 2, -24 },
  { 524, 16, 25, 20, 2, -25 },
  { 574, 11, 24, 20, 4, -24 },
  { 607, 18, 25, 20, 0, -25 },
  { 664, 17, 25, 20, 1, -25 },
  { 718, 18, 24, 20, 0, -24 },
  { 772, 17, 24, 20, 2, -24 },
  { 823, 15, 24, 20, 2, -24 },
  { 868, 17, 24, 20, 3, -24 },
  { 919, 18, 25, 20, 1, -25 },
  { 976, 15, 25, 20, 3, -25 },
  { 1023, 8, 19, 20, 6, -19 },
  { 1042, 10, 25, 20, 5, -19 },
  { 1074, 16, 15, 20, 2, -18 },
  { 1104, 17, 11, 20, 2, -16 },
  { 1128, 16, 15, 20, 1, -18 },
  { 1158, 15, 25, 20, 4, -25 },
  { 1205, 19, 24, 20, 1, -24 },
  { 1262, 19, 24, 20, -1, -24 },
  { 1319, 18, 24, 20, 1, -24 },
  { 1373, 18, 25, 20, 1, -25 },
  { 1430, 19, 24, 20, 0, -24 },
  { 1487, 19, 24, 20, 1, -24 },
  { 1544, 19, 24, 20, 1, -24 },
  { 1601, 18, 25, 20, 1, -25 },
  { 1658, 20, 24, 20, 0, -24 },
  { 1718, 18, 24, 20, 1, -24 },
  { 1772, 19, 24, 20, 1, -24 },
  { 1829, 21, 24, 20, 1, -24 },
  { 1892, 16, 24, 20, 1, -24 },
  { 1940, 20, 24, 20, 0, -24 },
  { 2000, 20, 24, 20, 0, -24 },
  { 2060, 18, 25, 20, 1, -25 },
  { 2117, 19, 24, 20, 1, -24 },
  { 2174, 18, 29, 20, 1, -25 },
  { 2240, 19, 24, 20, 1, -24 },
  { 2297, 19, 25, 20, 1, -25 },
  { 2357, 19, 24, 20, 3, -24 },
  { 2414, 18, 24, 20, 2, -24 },
  { 2468, 18, 24, 20, 3, -24 },
  { 2522, 20, 24, 20, 2, -24 },
  { 2582, 22, 24, 20, -1, -24 },
  { 2648, 19, 24, 20, 3, -24 },
  { 2705, 20, 24, 20, 0, -24 },
  { 2765, 12, 33, 20, 4, -28 },
  { 2815, 8, 26, 20, 6, -24 },
  { 2841, 12, 33, 20, 4, -28 },
  { 2891, 13, 13, 20, 4, -24 },
  { 2913, 15, 3, 20, 0, 0 },
  { 2919, 6, 5, 20, 9, -25 },
  { 2923, 16, 18, 20, 1, -18 },
  { 2959, 17, 26, 20, 1, -26 },
  { 3015, 16, 18, 20, 2, -18 },
  { 3051, 18, 26, 20, 2, -26 },
  { 3110, 16, 18, 20, 2, -18 },
  { 3146, 18, 26, 20, 3, -26 },
  { 3205, 18, 25, 20, 1, -18 },
  { 3262, 17, 26, 20, 1, -26 },
  { 3318, 15, 25, 20, 2, -25 },
  { 3365, 15, 32, 20, 1, -25 },
  { 3425, 18, 26, 20, 1, -26 },
  { 3484, 16, 26, 20, 1, -26 },
  { 3536, 19, 18, 20, 0, -18 },
  { 3579, 17, 18, 20, 1, -18 },
  { 3618, 17, 18, 20, 1, -18 },
  { 3657, 18, 25, 20, 0, -18 },
  { 3714, 17, 25, 20, 2, -18 },
  { 3768, 16, 18, 20, 3, -18 },
  { 3804, 16, 18, 20, 2, -18 },
  { 3840, 15, 22, 20, 3, -22 },
  { 3882, 17, 18, 20, 2, -18 },
  { 3921, 17, 18, 20, 3, -18 },
  { 3960, 19, 18, 20, 2, -18 },
  { 4003, 20, 18, 20, 0, -18 },
  { 4048, 21, 25, 20, 0, -18 },
  { 4114, 18, 18, 20, 1, -18 },
  { 4155, 13, 33, 20, 5, -27 },
  { 4209, 8, 31, 20, 6, -24 },
  { 4240, 13, 33, 20, 3, -27 },
  { 4294, 19, 8, 20, 0, -14 },
};

const GFXfont RobotoMono_MediumItalic34pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic34pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOMONO_MEDIUMITALIC34PT7B_H_
