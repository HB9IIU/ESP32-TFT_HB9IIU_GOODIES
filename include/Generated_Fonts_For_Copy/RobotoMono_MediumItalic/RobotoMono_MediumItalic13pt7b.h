#ifndef _ROBOTOMONO_MEDIUMITALIC13PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0xB6, 0x82, 0xC0, 0x55, 0xD0, 0x0A, 0x12, 0x7F, 0x14, 0x24,
  0xFE, 0x68, 0x48, 0x50, 0x08, 0x47, 0xD1, 0x45, 0x83, 0x83, 0x8F, 0x27,
  0x88, 0xE2, 0xBA, 0x94, 0x20, 0xF5, 0x65, 0x1C, 0x3C, 0x48, 0xB1, 0xC3,
  0x0B, 0x73, 0xE6, 0x7E, 0x5E, 0x12, 0x64, 0x4C, 0x88, 0x88, 0xC4, 0x20,
  0x21, 0x11, 0x11, 0x11, 0x32, 0x64, 0x80, 0x12, 0x5F, 0xCC, 0x7B, 0x20,
  0x10, 0xC3, 0x3F, 0x20, 0x82, 0x00, 0x6B, 0x00, 0x7F, 0xE0, 0xF0, 0x0C,
  0x21, 0x84, 0x30, 0x86, 0x10, 0xC2, 0x00, 0x79, 0x3C, 0x77, 0xBF, 0x38,
  0xB6, 0x70, 0x3F, 0xA2, 0x26, 0x66, 0x40, 0x3C, 0xCD, 0x18, 0x20, 0xC3,
  0x08, 0x20, 0xFC, 0x3C, 0xCC, 0x18, 0x21, 0xC0, 0x81, 0x66, 0x78, 0x06,
  0x18, 0x51, 0xA6, 0xC9, 0xBF, 0x84, 0x08, 0x7D, 0x04, 0x1E, 0xC8, 0x38,
  0xE6, 0x70, 0x39, 0x84, 0x3E, 0xCA, 0x38, 0xB6, 0x70, 0xFE, 0x08, 0x20,
  0xC1, 0x06, 0x18, 0x20, 0xC0, 0x7D, 0x34, 0x5A, 0x7B, 0x28, 0xE6, 0xF0,
  0x7B, 0x3C, 0xF3, 0xCD, 0xE1, 0x8C, 0xE0, 0x27, 0x00, 0x04, 0xE0, 0x23,
  0x00, 0x00, 0x44, 0x80, 0x04, 0xFE, 0x38, 0x38, 0x20, 0xFC, 0x00, 0x3F,
  0xC3, 0xC1, 0xCE, 0xE2, 0x00, 0xFC, 0x42, 0x33, 0x30, 0x08, 0xC0, 0x1E,
  0x22, 0x5D, 0x55, 0xAA, 0xAA, 0xBC, 0x40, 0x78, 0x0C, 0x38, 0x51, 0xA2,
  0x4C, 0x9F, 0x63, 0x86, 0x3E, 0x45, 0x8B, 0x37, 0xC8, 0xD1, 0xE3, 0xF8,
  0x7D, 0x1C, 0x60, 0x82, 0x08, 0xE2, 0x70, 0x3C, 0xCD, 0x8B, 0x14, 0x28,
  0xD1, 0xE6, 0xF8, 0x3F, 0x20, 0x60, 0x60, 0x7C, 0x40, 0x40, 0x40, 0xFC,
  0x3F, 0x20, 0x60, 0x62, 0x7C, 0x40, 0x40, 0x40, 0xC0, 0x7D, 0x1C, 0x60,
  0x9E, 0x78, 0xF3, 0x78, 0x23, 0x62, 0x62, 0x62, 0x7E, 0x46, 0x44, 0xC4,
  0xC4, 0x3E, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x08, 0xFC, 0x03, 0x02, 0x02,
  0x06, 0x06, 0x06, 0xC4, 0x4C, 0x78, 0x23, 0x26, 0x6C, 0x78, 0x78, 0x68,
  0x4C, 0xC4, 0xC6, 0x20, 0x82, 0x18, 0x61, 0x04, 0x10, 0xFC, 0x33, 0x76,
  0x76, 0x5A, 0x5A, 0x56, 0x46, 0xC4, 0xC4, 0x23, 0x72, 0x72, 0x76, 0x5E,
  0x4E, 0x4C, 0xCC, 0xCC, 0x7D, 0x3C, 0x61, 0x86, 0x38, 0xE6, 0x70, 0x3E,
  0x22, 0x63, 0x62, 0x7E, 0x40, 0x40, 0x40, 0xC0, 0x7D, 0x1C, 0x61, 0x86,
  0x18, 0xE6, 0x70, 0x30, 0x80, 0x3E, 0x45, 0x8B, 0x17, 0xC9, 0x13, 0x22,
  0xC6, 0x3E, 0x22, 0x61, 0x30, 0x1C, 0x06, 0xC6, 0x46, 0x3C, 0xFE, 0x20,
  0x41, 0x83, 0x04, 0x08, 0x10, 0x60, 0x47, 0x8B, 0x16, 0x28, 0xD1, 0xA3,
  0x4C, 0x70, 0xC7, 0x89, 0x32, 0x45, 0x8B, 0x14, 0x38, 0x60, 0xD3, 0x2E,
  0xD5, 0xAB, 0x5B, 0xB6, 0x6C, 0x98, 0x63, 0x36, 0x34, 0x1C, 0x18, 0x38,
  0x6C, 0x64, 0xC6, 0xC6, 0x89, 0xB3, 0xC3, 0x06, 0x08, 0x10, 0x60, 0x7F,
  0x06, 0x0C, 0x08, 0x18, 0x30, 0x60, 0x42, 0xFC, 0x37, 0x66, 0x44, 0x4C,
  0xCC, 0x88, 0xC0, 0xC4, 0x44, 0x66, 0x22, 0x23, 0x37, 0x33, 0x32, 0x22,
  0x66, 0x64, 0xC0, 0x11, 0x4A, 0x9C, 0x80, 0xFC, 0xE0, 0x3C, 0xCC, 0x1B,
  0xE4, 0x59, 0x9D, 0x00, 0x20, 0x40, 0x83, 0xE6, 0x6C, 0xD1, 0xA3, 0x4D,
  0xF0, 0x7B, 0x38, 0xE0, 0x82, 0x27, 0x00, 0x06, 0x08, 0x13, 0xAC, 0xD1,
  0xA3, 0x44, 0x99, 0xD0, 0x3B, 0x38, 0xFF, 0x83, 0x27, 0x80, 0x0E, 0x20,
  0xC7, 0xE2, 0x04, 0x08, 0x30, 0x60, 0xC0, 0x3A, 0xCD, 0x1A, 0x34, 0x4D,
  0x9F, 0x06, 0xF8, 0x60, 0x20, 0x40, 0x83, 0xE6, 0x6C, 0xD1, 0xA2, 0x45,
  0x88, 0x00, 0xC0, 0xE1, 0x18, 0xC6, 0x27, 0xC0, 0x00, 0x30, 0x0F, 0x0C,
  0x20, 0x82, 0x18, 0x61, 0xAC, 0xE0, 0x20, 0x40, 0x83, 0x36, 0xCF, 0x1E,
  0x3C, 0x4D, 0x9C, 0x7B, 0xC4, 0x21, 0x18, 0xC6, 0x27, 0xC0, 0x7E, 0xB5,
  0x6E, 0x9D, 0x72, 0xED, 0x00, 0x7C, 0xCD, 0x9A, 0x34, 0x48, 0xB1, 0x00,
  0x7B, 0x38, 0xE3, 0x8E, 0x67, 0x00, 0x7C, 0xCD, 0x9A, 0x34, 0x69, 0xBE,
  0x60, 0xC1, 0x00, 0x77, 0x38, 0xE3, 0x8A, 0x6E, 0x86, 0x18, 0x40, 0x7D,
  0xF6, 0x10, 0x43, 0x0C, 0x00, 0x7B, 0x3C, 0x1E, 0x0A, 0x2F, 0x80, 0x30,
  0xCF, 0xC8, 0x21, 0x86, 0x18, 0x38, 0xC7, 0x3C, 0xE3, 0x8A, 0x6E, 0x80,
  0xC7, 0x99, 0x22, 0xC5, 0x0E, 0x18, 0x00, 0x97, 0x6A, 0xD6, 0xED, 0x9B,
  0x26, 0x00, 0x63, 0x24, 0x3C, 0x18, 0x38, 0x6C, 0xC6, 0x63, 0x66, 0x26,
  0x2C, 0x28, 0x38, 0x10, 0x30, 0xE0, 0xC0, 0x7E, 0x0C, 0x30, 0xC3, 0x0C,
  0x3F, 0x00, 0x19, 0x8C, 0x42, 0x73, 0x0C, 0x62, 0x10, 0x40, 0x24, 0x94,
  0x92, 0x4A, 0x40, 0x20, 0x84, 0x21, 0x0C, 0x64, 0x21, 0x19, 0x80, 0x73,
  0x3C, 0x10,
};

const GFXglyph RobotoMono_MediumItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 9, 8, 2, -9 },
  { 5, 4, 3, 8, 2, -10 },
  { 7, 8, 9, 8, 0, -9 },
  { 16, 6, 12, 8, 1, -11 },
  { 25, 6, 9, 8, 1, -9 },
  { 32, 7, 9, 8, 0, -9 },
  { 40, 2, 4, 8, 3, -10 },
  { 41, 4, 13, 8, 2, -10 },
  { 48, 4, 13, 8, 1, -10 },
  { 55, 6, 6, 8, 1, -9 },
  { 60, 6, 7, 8, 1, -8 },
  { 66, 3, 3, 8, 1, -1 },
  { 68, 6, 2, 8, 1, -5 },
  { 70, 2, 2, 8, 2, -2 },
  { 71, 6, 10, 8, 1, -9 },
  { 79, 6, 9, 8, 1, -9 },
  { 86, 4, 9, 8, 2, -9 },
  { 91, 7, 9, 8, 0, -9 },
  { 99, 7, 9, 8, 0, -9 },
  { 107, 7, 9, 8, 0, -9 },
  { 115, 6, 9, 8, 1, -9 },
  { 122, 6, 9, 8, 1, -9 },
  { 129, 7, 9, 8, 1, -9 },
  { 137, 6, 9, 8, 1, -9 },
  { 144, 6, 9, 8, 1, -9 },
  { 151, 4, 7, 8, 2, -7 },
  { 155, 4, 9, 8, 2, -7 },
  { 160, 6, 6, 8, 1, -7 },
  { 165, 6, 4, 8, 1, -6 },
  { 168, 6, 6, 8, 1, -7 },
  { 173, 5, 9, 8, 2, -9 },
  { 179, 8, 9, 8, 0, -9 },
  { 188, 7, 9, 8, 0, -9 },
  { 196, 7, 9, 8, 0, -9 },
  { 204, 6, 9, 8, 1, -9 },
  { 211, 7, 9, 8, 0, -9 },
  { 219, 8, 9, 8, 0, -9 },
  { 228, 8, 9, 8, 0, -9 },
  { 237, 6, 9, 8, 1, -9 },
  { 244, 8, 9, 8, 0, -9 },
  { 253, 7, 9, 8, 0, -9 },
  { 261, 8, 9, 8, 0, -9 },
  { 270, 8, 9, 8, 0, -9 },
  { 279, 6, 9, 8, 0, -9 },
  { 286, 8, 9, 8, 0, -9 },
  { 295, 8, 9, 8, 0, -9 },
  { 304, 6, 9, 8, 1, -9 },
  { 311, 8, 9, 8, 0, -9 },
  { 320, 6, 11, 8, 1, -9 },
  { 329, 7, 9, 8, 0, -9 },
  { 337, 8, 9, 8, 0, -9 },
  { 346, 7, 9, 8, 1, -9 },
  { 354, 7, 9, 8, 1, -9 },
  { 362, 7, 9, 8, 1, -9 },
  { 370, 7, 9, 8, 1, -9 },
  { 378, 8, 9, 8, 0, -9 },
  { 387, 7, 9, 8, 1, -9 },
  { 395, 8, 9, 8, 0, -9 },
  { 404, 4, 13, 8, 2, -11 },
  { 411, 4, 10, 8, 2, -9 },
  { 416, 4, 13, 8, 2, -11 },
  { 423, 5, 5, 8, 1, -9 },
  { 427, 6, 1, 8, 0, 0 },
  { 428, 3, 1, 8, 3, -9 },
  { 429, 7, 7, 8, 0, -7 },
  { 436, 7, 10, 8, 0, -10 },
  { 445, 6, 7, 8, 1, -7 },
  { 451, 7, 10, 8, 1, -10 },
  { 460, 6, 7, 8, 1, -7 },
  { 466, 7, 10, 8, 1, -10 },
  { 475, 7, 10, 8, 0, -7 },
  { 484, 7, 10, 8, 0, -10 },
  { 493, 5, 10, 8, 1, -10 },
  { 500, 6, 13, 8, 0, -10 },
  { 510, 7, 10, 8, 0, -10 },
  { 519, 5, 10, 8, 1, -10 },
  { 526, 7, 7, 8, 0, -7 },
  { 533, 7, 7, 8, 0, -7 },
  { 540, 6, 7, 8, 1, -7 },
  { 546, 7, 10, 8, 0, -7 },
  { 555, 6, 10, 8, 1, -7 },
  { 563, 6, 7, 8, 1, -7 },
  { 569, 6, 7, 8, 1, -7 },
  { 575, 6, 9, 8, 1, -9 },
  { 582, 6, 7, 8, 1, -7 },
  { 588, 7, 7, 8, 1, -7 },
  { 595, 7, 7, 8, 1, -7 },
  { 602, 8, 7, 8, 0, -7 },
  { 609, 8, 10, 8, 0, -7 },
  { 619, 7, 7, 8, 0, -7 },
  { 626, 5, 12, 8, 2, -10 },
  { 634, 3, 12, 8, 2, -9 },
  { 639, 5, 12, 8, 1, -10 },
  { 647, 7, 3, 8, 0, -5 },
};

const GFXfont RobotoMono_MediumItalic13pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic13pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _ROBOTOMONO_MEDIUMITALIC13PT7B_H_
