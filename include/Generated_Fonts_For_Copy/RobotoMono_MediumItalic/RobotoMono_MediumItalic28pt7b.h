#ifndef _ROBOTOMONO_MEDIUMITALIC28PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC7,
  0x00, 0x00, 0x00, 0x41, 0xE3, 0xC7, 0x00, 0x73, 0xB1, 0x98, 0xCC, 0x6E,
  0x36, 0x3B, 0x18, 0x00, 0xE7, 0x00, 0x63, 0x00, 0x71, 0x80, 0x31, 0xC0,
  0x18, 0xC0, 0x1C, 0x64, 0x7F, 0xFC, 0x7F, 0xFE, 0x07, 0x18, 0x03, 0x18,
  0x01, 0x8C, 0x01, 0xCE, 0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x63, 0x80, 0x31,
  0x80, 0x18, 0xC0, 0x18, 0xE0, 0x0C, 0x60, 0x0E, 0x70, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x1F, 0x80, 0x7F, 0x81, 0xFF, 0x87, 0x87, 0x0E,
  0x0F, 0x1C, 0x1E, 0x38, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x39, 0xE0, 0x71, 0xC0, 0xE3, 0x83, 0xC7,
  0xDF, 0x87, 0xFE, 0x07, 0xF0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x3C,
  0x03, 0xF0, 0x39, 0x89, 0x8C, 0x6C, 0x67, 0x63, 0x33, 0xBB, 0x0F, 0xB0,
  0x33, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xDF, 0x0D, 0xFC, 0xEC, 0x66,
  0x63, 0x63, 0x18, 0x19, 0xC0, 0xFC, 0x03, 0xC0, 0x03, 0xE0, 0x1F, 0xE0,
  0x3D, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x3C, 0x0E, 0xF0, 0x0F,
  0x80, 0x1E, 0x00, 0xFC, 0x03, 0xFC, 0x77, 0x39, 0xDC, 0x7B, 0xB8, 0x7F,
  0x70, 0x7C, 0xE0, 0xF1, 0xE7, 0xE1, 0xFF, 0xE1, 0xF9, 0xE0, 0x77, 0x66,
  0x6E, 0xE0, 0x00, 0x80, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0xE0,
  0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0,
  0x20, 0x04, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x1E, 0x0F, 0x03, 0x00,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x63, 0x89, 0xED, 0xFF, 0xFF,
  0xC1, 0xF0, 0x07, 0x80, 0x36, 0x01, 0xDC, 0x0E, 0x38, 0x70, 0xE0, 0x41,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x81, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0x39, 0xCE, 0xF7, 0x3B, 0x98, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x77, 0xFD, 0xE0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0xFF,
  0x87, 0xBC, 0x70, 0x77, 0x83, 0xB8, 0x1D, 0xC0, 0xEE, 0x1F, 0xF1, 0xFF,
  0x1D, 0xFB, 0xDF, 0xF8, 0xFF, 0x87, 0x70, 0x3B, 0x81, 0xDC, 0x1E, 0xE0,
  0xE7, 0xDE, 0x1F, 0xF0, 0x7E, 0x00, 0x00, 0xC1, 0xE1, 0xF9, 0xFE, 0x7B,
  0xB0, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x03, 0xF0, 0x1F, 0xF0, 0x7F,
  0xF0, 0xE0, 0xE3, 0xC1, 0xE7, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xC0, 0x07, 0xE0, 0x3F,
  0xE1, 0xF7, 0x8F, 0x0F, 0x38, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x01,
  0xF0, 0x1F, 0x80, 0x7E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xB8,
  0x1C, 0xE0, 0xF3, 0xE7, 0x87, 0xFE, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x78,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xEE, 0x03, 0x9C, 0x0F,
  0x38, 0x1C, 0x70, 0x70, 0xE1, 0xC3, 0xC7, 0x07, 0x0F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFE, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xFE,
  0x1F, 0xFC, 0x3F, 0xF8, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0D,
  0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x61, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x78, 0x3C, 0x70, 0x70, 0xFB, 0xE0, 0xFF, 0x80, 0xFE, 0x00,
  0x00, 0xF0, 0x1F, 0x81, 0xFC, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x07,
  0x7C, 0x7F, 0xF3, 0xF7, 0xDE, 0x1E, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xEE, 0x0F, 0x70, 0x73, 0xEF, 0x8F, 0xF8, 0x3F, 0x00, 0x7F, 0xFD, 0xFF,
  0xF7, 0xFF, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x3F, 0xE1,
  0xF7, 0xC7, 0x07, 0x1C, 0x1C, 0xF0, 0x73, 0xC1, 0xC7, 0x0E, 0x1F, 0xF8,
  0x3F, 0x81, 0xFF, 0x0F, 0x1C, 0x70, 0x39, 0xC0, 0xEF, 0x03, 0xBC, 0x0E,
  0xF0, 0x79, 0xE7, 0xC3, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC,
  0xF0, 0xE7, 0x07, 0xB8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xDE,
  0x3C, 0xFF, 0xE3, 0xF7, 0x00, 0x70, 0x03, 0x80, 0x38, 0x07, 0xC3, 0xFC,
  0x1F, 0x80, 0xF0, 0x00, 0x1C, 0x7C, 0xF8, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x1F, 0x3E, 0x38, 0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x38, 0x38, 0x38, 0x38, 0x70,
  0x70, 0xE0, 0x40, 0x00, 0x18, 0x03, 0xC0, 0xFE, 0x1F, 0xE3, 0xF8, 0x7E,
  0x03, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xF8, 0x01, 0xC0, 0x02,
  0x00, 0x3F, 0xFC, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x9F, 0xFE, 0xFF, 0xF8, 0x20, 0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0x7C, 0x01, 0xE0, 0x7F, 0x1F, 0xE3, 0xFC, 0x1F, 0x01, 0xE0,
  0x08, 0x00, 0x00, 0x1F, 0x87, 0xFC, 0xFF, 0xEF, 0x0E, 0xE0, 0xF0, 0x0E,
  0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x10, 0x07, 0x80, 0x78, 0x07, 0x00, 0x01, 0xE0, 0x0F,
  0xF0, 0x38, 0x70, 0xE0, 0x63, 0x8C, 0x66, 0x7E, 0xD9, 0xCD, 0xB3, 0x33,
  0xCC, 0x67, 0x98, 0xCF, 0x31, 0x9E, 0x66, 0x2C, 0xCC, 0xD9, 0xB9, 0xB3,
  0xFE, 0x63, 0x38, 0xE0, 0x00, 0xE1, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xDC, 0x01,
  0xDC, 0x03, 0x9C, 0x03, 0x9C, 0x07, 0x1C, 0x07, 0x1C, 0x0F, 0x1C, 0x0E,
  0x1C, 0x1F, 0xFE, 0x1F, 0xFE, 0x3C, 0x0E, 0x38, 0x0E, 0x78, 0x0E, 0x70,
  0x0E, 0xF0, 0x0F, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF1, 0xE0, 0xF3, 0x80,
  0xE7, 0x01, 0xCE, 0x07, 0x9C, 0x0E, 0x38, 0xF8, 0xFF, 0xE1, 0xFF, 0xE3,
  0x81, 0xC7, 0x01, 0xCE, 0x03, 0xBC, 0x07, 0x78, 0x1E, 0xE0, 0x79, 0xFF,
  0xF3, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xE0,
  0xE3, 0x80, 0xE7, 0x01, 0xDC, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0xB8, 0x0E, 0x78, 0x1C, 0x70,
  0x78, 0xFB, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x1F,
  0xFC, 0x1E, 0x1E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0F, 0x1C, 0x0F, 0x3C,
  0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x78,
  0x1C, 0x70, 0x3C, 0x70, 0x78, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0x1F,
  0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xF8, 0xFF,
  0xF8, 0xFF, 0xF0, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3F, 0xF8, 0x7F,
  0xF8, 0x7F, 0xF8, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F,
  0xF0, 0xE0, 0xF3, 0x80, 0xE7, 0x01, 0xDC, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC7, 0xF7, 0x8F, 0xEE, 0x1F, 0xDC, 0x07, 0xBC, 0x0F, 0x38,
  0x1C, 0x70, 0x38, 0xF9, 0xF0, 0xFF, 0xC0, 0xFE, 0x00, 0x0E, 0x07, 0x87,
  0x03, 0x87, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x78, 0x70, 0x38,
  0x78, 0x1C, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0x03, 0xC3, 0x81,
  0xC3, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x1C, 0x1C,
  0x0E, 0x1E, 0x07, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x01,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x38, 0x0E, 0x70, 0x3C,
  0xF0, 0xF0, 0xF3, 0xC1, 0xFF, 0x80, 0xFC, 0x00, 0x1C, 0x07, 0x8E, 0x07,
  0x87, 0x07, 0x87, 0x87, 0x83, 0x87, 0x81, 0xC7, 0x80, 0xE7, 0x80, 0x77,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0x9C, 0x03,
  0x8F, 0x03, 0xC3, 0x81, 0xE1, 0xE0, 0xE0, 0x70, 0x70, 0x3C, 0x38, 0x1E,
  0x1C, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0x07, 0x87, 0x87, 0xC7, 0xC3, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF9,
  0xF8, 0x7C, 0xDC, 0x37, 0xEE, 0x3B, 0xEE, 0x1D, 0xF7, 0x0E, 0x73, 0x87,
  0x39, 0xC3, 0x98, 0xE3, 0xCC, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x1C,
  0x38, 0x0E, 0x1C, 0x07, 0x1C, 0x07, 0x00, 0x0E, 0x07, 0x0E, 0x07, 0x1F,
  0x07, 0x1F, 0x07, 0x1F, 0x0F, 0x1F, 0x0F, 0x1F, 0x8E, 0x3F, 0x8E, 0x3D,
  0x8E, 0x39, 0xCE, 0x39, 0xDE, 0x39, 0xDE, 0x38, 0xDC, 0x78, 0xFC, 0x78,
  0xFC, 0x70, 0x7C, 0x70, 0x7C, 0x70, 0x78, 0x70, 0x78, 0xF0, 0x38, 0x03,
  0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0xDC, 0x07,
  0xB8, 0x0F, 0x70, 0x1E, 0xE0, 0x3B, 0xC0, 0x77, 0x80, 0xEE, 0x01, 0xDC,
  0x07, 0xB8, 0x0E, 0x78, 0x1C, 0x70, 0x70, 0xFB, 0xE0, 0xFF, 0x80, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0xE0, 0xF3, 0xC0, 0xE7, 0x81,
  0xCE, 0x03, 0x9C, 0x07, 0x38, 0x1E, 0x70, 0xF9, 0xFF, 0xE3, 0xFF, 0x87,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xE0, 0xE3, 0x81,
  0xC7, 0x03, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x3F, 0xC0, 0x77,
  0x00, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x0E, 0x78, 0x1C, 0x70, 0x70, 0xFB,
  0xE0, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x1F,
  0xE0, 0x3F, 0xF0, 0x7F, 0xF1, 0xE0, 0xF3, 0x80, 0xE7, 0x01, 0xCE, 0x03,
  0x9C, 0x0F, 0x38, 0x1C, 0xF1, 0xF9, 0xFF, 0xC3, 0xFF, 0x07, 0x0E, 0x0E,
  0x1C, 0x1C, 0x3C, 0x78, 0x78, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xE7, 0x01,
  0xC0, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xE0, 0xF3, 0x80, 0xE7, 0x01,
  0xCE, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0,
  0x03, 0x80, 0x07, 0xB8, 0x07, 0x70, 0x1E, 0xF0, 0x38, 0xF9, 0xF0, 0xFF,
  0xC0, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x0F, 0x1C, 0x0E, 0x3C,
  0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x78,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0x38, 0xF0, 0x38, 0xF0,
  0x38, 0x70, 0x78, 0x70, 0x70, 0x7D, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0xF0,
  0x0F, 0x70, 0x1E, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0x3C, 0x78, 0x38, 0x78,
  0x78, 0x38, 0x70, 0x38, 0xF0, 0x38, 0xE0, 0x39, 0xE0, 0x39, 0xC0, 0x39,
  0xC0, 0x3B, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0xE1, 0x87, 0xE3, 0x8E, 0xE3, 0x8E, 0xE3, 0x8E, 0xE7,
  0x8C, 0xE7, 0x9C, 0xE7, 0x9C, 0xEF, 0x9C, 0xEF, 0xB8, 0xED, 0xB8, 0xED,
  0xB8, 0xFD, 0xB8, 0xF9, 0xF0, 0xF9, 0xF0, 0xF9, 0xF0, 0xF1, 0xE0, 0xF1,
  0xE0, 0xF1, 0xE0, 0xE1, 0xE0, 0xE1, 0xC0, 0x0F, 0x03, 0xE1, 0xE0, 0x78,
  0x1C, 0x1E, 0x03, 0xC3, 0x80, 0x38, 0xF0, 0x07, 0x3C, 0x00, 0xF7, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x0F, 0x70, 0x03, 0xCE, 0x00, 0x71, 0xE0, 0x1E, 0x1C, 0x07,
  0x83, 0xC1, 0xE0, 0x78, 0x7C, 0x07, 0x80, 0xE0, 0x1F, 0xC0, 0x7B, 0xC0,
  0xE3, 0x83, 0xC7, 0x07, 0x0E, 0x1C, 0x0E, 0x78, 0x1C, 0xE0, 0x3B, 0x80,
  0x77, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0x07, 0xC1, 0xF0, 0xFC, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0x72, 0x1F, 0x0F, 0xC0, 0xE1,
  0xC1, 0x83, 0x87, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0xE1, 0xC3, 0x83, 0x07,
  0x0E, 0x1C, 0x38, 0x70, 0x70, 0xE1, 0xC0, 0x07, 0xC3, 0xF0, 0xFC, 0x07,
  0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x1C, 0x1F, 0x0F, 0xC0, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xD8,
  0x3B, 0x8E, 0x71, 0xC6, 0x70, 0xCE, 0x1F, 0x83, 0x80, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFC, 0xF0, 0xE3, 0x87, 0x07, 0xE0, 0xFF, 0x8F, 0xBE, 0x70, 0x70,
  0x03, 0x80, 0x1C, 0x3F, 0xE7, 0xFF, 0x78, 0x7F, 0x83, 0xB8, 0x1D, 0xC1,
  0xEF, 0x1F, 0x3F, 0xF8, 0xFD, 0xC0, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x9E, 0x0F, 0xFC, 0x3F, 0xF8, 0xF0, 0xE7,
  0x83, 0xDE, 0x0F, 0x70, 0x3D, 0xC0, 0xF7, 0x03, 0x9C, 0x0E, 0xF0, 0x7B,
  0xC1, 0xCF, 0xDF, 0x3F, 0xF8, 0xEF, 0xC0, 0x07, 0xE0, 0x3F, 0xC1, 0xFF,
  0x8F, 0x0E, 0x78, 0x3D, 0xC0, 0x77, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x03, 0x9C, 0x1C, 0x7D, 0xF0, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x81, 0xE7, 0x0F,
  0xFE, 0x3F, 0xFC, 0x78, 0x79, 0xE0, 0xF3, 0x81, 0xC7, 0x03, 0x8E, 0x07,
  0x3C, 0x0E, 0x78, 0x1C, 0x70, 0x78, 0xE0, 0xE1, 0xF7, 0xC1, 0xFF, 0x81,
  0xF7, 0x00, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x0E, 0x78, 0x1D, 0xC0,
  0x77, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xC0, 0x07, 0x00, 0x1C, 0x0C, 0x7C,
  0xF8, 0xFF, 0xC1, 0xFC, 0x00, 0x00, 0x70, 0x07, 0xF0, 0x3F, 0xC1, 0xE0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC1, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x03, 0xEE, 0x1F, 0xFC,
  0x7F, 0xF8, 0xF0, 0xF3, 0xC0, 0xE7, 0x03, 0xCE, 0x07, 0x1C, 0x0E, 0x78,
  0x1C, 0xF0, 0x38, 0xE0, 0xF1, 0xC1, 0xE3, 0xEF, 0x83, 0xFF, 0x03, 0xEE,
  0x00, 0x1C, 0x20, 0x70, 0xC1, 0xE3, 0xFF, 0x81, 0xFE, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x9F,
  0x0E, 0xFE, 0x3F, 0xF8, 0xF0, 0xF7, 0x83, 0xDC, 0x0F, 0x70, 0x3D, 0xC0,
  0xE7, 0x03, 0x9C, 0x0E, 0xF0, 0x3B, 0x81, 0xEE, 0x07, 0x38, 0x1C, 0xE0,
  0x70, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x7F,
  0x07, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x83, 0xFF, 0xDF, 0xFD, 0xFF, 0xE0, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0xE0,
  0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x0F, 0xF0, 0xFE, 0x0F,
  0x80, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x07, 0x9C, 0x3E, 0x38, 0xF8, 0x73, 0xC1, 0xEF, 0x03, 0xFC, 0x07,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3D, 0xE0, 0xF1, 0xC1, 0xC3, 0xC3, 0x83,
  0xC7, 0x07, 0x8E, 0x07, 0x80, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3B, 0x9C, 0x3F, 0xFE, 0x3F, 0xFE, 0x39, 0xC7,
  0x71, 0xC6, 0x71, 0xCE, 0x71, 0xCE, 0x71, 0x8E, 0x73, 0x8E, 0x73, 0x8E,
  0xE3, 0x8C, 0xE3, 0x9C, 0xE3, 0x9C, 0xE3, 0x1C, 0xE7, 0x1C, 0x39, 0xF0,
  0xEF, 0xE3, 0xFF, 0x8F, 0x0F, 0x78, 0x3D, 0xC0, 0xF7, 0x03, 0x9C, 0x0E,
  0x70, 0x39, 0xC0, 0xEF, 0x03, 0xB8, 0x1E, 0xE0, 0x73, 0x81, 0xCE, 0x07,
  0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8E, 0x0E, 0x78, 0x3D, 0xC0, 0xF7,
  0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xEF, 0x03, 0x9C, 0x1C, 0x7D, 0xF0,
  0xFF, 0x81, 0xF8, 0x00, 0x1D, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0xE0, 0xE3,
  0xC1, 0xC7, 0x83, 0xCE, 0x07, 0x9C, 0x0E, 0x38, 0x1C, 0x70, 0x39, 0xE0,
  0xF3, 0xC1, 0xC7, 0xCF, 0x8F, 0xFE, 0x1D, 0xF8, 0x38, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xDC, 0x7F, 0xF3,
  0xFF, 0xCF, 0x0F, 0x78, 0x3D, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0xF0, 0x3B,
  0xC0, 0xE7, 0x07, 0x9C, 0x1C, 0x7D, 0xF0, 0xFF, 0xC1, 0xF7, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x39, 0xF9, 0xDF,
  0x8F, 0xFC, 0x7C, 0x27, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0xE0,
  0x7F, 0xE3, 0xE7, 0x8E, 0x0F, 0x38, 0x1C, 0xE0, 0x03, 0xF0, 0x07, 0xF8,
  0x03, 0xF0, 0x01, 0xEE, 0x03, 0xBC, 0x0E, 0x78, 0xF0, 0xFF, 0xC1, 0xFC,
  0x00, 0x07, 0x00, 0x38, 0x03, 0xC0, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0xEC, 0x1F, 0xE0, 0x7F, 0x00, 0x70, 0x3B, 0x81, 0xDC, 0x0E,
  0xE0, 0x77, 0x03, 0xF8, 0x3F, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0xB8,
  0x3D, 0xC1, 0xEF, 0xBE, 0x3F, 0xF1, 0xFB, 0x80, 0xE0, 0x1F, 0xC0, 0xF7,
  0x03, 0x9C, 0x1E, 0x70, 0x71, 0xC3, 0x83, 0x0E, 0x0E, 0x70, 0x39, 0xC0,
  0xEE, 0x03, 0xB8, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xC3,
  0x0F, 0x86, 0x1B, 0x1C, 0x76, 0x38, 0xEC, 0x71, 0x99, 0xE7, 0x33, 0xCE,
  0x6E, 0xD8, 0xD9, 0xF1, 0xB3, 0xE3, 0xC7, 0x87, 0x8F, 0x0F, 0x1C, 0x1C,
  0x38, 0x38, 0x70, 0x00, 0x1C, 0x0F, 0x1E, 0x0E, 0x0E, 0x1C, 0x0F, 0x3C,
  0x07, 0x78, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x0E, 0xF0, 0x1E, 0x70, 0x3C, 0x78, 0x78, 0x38, 0xF0, 0x1C, 0x38, 0x07,
  0x9E, 0x03, 0x87, 0x03, 0xC3, 0x81, 0xC1, 0xC1, 0xE0, 0xF0, 0xE0, 0x38,
  0xE0, 0x1C, 0xF0, 0x0E, 0x70, 0x07, 0x78, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0x00,
  0x00, 0x60, 0x3C, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xC0, 0x38, 0x0E, 0x0F, 0xC1, 0xE0, 0x3E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x18, 0x00, 0x0C, 0x30, 0xC7, 0x18, 0x61, 0x86, 0x18, 0xE3, 0x0C, 0x30,
  0xC3, 0x0C, 0x71, 0x86, 0x18, 0x61, 0x8E, 0x30, 0xC3, 0x00, 0x08, 0x07,
  0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x03, 0xC0, 0x70, 0x7C, 0x3C, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x0C, 0x00, 0x3E, 0x01, 0x7F, 0x06,
  0x7F, 0xCE, 0xE1, 0xFE, 0xC0, 0xFC, 0x00, 0x38,
};

const GFXglyph RobotoMono_MediumItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 7, 20, 16, 5, -20 },
  { 19, 9, 7, 16, 5, -21 },
  { 27, 17, 20, 16, 0, -20 },
  { 70, 15, 26, 16, 1, -23 },
  { 119, 13, 20, 16, 2, -20 },
  { 152, 15, 20, 16, 1, -20 },
  { 190, 4, 7, 16, 7, -21 },
  { 194, 10, 28, 16, 4, -22 },
  { 229, 10, 28, 16, 2, -22 },
  { 264, 14, 14, 16, 2, -20 },
  { 289, 14, 14, 16, 1, -16 },
  { 314, 5, 8, 16, 3, -3 },
  { 319, 11, 3, 16, 3, -10 },
  { 324, 5, 4, 16, 5, -4 },
  { 327, 15, 22, 16, 1, -20 },
  { 369, 13, 20, 16, 2, -20 },
  { 402, 10, 20, 16, 3, -20 },
  { 427, 15, 20, 16, 0, -20 },
  { 465, 14, 20, 16, 1, -20 },
  { 500, 15, 20, 16, 0, -20 },
  { 538, 15, 20, 16, 1, -20 },
  { 576, 13, 20, 16, 1, -20 },
  { 609, 14, 20, 16, 2, -20 },
  { 644, 14, 20, 16, 1, -20 },
  { 679, 13, 20, 16, 2, -20 },
  { 712, 7, 16, 16, 5, -16 },
  { 726, 8, 21, 16, 4, -16 },
  { 747, 13, 13, 16, 2, -15 },
  { 769, 14, 9, 16, 1, -13 },
  { 785, 13, 13, 16, 1, -15 },
  { 807, 12, 20, 16, 4, -20 },
  { 837, 15, 20, 16, 1, -20 },
  { 875, 16, 20, 16, -1, -20 },
  { 915, 15, 20, 16, 1, -20 },
  { 953, 15, 20, 16, 1, -20 },
  { 991, 16, 20, 16, 0, -20 },
  { 1031, 16, 20, 16, 1, -20 },
  { 1071, 16, 20, 16, 1, -20 },
  { 1111, 15, 20, 16, 1, -20 },
  { 1149, 17, 20, 16, 0, -20 },
  { 1192, 15, 20, 16, 1, -20 },
  { 1230, 15, 20, 16, 1, -20 },
  { 1268, 17, 20, 16, 1, -20 },
  { 1311, 13, 20, 16, 1, -20 },
  { 1344, 17, 20, 16, 0, -20 },
  { 1387, 16, 20, 16, 0, -20 },
  { 1427, 15, 20, 16, 1, -20 },
  { 1465, 15, 20, 16, 1, -20 },
  { 1503, 15, 23, 16, 1, -20 },
  { 1547, 15, 20, 16, 1, -20 },
  { 1585, 15, 20, 16, 1, -20 },
  { 1623, 16, 20, 16, 2, -20 },
  { 1663, 16, 20, 16, 1, -20 },
  { 1703, 16, 20, 16, 2, -20 },
  { 1743, 16, 20, 16, 2, -20 },
  { 1783, 19, 20, 16, -1, -20 },
  { 1831, 15, 20, 16, 3, -20 },
  { 1869, 16, 20, 16, 0, -20 },
  { 1909, 10, 27, 16, 3, -23 },
  { 1943, 7, 22, 16, 5, -20 },
  { 1963, 10, 27, 16, 3, -23 },
  { 1997, 11, 11, 16, 3, -20 },
  { 2013, 13, 3, 16, 0, 0 },
  { 2018, 6, 4, 16, 7, -20 },
  { 2021, 13, 15, 16, 1, -15 },
  { 2046, 14, 21, 16, 1, -21 },
  { 2083, 14, 15, 16, 1, -15 },
  { 2110, 15, 21, 16, 1, -21 },
  { 2150, 14, 15, 16, 1, -15 },
  { 2177, 14, 22, 16, 3, -22 },
  { 2216, 15, 21, 16, 0, -15 },
  { 2256, 14, 21, 16, 1, -21 },
  { 2293, 13, 20, 16, 1, -20 },
  { 2326, 12, 26, 16, 1, -20 },
  { 2365, 15, 21, 16, 1, -21 },
  { 2405, 13, 21, 16, 1, -21 },
  { 2440, 16, 15, 16, 0, -15 },
  { 2470, 14, 15, 16, 1, -15 },
  { 2497, 14, 15, 16, 1, -15 },
  { 2524, 15, 21, 16, 0, -15 },
  { 2564, 14, 21, 16, 1, -15 },
  { 2601, 13, 15, 16, 3, -15 },
  { 2626, 14, 15, 16, 1, -15 },
  { 2653, 13, 18, 16, 2, -18 },
  { 2683, 13, 15, 16, 2, -15 },
  { 2708, 14, 15, 16, 2, -15 },
  { 2735, 15, 15, 16, 2, -15 },
  { 2764, 16, 15, 16, 0, -15 },
  { 2794, 17, 21, 16, 0, -15 },
  { 2839, 15, 15, 16, 0, -15 },
  { 2868, 11, 27, 16, 4, -22 },
  { 2906, 6, 26, 16, 5, -20 },
  { 2926, 10, 27, 16, 3, -22 },
  { 2960, 16, 6, 16, 0, -11 },
};

const GFXfont RobotoMono_MediumItalic28pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic28pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _ROBOTOMONO_MEDIUMITALIC28PT7B_H_
