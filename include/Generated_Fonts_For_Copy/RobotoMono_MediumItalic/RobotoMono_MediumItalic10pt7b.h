#ifndef _ROBOTOMONO_MEDIUMITALIC10PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x57, 0x88, 0xB6, 0x80, 0x1C, 0xA7, 0xCC, 0xF9, 0x4E, 0x00, 0x10,
  0xE4, 0xD8, 0x30, 0x24, 0x9C, 0x20, 0xCD, 0xE4, 0x7B, 0x30, 0x39, 0x23,
  0x19, 0xDA, 0x67, 0x80, 0xE0, 0x2A, 0x49, 0x24, 0x98, 0x44, 0x92, 0x4A,
  0x50, 0x25, 0x5C, 0xC9, 0x00, 0x10, 0x9F, 0x42, 0x00, 0x78, 0xF0, 0xC0,
  0x0C, 0x21, 0x04, 0x20, 0x84, 0x30, 0x79, 0x9F, 0x99, 0xE0, 0x3E, 0x22,
  0x26, 0x40, 0x7A, 0x42, 0x22, 0x23, 0xE0, 0x3A, 0x42, 0x60, 0xC5, 0xC0,
  0x18, 0xCA, 0xBF, 0x88, 0x40, 0x7A, 0x39, 0x21, 0x4B, 0x80, 0x3B, 0x1C,
  0x94, 0xA5, 0xC0, 0xF8, 0x8C, 0x44, 0x22, 0x00, 0x3A, 0x52, 0x64, 0xE5,
  0xC0, 0x79, 0x99, 0x72, 0xC0, 0x50, 0xB0, 0x24, 0x00, 0x94, 0x3C, 0xC3,
  0xF0, 0xF0, 0x60, 0xCF, 0x80, 0x74, 0xC4, 0x44, 0x01, 0x00, 0x39, 0x56,
  0xED, 0xDA, 0x87, 0x00, 0x11, 0x8A, 0xD7, 0xE6, 0x20, 0x79, 0x14, 0x9E,
  0x4B, 0x2F, 0x00, 0x39, 0x14, 0x10, 0xC1, 0x27, 0x00, 0x79, 0x24, 0xD3,
  0x4B, 0x6F, 0x00, 0x7D, 0x04, 0x1E, 0x41, 0x0F, 0x80, 0x7D, 0x04, 0x1E,
  0x41, 0x0C, 0x00, 0x39, 0x14, 0x16, 0xC9, 0x27, 0x80, 0x45, 0x14, 0x9E,
  0x4A, 0x28, 0x80, 0x7C, 0x41, 0x0C, 0x20, 0x8F, 0x80, 0x04, 0x30, 0x82,
  0x0B, 0x27, 0x00, 0x6D, 0x25, 0x1C, 0x53, 0x68, 0x80, 0x62, 0x10, 0x84,
  0x23, 0xE0, 0x6D, 0xB7, 0x5E, 0x6A, 0x28, 0x80, 0x65, 0xB6, 0x96, 0x5B,
  0x69, 0x80, 0x39, 0x34, 0xD2, 0xC9, 0x27, 0x00, 0x79, 0x14, 0x5E, 0x41,
  0x0C, 0x00, 0x39, 0x34, 0x53, 0xC9, 0x27, 0x02, 0x79, 0x14, 0xDE, 0x53,
  0x68, 0x80, 0x39, 0x16, 0x0E, 0x0B, 0x27, 0x80, 0xF9, 0x08, 0xC4, 0x21,
  0x00, 0x45, 0x14, 0x92, 0x49, 0x27, 0x00, 0x8C, 0xE5, 0xE6, 0x31, 0x00,
  0xAD, 0x7B, 0xEF, 0x5A, 0x80, 0x44, 0xA3, 0x0C, 0x31, 0x6C, 0x80, 0x8E,
  0x9C, 0xC4, 0x21, 0x00, 0x7C, 0x21, 0x0C, 0x61, 0x0F, 0x80, 0x36, 0x44,
  0x44, 0x44, 0xCC, 0xA9, 0x55, 0x32, 0x22, 0x22, 0x26, 0x4C, 0x26, 0x59,
  0xF8, 0xC0, 0x78, 0x5F, 0x97, 0x80, 0x22, 0x10, 0xF4, 0xA7, 0x36, 0xF9,
  0x89, 0xE0, 0x04, 0x10, 0xDE, 0x49, 0x24, 0x9E, 0x7A, 0x5E, 0x87, 0x80,
  0x19, 0x19, 0xE4, 0x21, 0x08, 0x7D, 0x24, 0x92, 0x7A, 0x4F, 0x00, 0x22,
  0x10, 0xF4, 0xA7, 0x31, 0x10, 0x1C, 0x23, 0x13, 0xE0, 0x18, 0x0C, 0x21,
  0x08, 0xC4, 0xE0, 0x21, 0x84, 0x56, 0x71, 0xCD, 0x26, 0x38, 0x84, 0x21,
  0x18, 0x9F, 0x7F, 0xEA, 0xAA, 0xA8, 0x7A, 0x53, 0x98, 0x80, 0x7A, 0x72,
  0x97, 0x00, 0x7A, 0x53, 0x9F, 0x42, 0x00, 0x7A, 0x52, 0x97, 0x88, 0x40,
  0x7A, 0x31, 0x08, 0x00, 0x7A, 0x0F, 0x97, 0x00, 0x64, 0xF4, 0x44, 0x70,
  0x9C, 0xA5, 0x2F, 0x00, 0x9C, 0xA8, 0xC4, 0x00, 0xAF, 0xBD, 0x6A, 0x00,
  0x6C, 0xC3, 0x1C, 0xC8, 0x4D, 0x27, 0x0C, 0x21, 0x8C, 0x00, 0x7C, 0x42,
  0x10, 0xF8, 0x12, 0x22, 0x6C, 0x64, 0x42, 0x55, 0xAA, 0x80, 0x42, 0x22,
  0x32, 0x44, 0x48, 0x66, 0x60,
};

const GFXglyph RobotoMono_MediumItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 3, 3, 6, 2, -8 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 6, 9, 6, 0, -8 },
  { 18, 4, 7, 6, 1, -7 },
  { 22, 6, 7, 6, 0, -7 },
  { 28, 1, 3, 6, 3, -8 },
  { 29, 3, 10, 6, 2, -8 },
  { 33, 3, 10, 6, 1, -8 },
  { 37, 5, 5, 6, 1, -7 },
  { 41, 5, 5, 6, 0, -6 },
  { 45, 2, 3, 6, 1, -1 },
  { 46, 4, 1, 6, 1, -4 },
  { 47, 1, 2, 6, 2, -2 },
  { 48, 6, 8, 6, 0, -7 },
  { 54, 4, 7, 6, 1, -7 },
  { 58, 4, 7, 6, 1, -7 },
  { 62, 5, 7, 6, 0, -7 },
  { 67, 5, 7, 6, 0, -7 },
  { 72, 5, 7, 6, 0, -7 },
  { 77, 5, 7, 6, 1, -7 },
  { 82, 5, 7, 6, 0, -7 },
  { 87, 5, 7, 6, 1, -7 },
  { 92, 5, 7, 6, 0, -7 },
  { 97, 4, 7, 6, 1, -7 },
  { 101, 2, 6, 6, 2, -6 },
  { 103, 3, 8, 6, 1, -6 },
  { 106, 4, 4, 6, 1, -5 },
  { 108, 4, 3, 6, 1, -5 },
  { 110, 5, 4, 6, 0, -5 },
  { 113, 5, 7, 6, 1, -7 },
  { 118, 6, 7, 6, 0, -7 },
  { 124, 5, 7, 6, 0, -7 },
  { 129, 6, 7, 6, 0, -7 },
  { 135, 6, 7, 6, 0, -7 },
  { 141, 6, 7, 6, 0, -7 },
  { 147, 6, 7, 6, 0, -7 },
  { 153, 6, 7, 6, 0, -7 },
  { 159, 6, 7, 6, 0, -7 },
  { 165, 6, 7, 6, 0, -7 },
  { 171, 6, 7, 6, 0, -7 },
  { 177, 6, 7, 6, 0, -7 },
  { 183, 6, 7, 6, 0, -7 },
  { 189, 5, 7, 6, 0, -7 },
  { 194, 6, 7, 6, 0, -7 },
  { 200, 6, 7, 6, 0, -7 },
  { 206, 6, 7, 6, 0, -7 },
  { 212, 6, 7, 6, 0, -7 },
  { 218, 6, 8, 6, 0, -7 },
  { 224, 6, 7, 6, 0, -7 },
  { 230, 6, 7, 6, 0, -7 },
  { 236, 5, 7, 6, 1, -7 },
  { 241, 6, 7, 6, 0, -7 },
  { 247, 5, 7, 6, 1, -7 },
  { 252, 5, 7, 6, 1, -7 },
  { 257, 6, 7, 6, 0, -7 },
  { 263, 5, 7, 6, 1, -7 },
  { 268, 6, 7, 6, 0, -7 },
  { 274, 4, 10, 6, 1, -8 },
  { 279, 2, 8, 6, 2, -7 },
  { 281, 4, 10, 6, 1, -8 },
  { 286, 4, 4, 6, 1, -7 },
  { 288, 5, 1, 6, 0, 0 },
  { 289, 2, 1, 6, 3, -7 },
  { 290, 5, 5, 6, 0, -5 },
  { 294, 5, 8, 6, 0, -8 },
  { 299, 4, 5, 6, 1, -5 },
  { 302, 6, 8, 6, 0, -8 },
  { 308, 5, 5, 6, 0, -5 },
  { 312, 5, 8, 6, 1, -8 },
  { 317, 6, 7, 6, 0, -5 },
  { 323, 5, 8, 6, 0, -8 },
  { 328, 5, 7, 6, 0, -7 },
  { 333, 5, 9, 6, 0, -7 },
  { 339, 6, 8, 6, 0, -8 },
  { 345, 5, 8, 6, 0, -8 },
  { 350, 6, 5, 6, 0, -5 },
  { 354, 5, 5, 6, 0, -5 },
  { 358, 5, 5, 6, 0, -5 },
  { 362, 5, 7, 6, 0, -5 },
  { 367, 5, 7, 6, 0, -5 },
  { 372, 5, 5, 6, 1, -5 },
  { 376, 5, 5, 6, 0, -5 },
  { 380, 4, 7, 6, 1, -7 },
  { 384, 5, 5, 6, 1, -5 },
  { 388, 5, 5, 6, 1, -5 },
  { 392, 5, 5, 6, 1, -5 },
  { 396, 6, 5, 6, 0, -5 },
  { 400, 6, 7, 6, 0, -5 },
  { 406, 6, 5, 6, 0, -5 },
  { 410, 4, 10, 6, 1, -8 },
  { 415, 2, 9, 6, 2, -7 },
  { 418, 4, 10, 6, 1, -8 },
  { 423, 6, 2, 6, 0, -4 },
};

const GFXfont RobotoMono_MediumItalic10pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic10pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOMONO_MEDIUMITALIC10PT7B_H_
