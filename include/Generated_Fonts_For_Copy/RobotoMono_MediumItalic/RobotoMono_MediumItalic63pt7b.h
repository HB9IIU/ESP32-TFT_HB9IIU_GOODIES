#ifndef _ROBOTOMONO_MEDIUMITALIC63PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xF8, 0x03,
  0xE0, 0x00, 0x1F, 0x03, 0xF1, 0xF0, 0x3F, 0x3F, 0x03, 0xE3, 0xF0, 0x3E,
  0x3E, 0x03, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0x7C, 0x7E, 0x07,
  0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0x87, 0xC0,
  0xF8, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x81, 0xF0, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x07,
  0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x80,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x08, 0x1F,
  0x03, 0xE0, 0x38, 0xF8, 0x0F, 0x81, 0xF3, 0xE0, 0x3E, 0x07, 0xCF, 0x80,
  0xF8, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0xF8, 0x1F, 0x0F, 0xC3, 0xE0, 0x7C,
  0x3E, 0x0F, 0xC3, 0xF1, 0xF0, 0x3F, 0x9F, 0x8F, 0x80, 0x7F, 0xFE, 0x3E,
  0x00, 0xFF, 0xF1, 0xF0, 0x03, 0xFF, 0x8F, 0x80, 0x03, 0xF8, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x87, 0xF0, 0x00, 0x7C, 0x7F, 0xE0, 0x03, 0xF3,
  0xFF, 0xC0, 0x0F, 0x9F, 0xFF, 0x80, 0x7C, 0x7F, 0xFE, 0x03, 0xE3, 0xF0,
  0xFC, 0x0F, 0x8F, 0x81, 0xF0, 0x7C, 0x7E, 0x07, 0xC3, 0xE1, 0xF0, 0x1F,
  0x0F, 0x87, 0xC0, 0x7C, 0x7C, 0x1F, 0x01, 0xF0, 0xE0, 0x7C, 0x07, 0xC1,
  0x81, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x20, 0x7F, 0xFE, 0x01, 0xF8,
  0x1F, 0xFF, 0xE0, 0x3F, 0x07, 0xF9, 0xFC, 0x07, 0xE1, 0xFE, 0x3F, 0xC1,
  0xFC, 0x7F, 0x83, 0xF8, 0x3F, 0x8F, 0xF0, 0x7F, 0x87, 0xE3, 0xFC, 0x07,
  0xF9, 0xFC, 0x7F, 0x00, 0xFF, 0x7F, 0x0F, 0xE0, 0x0F, 0xFF, 0xE1, 0xFC,
  0x00, 0xFF, 0xF8, 0x7F, 0x80, 0x1F, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0xC0,
  0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFF,
  0xC0, 0x7F, 0xE1, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0x8F, 0xE0, 0x03,
  0xFF, 0x81, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x01, 0x80, 0x3E, 0x01,
  0xDF, 0x81, 0xF0, 0x3E, 0xFF, 0x0F, 0x0F, 0xFF, 0xFE, 0x79, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xBE, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xC7, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x01, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0x10, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x0F,
  0xE0, 0xFC, 0x03, 0x80, 0x10, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x04, 0x0F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0x8F, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x01,
  0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFC, 0xFE,
  0x00, 0x3F, 0xF3, 0xF8, 0x01, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0x7F, 0x80,
  0xFF, 0xFD, 0xFC, 0x0F, 0xFF, 0xF7, 0xF0, 0x7F, 0xBF, 0x9F, 0xC7, 0xF8,
  0xFE, 0x7F, 0x3F, 0xC3, 0xF9, 0xFF, 0xFC, 0x0F, 0xEF, 0xFF, 0xE0, 0x3F,
  0xBF, 0xFF, 0x01, 0xFE, 0xFF, 0xF0, 0x07, 0xF3, 0xFF, 0x80, 0x1F, 0xCF,
  0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xF8,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xE3, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x07, 0xF0,
  0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0x8F, 0xEF, 0xC1, 0xFC, 0xE0, 0x1F,
  0xC8, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x03,
  0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F,
  0x00, 0x0F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF7, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0x80, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0xE3, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x1C, 0x00, 0x1F, 0xC7, 0xFE, 0x00, 0xFE, 0xFF, 0xF8, 0x0F, 0xEF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x3F, 0xFE, 0x3F,
  0xF1, 0xFF, 0xC0, 0x7F, 0xCF, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF3,
  0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xFC,
  0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF,
  0x01, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x07,
  0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0x80, 0x3F,
  0x81, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE,
  0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF9,
  0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F,
  0xF8, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xF0, 0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xF3, 0xF8,
  0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xF7,
  0xFC, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFE, 0xFC, 0x07, 0xFF, 0xDF, 0xC0, 0x1F, 0xE1, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x40, 0x07, 0xF0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x07, 0xF0,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x01, 0xFC, 0x07, 0xF8, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFE, 0x01, 0xF8,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80,
  0x0F, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x03, 0x80,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xEF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x0F,
  0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0xF0,
  0x1F, 0x01, 0xFC, 0x0F, 0x03, 0xE0, 0xFF, 0xE1, 0xE0, 0xF8, 0x3F, 0xFE,
  0x3C, 0x3E, 0x0F, 0xFF, 0x87, 0x87, 0xC3, 0xF8, 0xF0, 0xF0, 0xF0, 0x7C,
  0x1E, 0x1E, 0x3E, 0x1F, 0x03, 0xC3, 0xC7, 0x83, 0xC0, 0xF8, 0x79, 0xF0,
  0xF8, 0x1E, 0x0F, 0x3E, 0x1E, 0x03, 0xC1, 0xE7, 0x87, 0xC0, 0x78, 0x3C,
  0xF0, 0xF8, 0x1F, 0x07, 0xBE, 0x1F, 0x03, 0xC0, 0xE7, 0xC3, 0xC0, 0x78,
  0x3C, 0xF0, 0xF8, 0x0F, 0x07, 0x9E, 0x1F, 0x03, 0xE0, 0xF3, 0xC3, 0xE0,
  0x78, 0x1C, 0x78, 0x7C, 0x0F, 0x07, 0x8F, 0x0F, 0x83, 0xE0, 0xF1, 0xE1,
  0xF0, 0x7C, 0x3C, 0x3C, 0x3F, 0x3F, 0x8F, 0x87, 0x83, 0xFF, 0xFF, 0xE0,
  0xF0, 0x7F, 0xFF, 0xF8, 0x1E, 0x07, 0xF9, 0xFE, 0x03, 0xE0, 0xFC, 0x3F,
  0x80, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x40, 0x00, 0x1F,
  0xE0, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0x7F, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x03,
  0xF9, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0xF0, 0x0F, 0xE0, 0x03,
  0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xE0,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xC0, 0x0F,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x1F,
  0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xFC,
  0x1F, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xF1, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F,
  0xC0, 0xFF, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F,
  0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0,
  0x0F, 0xFC, 0x07, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0xF9,
  0xFE, 0x01, 0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xFE, 0x7F, 0x00, 0x7F, 0xFF,
  0x3F, 0x80, 0x3F, 0xFF, 0x9F, 0xC0, 0x3F, 0xFF, 0x8F, 0xE0, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xFB, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x01,
  0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x80,
  0x01, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xF8,
  0x07, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xF0,
  0x00, 0x03, 0xF8, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0xE0, 0x00, 0x07,
  0xF8, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0xFF, 0x80, 0x00, 0x07, 0xF1, 0xFF,
  0x00, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0x7C, 0x3F,
  0xFE, 0x03, 0xFB, 0xE3, 0xF7, 0xE0, 0x1F, 0xDF, 0x1F, 0xBF, 0x00, 0xFC,
  0xF9, 0xF9, 0xF8, 0x07, 0xE7, 0xCF, 0xDF, 0xC0, 0x3F, 0x3E, 0xFC, 0xFE,
  0x03, 0xF9, 0xF7, 0xE7, 0xF0, 0x1F, 0xCF, 0xFE, 0x3F, 0x00, 0xFE, 0x7F,
  0xF1, 0xF8, 0x07, 0xF1, 0xFF, 0x1F, 0xC0, 0x3F, 0x0F, 0xF8, 0xFE, 0x01,
  0xF8, 0x7F, 0x87, 0xF0, 0x1F, 0xC3, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC1,
  0xF8, 0x07, 0xF0, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0xFE, 0x01, 0xF8,
  0x3F, 0x07, 0xF0, 0x0F, 0xC0, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0x81, 0xFC,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x1F,
  0xE0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xF0, 0x00, 0xFE, 0x03, 0xFF, 0x00,
  0x0F, 0xE0, 0x3F, 0xF8, 0x00, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x3F,
  0xF8, 0x01, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0x3F, 0xFC, 0x01, 0xFC,
  0x07, 0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0xFC, 0x03, 0xFC, 0x07, 0xF7, 0xE0,
  0x3F, 0xC0, 0x7F, 0x7E, 0x03, 0xF8, 0x07, 0xF7, 0xE0, 0x3F, 0x80, 0xFF,
  0x7E, 0x03, 0xF8, 0x0F, 0xF3, 0xF0, 0x3F, 0x80, 0xFE, 0x3F, 0x07, 0xF8,
  0x0F, 0xE3, 0xF0, 0x7F, 0x80, 0xFE, 0x1F, 0x87, 0xF0, 0x0F, 0xE1, 0xF8,
  0x7F, 0x01, 0xFE, 0x1F, 0x87, 0xF0, 0x1F, 0xE1, 0xF8, 0x7F, 0x01, 0xFC,
  0x0F, 0xCF, 0xF0, 0x1F, 0xC0, 0xFC, 0xFF, 0x01, 0xFC, 0x0F, 0xCF, 0xE0,
  0x1F, 0xC0, 0x7E, 0xFE, 0x03, 0xFC, 0x07, 0xEF, 0xE0, 0x3F, 0xC0, 0x7F,
  0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x3F, 0xFC, 0x03, 0xF8,
  0x03, 0xFF, 0xC0, 0x3F, 0x80, 0x3F, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0x00, 0x1F, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0x1F,
  0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03,
  0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xE0, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x03,
  0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x7F,
  0x9F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0xC7, 0xF0, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFE, 0x1F, 0xC0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0x8F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x0F, 0xE0, 0x03, 0xFE, 0x01,
  0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0xFF, 0xF1, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x07, 0xF8, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x1F,
  0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0xBF,
  0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0x80, 0x7F, 0x7F, 0x01, 0xF8,
  0x0F, 0xE7, 0xF0, 0x1F, 0x80, 0xFE, 0x7F, 0x03, 0xF8, 0x0F, 0xE7, 0xF0,
  0x3F, 0x80, 0xFC, 0x7F, 0x03, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x81, 0xFC,
  0x7F, 0x07, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x81, 0xF8, 0x7F, 0x07, 0xF8,
  0x3F, 0x87, 0xF0, 0xFF, 0x83, 0xF8, 0x7F, 0x0F, 0xF8, 0x3F, 0x07, 0xE0,
  0xFF, 0x83, 0xF0, 0x7E, 0x1F, 0xF8, 0x7F, 0x07, 0xE1, 0xFF, 0x87, 0xF0,
  0x7E, 0x1F, 0xF8, 0x7E, 0x07, 0xE3, 0xFF, 0x8F, 0xE0, 0x7E, 0x3E, 0xF8,
  0xFE, 0x07, 0xE3, 0xEF, 0x8F, 0xC0, 0x7E, 0x7E, 0xF8, 0xFC, 0x07, 0xE7,
  0xCF, 0x9F, 0xC0, 0x7E, 0x7C, 0xF9, 0xFC, 0x07, 0xE7, 0xCF, 0x9F, 0x80,
  0x7E, 0xF8, 0xF9, 0xF8, 0x07, 0xEF, 0x8F, 0xBF, 0x80, 0x7E, 0xF8, 0xFB,
  0xF0, 0x07, 0xFF, 0x8F, 0xBF, 0x00, 0x7F, 0xF0, 0xFB, 0xF0, 0x07, 0xFF,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x00, 0x0F, 0xE0,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFF, 0x0F,
  0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0,
  0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0xFD, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF8, 0xF8,
  0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0x7C,
  0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E,
  0x7F, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F,
  0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0x83, 0xFC,
  0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0x8F, 0xF8, 0x01, 0xFE, 0x3F,
  0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0,
  0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x01,
  0xFE, 0x1F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xCF, 0xE0,
  0x0F, 0xFC, 0x3F, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0xFF, 0xE0, 0x03, 0xFB, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0xFF,
  0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0xE0, 0x07, 0xF8,
  0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xFE, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0x7F, 0xFF, 0x80, 0x7F, 0x3F, 0xFF, 0x00,
  0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0x83, 0xFC,
  0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x01,
  0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xF1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x3F, 0xC0, 0x07, 0xFF, 0x8F, 0xE0,
  0x03, 0xFF, 0xF3, 0xF8, 0x01, 0xFF, 0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0x0F, 0xF0, 0x07,
  0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x03,
  0xF8, 0x07, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xEF, 0xC0, 0x01, 0xFF, 0xF7, 0xF0, 0x00,
  0x3F, 0xF1, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0x83, 0xFE,
  0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF3, 0xFC, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x07,
  0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x06, 0x07, 0xF8, 0x00,
  0x3C, 0x0F, 0xF8, 0x03, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x87, 0xF0, 0x03, 0xFF, 0xF9, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F,
  0xF8, 0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xE0,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x0F, 0xFE, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xEF, 0xE0, 0x01,
  0xFF, 0xF7, 0xF0, 0x00, 0x3F, 0xF1, 0xFC, 0x00, 0x00, 0xE0, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x04, 0x00, 0x07, 0xF8,
  0x01, 0x80, 0x01, 0xFE, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x03,
  0xF8, 0x7F, 0xF0, 0x03, 0xF9, 0xFF, 0xF8, 0x03, 0xFB, 0xFF, 0xFC, 0x03,
  0xF7, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x87, 0xFE, 0x07,
  0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x3F,
  0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x7F,
  0x80, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x40, 0xFE, 0x00, 0x1F, 0xF0,
  0x1F, 0xC0, 0x07, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x03, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0x03,
  0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0xC0, 0x01, 0xFC, 0x3F, 0xE0, 0x00, 0x3F,
  0x8F, 0xF8, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x80, 0x00,
  0x3F, 0xBF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xC0, 0x00, 0x7F,
  0xC7, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xF0, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x3F,
  0xC3, 0xFC, 0x03, 0xF7, 0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0xEF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0xCF,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0x7F, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0x7F, 0x0F,
  0xE0, 0xFE, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0xFE, 0x07,
  0xE1, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F,
  0xC0, 0xFE, 0x1F, 0xC1, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0xC0, 0xFC, 0x1F,
  0x81, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0x81, 0xFC, 0x3F, 0x81, 0xF8, 0x1F,
  0xC3, 0xF8, 0x1F, 0x81, 0xFC, 0x3F, 0x83, 0xF8, 0x1F, 0x83, 0xF0, 0x3F,
  0x81, 0xF8, 0x3F, 0x03, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x03, 0xF8, 0x7F,
  0x03, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0x3F,
  0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x7F, 0xF0, 0x03, 0xF1,
  0xFF, 0xF8, 0x03, 0xF3, 0xFF, 0xFC, 0x03, 0xF7, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x07, 0xF8,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0,
  0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x01, 0xFE,
  0x1F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFC,
  0xFF, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x1F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x8F, 0xFE, 0x00, 0x0F, 0xEF, 0xFF, 0xC0, 0x03, 0xF7, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x7F, 0xFF, 0x80, 0x1F, 0xCF,
  0xFF, 0xC0, 0x07, 0xF0, 0xFF, 0xC0, 0x03, 0xFC, 0x07, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0xFC, 0x03, 0xFF,
  0xF3, 0xF8, 0x0F, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x03,
  0xFC, 0x7F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE,
  0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x7F,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xDF, 0xC0, 0x07, 0xFE,
  0x3F, 0x80, 0x00, 0xE0, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0x83, 0xFF,
  0xC1, 0xFC, 0x7F, 0xFE, 0x0F, 0xE7, 0xFF, 0xF0, 0x7F, 0x7F, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFC, 0x3E, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0xC3,
  0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xF0,
  0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x7F,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x3F, 0xC7, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x3F, 0xFE,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xE7, 0xF0,
  0x0F, 0xFF, 0x8F, 0xC0, 0x07, 0xFC, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0,
  0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x1F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC1, 0xFC, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x03, 0xE0, 0x1F, 0xFF, 0x00, 0xF8, 0x07, 0xEF, 0xC0, 0x7E, 0x01,
  0xFB, 0xF0, 0x1F, 0x80, 0xFE, 0xFC, 0x07, 0xE0, 0x3F, 0x3F, 0x03, 0xF8,
  0x0F, 0xCF, 0xC0, 0xFE, 0x07, 0xF3, 0xF0, 0x7F, 0x81, 0xF8, 0xFC, 0x1F,
  0xE0, 0x7E, 0x3F, 0x07, 0xF8, 0x3F, 0x8F, 0xC3, 0xFE, 0x0F, 0xC3, 0xF0,
  0xFF, 0x83, 0xF0, 0xFC, 0x7D, 0xF1, 0xF8, 0x3F, 0x1F, 0x7C, 0x7E, 0x0F,
  0xC7, 0x9F, 0x1F, 0x83, 0xF3, 0xE7, 0xCF, 0xC0, 0xFC, 0xF9, 0xF3, 0xF0,
  0x3F, 0x3C, 0x7C, 0xFC, 0x0F, 0xDF, 0x1F, 0x7E, 0x03, 0xF7, 0xC7, 0xDF,
  0x80, 0xFF, 0xE1, 0xF7, 0xE0, 0x3E, 0xF8, 0x7D, 0xF0, 0x0F, 0xBC, 0x1F,
  0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x1F,
  0xC7, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x01,
  0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0xFF, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x40, 0x3F, 0xFF, 0x00, 0x0F, 0x8F, 0xFF, 0xF0, 0x01, 0xF3, 0xFF,
  0xFF, 0x00, 0x7E, 0x7F, 0xFF, 0xF0, 0x1F, 0x8F, 0xE1, 0xFF, 0x87, 0xF3,
  0xF0, 0x1F, 0xFF, 0xFE, 0x7C, 0x00, 0xFF, 0xFF, 0x8F, 0x80, 0x0F, 0xFF,
  0xE3, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x00,
};

const GFXglyph RobotoMono_MediumItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 15, 45, 37, 11, -45 },
  { 86, 20, 15, 37, 11, -47 },
  { 124, 37, 45, 37, 0, -45 },
  { 333, 33, 58, 37, 3, -52 },
  { 573, 30, 47, 37, 4, -46 },
  { 750, 35, 47, 37, 1, -46 },
  { 956, 8, 16, 37, 16, -47 },
  { 972, 21, 64, 37, 10, -50 },
  { 1140, 21, 64, 37, 5, -50 },
  { 1308, 29, 31, 37, 6, -45 },
  { 1421, 31, 33, 37, 3, -37 },
  { 1549, 12, 19, 37, 6, -7 },
  { 1578, 25, 6, 37, 7, -23 },
  { 1597, 10, 11, 37, 11, -10 },
  { 1611, 32, 49, 37, 3, -45 },
  { 1807, 30, 47, 37, 4, -46 },
  { 1984, 20, 45, 37, 8, -45 },
  { 2097, 33, 45, 37, 0, -45 },
  { 2283, 32, 46, 37, 2, -45 },
  { 2467, 32, 45, 37, 1, -45 },
  { 2647, 33, 46, 37, 3, -45 },
  { 2837, 29, 46, 37, 3, -45 },
  { 3004, 32, 45, 37, 5, -45 },
  { 3184, 31, 46, 37, 3, -45 },
  { 3363, 28, 45, 37, 5, -45 },
  { 3521, 15, 37, 37, 12, -36 },
  { 3591, 18, 48, 37, 9, -36 },
  { 3699, 30, 29, 37, 4, -34 },
  { 3808, 31, 19, 37, 3, -29 },
  { 3882, 29, 29, 37, 3, -34 },
  { 3988, 27, 46, 37, 8, -46 },
  { 4144, 35, 45, 37, 2, -45 },
  { 4341, 35, 45, 37, -2, -45 },
  { 4538, 35, 45, 37, 1, -45 },
  { 4735, 33, 47, 37, 3, -46 },
  { 4929, 34, 45, 37, 1, -45 },
  { 5121, 35, 45, 37, 2, -45 },
  { 5318, 36, 45, 37, 2, -45 },
  { 5521, 33, 46, 37, 3, -45 },
  { 5711, 36, 45, 37, 1, -45 },
  { 5914, 34, 45, 37, 2, -45 },
  { 6106, 35, 46, 37, 2, -45 },
  { 6308, 40, 45, 37, 1, -45 },
  { 6533, 29, 45, 37, 2, -45 },
  { 6697, 37, 45, 37, 1, -45 },
  { 6906, 36, 45, 37, 1, -45 },
  { 7109, 32, 46, 37, 3, -45 },
  { 7293, 35, 45, 37, 2, -45 },
  { 7490, 34, 53, 37, 2, -45 },
  { 7716, 35, 45, 37, 1, -45 },
  { 7913, 34, 46, 37, 2, -45 },
  { 8109, 35, 45, 37, 5, -45 },
  { 8306, 34, 46, 37, 3, -45 },
  { 8502, 33, 45, 37, 6, -45 },
  { 8688, 36, 45, 37, 4, -45 },
  { 8891, 41, 45, 37, -1, -45 },
  { 9122, 34, 45, 37, 6, -45 },
  { 9314, 37, 45, 37, 0, -45 },
  { 9523, 22, 62, 37, 8, -52 },
  { 9694, 15, 49, 37, 12, -45 },
  { 9786, 22, 62, 37, 8, -52 },
  { 9957, 24, 24, 37, 7, -45 },
  { 10029, 29, 6, 37, 0, 0 },
  { 10051, 11, 9, 37, 17, -46 },
  { 10064, 30, 35, 37, 2, -34 },
  { 10196, 32, 48, 37, 1, -47 },
  { 10388, 30, 35, 37, 3, -34 },
  { 10520, 34, 48, 37, 3, -47 },
  { 10724, 30, 35, 37, 3, -34 },
  { 10856, 33, 49, 37, 6, -49 },
  { 11059, 34, 47, 37, 1, -34 },
  { 11259, 32, 47, 37, 1, -47 },
  { 11447, 28, 46, 37, 3, -46 },
  { 11608, 29, 60, 37, 1, -46 },
  { 11826, 35, 47, 37, 1, -47 },
  { 12032, 28, 47, 37, 3, -47 },
  { 12197, 36, 34, 37, -1, -34 },
  { 12350, 32, 34, 37, 1, -34 },
  { 12486, 30, 35, 37, 3, -34 },
  { 12618, 34, 47, 37, -1, -34 },
  { 12818, 31, 47, 37, 3, -34 },
  { 13001, 29, 34, 37, 6, -34 },
  { 13125, 30, 35, 37, 3, -34 },
  { 13257, 28, 42, 37, 6, -41 },
  { 13404, 31, 34, 37, 4, -33 },
  { 13536, 32, 33, 37, 5, -33 },
  { 13668, 34, 33, 37, 4, -33 },
  { 13809, 37, 33, 37, 0, -33 },
  { 13962, 39, 47, 37, 0, -33 },
  { 14192, 34, 33, 37, 1, -33 },
  { 14333, 25, 60, 37, 9, -49 },
  { 14521, 14, 57, 37, 11, -45 },
  { 14621, 24, 60, 37, 6, -49 },
  { 14801, 35, 13, 37, 0, -25 },
};

const GFXfont RobotoMono_MediumItalic63pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic63pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic63pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _ROBOTOMONO_MEDIUMITALIC63PT7B_H_
