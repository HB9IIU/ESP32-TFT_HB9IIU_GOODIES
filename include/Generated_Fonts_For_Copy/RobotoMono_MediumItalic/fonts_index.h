#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &RobotoMono_MediumItalic6pt7b, 6, "RobotoMono_MediumItalic6pt7b" },
  { &RobotoMono_MediumItalic7pt7b, 7, "RobotoMono_MediumItalic7pt7b" },
  { &RobotoMono_MediumItalic8pt7b, 8, "RobotoMono_MediumItalic8pt7b" },
  { &RobotoMono_MediumItalic9pt7b, 9, "RobotoMono_MediumItalic9pt7b" },
  { &RobotoMono_MediumItalic10pt7b, 10, "RobotoMono_MediumItalic10pt7b" },
  { &RobotoMono_MediumItalic11pt7b, 11, "RobotoMono_MediumItalic11pt7b" },
  { &RobotoMono_MediumItalic12pt7b, 12, "RobotoMono_MediumItalic12pt7b" },
  { &RobotoMono_MediumItalic13pt7b, 13, "RobotoMono_MediumItalic13pt7b" },
  { &RobotoMono_MediumItalic14pt7b, 14, "RobotoMono_MediumItalic14pt7b" },
  { &RobotoMono_MediumItalic15pt7b, 15, "RobotoMono_MediumItalic15pt7b" },
  { &RobotoMono_MediumItalic16pt7b, 16, "RobotoMono_MediumItalic16pt7b" },
  { &RobotoMono_MediumItalic17pt7b, 17, "RobotoMono_MediumItalic17pt7b" },
  { &RobotoMono_MediumItalic18pt7b, 18, "RobotoMono_MediumItalic18pt7b" },
  { &RobotoMono_MediumItalic19pt7b, 19, "RobotoMono_MediumItalic19pt7b" },
  { &RobotoMono_MediumItalic20pt7b, 20, "RobotoMono_MediumItalic20pt7b" },
  { &RobotoMono_MediumItalic21pt7b, 21, "RobotoMono_MediumItalic21pt7b" },
  { &RobotoMono_MediumItalic22pt7b, 22, "RobotoMono_MediumItalic22pt7b" },
  { &RobotoMono_MediumItalic23pt7b, 23, "RobotoMono_MediumItalic23pt7b" },
  { &RobotoMono_MediumItalic24pt7b, 24, "RobotoMono_MediumItalic24pt7b" },
  { &RobotoMono_MediumItalic25pt7b, 25, "RobotoMono_MediumItalic25pt7b" },
  { &RobotoMono_MediumItalic26pt7b, 26, "RobotoMono_MediumItalic26pt7b" },
  { &RobotoMono_MediumItalic27pt7b, 27, "RobotoMono_MediumItalic27pt7b" },
  { &RobotoMono_MediumItalic28pt7b, 28, "RobotoMono_MediumItalic28pt7b" },
  { &RobotoMono_MediumItalic29pt7b, 29, "RobotoMono_MediumItalic29pt7b" },
  { &RobotoMono_MediumItalic30pt7b, 30, "RobotoMono_MediumItalic30pt7b" },
  { &RobotoMono_MediumItalic31pt7b, 31, "RobotoMono_MediumItalic31pt7b" },
  { &RobotoMono_MediumItalic32pt7b, 32, "RobotoMono_MediumItalic32pt7b" },
  { &RobotoMono_MediumItalic33pt7b, 33, "RobotoMono_MediumItalic33pt7b" },
  { &RobotoMono_MediumItalic34pt7b, 34, "RobotoMono_MediumItalic34pt7b" },
  { &RobotoMono_MediumItalic35pt7b, 35, "RobotoMono_MediumItalic35pt7b" },
  { &RobotoMono_MediumItalic36pt7b, 36, "RobotoMono_MediumItalic36pt7b" },
  { &RobotoMono_MediumItalic37pt7b, 37, "RobotoMono_MediumItalic37pt7b" },
  { &RobotoMono_MediumItalic38pt7b, 38, "RobotoMono_MediumItalic38pt7b" },
  { &RobotoMono_MediumItalic39pt7b, 39, "RobotoMono_MediumItalic39pt7b" },
  { &RobotoMono_MediumItalic40pt7b, 40, "RobotoMono_MediumItalic40pt7b" },
  { &RobotoMono_MediumItalic41pt7b, 41, "RobotoMono_MediumItalic41pt7b" },
  { &RobotoMono_MediumItalic42pt7b, 42, "RobotoMono_MediumItalic42pt7b" },
  { &RobotoMono_MediumItalic43pt7b, 43, "RobotoMono_MediumItalic43pt7b" },
  { &RobotoMono_MediumItalic44pt7b, 44, "RobotoMono_MediumItalic44pt7b" },
  { &RobotoMono_MediumItalic45pt7b, 45, "RobotoMono_MediumItalic45pt7b" },
  { &RobotoMono_MediumItalic46pt7b, 46, "RobotoMono_MediumItalic46pt7b" },
  { &RobotoMono_MediumItalic47pt7b, 47, "RobotoMono_MediumItalic47pt7b" },
  { &RobotoMono_MediumItalic48pt7b, 48, "RobotoMono_MediumItalic48pt7b" },
  { &RobotoMono_MediumItalic49pt7b, 49, "RobotoMono_MediumItalic49pt7b" },
  { &RobotoMono_MediumItalic50pt7b, 50, "RobotoMono_MediumItalic50pt7b" },
  { &RobotoMono_MediumItalic51pt7b, 51, "RobotoMono_MediumItalic51pt7b" },
  { &RobotoMono_MediumItalic52pt7b, 52, "RobotoMono_MediumItalic52pt7b" },
  { &RobotoMono_MediumItalic53pt7b, 53, "RobotoMono_MediumItalic53pt7b" },
  { &RobotoMono_MediumItalic54pt7b, 54, "RobotoMono_MediumItalic54pt7b" },
  { &RobotoMono_MediumItalic55pt7b, 55, "RobotoMono_MediumItalic55pt7b" },
  { &RobotoMono_MediumItalic56pt7b, 56, "RobotoMono_MediumItalic56pt7b" },
  { &RobotoMono_MediumItalic57pt7b, 57, "RobotoMono_MediumItalic57pt7b" },
  { &RobotoMono_MediumItalic58pt7b, 58, "RobotoMono_MediumItalic58pt7b" },
  { &RobotoMono_MediumItalic59pt7b, 59, "RobotoMono_MediumItalic59pt7b" },
  { &RobotoMono_MediumItalic60pt7b, 60, "RobotoMono_MediumItalic60pt7b" },
  { &RobotoMono_MediumItalic61pt7b, 61, "RobotoMono_MediumItalic61pt7b" },
  { &RobotoMono_MediumItalic62pt7b, 62, "RobotoMono_MediumItalic62pt7b" },
  { &RobotoMono_MediumItalic63pt7b, 63, "RobotoMono_MediumItalic63pt7b" },
  { &RobotoMono_MediumItalic64pt7b, 64, "RobotoMono_MediumItalic64pt7b" },
  { &RobotoMono_MediumItalic65pt7b, 65, "RobotoMono_MediumItalic65pt7b" },
  { &RobotoMono_MediumItalic66pt7b, 66, "RobotoMono_MediumItalic66pt7b" },
  { &RobotoMono_MediumItalic67pt7b, 67, "RobotoMono_MediumItalic67pt7b" },
  { &RobotoMono_MediumItalic68pt7b, 68, "RobotoMono_MediumItalic68pt7b" },
  { &RobotoMono_MediumItalic69pt7b, 69, "RobotoMono_MediumItalic69pt7b" },
  { &RobotoMono_MediumItalic70pt7b, 70, "RobotoMono_MediumItalic70pt7b" },
  { &RobotoMono_MediumItalic71pt7b, 71, "RobotoMono_MediumItalic71pt7b" },
  { &RobotoMono_MediumItalic72pt7b, 72, "RobotoMono_MediumItalic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
