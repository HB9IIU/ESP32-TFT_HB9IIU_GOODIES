#ifndef _ROBOTOMONO_MEDIUMITALIC25PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC7, 0x1C, 0x63, 0x8E, 0x38, 0xE3, 0x8C, 0x00, 0x00,
  0x1C, 0xF1, 0xC0, 0x73, 0x63, 0x63, 0x63, 0x66, 0xE6, 0x01, 0x8C, 0x03,
  0x18, 0x06, 0x60, 0x18, 0xC0, 0x31, 0x87, 0xFF, 0xCF, 0xFF, 0x83, 0x30,
  0x0E, 0x60, 0x18, 0xC0, 0x33, 0x07, 0xFF, 0xCF, 0xFF, 0x83, 0x30, 0x0C,
  0x60, 0x18, 0xC0, 0x33, 0x00, 0xC6, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x07, 0xC0, 0xFF, 0x0F, 0x78, 0x70, 0xE7, 0x07, 0x38, 0x39, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0xE0, 0x77, 0x83,
  0x9C, 0x78, 0xFF, 0x81, 0xF8, 0x06, 0x00, 0x30, 0x01, 0x80, 0x78, 0x0F,
  0xC0, 0xCC, 0x4C, 0xC6, 0xCC, 0xCC, 0xD8, 0xFB, 0x07, 0x30, 0x06, 0x00,
  0xC0, 0x0C, 0x81, 0xBE, 0x37, 0x67, 0x67, 0x66, 0x64, 0x66, 0x07, 0xE0,
  0x3C, 0x03, 0xC0, 0x1F, 0x80, 0xE7, 0x03, 0x1C, 0x0C, 0x70, 0x31, 0x80,
  0xDE, 0x03, 0xF0, 0x07, 0x00, 0x7C, 0x03, 0xF9, 0xDC, 0xE7, 0x71, 0xD9,
  0xC7, 0xE7, 0x0F, 0x1C, 0x7C, 0x7F, 0xF0, 0xFC, 0xE0, 0x76, 0x66, 0x66,
  0xC0, 0x01, 0x03, 0x06, 0x0E, 0x1C, 0x38, 0x38, 0x30, 0x70, 0x60, 0x60,
  0xE0, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x70,
  0x30, 0x18, 0x08, 0x08, 0x1C, 0x0E, 0x06, 0x07, 0x07, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0C, 0x1C,
  0x38, 0x30, 0x60, 0xC0, 0x80, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x62,
  0x7F, 0xFF, 0x1F, 0xC0, 0xE0, 0x1F, 0x03, 0xB8, 0x71, 0x82, 0x1C, 0x01,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x3F, 0xFF, 0xFF,
  0xDF, 0xFE, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x39,
  0xCE, 0x73, 0x3B, 0x88, 0xFF, 0xFF, 0xF0, 0x73, 0xBE, 0xE0, 0x00, 0x38,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x00, 0x0F, 0x81, 0xFC, 0x3D, 0xE7,
  0x06, 0x70, 0x76, 0x07, 0xE0, 0xFE, 0x3E, 0xE7, 0xEF, 0xEE, 0xF8, 0xEF,
  0x0E, 0xC0, 0xEC, 0x1C, 0xC1, 0xCE, 0x38, 0x7F, 0x83, 0xE0, 0x01, 0x0F,
  0x3F, 0xFF, 0xE7, 0x86, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x18, 0x38, 0x03, 0xE0, 0x7F, 0x87, 0xBE, 0x70, 0x73, 0x83,
  0x9C, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x07, 0xC1,
  0xFE, 0x3C, 0xF3, 0x87, 0x70, 0x70, 0x07, 0x00, 0x70, 0x1E, 0x0F, 0xC0,
  0xFC, 0x01, 0xE0, 0x0E, 0x00, 0xEC, 0x0E, 0xE0, 0xEF, 0x1C, 0x7F, 0xC3,
  0xF0, 0x00, 0x38, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x1D,
  0xC1, 0xCE, 0x1C, 0x70, 0xC3, 0x0E, 0x38, 0xE1, 0xCF, 0xFF, 0xFF, 0xFC,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x0F, 0xF8, 0x7F, 0xC7, 0xFE,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0xEC, 0x07, 0xF8, 0x3F, 0xE2, 0x87, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x70, 0x3B, 0x83, 0x8E, 0x3C, 0x7F, 0xC0, 0xF8,
  0x00, 0x00, 0xE0, 0x7E, 0x0F, 0xE1, 0xE0, 0x3C, 0x03, 0x80, 0x73, 0x87,
  0xFC, 0x7F, 0xE7, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0x60, 0xE7,
  0x1C, 0x3F, 0xC1, 0xF0, 0x7F, 0xFF, 0xFF, 0xBF, 0xFC, 0x00, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0xC0,
  0x7F, 0x87, 0xBC, 0x70, 0x73, 0x83, 0x9C, 0x18, 0xE1, 0xC3, 0x9C, 0x1F,
  0xC1, 0xFE, 0x1E, 0x38, 0xE0, 0xCE, 0x07, 0x70, 0x33, 0x83, 0x8E, 0x3C,
  0x7F, 0xC1, 0xFC, 0x00, 0x0F, 0x87, 0xF9, 0xF7, 0x38, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xEE, 0x3D, 0xFF, 0x9F, 0x60, 0x1C, 0x07, 0x01,
  0xE0, 0xF8, 0x7E, 0x0F, 0x00, 0x38, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x3C, 0xF3, 0x80, 0x0C, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC7, 0x0E, 0x1C, 0x38, 0xE1, 0x81, 0x00, 0x00, 0x20, 0x0C,
  0x0F, 0x87, 0xF7, 0xF1, 0xF0, 0x38, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x00, 0x40, 0x3F, 0xFB, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xDF, 0xFC, 0x30, 0x03, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x0F,
  0x07, 0xE3, 0xF8, 0xFC, 0x0F, 0x00, 0x80, 0x00, 0x1F, 0x87, 0xF9, 0xEF,
  0xF8, 0x7E, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x0E,
  0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x01, 0x80, 0x3F,
  0xC1, 0xC3, 0x0E, 0x06, 0x33, 0xC9, 0x9F, 0x26, 0xCC, 0xB3, 0x32, 0xD8,
  0xCB, 0x62, 0x69, 0x99, 0xA6, 0x64, 0x9F, 0xB3, 0x3B, 0x8C, 0x00, 0x38,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x0E, 0xC0, 0x3B, 0x01, 0xCE, 0x07, 0x38, 0x38, 0xE0, 0xE3,
  0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xE3, 0x81, 0x9C, 0x07, 0x70, 0x1F, 0xC0,
  0x70, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x73,
  0x81, 0xCE, 0x1E, 0x3F, 0xF0, 0xFF, 0xC3, 0x83, 0x8C, 0x0E, 0x70, 0x39,
  0xC0, 0xE7, 0x03, 0x9C, 0x7C, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xC0, 0x7F,
  0x87, 0xBC, 0x70, 0x73, 0x03, 0xB8, 0x1D, 0xC0, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x01, 0x70, 0x3B, 0x83, 0x8E, 0x3C, 0x7F,
  0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x81, 0xFF, 0x07, 0x0E, 0x1C, 0x3C,
  0x60, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xDC, 0x0E,
  0x70, 0x39, 0xC1, 0xC7, 0x0F, 0x1C, 0xF8, 0x7F, 0xC3, 0xFC, 0x00, 0x1F,
  0xFC, 0xFF, 0xF3, 0xFF, 0x8E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x7F, 0xE1, 0xFF, 0x87, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF3, 0xFF,
  0xCE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x7F, 0xF1, 0xFF,
  0x87, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0xBE, 0x70, 0x73, 0x83, 0xB8,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x0F, 0xF8, 0xFD, 0xC0, 0xEE, 0x07,
  0x70, 0x39, 0xC1, 0xCE, 0x1E, 0x3F, 0xE0, 0xFC, 0x00, 0x1C, 0x0E, 0x38,
  0x1C, 0x70, 0x30, 0xE0, 0xE1, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0C,
  0x3F, 0xF8, 0x7F, 0xF0, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x06, 0x1C,
  0x1C, 0x38, 0x38, 0x60, 0x71, 0xC0, 0xE0, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC4, 0xFF, 0xC7, 0xFE,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x63,
  0x83, 0x8E, 0x0E, 0x3C, 0x70, 0x7F, 0x80, 0xFC, 0x00, 0x1C, 0x0F, 0x1C,
  0x1E, 0x1C, 0x3C, 0x1C, 0x38, 0x1C, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x3B,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3D, 0xC0, 0x39, 0xC0, 0x70, 0xE0, 0x70,
  0xE0, 0x70, 0xF0, 0x70, 0x70, 0x70, 0x78, 0xE0, 0x38, 0x1C, 0x03, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFC, 0x1E, 0x1E,
  0x3C, 0x3C, 0x78, 0xF8, 0xF1, 0xE1, 0xE7, 0xC3, 0xED, 0x8E, 0xFF, 0x1D,
  0xEE, 0x3B, 0xDC, 0x67, 0x30, 0xCE, 0x63, 0x99, 0xC7, 0x33, 0x8E, 0x07,
  0x1C, 0x0E, 0x30, 0x18, 0x60, 0x71, 0xC0, 0xE0, 0x1C, 0x0E, 0x3C, 0x1C,
  0x78, 0x70, 0xF0, 0xE1, 0xE1, 0xC7, 0xE3, 0x8E, 0xC7, 0x1D, 0x8C, 0x3B,
  0xB8, 0x77, 0x70, 0xC6, 0xE3, 0x8D, 0xC7, 0x1F, 0x8E, 0x1E, 0x1C, 0x3C,
  0x38, 0x78, 0x60, 0xF1, 0xC0, 0xE0, 0x07, 0xC0, 0x7F, 0x07, 0xBC, 0x70,
  0x73, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x83, 0x8E, 0x38, 0x7F, 0xC0, 0xF8, 0x00,
  0x1F, 0xC0, 0x7F, 0xC3, 0xFF, 0x8E, 0x0E, 0x38, 0x1C, 0xE0, 0x73, 0x83,
  0x8C, 0x0E, 0x70, 0x79, 0xFF, 0xC7, 0xFC, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x7F, 0x07,
  0xBC, 0x70, 0x73, 0x03, 0xB8, 0x1D, 0xC0, 0xEC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x6E, 0x07, 0x70, 0x3B, 0x83, 0x8E, 0x38, 0x7F, 0xC0,
  0xFE, 0x00, 0x78, 0x01, 0xE0, 0x04, 0x00, 0x1F, 0x81, 0xFF, 0x8F, 0xFE,
  0x70, 0x73, 0x83, 0x9C, 0x1C, 0xC0, 0xEE, 0x07, 0x70, 0xF3, 0xFF, 0x1F,
  0xE0, 0xE3, 0x8E, 0x1C, 0x70, 0xE3, 0x83, 0x9C, 0x1C, 0xE0, 0xE6, 0x07,
  0x80, 0x07, 0xC0, 0xFF, 0x87, 0xBE, 0x70, 0x73, 0x83, 0x98, 0x00, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x70, 0x3B,
  0x81, 0xCE, 0x3E, 0x7F, 0xE0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0x8E, 0x0E, 0x30, 0x39,
  0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x31, 0xC1, 0xC6, 0x07, 0x38, 0x1C,
  0xE0, 0x73, 0x81, 0x8E, 0x0E, 0x1C, 0x70, 0x7F, 0xC0, 0x7C, 0x00, 0xE0,
  0x3F, 0x80, 0xE7, 0x07, 0x9C, 0x1C, 0x70, 0x71, 0xC3, 0x87, 0x0E, 0x1C,
  0x70, 0x71, 0xC0, 0xCE, 0x03, 0x38, 0x0E, 0xE0, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xE3, 0x1F, 0x9C, 0x6E, 0x71,
  0xB9, 0xCE, 0xE7, 0x3B, 0xBC, 0xCE, 0xF7, 0x33, 0xDC, 0xDB, 0x63, 0x6D,
  0x8D, 0xBE, 0x3C, 0xF8, 0xF3, 0xC3, 0xCF, 0x0E, 0x3C, 0x38, 0xF0, 0xE3,
  0x83, 0x8E, 0x00, 0x1E, 0x07, 0x87, 0x07, 0x83, 0x83, 0x80, 0xE3, 0x80,
  0x73, 0xC0, 0x19, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0xF7, 0x00, 0x73, 0x80, 0x70, 0xE0, 0x78,
  0x70, 0x78, 0x38, 0x78, 0x0E, 0x00, 0xF0, 0x3D, 0xC0, 0xE7, 0x07, 0x9C,
  0x1C, 0x38, 0xE0, 0xE7, 0x83, 0x9C, 0x06, 0xE0, 0x1F, 0x80, 0x7C, 0x01,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x04, 0xFF, 0xF1, 0xFF, 0xE0,
  0x0F, 0x87, 0xC3, 0xE3, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x03, 0x91, 0xF0, 0xF8, 0x00, 0xC3, 0x0E, 0x38, 0xE1, 0x86, 0x18, 0x71,
  0xC7, 0x0C, 0x30, 0xE3, 0x8E, 0x18, 0x61, 0x87, 0x0F, 0x87, 0xC7, 0xE0,
  0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x61, 0xF0, 0xF8,
  0x00, 0x06, 0x07, 0x03, 0xC3, 0xE1, 0xB1, 0xD8, 0xCE, 0xC3, 0xE1, 0xE0,
  0xC0, 0xFF, 0xFF, 0xFC, 0xE6, 0x30, 0x1F, 0xC3, 0xFE, 0x38, 0xF7, 0x07,
  0x00, 0x71, 0xFE, 0x7F, 0xEF, 0x0E, 0xE0, 0xEE, 0x0E, 0xE3, 0xEF, 0xFE,
  0x7E, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3F,
  0xC3, 0xFE, 0x78, 0xF7, 0x07, 0x70, 0x77, 0x07, 0x70, 0x76, 0x07, 0xE0,
  0x7E, 0x0E, 0xF1, 0xEF, 0xFC, 0xCF, 0x80, 0x0F, 0xC1, 0xFE, 0x38, 0x77,
  0x07, 0x70, 0x76, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x0E, 0x71, 0xE3,
  0xFC, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE1, 0xFB, 0x8F, 0xFC, 0x38, 0xF1, 0xC1, 0xC7, 0x07, 0x38, 0x1C,
  0xE0, 0x73, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0x71, 0xE1, 0xFF, 0x83, 0xEC,
  0x00, 0x0F, 0xC1, 0xFE, 0x38, 0x77, 0x07, 0x70, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0xE0, 0x07, 0x04, 0x78, 0xE3, 0xFE, 0x1F, 0x80, 0x01, 0xFC, 0x0F,
  0xE0, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x07, 0xFF, 0x3F, 0xF8, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0xDC, 0x7F, 0xF1, 0xC3,
  0x8E, 0x0E, 0x38, 0x38, 0xC0, 0xE7, 0x03, 0x9C, 0x0C, 0x70, 0x71, 0xC1,
  0xC3, 0x8F, 0x0F, 0xFC, 0x1F, 0x70, 0x01, 0x84, 0x0E, 0x38, 0x78, 0x7F,
  0xC0, 0xFC, 0x00, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x37, 0xE3, 0xFF, 0x78, 0x77, 0x07, 0x70, 0x77, 0x07, 0x70, 0x76, 0x07,
  0xE0, 0x6E, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xE0, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x0E, 0x01, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0xE1, 0xF8, 0x3E, 0x00, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE1, 0xE6, 0x1C, 0x71, 0xC3, 0x9C, 0x1F, 0xC0, 0xFC,
  0x07, 0xF0, 0x3F, 0x83, 0xCE, 0x1C, 0x78, 0xE1, 0xC7, 0x0F, 0x38, 0x38,
  0x1F, 0xC3, 0xF8, 0x7F, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x1F,
  0xFF, 0xFF, 0x80, 0x37, 0xF8, 0xFF, 0xF3, 0x39, 0xDC, 0xE7, 0x73, 0x9D,
  0xCE, 0x66, 0x31, 0x98, 0xC6, 0xE7, 0x3B, 0x9C, 0xEE, 0x73, 0xB9, 0xCE,
  0xC6, 0x30, 0x37, 0xE3, 0xFF, 0x78, 0x77, 0x07, 0x70, 0x77, 0x07, 0x70,
  0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xE0, 0x0F, 0xC3,
  0xFE, 0x38, 0xF7, 0x07, 0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0E, 0x71, 0xE7, 0xFC, 0x3F, 0x00, 0x1B, 0xE0, 0xFF, 0x8F, 0x1E, 0x70,
  0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE6, 0x07, 0x70, 0x33, 0x83, 0x9E, 0x3C,
  0xFF, 0xC7, 0xFC, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x1F, 0xB9, 0xFF, 0x8E, 0x1C, 0xE0, 0xE7, 0x07, 0x30, 0x3B, 0x81, 0xDC,
  0x1C, 0xE0, 0xE7, 0x07, 0x1C, 0x78, 0xFF, 0xC3, 0xEC, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x3B, 0xF3, 0xFF, 0x3F, 0x23, 0xC0,
  0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x00, 0x1F, 0xE3, 0xFF, 0x38, 0x77, 0x07, 0x38, 0x03, 0xF0, 0x1F,
  0xC0, 0x3E, 0x00, 0xEE, 0x06, 0xF0, 0xE7, 0xFC, 0x3F, 0x80, 0x0E, 0x01,
  0xC0, 0x38, 0x7F, 0xFF, 0xFE, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x78, 0x87, 0xF0, 0x7E, 0x70, 0x77, 0x07, 0xE0,
  0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0C, 0xC1, 0xCC, 0x1C, 0xE3,
  0xCF, 0xFC, 0x7D, 0xC0, 0xE0, 0x7F, 0x03, 0x98, 0x38, 0xC1, 0xC7, 0x1C,
  0x38, 0xC1, 0xCE, 0x06, 0x60, 0x37, 0x01, 0xF0, 0x0F, 0x80, 0x38, 0x01,
  0xC0, 0x00, 0xE3, 0x1F, 0x8C, 0x6E, 0x71, 0x99, 0xCE, 0x6D, 0x31, 0xB4,
  0xC6, 0xD7, 0x1E, 0x58, 0x79, 0x61, 0xC7, 0x87, 0x1C, 0x1C, 0x70, 0x61,
  0xC0, 0x3C, 0x1E, 0x38, 0x70, 0x39, 0xC0, 0x77, 0x80, 0x7E, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x39, 0xC0, 0xE3, 0x83, 0xC3, 0x8F,
  0x07, 0x80, 0x38, 0x0E, 0x70, 0x38, 0xE0, 0x70, 0xE1, 0xC1, 0xC7, 0x03,
  0x8E, 0x03, 0x38, 0x07, 0x70, 0x0F, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0xF8, 0x01, 0xE0, 0x00,
  0x1F, 0xFC, 0xFF, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0xFC, 0xFF, 0xF0, 0x00,
  0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x0E, 0x1E,
  0x0E, 0x07, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0xC0,
  0x70, 0x38, 0x0C, 0x30, 0xC6, 0x18, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x30,
  0xC3, 0x0C, 0x61, 0x86, 0x18, 0x61, 0x8C, 0x00, 0x0C, 0x03, 0x80, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0xC0, 0x3C, 0x07, 0x07,
  0xC3, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x0E,
  0x00, 0x3C, 0x01, 0xFC, 0x37, 0xF9, 0xF8, 0xFE, 0x41, 0xF0,
};

const GFXglyph RobotoMono_MediumItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 6, 18, 15, 4, -18 },
  { 15, 8, 6, 15, 4, -19 },
  { 21, 15, 18, 15, 0, -18 },
  { 55, 13, 24, 15, 1, -21 },
  { 94, 12, 18, 15, 2, -18 },
  { 121, 14, 18, 15, 0, -18 },
  { 153, 4, 7, 15, 6, -19 },
  { 157, 8, 26, 15, 4, -20 },
  { 183, 8, 26, 15, 2, -20 },
  { 209, 12, 13, 15, 2, -18 },
  { 229, 13, 13, 15, 1, -15 },
  { 251, 5, 8, 15, 2, -3 },
  { 256, 10, 2, 15, 3, -9 },
  { 259, 5, 4, 15, 4, -4 },
  { 262, 13, 20, 15, 1, -18 },
  { 295, 12, 18, 15, 2, -18 },
  { 322, 8, 18, 15, 3, -18 },
  { 340, 13, 18, 15, 0, -18 },
  { 370, 12, 18, 15, 1, -18 },
  { 397, 13, 18, 15, 0, -18 },
  { 427, 13, 18, 15, 1, -18 },
  { 457, 12, 18, 15, 1, -18 },
  { 484, 13, 18, 15, 2, -18 },
  { 514, 13, 18, 15, 1, -18 },
  { 544, 11, 18, 15, 2, -18 },
  { 569, 6, 14, 15, 5, -14 },
  { 580, 7, 19, 15, 4, -14 },
  { 597, 11, 12, 15, 2, -14 },
  { 614, 13, 8, 15, 1, -12 },
  { 627, 12, 11, 15, 1, -13 },
  { 644, 11, 18, 15, 3, -18 },
  { 669, 14, 18, 15, 1, -18 },
  { 701, 14, 18, 15, -1, -18 },
  { 733, 14, 18, 15, 0, -18 },
  { 765, 13, 18, 15, 1, -18 },
  { 795, 14, 18, 15, 0, -18 },
  { 827, 14, 18, 15, 1, -18 },
  { 859, 14, 18, 15, 1, -18 },
  { 891, 13, 18, 15, 1, -18 },
  { 921, 15, 18, 15, 0, -18 },
  { 955, 13, 18, 15, 1, -18 },
  { 985, 14, 18, 15, 1, -18 },
  { 1017, 16, 18, 15, 0, -18 },
  { 1053, 11, 18, 15, 1, -18 },
  { 1078, 15, 18, 15, 0, -18 },
  { 1112, 15, 18, 15, 0, -18 },
  { 1146, 13, 18, 15, 1, -18 },
  { 1176, 14, 18, 15, 1, -18 },
  { 1208, 13, 21, 15, 1, -18 },
  { 1243, 13, 18, 15, 1, -18 },
  { 1273, 13, 18, 15, 1, -18 },
  { 1303, 14, 18, 15, 2, -18 },
  { 1335, 14, 18, 15, 1, -18 },
  { 1367, 14, 18, 15, 2, -18 },
  { 1399, 14, 18, 15, 2, -18 },
  { 1431, 17, 18, 15, -1, -18 },
  { 1470, 14, 18, 15, 2, -18 },
  { 1502, 15, 18, 15, 0, -18 },
  { 1536, 9, 25, 15, 3, -21 },
  { 1565, 6, 20, 15, 5, -18 },
  { 1580, 9, 25, 15, 3, -21 },
  { 1609, 9, 10, 15, 3, -18 },
  { 1621, 11, 2, 15, 0, 0 },
  { 1624, 4, 3, 15, 7, -18 },
  { 1626, 12, 13, 15, 1, -13 },
  { 1646, 12, 19, 15, 1, -19 },
  { 1675, 12, 13, 15, 1, -13 },
  { 1695, 14, 19, 15, 1, -19 },
  { 1729, 12, 13, 15, 1, -13 },
  { 1749, 14, 19, 15, 2, -19 },
  { 1783, 14, 18, 15, 0, -13 },
  { 1815, 12, 19, 15, 1, -19 },
  { 1844, 11, 18, 15, 1, -18 },
  { 1869, 11, 23, 15, 1, -18 },
  { 1901, 13, 19, 15, 1, -19 },
  { 1932, 11, 19, 15, 1, -19 },
  { 1959, 14, 13, 15, 0, -13 },
  { 1982, 12, 13, 15, 1, -13 },
  { 2002, 12, 13, 15, 1, -13 },
  { 2022, 13, 18, 15, 0, -13 },
  { 2052, 13, 18, 15, 1, -13 },
  { 2082, 12, 13, 15, 2, -13 },
  { 2102, 12, 13, 15, 1, -13 },
  { 2122, 11, 16, 15, 2, -16 },
  { 2144, 12, 13, 15, 2, -13 },
  { 2164, 13, 13, 15, 2, -13 },
  { 2186, 14, 13, 15, 1, -13 },
  { 2209, 15, 13, 15, 0, -13 },
  { 2234, 15, 18, 15, 0, -13 },
  { 2268, 14, 13, 15, 0, -13 },
  { 2291, 9, 24, 15, 4, -20 },
  { 2318, 6, 23, 15, 4, -18 },
  { 2336, 10, 23, 15, 2, -19 },
  { 2365, 14, 5, 15, 0, -10 },
};

const GFXfont RobotoMono_MediumItalic25pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic25pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOMONO_MEDIUMITALIC25PT7B_H_
