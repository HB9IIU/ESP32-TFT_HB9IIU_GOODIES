#ifndef _ROBOTOMONO_MEDIUMITALIC55PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x01, 0xF0, 0x00, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x03, 0xEF,
  0x81, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF0, 0x3C, 0x78, 0x1E,
  0x7C, 0x0F, 0x3E, 0x0F, 0x9E, 0x07, 0xCF, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x07, 0x81, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0xF8, 0x7C, 0x04, 0x1E, 0x07, 0x81, 0xC3, 0xC0, 0xF0, 0x3C, 0x78,
  0x1E, 0x0F, 0x0F, 0x03, 0xC3, 0xE3, 0xE0, 0xF8, 0x78, 0x7C, 0x1F, 0x1E,
  0x07, 0x83, 0xC7, 0xC0, 0xFD, 0xF9, 0xF0, 0x1F, 0xFE, 0x3C, 0x01, 0xFF,
  0x8F, 0x00, 0x1F, 0xE3, 0xE0, 0x00, 0x60, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0xC0, 0x00, 0x78, 0xFF, 0x00, 0x1E, 0x3F, 0xF0,
  0x07, 0xCF, 0xFF, 0x00, 0xF3, 0xF3, 0xE0, 0x3C, 0x78, 0x3E, 0x0F, 0x9F,
  0x07, 0xC3, 0xE3, 0xE0, 0xF8, 0x78, 0x7C, 0x1F, 0x1E, 0x0F, 0x03, 0xE1,
  0xC1, 0xE0, 0x78, 0x10, 0x3C, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xFC,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x0F,
  0x80, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7C, 0x07, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0x9F, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x01, 0xF0, 0xFF, 0xFC, 0x0F, 0xC7, 0xFB, 0xF0, 0x3F, 0x1F, 0xCF, 0xE0,
  0xF8, 0xFE, 0x1F, 0x87, 0xE7, 0xF0, 0x7F, 0x1F, 0x9F, 0xC0, 0xFE, 0xFE,
  0x7E, 0x03, 0xFB, 0xF3, 0xF8, 0x07, 0xFF, 0xCF, 0xE0, 0x0F, 0xFE, 0x3F,
  0x80, 0x3F, 0xF0, 0xFE, 0x00, 0x7F, 0x81, 0xF8, 0x01, 0xFE, 0x07, 0xF0,
  0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xC1, 0xFC, 0x00, 0x70, 0x00,
  0x00, 0x3E, 0x7C, 0xF9, 0xF7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF1, 0xE7, 0xCF,
  0x9E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x80, 0x3C, 0x02, 0x38,
  0x0F, 0x03, 0x9F, 0x83, 0x87, 0xE7, 0xF9, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x1F,
  0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x3F, 0x01,
  0xFC, 0x07, 0xE0, 0x1E, 0x01, 0xF0, 0x03, 0x00, 0x30, 0x00, 0x40, 0x08,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x1F,
  0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x01, 0x80, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0xFC, 0x08, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFE,
  0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC,
  0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7F, 0x00,
  0x1F, 0xCF, 0xE0, 0x07, 0xF9, 0xF8, 0x01, 0xFF, 0x3F, 0x00, 0xFF, 0xE7,
  0xE0, 0x3F, 0xF8, 0xFC, 0x1F, 0xFF, 0x3F, 0x87, 0xF7, 0xE7, 0xF3, 0xF8,
  0xFC, 0xFC, 0xFE, 0x1F, 0x9F, 0xFF, 0x07, 0xF3, 0xFF, 0xC0, 0xFE, 0x7F,
  0xE0, 0x1F, 0x8F, 0xF8, 0x03, 0xF3, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x0F,
  0xCF, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0xC0, 0xFC, 0x07, 0xF0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x01, 0xE0, 0x03, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF,
  0xF9, 0xFF, 0xFC, 0xFF, 0xBF, 0x3F, 0x0F, 0xCE, 0x03, 0xF2, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x7F,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x00,
  0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFD,
  0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0,
  0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x30,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x3E, 0x00, 0xFC, 0xFF, 0xC0, 0x7E, 0xFF, 0xF8, 0x7E, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFC, 0x7F, 0xCF, 0xF8, 0x0F, 0xEF, 0xF0,
  0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xEF,
  0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFC,
  0x7F, 0x00, 0xFE, 0x3F, 0x81, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x20,
  0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x07, 0xF0,
  0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7F,
  0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x7F,
  0x00, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x83, 0xF0, 0x01,
  0xF8, 0x7F, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0xC7,
  0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x3F, 0x87, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0x80,
  0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0,
  0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF,
  0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF0, 0x0F, 0xF1,
  0xFC, 0x1F, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xBE,
  0x03, 0xFF, 0xBF, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x7E,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xF8, 0x3F, 0xC0,
  0xFC, 0x01, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF8, 0x06, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x00, 0xFE,
  0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x78, 0x3C, 0x0F,
  0x07, 0xFC, 0x38, 0x3E, 0x1F, 0xFC, 0x70, 0x78, 0x7F, 0xF8, 0xE1, 0xE1,
  0xF8, 0xF1, 0xE3, 0xC3, 0xC1, 0xC3, 0xCF, 0x0F, 0x83, 0x87, 0x9E, 0x1E,
  0x0F, 0x0F, 0x3C, 0x78, 0x1E, 0x1C, 0xF0, 0xF0, 0x38, 0x39, 0xE1, 0xE0,
  0x70, 0x73, 0xC7, 0xC1, 0xE1, 0xE7, 0x8F, 0x03, 0xC3, 0xCF, 0x1E, 0x07,
  0x07, 0x1C, 0x3C, 0x1E, 0x0E, 0x78, 0x78, 0x3C, 0x1C, 0xF0, 0xF0, 0x78,
  0x71, 0xE1, 0xE1, 0xF0, 0xE3, 0xC3, 0xE7, 0xE3, 0x87, 0x87, 0xFF, 0xFF,
  0x07, 0x87, 0xFB, 0xFC, 0x0F, 0x07, 0xC7, 0xF0, 0x1E, 0x02, 0x03, 0x80,
  0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x01, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0xC3, 0xE0,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x7F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F,
  0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xFC,
  0x7F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7E, 0x01, 0xFF, 0x80, 0xFC,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x07,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x07, 0xFC,
  0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF0,
  0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0xE0, 0xFC, 0x03, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0x7E,
  0x07, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7E, 0x3F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xC1, 0xFF, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80,
  0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01,
  0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F,
  0x0F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0x80, 0x1F, 0xE0,
  0x7E, 0x01, 0xFF, 0x01, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x1F, 0xFF, 0x3F, 0x00, 0xFF, 0xF9, 0xF8, 0x0F, 0xFF, 0xCF, 0xC0,
  0x7F, 0xFC, 0xFE, 0x03, 0xFF, 0xE7, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x01,
  0xF9, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x7F,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03,
  0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F,
  0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0x7E, 0x00,
  0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0x00, 0x0F,
  0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x3F, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFC, 0x07, 0xF8, 0x00,
  0x1F, 0x81, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x80, 0x00, 0x7E, 0x1F, 0xE0,
  0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x7E, 0x7F,
  0x80, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xC0,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x00,
  0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xDE, 0x1F,
  0xFC, 0x07, 0xDE, 0x1F, 0x7C, 0x0F, 0xDE, 0x3F, 0xFC, 0x0F, 0xDF, 0x3E,
  0xFC, 0x0F, 0xDF, 0x7E, 0xFC, 0x0F, 0xDF, 0x7C, 0xF8, 0x0F, 0xDF, 0x7C,
  0xF8, 0x0F, 0x9F, 0xF9, 0xF8, 0x1F, 0x8F, 0xF9, 0xF8, 0x1F, 0x8F, 0xF1,
  0xF8, 0x1F, 0x8F, 0xF1, 0xF8, 0x1F, 0x8F, 0xE1, 0xF0, 0x1F, 0x8F, 0xE3,
  0xF0, 0x1F, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0x83,
  0xF0, 0x3F, 0x07, 0x83, 0xF0, 0x3F, 0x07, 0x07, 0xE0, 0x3F, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xE0, 0x07,
  0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x80, 0x1F, 0x81, 0xFF, 0x80, 0x3F,
  0x03, 0xFF, 0x00, 0x7E, 0x07, 0xFE, 0x00, 0xFC, 0x0F, 0xFC, 0x03, 0xF8,
  0x1F, 0xFC, 0x07, 0xF0, 0x7F, 0xF8, 0x0F, 0xC0, 0xFF, 0xF0, 0x1F, 0x81,
  0xFB, 0xE0, 0x3F, 0x03, 0xF7, 0xE0, 0xFE, 0x07, 0xE7, 0xC1, 0xFC, 0x0F,
  0xCF, 0x83, 0xF8, 0x3F, 0x9F, 0x87, 0xE0, 0x7F, 0x1F, 0x0F, 0xC0, 0xFC,
  0x3E, 0x1F, 0x81, 0xF8, 0x7C, 0x7F, 0x03, 0xF0, 0xFC, 0xFE, 0x0F, 0xE0,
  0xF9, 0xF8, 0x1F, 0xC1, 0xF3, 0xF0, 0x3F, 0x83, 0xF7, 0xE0, 0x7E, 0x03,
  0xEF, 0xC0, 0xFC, 0x07, 0xFF, 0x81, 0xF8, 0x0F, 0xFF, 0x07, 0xF0, 0x1F,
  0xFC, 0x0F, 0xE0, 0x1F, 0xF8, 0x1F, 0x80, 0x3F, 0xF0, 0x3F, 0x00, 0x7F,
  0xE0, 0x7E, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0xFF, 0x83, 0xF8, 0x01, 0xFE,
  0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xF0,
  0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x00, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x07,
  0xF1, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0xFE, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x07,
  0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x80,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0xE0, 0x7E, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF0,
  0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0xC0,
  0x07, 0xF8, 0x7F, 0x00, 0x3F, 0xC1, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF0, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x7F, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F,
  0x9F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFE, 0xFC, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF,
  0x80, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x3F,
  0x81, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x10, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x7E, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80,
  0x1F, 0xE0, 0x3F, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x07,
  0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xC0, 0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF8,
  0xFE, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xFC, 0x07, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01,
  0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC,
  0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x0F,
  0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFC, 0x0F, 0xE0,
  0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x0F,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFD, 0xFC,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x01, 0xFC,
  0x1F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x01,
  0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x03,
  0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0xFE, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x07,
  0xC0, 0x7E, 0xFC, 0x0F, 0x81, 0xF9, 0xF0, 0x3F, 0x03, 0xF3, 0xE0, 0x7E,
  0x07, 0xE7, 0xC0, 0xFC, 0x0F, 0xCF, 0x83, 0xF8, 0x3F, 0x1F, 0x07, 0xF0,
  0x7E, 0x3E, 0x0F, 0xE0, 0xFC, 0x7C, 0x1F, 0xC1, 0xF0, 0xF8, 0x7F, 0x87,
  0xE1, 0xF0, 0xFF, 0x0F, 0xC7, 0xE1, 0xFE, 0x1F, 0x8F, 0xC7, 0xFC, 0x3E,
  0x1F, 0x8F, 0xF8, 0xFC, 0x3F, 0x1E, 0xF1, 0xF8, 0x7E, 0x7D, 0xE3, 0xE0,
  0xFC, 0xFB, 0xCF, 0xC1, 0xF9, 0xE7, 0x9F, 0x83, 0xF7, 0xCF, 0x3F, 0x07,
  0xEF, 0x9E, 0x7C, 0x0F, 0xDE, 0x3D, 0xF8, 0x1F, 0xBC, 0x7B, 0xF0, 0x3E,
  0xF8, 0xF7, 0xC0, 0x7D, 0xF1, 0xEF, 0x80, 0xFB, 0xC3, 0xFF, 0x01, 0xFF,
  0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F,
  0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F,
  0xC0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x80,
  0x7E, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x0F,
  0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF8,
  0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xBF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFE, 0x04, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x10, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x9F, 0x00, 0xF8,
  0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xE0, 0xF0, 0x7E, 0x07, 0xC3,
  0xE0, 0x3E, 0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x80, 0x3E, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0x87, 0xE0,
  0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFE,
  0x3F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xF8,
  0x1F, 0x9F, 0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xF8, 0x00, 0xFC, 0xFE,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xF3, 0xF8, 0x03, 0xFC,
  0xFF, 0x03, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0x7F, 0x03, 0xFF, 0x1F, 0xC0, 0x04, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x06, 0x00, 0x07, 0xE3, 0xFE, 0x00, 0x7E, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0x81, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F,
  0x80, 0x07, 0xF1, 0xF8, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF1, 0xF8, 0x00,
  0x7E, 0x3F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x80,
  0x3F, 0x87, 0xFC, 0x07, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0,
  0x7E, 0xFF, 0xFC, 0x07, 0xE7, 0xFF, 0x80, 0xFC, 0x3F, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFE, 0x03,
  0xF8, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xC0, 0x03, 0xF7, 0xF0,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x3F, 0x80,
  0x0F, 0xCF, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x38, 0x0F, 0xC0, 0x0F, 0xFC, 0x7E, 0x01, 0xFF, 0xF7, 0xF0, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFE,
  0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F,
  0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFE, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7E,
  0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80,
  0x3F, 0x80, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFD, 0xF8, 0x03, 0xFF, 0xCF, 0x80, 0x07, 0xFC, 0xFC, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1,
  0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xCF, 0xC0, 0x03,
  0xF7, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x81, 0xFC, 0x00, 0x70, 0x7F, 0x80,
  0x7E, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x08, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF,
  0x8F, 0xC0, 0x1F, 0xFE, 0x7E, 0x03, 0xFF, 0xFB, 0xF0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x00,
  0x0F, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x0F,
  0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xF9, 0xF8, 0x00, 0xFF, 0x9F, 0x80, 0x00, 0x40, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x80, 0x07, 0xF0, 0x0E, 0x00, 0x7F,
  0x80, 0xF8, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0x00, 0x07, 0xE1, 0xFF,
  0x00, 0x7E, 0x7F, 0xF8, 0x07, 0xEF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1,
  0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0xFE,
  0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x1F,
  0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x1F,
  0x80, 0x1F, 0xE0, 0x7E, 0x00, 0xFF, 0x01, 0xF8, 0x0F, 0xF8, 0x07, 0xE0,
  0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x00, 0xFC, 0x1F, 0xE0, 0x03, 0xF0, 0xFF,
  0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x3F, 0x3F, 0xC0, 0x00, 0xFD, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0x9F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8,
  0x1F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x60, 0x07, 0xE7, 0xE1,
  0xF8, 0x07, 0xFF, 0xF3, 0xFC, 0x07, 0xDF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xE1, 0xFC, 0x7F, 0x0F, 0xC1, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0,
  0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0,
  0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x03, 0xE0,
  0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0,
  0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1,
  0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1,
  0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83,
  0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x7E, 0x1F, 0xF0,
  0x07, 0xE7, 0xFF, 0x80, 0x7E, 0xFF, 0xFC, 0x07, 0xDF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F,
  0xC0, 0x07, 0xF1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00,
  0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00,
  0x0F, 0xC7, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xE0,
  0x03, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0, 0x01, 0xFC,
  0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0x7E, 0xFC, 0x00,
  0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x01,
  0xFC, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x3F,
  0x80, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0xE3, 0xFE, 0x00, 0x1F, 0xBF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0,
  0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x07,
  0xE0, 0x3F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC,
  0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x07,
  0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xBF, 0xFE, 0x00,
  0xFE, 0x3F, 0xE0, 0x03, 0xF8, 0x0C, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1F, 0xF8, 0xFC, 0x0F, 0xFF, 0x9F, 0x83, 0xFF, 0xFB, 0xF0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xF8, 0x0F, 0xF1, 0xFE, 0x00, 0xFE,
  0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xE7,
  0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFE, 0x3F,
  0x80, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x7F, 0x03, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xEF, 0xC0, 0x0F,
  0xF9, 0xF8, 0x00, 0x10, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xF8, 0x7F, 0xF0, 0x7E,
  0x3F, 0xF8, 0x1F, 0xBF, 0xFE, 0x07, 0xDF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFE,
  0x3F, 0xE1, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xCF,
  0xE0, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC,
  0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x08, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x0E, 0x00, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F,
  0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x8F, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF8,
  0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x8F,
  0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0xC3, 0xF8, 0x1F, 0xF0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0x3F,
  0x00, 0xFF, 0x87, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0xC3, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0,
  0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x01, 0xF8,
  0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x83, 0xF0,
  0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x7D, 0xF0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x07, 0x80, 0xFF, 0xF0, 0x3E, 0x03, 0xFF, 0xC0, 0xF8,
  0x0F, 0xBF, 0x03, 0xE0, 0x7E, 0xFC, 0x1F, 0x81, 0xFB, 0xF0, 0x7E, 0x07,
  0xCF, 0xC1, 0xF8, 0x3F, 0x3F, 0x0F, 0xE0, 0xFC, 0xFC, 0x3F, 0x83, 0xE3,
  0xF1, 0xEE, 0x1F, 0x8F, 0xC7, 0xBC, 0x7C, 0x3E, 0x1E, 0xF1, 0xF0, 0xF8,
  0xF3, 0xCF, 0xC3, 0xE3, 0xCF, 0x3E, 0x0F, 0x9F, 0x3C, 0xF8, 0x3E, 0x78,
  0xF7, 0xE0, 0xF9, 0xE3, 0xDF, 0x03, 0xEF, 0x0F, 0x7C, 0x0F, 0xBC, 0x3D,
  0xF0, 0x1E, 0xF0, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xF0,
  0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x01,
  0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x7E, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x3F, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01,
  0xFC, 0x7E, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0,
  0x3F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x80, 0x00,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x40, 0x7F, 0xFC, 0x00, 0xF8, 0xFF,
  0xFC, 0x01, 0xE3, 0xFF, 0xFC, 0x07, 0xCF, 0xFF, 0xFC, 0x1F, 0x9F, 0x83,
  0xFF, 0xFE, 0x3E, 0x01, 0xFF, 0xFC, 0x78, 0x01, 0xFF, 0xF1, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x30, 0x00,
};

const GFXglyph RobotoMono_MediumItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 13, 39, 32, 10, -39 },
  { 65, 17, 13, 32, 10, -41 },
  { 93, 32, 39, 32, 0, -39 },
  { 249, 28, 51, 32, 3, -45 },
  { 428, 27, 41, 32, 3, -40 },
  { 567, 30, 41, 32, 1, -40 },
  { 721, 7, 14, 32, 14, -41 },
  { 734, 18, 56, 32, 9, -44 },
  { 860, 19, 56, 32, 4, -44 },
  { 993, 26, 27, 32, 5, -39 },
  { 1081, 27, 28, 32, 3, -32 },
  { 1176, 11, 16, 32, 5, -6 },
  { 1198, 22, 5, 32, 6, -20 },
  { 1212, 9, 9, 32, 10, -8 },
  { 1223, 28, 42, 32, 3, -39 },
  { 1370, 27, 41, 32, 3, -40 },
  { 1509, 18, 39, 32, 7, -39 },
  { 1597, 29, 40, 32, 0, -40 },
  { 1742, 29, 41, 32, 1, -40 },
  { 1891, 28, 39, 32, 1, -39 },
  { 2028, 28, 40, 32, 3, -39 },
  { 2168, 25, 40, 32, 3, -39 },
  { 2293, 28, 39, 32, 4, -39 },
  { 2430, 28, 41, 32, 2, -40 },
  { 2574, 25, 40, 32, 4, -40 },
  { 2699, 13, 32, 32, 10, -31 },
  { 2751, 16, 41, 32, 8, -31 },
  { 2833, 25, 25, 32, 4, -30 },
  { 2912, 27, 16, 32, 3, -25 },
  { 2966, 26, 25, 32, 2, -29 },
  { 3048, 24, 40, 32, 7, -40 },
  { 3168, 31, 39, 32, 1, -39 },
  { 3320, 30, 39, 32, -2, -39 },
  { 3467, 31, 39, 32, 1, -39 },
  { 3619, 29, 41, 32, 2, -40 },
  { 3768, 30, 39, 32, 1, -39 },
  { 3915, 32, 39, 32, 1, -39 },
  { 4071, 31, 39, 32, 2, -39 },
  { 4223, 29, 41, 32, 2, -40 },
  { 4372, 31, 39, 32, 1, -39 },
  { 4524, 29, 39, 32, 2, -39 },
  { 4666, 30, 40, 32, 2, -39 },
  { 4816, 35, 39, 32, 1, -39 },
  { 4987, 25, 39, 32, 2, -39 },
  { 5109, 32, 39, 32, 1, -39 },
  { 5265, 31, 39, 32, 1, -39 },
  { 5417, 29, 41, 32, 2, -40 },
  { 5566, 30, 39, 32, 2, -39 },
  { 5713, 29, 47, 32, 2, -40 },
  { 5884, 31, 39, 32, 1, -39 },
  { 6036, 30, 41, 32, 2, -40 },
  { 6190, 31, 39, 32, 4, -39 },
  { 6342, 30, 40, 32, 3, -39 },
  { 6492, 29, 39, 32, 5, -39 },
  { 6634, 31, 39, 32, 4, -39 },
  { 6786, 36, 39, 32, -1, -39 },
  { 6962, 30, 39, 32, 5, -39 },
  { 7109, 32, 39, 32, 0, -39 },
  { 7265, 19, 54, 32, 7, -45 },
  { 7394, 13, 42, 32, 10, -39 },
  { 7463, 19, 54, 32, 7, -45 },
  { 7592, 21, 21, 32, 6, -39 },
  { 7648, 25, 5, 32, 0, 0 },
  { 7664, 10, 8, 32, 15, -40 },
  { 7674, 26, 31, 32, 2, -30 },
  { 7775, 28, 42, 32, 1, -41 },
  { 7922, 26, 31, 32, 3, -30 },
  { 8023, 29, 42, 32, 3, -41 },
  { 8176, 26, 31, 32, 3, -30 },
  { 8277, 29, 42, 32, 5, -42 },
  { 8430, 29, 42, 32, 1, -30 },
  { 8583, 28, 41, 32, 1, -41 },
  { 8727, 24, 40, 32, 3, -40 },
  { 8847, 25, 52, 32, 1, -40 },
  { 9010, 30, 41, 32, 1, -41 },
  { 9164, 25, 41, 32, 2, -41 },
  { 9293, 32, 30, 32, -1, -30 },
  { 9413, 28, 30, 32, 1, -30 },
  { 9518, 27, 31, 32, 2, -30 },
  { 9623, 30, 41, 32, -1, -30 },
  { 9777, 27, 41, 32, 3, -30 },
  { 9916, 26, 30, 32, 5, -30 },
  { 10014, 26, 31, 32, 3, -30 },
  { 10115, 24, 37, 32, 5, -36 },
  { 10226, 27, 30, 32, 3, -29 },
  { 10328, 28, 29, 32, 4, -29 },
  { 10430, 30, 29, 32, 3, -29 },
  { 10539, 32, 29, 32, 0, -29 },
  { 10655, 34, 41, 32, 0, -29 },
  { 10830, 29, 29, 32, 1, -29 },
  { 10936, 21, 53, 32, 8, -43 },
  { 11076, 12, 50, 32, 10, -39 },
  { 11151, 21, 53, 32, 5, -43 },
  { 11291, 31, 12, 32, 0, -22 },
};

const GFXfont RobotoMono_MediumItalic55pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic55pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOMONO_MEDIUMITALIC55PT7B_H_
