#ifndef _ROBOTOMONO_MEDIUMITALIC54PT7B_H_
#define _ROBOTOMONO_MEDIUMITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-MediumItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_MediumItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x07, 0xC0, 0x3E, 0x0F,
  0x3C, 0x0F, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01,
  0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF,
  0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x0F,
  0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x81, 0x87, 0x83,
  0xE0, 0x79, 0xE0, 0x78, 0x3C, 0xF8, 0x3E, 0x1F, 0x3E, 0x0F, 0x8F, 0x8F,
  0x83, 0xE3, 0xC3, 0xE0, 0xF1, 0xE0, 0x7C, 0x7C, 0xF8, 0x1F, 0xFE, 0x3C,
  0x03, 0xFF, 0x9E, 0x00, 0x7F, 0x8F, 0x80, 0x07, 0x83, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE3, 0xF8, 0x00, 0xF1, 0xFF,
  0x00, 0x7C, 0xFF, 0xE0, 0x1E, 0x7F, 0xFC, 0x0F, 0x3E, 0x1F, 0x07, 0x8F,
  0x83, 0xC3, 0xE3, 0xC0, 0xF0, 0xF0, 0xF0, 0x3C, 0x78, 0x3C, 0x0F, 0x1E,
  0x0F, 0x03, 0xC1, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x07,
  0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x80,
  0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x07, 0xF0,
  0x00, 0xFC, 0x7F, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x7C, 0x3F, 0xFF, 0x03,
  0xE3, 0xF9, 0xF8, 0x3F, 0x3F, 0x8F, 0xE1, 0xFB, 0xF8, 0x3F, 0x0F, 0x9F,
  0xC1, 0xFC, 0xFC, 0xFC, 0x07, 0xF7, 0xEF, 0xE0, 0x1F, 0xFE, 0x7F, 0x00,
  0xFF, 0xF3, 0xF8, 0x03, 0xFF, 0x1F, 0xC0, 0x1F, 0xF0, 0xFE, 0x00, 0x7F,
  0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE7, 0xF0, 0x0F, 0xFC, 0x3F, 0x80, 0x06,
  0x00, 0x02, 0x3E, 0x7C, 0xFB, 0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0xF3, 0xE7,
  0xCF, 0x1E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x60,
  0x3C, 0x03, 0x7C, 0x1E, 0x0F, 0xBF, 0x8F, 0x1F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x01, 0xF1, 0xE0,
  0x01, 0xF8, 0xF8, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x1F, 0x01, 0xFC, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1C, 0x01, 0xC0, 0x04, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x07, 0xE1,
  0xF8, 0x1E, 0x00, 0x80, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x10, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x7F,
  0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xF3, 0xF0, 0x03, 0xFC, 0xFC, 0x03, 0xFF, 0x3F, 0x01, 0xFF, 0xCF, 0xC1,
  0xFF, 0xF7, 0xF0, 0xFF, 0xFD, 0xF8, 0xFE, 0x7E, 0x7E, 0x7F, 0x1F, 0x9F,
  0xBF, 0x07, 0xE7, 0xFF, 0x81, 0xF9, 0xFF, 0xC0, 0x7E, 0x7F, 0xC0, 0x1F,
  0xBF, 0xE0, 0x0F, 0xEF, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7E,
  0x00, 0xFC, 0x1F, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF3,
  0xFF, 0xF9, 0xFF, 0xFD, 0xFF, 0xFE, 0xFE, 0x3F, 0x78, 0x1F, 0xB0, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xE1, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x7F,
  0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xE1, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8,
  0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x7E,
  0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0,
  0x0F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF9, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xC1, 0xFF, 0x00, 0x70, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0xE0, 0x3F, 0x7F,
  0xF8, 0x7E, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xC0,
  0xFE, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFE, 0x00,
  0xFE, 0x7E, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xE3, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0,
  0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x03, 0xFC,
  0x7F, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0x01, 0xF8,
  0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x1F,
  0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0x8F, 0xF0, 0x7F, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF7,
  0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7E,
  0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xCF, 0xE0, 0x1F,
  0xE7, 0xF8, 0x1F, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0x7E, 0x01, 0xFE, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xE0, 0x3F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xC0,
  0xFC, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x0F, 0xE0, 0x7F, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xF0, 0x1F,
  0x80, 0x20, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x1F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xCF, 0xF8, 0xFF, 0x9F, 0xC0, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x0E, 0x07, 0x81, 0xFC, 0x3C, 0x1E, 0x1F, 0xF8, 0xF0, 0xF0, 0xFF,
  0xF3, 0xC7, 0xC7, 0xF7, 0x8F, 0x1E, 0x1F, 0x0E, 0x1C, 0x78, 0xF8, 0x78,
  0x73, 0xC3, 0xC1, 0xE1, 0xCF, 0x1E, 0x07, 0x0F, 0x38, 0x78, 0x1C, 0x3D,
  0xE1, 0xE0, 0xF0, 0xF7, 0x8F, 0x03, 0xC3, 0x9E, 0x3C, 0x0E, 0x0E, 0x78,
  0xF0, 0x78, 0x39, 0xC3, 0xC1, 0xE1, 0xEF, 0x0F, 0x07, 0x87, 0x3C, 0x3C,
  0x1C, 0x1C, 0xF0, 0xF0, 0xF0, 0xF3, 0xC3, 0xC7, 0xC7, 0x8F, 0x0F, 0xFF,
  0xFC, 0x1C, 0x1F, 0xDF, 0xF0, 0x78, 0x7E, 0x3F, 0x81, 0xE0, 0xF0, 0x78,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x01, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x7E,
  0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x07, 0xE0,
  0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0x7E,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F,
  0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x7F, 0x03, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7E, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F,
  0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xF0, 0x7E, 0x00, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xF0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x03, 0xF8, 0x1F, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x00, 0xFE, 0x07,
  0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFE, 0x1F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0x87,
  0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x0F, 0xC0,
  0x3F, 0xE0, 0x7E, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7E,
  0x3F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xFE,
  0x3F, 0x01, 0xFF, 0xF1, 0xF8, 0x0F, 0xFF, 0x9F, 0xC0, 0x7F, 0xFC, 0xFE,
  0x03, 0xFF, 0xE7, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF1, 0xFC, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7F,
  0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0x81, 0xFE, 0x03, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07,
  0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0,
  0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7F,
  0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x01, 0xFC, 0x1F,
  0xC0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0xFE, 0x00,
  0x3F, 0xC0, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x0F, 0xF0, 0x03, 0xF0,
  0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x07, 0xE0, 0x3F, 0xC0, 0x01, 0xF8, 0x1F, 0xE0, 0x00,
  0x7E, 0x0F, 0xF0, 0x00, 0x1F, 0x87, 0xF8, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x03, 0xF1, 0xFE, 0x00, 0x00, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0x3F, 0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x3F,
  0xC1, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x07, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03,
  0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0xE0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFE,
  0x07, 0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0x78, 0xFB, 0xE0,
  0x7E, 0xF1, 0xF7, 0xC0, 0xFD, 0xE7, 0xCF, 0x81, 0xFB, 0xCF, 0xBF, 0x03,
  0xE7, 0xFE, 0x7E, 0x07, 0xCF, 0xFC, 0xFC, 0x1F, 0x9F, 0xF1, 0xF0, 0x3F,
  0x3F, 0xE3, 0xE0, 0x7E, 0x3F, 0x8F, 0xC0, 0xFC, 0x7F, 0x1F, 0x81, 0xF0,
  0xFC, 0x3F, 0x03, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xF8, 0x1F, 0x87,
  0xC3, 0xF0, 0x3F, 0x0F, 0x87, 0xE0, 0x7E, 0x1E, 0x0F, 0xC0, 0xFC, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xFC,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x07,
  0xE0, 0x7F, 0xC0, 0x0F, 0xC0, 0xFF, 0x80, 0x1F, 0x81, 0xFF, 0x00, 0x7F,
  0x03, 0xFF, 0x00, 0xFC, 0x07, 0xFE, 0x01, 0xF8, 0x0F, 0xFC, 0x03, 0xF0,
  0x3F, 0xF8, 0x07, 0xE0, 0x7E, 0xF8, 0x1F, 0xC0, 0xFD, 0xF0, 0x3F, 0x81,
  0xFB, 0xE0, 0x7E, 0x03, 0xF7, 0xE0, 0xFC, 0x0F, 0xE7, 0xC1, 0xF8, 0x1F,
  0xCF, 0x83, 0xF0, 0x3F, 0x1F, 0x0F, 0xE0, 0x7E, 0x1F, 0x1F, 0xC0, 0xFC,
  0x3E, 0x3F, 0x01, 0xF8, 0x7C, 0x7E, 0x07, 0xF0, 0xFC, 0xFC, 0x0F, 0xE0,
  0xF9, 0xF8, 0x1F, 0x81, 0xF7, 0xF0, 0x3F, 0x03, 0xEF, 0xC0, 0x7E, 0x03,
  0xFF, 0x80, 0xFC, 0x07, 0xFF, 0x03, 0xF8, 0x0F, 0xFE, 0x07, 0xF0, 0x1F,
  0xFC, 0x0F, 0xC0, 0x1F, 0xF8, 0x1F, 0x80, 0x3F, 0xE0, 0x3F, 0x00, 0x7F,
  0xC0, 0x7E, 0x00, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0x03, 0xF0, 0x01, 0xFE,
  0x07, 0xE0, 0x03, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xF7, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF3, 0xF0,
  0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0x7E,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x3F, 0x87, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x1F, 0xE0,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8,
  0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x0F,
  0xC0, 0x07, 0xF8, 0x1F, 0x80, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x1F,
  0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F,
  0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x7F,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F,
  0x00, 0x03, 0xF9, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x3F, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x7F,
  0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80,
  0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE,
  0x0F, 0xC0, 0x0F, 0xF0, 0x3F, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x03,
  0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0,
  0x7E, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x1F,
  0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F,
  0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xFC,
  0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F,
  0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x87,
  0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x03,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x1F, 0xC7,
  0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0,
  0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x1F,
  0xC0, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x00,
  0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF8,
  0x1F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0xFD, 0xF0, 0x3F, 0x03, 0xF7, 0xC0,
  0xFC, 0x0F, 0x9F, 0x03, 0xF0, 0x7E, 0x7C, 0x1F, 0xC1, 0xF9, 0xF0, 0x7F,
  0x07, 0xE7, 0xC1, 0xFC, 0x1F, 0x3F, 0x0F, 0xF0, 0xFC, 0xFC, 0x3F, 0xC3,
  0xF3, 0xF0, 0xFF, 0x0F, 0x8F, 0xC3, 0xFC, 0x7E, 0x3F, 0x1F, 0xF1, 0xF8,
  0xFC, 0x7F, 0xC7, 0xE3, 0xF1, 0xFF, 0x1F, 0x0F, 0xCF, 0xFC, 0xFC, 0x3F,
  0x3F, 0xF3, 0xF0, 0xFC, 0xF7, 0xCF, 0x83, 0xF7, 0xDF, 0x3E, 0x0F, 0x9F,
  0x7D, 0xF8, 0x3E, 0x79, 0xF7, 0xE0, 0xFB, 0xE7, 0xDF, 0x03, 0xEF, 0x9F,
  0x7C, 0x0F, 0xBC, 0x7F, 0xF0, 0x3E, 0xF1, 0xFF, 0x80, 0xFF, 0xC7, 0xFE,
  0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0x00,
  0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F,
  0xC1, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7E,
  0x3F, 0x80, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F,
  0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x7E,
  0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x00, 0x7F, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x3E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x3E,
  0x01, 0xF8, 0xF0, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7C,
  0x0F, 0x87, 0xE0, 0x3E, 0x3E, 0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x00, 0x7D,
  0xF8, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7E,
  0x0F, 0x81, 0xF0, 0x7C, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xE1,
  0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0x3F, 0x1F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7F,
  0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x0F, 0xF8, 0x7F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xF9, 0xF8, 0x0F,
  0xFC, 0x7E, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0xCF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0x3F, 0x07, 0xF0,
  0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xCF,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x03,
  0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0xE0, 0x7F, 0x87, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xE7, 0xFF, 0xC0, 0xFC, 0x3F, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0x83, 0xF8, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF,
  0x80, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xE7, 0xF0, 0x03,
  0xF1, 0xF8, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0xFE, 0x00, 0xFF, 0xE7, 0xE0, 0x0F, 0xFF, 0xBF, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0x87, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F,
  0x00, 0x7F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E,
  0x00, 0x3F, 0x83, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0x7E, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x07, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xDF, 0x80, 0x07, 0xF8, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0xFE,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x1F,
  0x1F, 0x80, 0x03, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x08, 0x0F, 0xE0, 0x07, 0x81, 0xFE, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC1, 0xF8,
  0x03, 0xFF, 0x8F, 0xC0, 0x3F, 0xFE, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x1F, 0xC0, 0x3F, 0xC1, 0xFC, 0x00,
  0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xF0, 0xFC,
  0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xF8,
  0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x1F, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0x7E, 0x00, 0x1F, 0xF3, 0xF0, 0x00, 0x08, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x30, 0x00, 0xFE, 0x01, 0xC0, 0x0F, 0xE0, 0x1F,
  0x00, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC7, 0xFE, 0x01, 0xFB, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0x87, 0xFC, 0x3F, 0xC0,
  0x3F, 0x87, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC7,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0xCF, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0,
  0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xF8,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x03, 0xFC, 0x1F, 0x80, 0x1F, 0xE0, 0x7E, 0x00, 0xFF, 0x01, 0xF8, 0x07,
  0xF8, 0x07, 0xE0, 0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x00, 0xFC, 0x1F, 0xE0,
  0x03, 0xF0, 0xFF, 0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x3F, 0x3F, 0xC0, 0x01,
  0xFD, 0xFE, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0x9F, 0x80, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0,
  0x1F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x07,
  0xE0, 0x07, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE7, 0xC1, 0xF0,
  0x0F, 0x9F, 0xE7, 0xF0, 0x1F, 0x7F, 0xDF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE1, 0xFC, 0x7F, 0x8F, 0xC3, 0xF0, 0x7E, 0x1F, 0x87,
  0xE0, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x07, 0xE0, 0xFC, 0x3E,
  0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x83, 0xE1, 0xF8, 0x3F, 0x07, 0xC3, 0xF0,
  0x7C, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0x83, 0xF0, 0x7E, 0x1F, 0x07,
  0xE0, 0xFC, 0x7E, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x83, 0xE1, 0xF8, 0x3E,
  0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xC1, 0xF8, 0x3F, 0x1F, 0x83, 0xF0,
  0x7E, 0x3F, 0x07, 0xE0, 0xF8, 0x7E, 0x0F, 0x81, 0xF0, 0xFC, 0x1F, 0x07,
  0xE1, 0xF0, 0x3E, 0x0F, 0xC3, 0xE0, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0x3F,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x7F, 0xE0, 0x1F, 0x3F, 0xFE, 0x03,
  0xEF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x7F, 0xC3, 0xFC, 0x03,
  0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7F,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0xC7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xE0,
  0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xFC,
  0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x01,
  0xF8, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC,
  0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F,
  0xDF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0,
  0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x0F, 0xCF, 0xFC, 0x00, 0x7D, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0x87, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F,
  0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC,
  0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0x7E,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00,
  0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xFE, 0x07, 0xF8,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0x7F, 0xFC, 0x03, 0xF8, 0xFF, 0x80, 0x1F, 0x80, 0x40, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x07, 0xE0, 0x3F, 0xF8, 0xF8, 0x0F, 0xFF, 0xBF, 0x03, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xE1, 0xFF, 0x8F, 0xF0, 0x0F, 0xF1, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0xFC,
  0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x7E, 0x00, 0x7F, 0x8F, 0xC0,
  0x01, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0xFF, 0x83, 0xF1, 0xFF, 0xC1, 0xF1, 0xFF, 0xE1, 0xFB,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xF8, 0x0C, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xE0, 0x3F, 0x83, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC7, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x1C, 0x00, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0x7F, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07,
  0xE1, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x1F, 0xF0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFD, 0xF0, 0x0F, 0xFE, 0x3E,
  0x00, 0xFF, 0x8F, 0xC0, 0x01, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x01,
  0xF8, 0xFC, 0x00, 0x7F, 0x0F, 0x80, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F,
  0x00, 0x7E, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0xFC,
  0x01, 0xF0, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x3F, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x07,
  0x80, 0xFF, 0xF0, 0x3E, 0x03, 0xEF, 0xC0, 0xF8, 0x1F, 0xBF, 0x03, 0xE0,
  0x7E, 0xFC, 0x1F, 0x81, 0xF3, 0xE0, 0x7E, 0x0F, 0xCF, 0x83, 0xF8, 0x3E,
  0x3E, 0x0F, 0xE0, 0xF8, 0xF8, 0x3F, 0x87, 0xE3, 0xE1, 0xFE, 0x1F, 0x0F,
  0x87, 0xF8, 0x7C, 0x3E, 0x1F, 0xE3, 0xF0, 0xF8, 0xF7, 0x8F, 0x83, 0xE3,
  0xDE, 0x3E, 0x0F, 0x9E, 0x79, 0xF8, 0x3E, 0x79, 0xE7, 0xC0, 0xF9, 0xE7,
  0x9F, 0x03, 0xEF, 0x0E, 0x78, 0x0F, 0xBC, 0x3B, 0xE0, 0x3E, 0xF0, 0xEF,
  0x80, 0xFF, 0x83, 0xBC, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x07,
  0xE0, 0x3F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x00,
  0xFE, 0x1F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x7F,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF8,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x0F, 0xBF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0x80,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x10, 0x00,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x03,
  0xC7, 0xFF, 0xC0, 0x1F, 0x3F, 0xFF, 0x80, 0x7C, 0xFF, 0xFF, 0x83, 0xE7,
  0xE0, 0xFF, 0xBF, 0x9F, 0x01, 0xFF, 0xFC, 0x78, 0x03, 0xFF, 0xF3, 0xE0,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoMono_MediumItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 12, 38, 32, 10, -38 },
  { 58, 16, 14, 32, 10, -41 },
  { 86, 32, 38, 32, 0, -38 },
  { 238, 27, 51, 32, 3, -45 },
  { 411, 26, 40, 32, 3, -39 },
  { 541, 29, 40, 32, 1, -39 },
  { 686, 7, 14, 32, 14, -41 },
  { 699, 19, 55, 32, 8, -43 },
  { 830, 19, 55, 32, 4, -43 },
  { 961, 25, 26, 32, 5, -38 },
  { 1043, 26, 28, 32, 3, -32 },
  { 1134, 11, 16, 32, 5, -6 },
  { 1156, 22, 5, 32, 6, -19 },
  { 1170, 8, 9, 32, 10, -8 },
  { 1179, 28, 41, 32, 2, -38 },
  { 1323, 26, 40, 32, 3, -39 },
  { 1453, 17, 38, 32, 7, -38 },
  { 1534, 28, 39, 32, 0, -39 },
  { 1671, 28, 40, 32, 1, -39 },
  { 1811, 27, 38, 32, 1, -38 },
  { 1940, 28, 39, 32, 3, -38 },
  { 2077, 24, 40, 32, 3, -39 },
  { 2197, 28, 38, 32, 4, -38 },
  { 2330, 28, 40, 32, 2, -39 },
  { 2470, 25, 39, 32, 4, -39 },
  { 2592, 13, 31, 32, 10, -30 },
  { 2643, 15, 40, 32, 8, -30 },
  { 2718, 25, 24, 32, 4, -29 },
  { 2793, 26, 17, 32, 3, -25 },
  { 2849, 26, 25, 32, 2, -29 },
  { 2931, 23, 39, 32, 7, -39 },
  { 3044, 30, 38, 32, 1, -38 },
  { 3187, 30, 38, 32, -2, -38 },
  { 3330, 30, 38, 32, 1, -38 },
  { 3473, 29, 40, 32, 2, -39 },
  { 3618, 29, 38, 32, 1, -38 },
  { 3756, 31, 38, 32, 1, -38 },
  { 3904, 31, 38, 32, 1, -38 },
  { 4052, 29, 40, 32, 2, -39 },
  { 4197, 31, 38, 32, 1, -38 },
  { 4345, 29, 38, 32, 2, -38 },
  { 4483, 29, 39, 32, 2, -38 },
  { 4625, 34, 38, 32, 1, -38 },
  { 4787, 24, 38, 32, 2, -38 },
  { 4901, 31, 38, 32, 1, -38 },
  { 5049, 31, 38, 32, 1, -38 },
  { 5197, 28, 40, 32, 2, -39 },
  { 5337, 31, 38, 32, 1, -38 },
  { 5485, 29, 46, 32, 2, -39 },
  { 5652, 30, 38, 32, 1, -38 },
  { 5795, 29, 40, 32, 2, -39 },
  { 5940, 30, 38, 32, 4, -38 },
  { 6083, 29, 39, 32, 3, -38 },
  { 6225, 29, 38, 32, 5, -38 },
  { 6363, 30, 38, 32, 4, -38 },
  { 6506, 35, 38, 32, -1, -38 },
  { 6673, 30, 38, 32, 5, -38 },
  { 6816, 32, 38, 32, 0, -38 },
  { 6968, 19, 53, 32, 7, -44 },
  { 7094, 13, 41, 32, 10, -38 },
  { 7161, 20, 53, 32, 6, -44 },
  { 7294, 21, 20, 32, 6, -38 },
  { 7347, 25, 5, 32, 0, 0 },
  { 7363, 10, 7, 32, 14, -39 },
  { 7372, 26, 30, 32, 2, -29 },
  { 7470, 27, 42, 32, 1, -41 },
  { 7612, 25, 30, 32, 3, -29 },
  { 7706, 29, 42, 32, 3, -41 },
  { 7859, 27, 30, 32, 2, -29 },
  { 7961, 28, 42, 32, 5, -42 },
  { 8108, 29, 40, 32, 1, -29 },
  { 8253, 27, 41, 32, 1, -41 },
  { 8392, 23, 39, 32, 3, -39 },
  { 8505, 25, 51, 32, 1, -39 },
  { 8665, 30, 41, 32, 1, -41 },
  { 8819, 25, 41, 32, 2, -41 },
  { 8948, 31, 29, 32, -1, -29 },
  { 9061, 27, 29, 32, 1, -29 },
  { 9159, 27, 30, 32, 2, -29 },
  { 9261, 29, 40, 32, -1, -29 },
  { 9406, 27, 40, 32, 3, -29 },
  { 9541, 25, 29, 32, 5, -29 },
  { 9632, 27, 30, 32, 2, -29 },
  { 9734, 24, 36, 32, 5, -35 },
  { 9842, 27, 30, 32, 3, -29 },
  { 9944, 27, 29, 32, 4, -29 },
  { 10042, 30, 29, 32, 3, -29 },
  { 10151, 32, 29, 32, 0, -29 },
  { 10267, 33, 41, 32, 0, -29 },
  { 10437, 29, 29, 32, 1, -29 },
  { 10543, 21, 52, 32, 8, -42 },
  { 10680, 11, 49, 32, 10, -38 },
  { 10748, 21, 52, 32, 5, -42 },
  { 10885, 30, 12, 32, 0, -22 },
};

const GFXfont RobotoMono_MediumItalic54pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_MediumItalic54pt7bBitmaps,
  (GFXglyph *)RobotoMono_MediumItalic54pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOMONO_MEDIUMITALIC54PT7B_H_
