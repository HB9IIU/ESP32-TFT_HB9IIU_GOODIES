#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC19PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x12, 0x22, 0x22, 0x24, 0x44, 0x00, 0x0C, 0xB6, 0xD0, 0x04, 0x81,
  0x20, 0x48, 0x24, 0x3F, 0xC2, 0x41, 0x20, 0x48, 0x12, 0x3F, 0xC2, 0x40,
  0x90, 0x44, 0x12, 0x00, 0x04, 0x08, 0x1C, 0x22, 0x41, 0x41, 0x40, 0x40,
  0x30, 0x08, 0x04, 0x02, 0x82, 0x84, 0x84, 0x78, 0x20, 0x20, 0x70, 0x48,
  0x24, 0x52, 0x49, 0x47, 0x20, 0x20, 0x20, 0x17, 0x14, 0x52, 0x29, 0x10,
  0x90, 0x30, 0x1C, 0x22, 0x22, 0x24, 0x24, 0x28, 0x30, 0x50, 0x89, 0x89,
  0x86, 0x86, 0x86, 0x7A, 0xF0, 0x08, 0x84, 0x44, 0x21, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x82, 0x10, 0x10, 0x82, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x11, 0x08, 0x44, 0x22, 0x20, 0x08, 0x13, 0x49, 0xE2, 0x89, 0x11, 0x00,
  0x08, 0x08, 0x08, 0x10, 0x10, 0xFE, 0x10, 0x10, 0x10, 0x20, 0x20, 0x29,
  0x40, 0xE0, 0xC0, 0x01, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x1C, 0x45, 0x0A, 0x14, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x14, 0x28, 0x8E, 0x00, 0x3D, 0x22, 0x22, 0x22, 0x44,
  0x44, 0x44, 0x0E, 0x11, 0x21, 0x21, 0x01, 0x01, 0x02, 0x04, 0x04, 0x08,
  0x10, 0x20, 0x40, 0xFE, 0x1C, 0x45, 0x0A, 0x10, 0x20, 0xC6, 0x02, 0x02,
  0x06, 0x0C, 0x28, 0x4F, 0x00, 0x01, 0x03, 0x05, 0x05, 0x0A, 0x12, 0x12,
  0x22, 0x42, 0x7F, 0x04, 0x04, 0x04, 0x04, 0x1F, 0x20, 0x20, 0x20, 0x40,
  0x7C, 0x42, 0x02, 0x02, 0x02, 0x82, 0x84, 0x44, 0x78, 0x0E, 0x20, 0x82,
  0x04, 0x0F, 0xB0, 0xC1, 0x83, 0x06, 0x0C, 0x28, 0x4F, 0x00, 0xFE, 0x04,
  0x10, 0x20, 0x81, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x00, 0x0E,
  0x08, 0x88, 0x24, 0x12, 0x11, 0x08, 0x78, 0x44, 0x41, 0x20, 0xA0, 0x50,
  0x44, 0x21, 0xE0, 0x1C, 0x45, 0x0A, 0x18, 0x30, 0x60, 0xA3, 0x3A, 0x04,
  0x10, 0x21, 0x8C, 0x00, 0x20, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x00,
  0x24, 0x48, 0x02, 0x18, 0xC6, 0x0C, 0x04, 0x06, 0x02, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x40, 0x40, 0x60, 0x20, 0x43, 0x18, 0x40, 0x74, 0x62, 0x10,
  0x84, 0x44, 0x42, 0x00, 0x00, 0x40, 0x07, 0xC0, 0x41, 0x84, 0x04, 0x40,
  0x14, 0x38, 0xA2, 0x06, 0x22, 0x31, 0x11, 0x90, 0x8C, 0x88, 0xA4, 0x45,
  0x26, 0x49, 0xCC, 0x40, 0x02, 0x00, 0x08, 0x00, 0x3E, 0x00, 0x01, 0x00,
  0xC0, 0x30, 0x14, 0x05, 0x02, 0x20, 0x88, 0x42, 0x10, 0x87, 0xE2, 0x09,
  0x02, 0x40, 0x90, 0x10, 0x3E, 0x21, 0x41, 0x41, 0x41, 0x42, 0x7C, 0x42,
  0x81, 0x81, 0x81, 0x82, 0x82, 0xFC, 0x1F, 0x10, 0x48, 0x28, 0x14, 0x02,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x50, 0x24, 0x21, 0xE0, 0x3E, 0x10,
  0x90, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x81, 0x40, 0xA0, 0x50, 0x48,
  0x47, 0xC0, 0x3F, 0x90, 0x10, 0x08, 0x04, 0x02, 0x01, 0xF8, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x07, 0xF0, 0x3F, 0x90, 0x10, 0x08, 0x04, 0x02,
  0x01, 0xF8, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x0F, 0x18,
  0x48, 0x28, 0x14, 0x02, 0x01, 0x01, 0x0F, 0x80, 0xC0, 0xA0, 0x50, 0x24,
  0x31, 0xE0, 0x20, 0x48, 0x14, 0x05, 0x01, 0x40, 0x90, 0x27, 0xF9, 0x02,
  0x80, 0xA0, 0x28, 0x12, 0x04, 0x81, 0x20, 0x40, 0x24, 0x94, 0x92, 0x4A,
  0x49, 0x00, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02,
  0x01, 0x20, 0x90, 0x44, 0x43, 0xC0, 0x20, 0x88, 0x44, 0x21, 0x10, 0x48,
  0x12, 0x05, 0x01, 0xC0, 0x48, 0x22, 0x08, 0x42, 0x10, 0x82, 0x20, 0x80,
  0x20, 0x84, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x83, 0xF0, 0x20,
  0x11, 0x00, 0x94, 0x0C, 0xA0, 0x65, 0x05, 0x28, 0x29, 0x42, 0x4A, 0x14,
  0x89, 0x24, 0x49, 0x22, 0x89, 0x14, 0x48, 0xC2, 0x42, 0x20, 0x20, 0x48,
  0x15, 0x05, 0x41, 0x50, 0x52, 0x24, 0x89, 0x12, 0x84, 0xA1, 0x28, 0x2A,
  0x0C, 0x81, 0x20, 0x40, 0x1F, 0x10, 0x48, 0x28, 0x14, 0x0A, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xA0, 0x50, 0x24, 0x21, 0xE0, 0x3E, 0x10, 0x90, 0x28,
  0x14, 0x0A, 0x09, 0x04, 0xFC, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00,
  0x1F, 0x10, 0x48, 0x28, 0x14, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xA0,
  0x50, 0x24, 0x21, 0xE0, 0x10, 0x04, 0x3E, 0x10, 0x90, 0x28, 0x14, 0x0A,
  0x09, 0x0C, 0xF8, 0x84, 0x42, 0x21, 0x10, 0x48, 0x24, 0x10, 0x0F, 0x04,
  0x22, 0x08, 0x81, 0x20, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x28, 0x0A,
  0x04, 0x43, 0x0F, 0x00, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x20, 0x50, 0x24, 0x09, 0x02, 0x40,
  0x90, 0x24, 0x0A, 0x04, 0x81, 0x20, 0x48, 0x12, 0x04, 0x42, 0x0F, 0x00,
  0x80, 0xC0, 0xA0, 0x50, 0x48, 0x24, 0x22, 0x10, 0x90, 0x48, 0x24, 0x14,
  0x0A, 0x06, 0x01, 0x00, 0x82, 0x0C, 0x10, 0x61, 0x85, 0x0C, 0x28, 0xA1,
  0x45, 0x12, 0x44, 0x92, 0x28, 0x91, 0x45, 0x0A, 0x28, 0x61, 0x43, 0x04,
  0x18, 0x20, 0x80, 0x20, 0x48, 0x21, 0x08, 0x44, 0x0A, 0x02, 0x80, 0x40,
  0x30, 0x14, 0x04, 0x82, 0x21, 0x08, 0x41, 0x20, 0x40, 0x81, 0x40, 0xA0,
  0x88, 0x44, 0x42, 0x40, 0xA0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02,
  0x00, 0x3F, 0xC0, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10,
  0x04, 0x02, 0x01, 0x00, 0x40, 0x3F, 0xC0, 0x18, 0x88, 0x42, 0x10, 0x84,
  0x22, 0x10, 0x84, 0x21, 0x10, 0x87, 0x00, 0x92, 0x48, 0x92, 0x49, 0x22,
  0x48, 0x18, 0x42, 0x11, 0x08, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x26,
  0x00, 0x10, 0x8A, 0x54, 0xA6, 0x20, 0xFE, 0x48, 0x80, 0x1E, 0x22, 0x01,
  0x02, 0x3E, 0x42, 0x82, 0x82, 0x86, 0x7A, 0x10, 0x20, 0x20, 0x20, 0x3E,
  0x21, 0x21, 0x41, 0x41, 0x41, 0x41, 0x42, 0x42, 0xBC, 0x3C, 0x8A, 0x0C,
  0x18, 0x10, 0x20, 0x42, 0x88, 0xE0, 0x01, 0x01, 0x01, 0x01, 0x3E, 0x42,
  0x82, 0x82, 0x82, 0x84, 0x84, 0x84, 0x8C, 0x74, 0x3C, 0x8A, 0x0C, 0x1F,
  0xF0, 0x20, 0x40, 0x80, 0xF0, 0x1C, 0x82, 0x08, 0xF1, 0x04, 0x10, 0x41,
  0x04, 0x20, 0x82, 0x00, 0x1F, 0x21, 0x41, 0x41, 0x41, 0x42, 0x42, 0x42,
  0x46, 0x3A, 0x02, 0x04, 0x84, 0x78, 0x10, 0x20, 0x20, 0x20, 0x2E, 0x31,
  0x21, 0x41, 0x41, 0x42, 0x42, 0x42, 0x42, 0x82, 0x20, 0x24, 0x94, 0x92,
  0x48, 0x04, 0x00, 0x02, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82,
  0x08, 0xC0, 0x10, 0x20, 0x20, 0x20, 0x21, 0x22, 0x24, 0x48, 0x70, 0x50,
  0x48, 0x48, 0x44, 0x84, 0x25, 0x24, 0x92, 0x92, 0x49, 0x00, 0x2E, 0x71,
  0x8C, 0x48, 0x42, 0x82, 0x14, 0x10, 0xA1, 0x05, 0x08, 0x28, 0x41, 0x82,
  0x14, 0x10, 0x80, 0x2E, 0x31, 0x21, 0x41, 0x41, 0x42, 0x42, 0x42, 0x42,
  0x82, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0x84, 0xF0, 0x3E, 0x21,
  0x21, 0x41, 0x41, 0x41, 0x41, 0x42, 0x42, 0xBC, 0x80, 0x80, 0x80, 0x80,
  0x3E, 0x86, 0x0C, 0x18, 0x30, 0xA1, 0x42, 0x8C, 0xE8, 0x10, 0x40, 0x81,
  0x00, 0x2C, 0xC2, 0x10, 0x41, 0x04, 0x10, 0x42, 0x00, 0x1C, 0x45, 0x01,
  0x01, 0x01, 0x80, 0xC1, 0x84, 0xF0, 0x22, 0x2F, 0x44, 0x44, 0x48, 0x88,
  0x60, 0x42, 0x85, 0x0C, 0x18, 0x30, 0xA1, 0x42, 0x8C, 0xE8, 0x83, 0x0A,
  0x12, 0x24, 0x89, 0x14, 0x28, 0x20, 0x40, 0x84, 0x30, 0x85, 0x31, 0x25,
  0x25, 0x28, 0xA5, 0x18, 0xA3, 0x18, 0x43, 0x08, 0x40, 0x41, 0x22, 0x24,
  0x18, 0x18, 0x10, 0x28, 0x48, 0x44, 0x84, 0x20, 0x90, 0x48, 0x42, 0x21,
  0x20, 0x90, 0x50, 0x28, 0x08, 0x04, 0x04, 0x02, 0x02, 0x06, 0x00, 0x3F,
  0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x40, 0xFC, 0x0C, 0x41, 0x08,
  0x20, 0x82, 0x08, 0x42, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x02, 0x00,
  0x12, 0x22, 0x22, 0x22, 0x44, 0x44, 0x44, 0x48, 0x80, 0x10, 0x40, 0x82,
  0x08, 0x20, 0x84, 0x08, 0x11, 0x84, 0x10, 0x82, 0x08, 0x21, 0x08, 0x00,
  0x70, 0xC4, 0x61, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 14, 4, 0, -14 },
  { 8, 3, 4, 5, 2, -14 },
  { 10, 10, 14, 9, 0, -14 },
  { 28, 8, 18, 9, 1, -16 },
  { 46, 9, 14, 12, 2, -14 },
  { 62, 8, 14, 10, 1, -14 },
  { 76, 1, 4, 3, 2, -14 },
  { 77, 5, 19, 5, 1, -15 },
  { 89, 5, 19, 5, -1, -15 },
  { 101, 7, 7, 8, 1, -14 },
  { 108, 8, 11, 9, 1, -12 },
  { 119, 3, 4, 3, -1, -2 },
  { 121, 3, 1, 5, 1, -7 },
  { 122, 2, 1, 4, 0, -1 },
  { 123, 8, 15, 6, -1, -14 },
  { 138, 7, 14, 9, 1, -14 },
  { 151, 4, 14, 9, 3, -14 },
  { 158, 8, 14, 9, 0, -14 },
  { 172, 7, 14, 9, 1, -14 },
  { 185, 8, 14, 9, 0, -14 },
  { 199, 8, 14, 9, 1, -14 },
  { 213, 7, 14, 9, 1, -14 },
  { 226, 7, 14, 9, 2, -14 },
  { 239, 9, 14, 9, 0, -14 },
  { 255, 7, 14, 9, 1, -14 },
  { 268, 3, 10, 4, 0, -10 },
  { 272, 4, 12, 3, -1, -10 },
  { 278, 7, 8, 8, 1, -10 },
  { 285, 7, 5, 9, 1, -9 },
  { 290, 7, 8, 8, 1, -10 },
  { 297, 5, 14, 7, 2, -14 },
  { 306, 13, 17, 15, 1, -13 },
  { 334, 10, 14, 10, -1, -14 },
  { 352, 8, 14, 10, 1, -14 },
  { 366, 9, 14, 10, 1, -14 },
  { 382, 9, 14, 11, 1, -14 },
  { 398, 9, 14, 9, 1, -14 },
  { 414, 9, 14, 9, 1, -14 },
  { 430, 9, 14, 11, 1, -14 },
  { 446, 10, 14, 11, 1, -14 },
  { 464, 3, 14, 4, 1, -14 },
  { 470, 9, 14, 9, 0, -14 },
  { 486, 10, 14, 10, 1, -14 },
  { 504, 6, 14, 8, 1, -14 },
  { 515, 13, 14, 14, 1, -14 },
  { 538, 10, 14, 11, 1, -14 },
  { 556, 9, 14, 11, 1, -14 },
  { 572, 9, 14, 10, 1, -14 },
  { 588, 9, 16, 11, 1, -14 },
  { 606, 9, 14, 10, 1, -14 },
  { 622, 10, 14, 10, 0, -14 },
  { 640, 8, 14, 10, 2, -14 },
  { 654, 10, 14, 11, 1, -14 },
  { 672, 9, 14, 10, 2, -14 },
  { 688, 13, 14, 14, 2, -14 },
  { 711, 10, 14, 10, 0, -14 },
  { 729, 9, 14, 10, 2, -14 },
  { 745, 10, 14, 10, 0, -14 },
  { 763, 5, 18, 4, 0, -15 },
  { 775, 3, 15, 6, 2, -14 },
  { 781, 5, 18, 4, -1, -15 },
  { 793, 5, 7, 7, 1, -14 },
  { 798, 7, 1, 7, -1, 0 },
  { 799, 3, 3, 5, 2, -15 },
  { 801, 8, 10, 9, 0, -10 },
  { 811, 8, 14, 9, 0, -14 },
  { 825, 7, 10, 8, 1, -10 },
  { 834, 8, 14, 9, 1, -14 },
  { 848, 7, 10, 8, 1, -10 },
  { 857, 6, 14, 5, 1, -14 },
  { 868, 8, 14, 9, 0, -10 },
  { 882, 8, 14, 9, 0, -14 },
  { 896, 3, 13, 4, 1, -13 },
  { 901, 6, 17, 4, -2, -13 },
  { 914, 8, 14, 8, 0, -14 },
  { 928, 3, 14, 4, 1, -14 },
  { 934, 13, 10, 14, 0, -10 },
  { 951, 8, 10, 9, 0, -10 },
  { 961, 7, 10, 9, 1, -10 },
  { 970, 8, 14, 9, 0, -10 },
  { 984, 7, 14, 9, 1, -10 },
  { 997, 6, 10, 6, 0, -10 },
  { 1005, 7, 10, 8, 0, -10 },
  { 1014, 4, 13, 5, 1, -13 },
  { 1021, 7, 10, 9, 1, -10 },
  { 1030, 7, 10, 8, 1, -10 },
  { 1039, 11, 10, 12, 1, -10 },
  { 1053, 8, 10, 8, 0, -10 },
  { 1063, 9, 14, 8, -1, -10 },
  { 1079, 8, 10, 8, 0, -10 },
  { 1089, 6, 19, 5, 1, -15 },
  { 1104, 4, 17, 4, 0, -14 },
  { 1113, 6, 19, 5, -1, -15 },
  { 1128, 9, 3, 11, 1, -7 },
};

const GFXfont RobotoCondensed_ExtraLightItalic19pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic19pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic19pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC19PT7B_H_
