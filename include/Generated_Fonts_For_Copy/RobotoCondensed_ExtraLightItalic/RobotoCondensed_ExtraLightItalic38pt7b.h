#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC38PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x30, 0xC2, 0x08, 0x20, 0x86, 0x18, 0x41, 0x04, 0x10, 0xC3,
  0x08, 0x20, 0x82, 0x18, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x66, 0xC9,
  0x12, 0x24, 0x49, 0xB3, 0x44, 0x00, 0x20, 0xC0, 0x04, 0x10, 0x01, 0x82,
  0x00, 0x20, 0xC0, 0x04, 0x10, 0x01, 0x82, 0x00, 0x20, 0xC0, 0x04, 0x10,
  0x1F, 0xFF, 0xE0, 0x20, 0xC0, 0x04, 0x10, 0x01, 0x82, 0x00, 0x20, 0xC0,
  0x04, 0x10, 0x01, 0x82, 0x00, 0x20, 0xC0, 0x04, 0x10, 0x01, 0x82, 0x03,
  0xFF, 0xFC, 0x04, 0x10, 0x01, 0x82, 0x00, 0x20, 0xC0, 0x04, 0x10, 0x01,
  0x82, 0x00, 0x20, 0xC0, 0x04, 0x10, 0x01, 0x82, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0xF8, 0x03, 0x8C, 0x06, 0x06,
  0x0C, 0x03, 0x08, 0x03, 0x08, 0x01, 0x18, 0x01, 0x18, 0x01, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x40, 0x04, 0x40, 0x04,
  0x40, 0x0C, 0x40, 0x08, 0x60, 0x18, 0x20, 0x30, 0x38, 0xE0, 0x0F, 0xC0,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x06, 0x60, 0x02, 0x08,
  0x01, 0x82, 0x00, 0x40, 0x81, 0x10, 0x20, 0xC4, 0x08, 0x21, 0x02, 0x10,
  0x40, 0x8C, 0x10, 0x62, 0x04, 0x11, 0x01, 0x98, 0x80, 0x3C, 0x60, 0x00,
  0x10, 0x00, 0x08, 0x70, 0x06, 0x62, 0x01, 0x10, 0xC0, 0x88, 0x10, 0x42,
  0x04, 0x30, 0x81, 0x08, 0x60, 0x44, 0x18, 0x13, 0x04, 0x0C, 0x81, 0x82,
  0x00, 0x21, 0x80, 0x0C, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xCC, 0x00,
  0xC3, 0x00, 0xC0, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x30, 0x08, 0x10,
  0x04, 0x10, 0x02, 0x18, 0x01, 0xB0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x3C,
  0x00, 0x22, 0x00, 0x21, 0x81, 0x30, 0x41, 0xB0, 0x30, 0x90, 0x08, 0x58,
  0x06, 0x6C, 0x01, 0x26, 0x00, 0xF3, 0x00, 0x30, 0x80, 0x38, 0x60, 0x36,
  0x1C, 0x71, 0x07, 0xE0, 0xC0, 0x49, 0x2D, 0xA4, 0x00, 0x40, 0x30, 0x18,
  0x0C, 0x02, 0x01, 0x80, 0x40, 0x20, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20,
  0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00,
  0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x02, 0x00, 0x80,
  0x10, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0,
  0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x60,
  0x10, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x00, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x1C, 0x21, 0xDE, 0x4E, 0x07,
  0xF0, 0x03, 0x00, 0x0F, 0x00, 0x32, 0x00, 0xC6, 0x03, 0x04, 0x04, 0x0C,
  0x18, 0x08, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x01, 0xFF, 0xFC, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x13, 0x33, 0x26, 0xC8, 0xFF, 0xF0, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x00, 0x01, 0xF0, 0x0E, 0x30, 0x30, 0x30, 0x40, 0x21,
  0x80, 0x42, 0x00, 0xCC, 0x01, 0x90, 0x03, 0x20, 0x06, 0xC0, 0x0D, 0x80,
  0x1A, 0x00, 0x24, 0x00, 0x48, 0x00, 0xB0, 0x03, 0x60, 0x06, 0x80, 0x0D,
  0x00, 0x12, 0x00, 0x24, 0x00, 0xC8, 0x01, 0x90, 0x02, 0x30, 0x0C, 0x60,
  0x30, 0x60, 0xC0, 0x63, 0x00, 0x7C, 0x00, 0x01, 0x0F, 0x39, 0xE3, 0x83,
  0x02, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C,
  0x08, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x01, 0xF8,
  0x03, 0x9C, 0x06, 0x06, 0x0C, 0x02, 0x18, 0x02, 0x10, 0x02, 0x10, 0x02,
  0x30, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xF8, 0x03, 0x9C, 0x06, 0x06, 0x0C, 0x02,
  0x18, 0x03, 0x10, 0x03, 0x10, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x70, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0xC0, 0x04, 0xC0, 0x04, 0xC0, 0x0C,
  0x40, 0x08, 0x60, 0x18, 0x60, 0x30, 0x38, 0xE0, 0x0F, 0x80, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x34, 0x00, 0x24, 0x00, 0x44,
  0x00, 0xCC, 0x00, 0x8C, 0x01, 0x0C, 0x03, 0x08, 0x06, 0x08, 0x04, 0x08,
  0x0C, 0x18, 0x18, 0x18, 0x10, 0x10, 0x20, 0x10, 0x60, 0x10, 0xC0, 0x10,
  0xFF, 0xFE, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x07, 0xFF, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x13, 0xE0, 0x1E, 0x70, 0x30, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18,
  0x40, 0x18, 0x60, 0x30, 0x20, 0x60, 0x38, 0xC0, 0x0F, 0x80, 0x00, 0x3C,
  0x03, 0xC0, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x8F, 0x86, 0xE7, 0x16, 0x06, 0x60, 0x09, 0x80, 0x2C, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xA0, 0x02, 0x80, 0x0B, 0x00,
  0x6C, 0x01, 0x10, 0x0C, 0x60, 0x60, 0xE7, 0x01, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x00, 0x00, 0xF8, 0x03, 0x9C, 0x06, 0x06, 0x0C, 0x03, 0x08, 0x03, 0x18,
  0x01, 0x18, 0x01, 0x10, 0x01, 0x10, 0x03, 0x18, 0x02, 0x18, 0x06, 0x0C,
  0x0C, 0x06, 0x38, 0x07, 0xE0, 0x1C, 0x38, 0x30, 0x08, 0x60, 0x0C, 0x40,
  0x04, 0xC0, 0x04, 0xC0, 0x04, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x08, 0x40,
  0x18, 0x60, 0x30, 0x38, 0xE0, 0x1F, 0x80, 0x07, 0xC0, 0x39, 0xC1, 0x81,
  0x8C, 0x06, 0x60, 0x09, 0x00, 0x34, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xA0, 0x02, 0x80, 0x1B, 0x00, 0x6C, 0x03, 0x98, 0x16, 0x31,
  0x90, 0x7C, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x18, 0x06, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x60, 0x80, 0x00, 0x04, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x20, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x10, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x08, 0x00, 0x00, 0x07, 0x81, 0xCC, 0x30, 0x62, 0x02,
  0x60, 0x34, 0x03, 0xC0, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0x87, 0x00, 0x07, 0x00, 0x30, 0x03, 0x00, 0x04,
  0x01, 0x80, 0x00, 0x80, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x04, 0x10, 0x00,
  0x01, 0x0C, 0x07, 0xC0, 0x46, 0x03, 0x18, 0x11, 0x01, 0x82, 0x04, 0xC0,
  0xC0, 0x81, 0x20, 0x20, 0x20, 0x48, 0x10, 0x18, 0x16, 0x04, 0x04, 0x05,
  0x03, 0x01, 0x01, 0x40, 0x80, 0x40, 0x50, 0x20, 0x30, 0x34, 0x18, 0x08,
  0x0B, 0x06, 0x02, 0x02, 0xC1, 0x01, 0x81, 0xB0, 0x40, 0x60, 0x4C, 0x10,
  0x28, 0x33, 0x06, 0x1A, 0x08, 0xC0, 0xCC, 0xCC, 0x10, 0x3C, 0x1E, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x68, 0x00,
  0x12, 0x00, 0x0C, 0x80, 0x02, 0x20, 0x01, 0x88, 0x00, 0x42, 0x00, 0x30,
  0xC0, 0x08, 0x30, 0x06, 0x04, 0x01, 0x01, 0x00, 0xC0, 0x40, 0x20, 0x10,
  0x18, 0x04, 0x04, 0x01, 0x83, 0x00, 0x60, 0xFF, 0xF8, 0x60, 0x02, 0x18,
  0x00, 0x84, 0x00, 0x23, 0x00, 0x08, 0x80, 0x03, 0x60, 0x00, 0xD0, 0x00,
  0x3C, 0x00, 0x0C, 0x07, 0xFC, 0x01, 0x03, 0xC0, 0x40, 0x10, 0x30, 0x06,
  0x0C, 0x00, 0x82, 0x00, 0x20, 0x80, 0x08, 0x20, 0x02, 0x08, 0x01, 0x86,
  0x00, 0x61, 0x80, 0x30, 0x40, 0x18, 0x10, 0x1C, 0x07, 0xFE, 0x03, 0x00,
  0xE0, 0xC0, 0x08, 0x30, 0x03, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04,
  0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x21, 0x00, 0x18, 0x40, 0x0C, 0x10,
  0x1E, 0x0F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xF3, 0xC0, 0x60, 0x18, 0x30,
  0x02, 0x08, 0x00, 0xC6, 0x00, 0x31, 0x00, 0x0C, 0xC0, 0x01, 0x20, 0x00,
  0x48, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x13, 0x00,
  0x0C, 0xC0, 0x02, 0x10, 0x01, 0x84, 0x00, 0x61, 0x80, 0x30, 0x30, 0x18,
  0x07, 0x1C, 0x00, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x81, 0xE0, 0x10, 0x06,
  0x06, 0x00, 0x40, 0xC0, 0x0C, 0x10, 0x00, 0x82, 0x00, 0x10, 0x40, 0x03,
  0x08, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x88, 0x00, 0x21, 0x00, 0x04,
  0x20, 0x00, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC4, 0x00, 0x10,
  0x80, 0x02, 0x10, 0x00, 0xC6, 0x00, 0x10, 0xC0, 0x06, 0x18, 0x01, 0x82,
  0x00, 0x60, 0x40, 0x18, 0x08, 0x1E, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xFC, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xFC,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x38,
  0xE0, 0x1C, 0x06, 0x02, 0x00, 0x60, 0xC0, 0x04, 0x30, 0x00, 0x84, 0x00,
  0x19, 0x80, 0x03, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x03, 0xFC, 0x40, 0x00,
  0x88, 0x00, 0x31, 0x00, 0x06, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02,
  0x18, 0x00, 0xC1, 0x00, 0x18, 0x30, 0x0E, 0x03, 0xCF, 0x80, 0x1F, 0x80,
  0x00, 0x04, 0x00, 0x08, 0x20, 0x00, 0xC1, 0x00, 0x06, 0x18, 0x00, 0x30,
  0xC0, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x06, 0x08, 0x00,
  0x30, 0xC0, 0x01, 0x06, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0x02, 0x0F,
  0xFF, 0xF0, 0xC0, 0x01, 0x86, 0x00, 0x08, 0x30, 0x00, 0x41, 0x00, 0x02,
  0x08, 0x00, 0x10, 0x40, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x41, 0x80,
  0x02, 0x08, 0x00, 0x10, 0x40, 0x01, 0x82, 0x00, 0x0C, 0x30, 0x00, 0x60,
  0x0C, 0x30, 0x82, 0x08, 0x21, 0x86, 0x10, 0x41, 0x0C, 0x30, 0xC2, 0x08,
  0x21, 0x86, 0x18, 0x41, 0x04, 0x30, 0xC3, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x80,
  0x08, 0x80, 0x18, 0x80, 0x10, 0x80, 0x30, 0xC0, 0x20, 0x40, 0x60, 0x79,
  0xC0, 0x1F, 0x00, 0x04, 0x00, 0x30, 0x40, 0x06, 0x04, 0x00, 0xC0, 0xC0,
  0x18, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x08, 0x0C, 0x00, 0x81, 0x80, 0x08,
  0x30, 0x01, 0x86, 0x00, 0x18, 0xC0, 0x01, 0x18, 0x00, 0x13, 0x80, 0x01,
  0x68, 0x00, 0x3C, 0xC0, 0x03, 0x84, 0x00, 0x30, 0x60, 0x02, 0x02, 0x00,
  0x20, 0x30, 0x02, 0x01, 0x00, 0x60, 0x18, 0x06, 0x00, 0x80, 0x60, 0x0C,
  0x04, 0x00, 0x60, 0x40, 0x06, 0x04, 0x00, 0x30, 0xC0, 0x03, 0x00, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x3F, 0xFE, 0x06, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x70, 0x60, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x0F, 0x00, 0x02, 0x82,
  0xC0, 0x01, 0xA0, 0x90, 0x00, 0x48, 0x24, 0x00, 0x36, 0x09, 0x00, 0x09,
  0x86, 0x60, 0x06, 0x41, 0x98, 0x01, 0x10, 0x42, 0x00, 0xC4, 0x10, 0x80,
  0x23, 0x04, 0x20, 0x10, 0xC3, 0x08, 0x04, 0x30, 0xC3, 0x02, 0x08, 0x30,
  0xC1, 0x82, 0x08, 0x10, 0x40, 0x82, 0x04, 0x30, 0x60, 0x81, 0x08, 0x18,
  0x60, 0x46, 0x06, 0x18, 0x19, 0x01, 0x06, 0x02, 0xC0, 0x41, 0x00, 0xA0,
  0x10, 0x40, 0x38, 0x0C, 0x10, 0x0C, 0x03, 0x0C, 0x03, 0x00, 0x80, 0x06,
  0x00, 0x08, 0x30, 0x00, 0x41, 0x80, 0x06, 0x1E, 0x00, 0x30, 0xD0, 0x01,
  0x86, 0xC0, 0x08, 0x26, 0x00, 0x41, 0x10, 0x02, 0x08, 0xC0, 0x30, 0xC2,
  0x01, 0x86, 0x10, 0x08, 0x30, 0xC0, 0x41, 0x02, 0x02, 0x08, 0x18, 0x30,
  0xC0, 0x41, 0x86, 0x02, 0x0C, 0x30, 0x18, 0x41, 0x00, 0x42, 0x08, 0x02,
  0x10, 0x40, 0x19, 0x86, 0x00, 0x4C, 0x30, 0x03, 0x61, 0x80, 0x0A, 0x08,
  0x00, 0x50, 0x40, 0x03, 0x82, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x00, 0xFC,
  0x00, 0xF3, 0xC0, 0x60, 0x18, 0x30, 0x02, 0x08, 0x00, 0xC6, 0x00, 0x11,
  0x00, 0x04, 0xC0, 0x01, 0x20, 0x00, 0x48, 0x00, 0x16, 0x00, 0x05, 0x80,
  0x01, 0x40, 0x00, 0xD0, 0x00, 0x34, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00,
  0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x04, 0xC0, 0x03, 0x30, 0x00, 0x84,
  0x00, 0x61, 0x80, 0x30, 0x30, 0x18, 0x07, 0x3C, 0x00, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x80, 0xE0, 0x10, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x04, 0x10,
  0x00, 0x82, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x43, 0x00, 0x18, 0x60,
  0x03, 0x08, 0x00, 0xC1, 0x00, 0x18, 0x20, 0x06, 0x0C, 0x07, 0x81, 0xFF,
  0xC0, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xF3, 0xC0, 0x60, 0x18, 0x30,
  0x02, 0x08, 0x00, 0xC6, 0x00, 0x13, 0x00, 0x04, 0xC0, 0x01, 0x20, 0x00,
  0x58, 0x00, 0x16, 0x00, 0x05, 0x80, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x34,
  0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x04, 0xC0, 0x03, 0x30, 0x00, 0x84, 0x00, 0x61, 0x80, 0x30, 0x30, 0x18,
  0x07, 0x3C, 0x00, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x07, 0xFE, 0x01, 0x01, 0xC0, 0xC0, 0x18, 0x30,
  0x03, 0x0C, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x18, 0x00,
  0x46, 0x00, 0x31, 0x80, 0x0C, 0x40, 0x06, 0x10, 0x01, 0x04, 0x00, 0xC3,
  0x01, 0xC0, 0xFF, 0xE0, 0x30, 0x10, 0x08, 0x06, 0x02, 0x01, 0x80, 0x80,
  0x20, 0x60, 0x0C, 0x18, 0x03, 0x04, 0x00, 0x41, 0x00, 0x18, 0x40, 0x06,
  0x10, 0x00, 0x8C, 0x00, 0x30, 0x00, 0xFC, 0x00, 0xF1, 0xC0, 0x60, 0x18,
  0x30, 0x02, 0x08, 0x00, 0xC6, 0x00, 0x31, 0x00, 0x0C, 0x40, 0x03, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x33,
  0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x8C, 0x00, 0x61, 0x80, 0x18, 0x60,
  0x1C, 0x0F, 0x1C, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x23, 0x00, 0x0C, 0x60, 0x01, 0x8C,
  0x00, 0x31, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x11, 0x80, 0x06, 0x30,
  0x00, 0xC4, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0xC0,
  0x03, 0x18, 0x00, 0x62, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x23, 0x00,
  0x0C, 0x60, 0x01, 0x8C, 0x00, 0x21, 0x80, 0x04, 0x10, 0x01, 0x83, 0x00,
  0x60, 0x60, 0x18, 0x07, 0x8E, 0x00, 0x3F, 0x00, 0x00, 0xC0, 0x00, 0xD0,
  0x00, 0x34, 0x00, 0x09, 0x00, 0x06, 0x40, 0x01, 0x18, 0x00, 0xC6, 0x00,
  0x21, 0x80, 0x18, 0x20, 0x04, 0x08, 0x03, 0x02, 0x00, 0x80, 0x80, 0x60,
  0x30, 0x18, 0x0C, 0x04, 0x01, 0x03, 0x00, 0x40, 0x80, 0x10, 0x60, 0x04,
  0x10, 0x01, 0x0C, 0x00, 0x62, 0x00, 0x19, 0x80, 0x02, 0x40, 0x00, 0xB0,
  0x00, 0x28, 0x00, 0x0A, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x80, 0x0C,
  0x00, 0xE0, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0A, 0x00, 0x50, 0x06, 0x80,
  0x34, 0x01, 0x30, 0x09, 0x00, 0x4C, 0x02, 0x40, 0x33, 0x01, 0x90, 0x08,
  0xC0, 0x44, 0x06, 0x30, 0x31, 0x01, 0x8C, 0x08, 0x60, 0x43, 0x02, 0x18,
  0x30, 0xC1, 0x86, 0x08, 0x10, 0x41, 0x82, 0x04, 0x30, 0x21, 0x81, 0x08,
  0x08, 0x40, 0x42, 0x02, 0x30, 0x11, 0x80, 0x8C, 0x04, 0x40, 0x22, 0x01,
  0x30, 0x09, 0x80, 0x48, 0x02, 0x40, 0x12, 0x00, 0x90, 0x05, 0x80, 0x2C,
  0x01, 0x40, 0x0E, 0x00, 0x50, 0x03, 0x80, 0x18, 0x00, 0xE0, 0x06, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x08, 0x08, 0x00, 0x60, 0x30, 0x03, 0x00, 0xC0,
  0x18, 0x01, 0x00, 0x40, 0x06, 0x03, 0x00, 0x08, 0x18, 0x00, 0x30, 0x40,
  0x00, 0xC3, 0x00, 0x01, 0x18, 0x00, 0x06, 0xC0, 0x00, 0x0A, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x16, 0x00, 0x00, 0xC8,
  0x00, 0x06, 0x30, 0x00, 0x10, 0x40, 0x00, 0x81, 0x80, 0x06, 0x06, 0x00,
  0x30, 0x08, 0x00, 0x80, 0x30, 0x06, 0x00, 0x40, 0x30, 0x01, 0x81, 0x80,
  0x06, 0x06, 0x00, 0x08, 0x00, 0x80, 0x01, 0xE0, 0x00, 0xB0, 0x00, 0xC8,
  0x00, 0xC6, 0x00, 0x43, 0x00, 0x60, 0x80, 0x60, 0x40, 0x20, 0x30, 0x30,
  0x08, 0x30, 0x04, 0x10, 0x03, 0x18, 0x01, 0x98, 0x00, 0x48, 0x00, 0x2C,
  0x00, 0x1C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xE0, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x0F, 0x80, 0x84, 0x31, 0x84, 0x21, 0x08, 0x43, 0x18, 0x42, 0x10, 0x84,
  0x31, 0x84, 0x21, 0x08, 0x63, 0x18, 0x42, 0x10, 0x80, 0x07, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0xF0, 0x00, 0x01, 0x00, 0xC0, 0x30,
  0x16, 0x0C, 0x82, 0x21, 0x88, 0x42, 0x30, 0x88, 0x36, 0x0D, 0x01, 0xC0,
  0x40, 0xFF, 0xFC, 0xC6, 0x23, 0x10, 0x03, 0xE0, 0x38, 0xE1, 0x80, 0xC4,
  0x03, 0x30, 0x04, 0x80, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x1F, 0xE1,
  0xC0, 0x98, 0x02, 0x40, 0x1B, 0x00, 0x68, 0x01, 0x20, 0x0C, 0x80, 0x33,
  0x03, 0x46, 0x3B, 0x0F, 0x8C, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x33, 0xE0,
  0x4E, 0x70, 0xA0, 0x21, 0x80, 0x66, 0x00, 0xCC, 0x00, 0x98, 0x01, 0x20,
  0x06, 0x40, 0x0C, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x4C, 0x00, 0x90, 0x03,
  0x20, 0x06, 0x40, 0x09, 0xC0, 0x33, 0x80, 0xC4, 0xC7, 0x08, 0xF8, 0x00,
  0x03, 0xF0, 0x1C, 0x70, 0x60, 0x30, 0x80, 0x63, 0x00, 0x44, 0x00, 0x98,
  0x01, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x01, 0x30, 0x06, 0x60, 0x08, 0x40, 0x30, 0xC0, 0xC0, 0xE7, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x07, 0xC4, 0x1C, 0x64,
  0x10, 0x14, 0x30, 0x0C, 0x60, 0x0C, 0x40, 0x0C, 0x40, 0x08, 0xC0, 0x08,
  0xC0, 0x08, 0x80, 0x08, 0x80, 0x18, 0x80, 0x18, 0x80, 0x10, 0x80, 0x10,
  0x80, 0x10, 0x80, 0x10, 0x80, 0x30, 0xC0, 0x70, 0x73, 0xA0, 0x3E, 0x20,
  0x03, 0xF0, 0x18, 0xE1, 0x80, 0xC4, 0x03, 0x30, 0x04, 0x80, 0x16, 0x00,
  0x50, 0x01, 0x40, 0x05, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0xC3, 0x8E, 0x03, 0xE0, 0x01,
  0xF0, 0x38, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08,
  0x07, 0xF8, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0xF1, 0x83, 0x8C, 0x83,
  0x01, 0x41, 0x80, 0x61, 0x80, 0x30, 0x80, 0x18, 0x40, 0x0C, 0x60, 0x04,
  0x30, 0x02, 0x10, 0x01, 0x08, 0x01, 0x84, 0x00, 0xC2, 0x00, 0x41, 0x00,
  0x20, 0x80, 0x10, 0x40, 0x18, 0x20, 0x0C, 0x18, 0x0E, 0x07, 0x3A, 0x01,
  0xF1, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x20, 0x30, 0x1C, 0x70, 0x03, 0xF0, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x31, 0xE0, 0x4E, 0x70, 0xB0, 0x61, 0x40, 0x43, 0x00, 0x8C, 0x01, 0x18,
  0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x13, 0x00, 0x66, 0x00, 0xCC, 0x01,
  0x10, 0x02, 0x20, 0x04, 0x40, 0x09, 0x80, 0x33, 0x00, 0x66, 0x00, 0x88,
  0x01, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x30, 0x40,
  0x81, 0x06, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0x41,
  0x83, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x04, 0xC0, 0x3C, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x0C, 0x40, 0x30, 0x80, 0xC1, 0x03, 0x02,
  0x0C, 0x0C, 0x30, 0x18, 0xC0, 0x23, 0x00, 0x4C, 0x00, 0xB8, 0x03, 0x90,
  0x06, 0x30, 0x0C, 0x20, 0x10, 0x60, 0x20, 0x40, 0x40, 0xC1, 0x80, 0xC3,
  0x01, 0x86, 0x01, 0x88, 0x03, 0x00, 0x04, 0x10, 0x43, 0x0C, 0x30, 0x82,
  0x08, 0x61, 0x86, 0x10, 0x41, 0x0C, 0x30, 0x82, 0x08, 0x21, 0x86, 0x10,
  0x41, 0x04, 0x30, 0xC0, 0x18, 0xF0, 0x3E, 0x09, 0x8C, 0x31, 0x85, 0x83,
  0x20, 0x63, 0x80, 0xA0, 0x13, 0x80, 0x70, 0x09, 0x80, 0x30, 0x04, 0xC0,
  0x18, 0x02, 0x40, 0x08, 0x01, 0x20, 0x04, 0x01, 0x90, 0x06, 0x00, 0xD8,
  0x03, 0x00, 0x6C, 0x01, 0x80, 0x24, 0x00, 0x80, 0x12, 0x00, 0x40, 0x09,
  0x00, 0x20, 0x0C, 0x80, 0x30, 0x06, 0xC0, 0x18, 0x03, 0x60, 0x08, 0x01,
  0x20, 0x04, 0x00, 0x90, 0x02, 0x00, 0x40, 0x18, 0xF0, 0x27, 0x38, 0x58,
  0x30, 0xA0, 0x21, 0x80, 0x46, 0x00, 0x8C, 0x01, 0x18, 0x02, 0x20, 0x04,
  0x40, 0x08, 0x80, 0x33, 0x00, 0x66, 0x00, 0x88, 0x01, 0x10, 0x02, 0x20,
  0x04, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x44, 0x00, 0x80, 0x03, 0xF0, 0x0E,
  0x70, 0x30, 0x30, 0xC0, 0x33, 0x00, 0x64, 0x00, 0x48, 0x00, 0xB0, 0x01,
  0x40, 0x02, 0x80, 0x0D, 0x00, 0x1A, 0x00, 0x2C, 0x00, 0x58, 0x01, 0x90,
  0x03, 0x20, 0x04, 0x60, 0x18, 0xC0, 0x60, 0xE3, 0x80, 0x7C, 0x00, 0x0C,
  0xF8, 0x09, 0xCE, 0x0A, 0x02, 0x0C, 0x03, 0x08, 0x03, 0x18, 0x01, 0x18,
  0x01, 0x10, 0x01, 0x10, 0x03, 0x10, 0x03, 0x10, 0x03, 0x30, 0x02, 0x30,
  0x02, 0x20, 0x06, 0x20, 0x06, 0x20, 0x04, 0x30, 0x0C, 0x70, 0x18, 0x6C,
  0x70, 0x47, 0xE0, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x07, 0xC4, 0x38, 0xC8, 0xC0,
  0x51, 0x80, 0x66, 0x00, 0xC8, 0x01, 0x90, 0x02, 0x60, 0x04, 0xC0, 0x09,
  0x00, 0x12, 0x00, 0x64, 0x00, 0xC8, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40,
  0x08, 0x80, 0x31, 0x80, 0xE1, 0xCE, 0x81, 0xF1, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x19, 0xE3, 0x74, 0x50, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x40, 0x00, 0x03, 0xE0, 0x3D, 0xC1, 0x81, 0x8C, 0x02, 0x20,
  0x0C, 0x80, 0x33, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x48, 0x01, 0x20, 0x04, 0xC0, 0x33, 0x01, 0x87,
  0xBC, 0x07, 0xC0, 0x0C, 0x08, 0x08, 0x08, 0x18, 0xFF, 0x18, 0x10, 0x10,
  0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x60, 0x38, 0x30, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22,
  0x00, 0xCC, 0x01, 0x98, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x33, 0x00,
  0x66, 0x00, 0xCC, 0x01, 0x10, 0x02, 0x20, 0x0C, 0x40, 0x18, 0xC0, 0x71,
  0x81, 0xE1, 0xCE, 0x81, 0xF1, 0x00, 0xC0, 0x0D, 0x00, 0x24, 0x01, 0x90,
  0x04, 0x40, 0x11, 0x80, 0xC6, 0x02, 0x08, 0x18, 0x20, 0x40, 0x83, 0x02,
  0x08, 0x0C, 0x60, 0x31, 0x00, 0xCC, 0x01, 0x20, 0x05, 0x80, 0x14, 0x00,
  0x50, 0x01, 0x80, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xF0, 0x18,
  0x05, 0x81, 0xE0, 0x6C, 0x0B, 0x02, 0x60, 0x58, 0x33, 0x04, 0xC1, 0x98,
  0x22, 0x08, 0x43, 0x10, 0xC2, 0x10, 0x84, 0x11, 0x84, 0x60, 0x88, 0x22,
  0x04, 0xC1, 0x10, 0x24, 0x09, 0x81, 0x20, 0x48, 0x0B, 0x03, 0xC0, 0x50,
  0x1C, 0x03, 0x80, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x10, 0x00, 0x0C, 0x01,
  0x06, 0x01, 0x81, 0x01, 0x80, 0xC1, 0x80, 0x20, 0x80, 0x18, 0xC0, 0x04,
  0xC0, 0x02, 0x40, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x28, 0x00,
  0x26, 0x00, 0x31, 0x00, 0x30, 0xC0, 0x10, 0x60, 0x18, 0x10, 0x18, 0x0C,
  0x18, 0x02, 0x08, 0x01, 0x80, 0x04, 0x00, 0xC1, 0x00, 0x30, 0x40, 0x08,
  0x10, 0x06, 0x06, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x08, 0x18, 0x02,
  0x04, 0x00, 0x83, 0x00, 0x20, 0x80, 0x0C, 0x60, 0x03, 0x10, 0x00, 0xCC,
  0x00, 0x12, 0x00, 0x05, 0x80, 0x01, 0x40, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x70, 0x0E, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x30, 0xC3, 0x08, 0x20,
  0x86, 0x18, 0x61, 0x04, 0x10, 0x43, 0x0C, 0x30, 0x82, 0x08, 0x61, 0x86,
  0x10, 0x41, 0x04, 0x30, 0xC3, 0x08, 0x20, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0x70,
  0x06, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03,
  0x00, 0xE0, 0x08, 0x00, 0x1E, 0x00, 0xCE, 0xE0, 0x26, 0x0C, 0x09, 0x01,
  0x06, 0x40, 0x33, 0x30, 0x07, 0x80,
};

const GFXglyph RobotoCondensed_ExtraLightItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 27, 7, 1, -27 },
  { 22, 7, 8, 10, 4, -29 },
  { 29, 19, 27, 18, 1, -27 },
  { 94, 16, 34, 18, 1, -31 },
  { 162, 18, 27, 24, 3, -27 },
  { 223, 17, 27, 20, 1, -27 },
  { 281, 3, 8, 6, 4, -29 },
  { 284, 10, 39, 10, 2, -30 },
  { 333, 10, 39, 11, -2, -30 },
  { 382, 15, 15, 16, 2, -27 },
  { 411, 15, 19, 18, 2, -22 },
  { 447, 4, 8, 7, -1, -3 },
  { 451, 8, 1, 10, 1, -13 },
  { 452, 2, 2, 8, 1, -2 },
  { 453, 15, 29, 13, -1, -27 },
  { 508, 15, 27, 18, 2, -27 },
  { 559, 8, 27, 18, 5, -27 },
  { 586, 16, 27, 18, 1, -27 },
  { 640, 16, 27, 18, 1, -27 },
  { 694, 16, 27, 18, 1, -27 },
  { 748, 16, 27, 18, 2, -27 },
  { 802, 14, 27, 18, 2, -27 },
  { 850, 15, 27, 18, 3, -27 },
  { 901, 16, 27, 18, 1, -27 },
  { 955, 14, 27, 18, 3, -27 },
  { 1003, 6, 20, 7, 0, -20 },
  { 1018, 7, 25, 7, -1, -20 },
  { 1040, 14, 15, 17, 2, -20 },
  { 1067, 14, 9, 18, 2, -17 },
  { 1083, 14, 15, 17, 1, -20 },
  { 1110, 12, 27, 15, 3, -27 },
  { 1151, 26, 34, 29, 1, -26 },
  { 1262, 18, 27, 20, -1, -27 },
  { 1323, 18, 27, 20, 1, -27 },
  { 1384, 18, 27, 21, 2, -27 },
  { 1445, 19, 27, 21, 1, -27 },
  { 1510, 19, 27, 18, 1, -27 },
  { 1575, 19, 27, 18, 1, -27 },
  { 1640, 19, 27, 22, 2, -27 },
  { 1705, 21, 27, 23, 1, -27 },
  { 1776, 6, 27, 9, 2, -27 },
  { 1797, 16, 27, 18, 1, -27 },
  { 1851, 20, 27, 20, 1, -27 },
  { 1919, 13, 27, 17, 1, -27 },
  { 1963, 26, 27, 28, 1, -27 },
  { 2051, 21, 27, 23, 1, -27 },
  { 2122, 18, 27, 22, 2, -27 },
  { 2183, 19, 27, 20, 1, -27 },
  { 2248, 18, 32, 22, 2, -27 },
  { 2320, 18, 27, 21, 1, -27 },
  { 2381, 18, 27, 19, 1, -27 },
  { 2442, 17, 27, 19, 4, -27 },
  { 2500, 19, 27, 21, 2, -27 },
  { 2565, 18, 27, 20, 3, -27 },
  { 2626, 26, 27, 29, 4, -27 },
  { 2714, 22, 27, 20, -1, -27 },
  { 2789, 17, 27, 19, 4, -27 },
  { 2847, 20, 27, 19, 0, -27 },
  { 2915, 11, 37, 8, 0, -31 },
  { 2966, 5, 29, 13, 4, -27 },
  { 2985, 10, 37, 8, -2, -31 },
  { 3032, 10, 13, 14, 2, -27 },
  { 3049, 14, 1, 14, -2, 0 },
  { 3051, 4, 5, 10, 5, -28 },
  { 3054, 14, 20, 17, 1, -20 },
  { 3089, 15, 29, 18, 1, -29 },
  { 3144, 15, 20, 17, 1, -20 },
  { 3182, 16, 29, 18, 2, -29 },
  { 3240, 14, 20, 17, 1, -20 },
  { 3275, 12, 29, 11, 2, -29 },
  { 3319, 17, 28, 18, 0, -20 },
  { 3379, 15, 29, 18, 1, -29 },
  { 3434, 7, 27, 7, 1, -27 },
  { 3458, 13, 35, 8, -5, -27 },
  { 3515, 15, 29, 16, 1, -29 },
  { 3570, 6, 29, 7, 1, -29 },
  { 3592, 25, 20, 28, 1, -20 },
  { 3655, 15, 20, 18, 1, -20 },
  { 3693, 15, 20, 18, 1, -20 },
  { 3731, 16, 28, 18, 0, -20 },
  { 3787, 15, 28, 18, 2, -20 },
  { 3840, 11, 20, 11, 1, -20 },
  { 3868, 14, 20, 16, 1, -20 },
  { 3903, 8, 25, 11, 2, -25 },
  { 3928, 15, 20, 18, 2, -20 },
  { 3966, 14, 20, 16, 2, -20 },
  { 4001, 21, 20, 24, 3, -20 },
  { 4054, 17, 20, 16, -1, -20 },
  { 4097, 18, 28, 16, -2, -20 },
  { 4160, 15, 20, 16, 0, -20 },
  { 4198, 12, 38, 11, 1, -30 },
  { 4255, 6, 32, 8, 1, -27 },
  { 4279, 12, 38, 11, -2, -30 },
  { 4336, 18, 6, 22, 2, -14 },
};

const GFXfont RobotoCondensed_ExtraLightItalic38pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic38pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic38pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC38PT7B_H_
