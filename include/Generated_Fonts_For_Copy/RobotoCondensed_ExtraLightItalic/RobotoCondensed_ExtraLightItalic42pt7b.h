#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC42PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x10, 0x20, 0xC1, 0x83, 0x04, 0x08, 0x10, 0x60, 0xC1,
  0x82, 0x04, 0x08, 0x30, 0x60, 0x81, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x0C, 0x18, 0x00, 0x46, 0x8D, 0x16, 0x2C, 0x59, 0xA3, 0x44, 0x88,
  0x00, 0x10, 0x30, 0x00, 0x81, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x02,
  0x04, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x08, 0x10, 0x00, 0xC1, 0x80,
  0xFF, 0xFF, 0xC0, 0x20, 0x40, 0x03, 0x02, 0x00, 0x18, 0x30, 0x00, 0x81,
  0x00, 0x04, 0x08, 0x00, 0x60, 0xC0, 0x02, 0x04, 0x00, 0x10, 0x20, 0x01,
  0x83, 0x00, 0x08, 0x10, 0x0F, 0xFF, 0xFC, 0x06, 0x0C, 0x00, 0x20, 0x40,
  0x01, 0x02, 0x00, 0x18, 0x30, 0x00, 0x81, 0x00, 0x04, 0x08, 0x00, 0x60,
  0xC0, 0x02, 0x04, 0x00, 0x10, 0x20, 0x00, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x18, 0x1C, 0x18, 0x06,
  0x08, 0x01, 0x0C, 0x00, 0xC6, 0x00, 0x62, 0x00, 0x31, 0x00, 0x18, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x40, 0x03, 0x20, 0x01, 0x90, 0x00, 0x88, 0x00, 0xC6, 0x00, 0x61, 0x00,
  0x60, 0xC0, 0x60, 0x3D, 0xE0, 0x07, 0xC0, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x07, 0x70, 0x00, 0x82, 0x00, 0x30,
  0x60, 0x04, 0x0C, 0x0D, 0x81, 0x81, 0x30, 0x30, 0x44, 0x04, 0x18, 0x80,
  0x82, 0x10, 0x10, 0x83, 0x06, 0x30, 0x61, 0x8C, 0x06, 0x61, 0x00, 0x78,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x87, 0x80, 0x31, 0x98, 0x0C,
  0x61, 0x81, 0x08, 0x10, 0x63, 0x02, 0x18, 0x40, 0x42, 0x08, 0x08, 0x81,
  0x01, 0x30, 0x20, 0x2C, 0x04, 0x0D, 0x00, 0x81, 0x00, 0x18, 0x60, 0x01,
  0xB8, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x06, 0x08, 0x01,
  0x81, 0x80, 0x20, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x10, 0x06,
  0x06, 0x00, 0xC1, 0x80, 0x08, 0x60, 0x01, 0x98, 0x00, 0x3C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x36, 0x00, 0x0C, 0x40, 0x63, 0x0C, 0x0C, 0xC0,
  0x81, 0x30, 0x18, 0x66, 0x01, 0x8C, 0x80, 0x31, 0x30, 0x03, 0x66, 0x00,
  0x28, 0xC0, 0x07, 0x08, 0x00, 0xC1, 0x80, 0x3C, 0x18, 0x0C, 0xC3, 0xEF,
  0x18, 0x1F, 0x81, 0x80, 0x2D, 0xB6, 0x96, 0xC0, 0x00, 0x10, 0x06, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40,
  0x18, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x02,
  0x06, 0x09, 0xE2, 0x3C, 0x3D, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xB0,
  0x00, 0x8C, 0x00, 0xC2, 0x00, 0xC1, 0x80, 0xC0, 0x40, 0x40, 0x20, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x8C,
  0x63, 0x31, 0x98, 0x80, 0xFF, 0x00, 0x5F, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00,
  0xF8, 0x01, 0xEF, 0x01, 0x81, 0x81, 0x80, 0x60, 0xC0, 0x10, 0xC0, 0x08,
  0x60, 0x04, 0x20, 0x03, 0x30, 0x01, 0x90, 0x00, 0xC8, 0x00, 0x4C, 0x00,
  0x26, 0x00, 0x13, 0x00, 0x19, 0x80, 0x0C, 0x80, 0x06, 0x40, 0x03, 0x60,
  0x01, 0x30, 0x00, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x23, 0x00, 0x31,
  0x80, 0x18, 0xC0, 0x08, 0x20, 0x0C, 0x18, 0x0C, 0x0C, 0x0C, 0x03, 0xDC,
  0x00, 0xFC, 0x00, 0x01, 0x83, 0xCF, 0x5E, 0x28, 0x10, 0x18, 0x0C, 0x06,
  0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x80, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xC0, 0xC0, 0xC0, 0x30, 0xC0, 0x18,
  0x40, 0x04, 0x60, 0x02, 0x30, 0x01, 0x10, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x30, 0x30,
  0x18, 0x06, 0x0C, 0x00, 0x82, 0x00, 0x21, 0x80, 0x0C, 0x60, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x7F,
  0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x08, 0x40,
  0x06, 0x18, 0x01, 0x06, 0x00, 0xC0, 0xC0, 0x60, 0x1E, 0xF0, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xA0, 0x00, 0x90,
  0x00, 0xD8, 0x00, 0xCC, 0x00, 0x46, 0x00, 0x62, 0x00, 0x61, 0x00, 0x21,
  0x80, 0x30, 0xC0, 0x30, 0x60, 0x30, 0x30, 0x10, 0x10, 0x18, 0x08, 0x18,
  0x0C, 0x08, 0x06, 0x0C, 0x03, 0x0C, 0x01, 0x8C, 0x00, 0x87, 0xFF, 0xFC,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x7C, 0x03, 0xFF, 0x01, 0xC0, 0xC0, 0x80,
  0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x22, 0x00, 0x31, 0x00, 0x18, 0x80, 0x08, 0x60, 0x0C,
  0x30, 0x0C, 0x0C, 0x0C, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00,
  0xFC, 0x07, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC7, 0xC1, 0x3F, 0xC2, 0xC0, 0xCE, 0x00, 0xDC,
  0x01, 0xB0, 0x01, 0x40, 0x02, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x02, 0xC0, 0x0C, 0x80, 0x11, 0x80, 0x61,
  0x81, 0x81, 0xDE, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xC0, 0x30, 0x18, 0x18, 0x06, 0x04, 0x00, 0xC3, 0x00, 0x30,
  0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x20, 0x80, 0x18, 0x30,
  0x0C, 0x06, 0x06, 0x00, 0xEF, 0x00, 0x3F, 0x00, 0x38, 0x70, 0x18, 0x06,
  0x0C, 0x00, 0x86, 0x00, 0x31, 0x80, 0x0C, 0x40, 0x03, 0x30, 0x00, 0xCC,
  0x00, 0x33, 0x00, 0x0C, 0xC0, 0x06, 0x10, 0x01, 0x86, 0x00, 0xC0, 0xC0,
  0x60, 0x1E, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x30, 0x30,
  0xC0, 0x33, 0x00, 0x64, 0x00, 0xD8, 0x00, 0xA0, 0x01, 0x40, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xA0, 0x07,
  0x60, 0x14, 0xC0, 0x68, 0xF7, 0x30, 0x7C, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x07, 0xE0,
  0x0F, 0x00, 0x00, 0x08, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0xC3, 0x00, 0x02, 0x07, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x80,
  0x00, 0x02, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x08, 0x3F, 0xFF, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFC, 0x10, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x80, 0x00, 0x0F, 0x81, 0xFE, 0x30, 0x66, 0x03, 0xC0, 0x3C,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x08, 0x60, 0x0F,
  0x80, 0x43, 0x01, 0xEE, 0x02, 0x30, 0x18, 0x18, 0x11, 0x80, 0x80, 0x80,
  0x88, 0x0C, 0x04, 0x04, 0xC0, 0xC0, 0x60, 0x24, 0x04, 0x03, 0x01, 0x20,
  0x60, 0x10, 0x0B, 0x03, 0x00, 0x80, 0xD8, 0x10, 0x0C, 0x06, 0x80, 0x80,
  0x60, 0x24, 0x0C, 0x02, 0x01, 0x20, 0x60, 0x10, 0x19, 0x02, 0x01, 0x80,
  0xD8, 0x10, 0x0C, 0x04, 0xC0, 0x80, 0xE0, 0x66, 0x04, 0x0F, 0x02, 0x10,
  0x30, 0xD8, 0x20, 0x80, 0xDC, 0x66, 0x04, 0x07, 0xC1, 0xE0, 0x20, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x01, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x05, 0x00, 0x00, 0xD0, 0x00, 0x09, 0x00, 0x01, 0x90, 0x00, 0x19,
  0x80, 0x01, 0x18, 0x00, 0x31, 0x80, 0x02, 0x08, 0x00, 0x60, 0x80, 0x04,
  0x08, 0x00, 0xC0, 0x80, 0x08, 0x0C, 0x01, 0x80, 0xC0, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x04, 0x06, 0x00, 0x40, 0x40, 0x04, 0x0F, 0xFF, 0xE0,
  0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0x63, 0x00, 0x02,
  0x60, 0x00, 0x26, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x03, 0xFE,
  0x00, 0xC1, 0xF0, 0x18, 0x03, 0x03, 0x00, 0x30, 0x40, 0x06, 0x08, 0x00,
  0x41, 0x00, 0x08, 0x60, 0x01, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x20, 0x03,
  0x04, 0x00, 0x61, 0x80, 0x38, 0x30, 0x3C, 0x07, 0xFF, 0x80, 0xC0, 0x38,
  0x10, 0x01, 0x82, 0x00, 0x10, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C,
  0x60, 0x01, 0x88, 0x00, 0x31, 0x00, 0x04, 0x60, 0x01, 0x8C, 0x00, 0x21,
  0x80, 0x0C, 0x20, 0x07, 0x04, 0x07, 0xC0, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0x78, 0x03, 0x80, 0xC0, 0x60, 0x06, 0x0C, 0x00, 0x20, 0xC0,
  0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x10, 0x00, 0x33, 0x00, 0x01, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0xC4, 0x00, 0x0C, 0x40, 0x00, 0x84, 0x00, 0x18, 0x60, 0x01,
  0x86, 0x00, 0x30, 0x30, 0x06, 0x03, 0x80, 0xC0, 0x1F, 0xF8, 0x00, 0x7E,
  0x00, 0x03, 0xFE, 0x00, 0x30, 0x7C, 0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0,
  0x40, 0x03, 0x02, 0x00, 0x18, 0x10, 0x00, 0x41, 0x80, 0x03, 0x0C, 0x00,
  0x18, 0x60, 0x00, 0xC2, 0x00, 0x06, 0x10, 0x00, 0x31, 0x80, 0x01, 0x0C,
  0x00, 0x08, 0x60, 0x00, 0x43, 0x00, 0x06, 0x10, 0x00, 0x30, 0x80, 0x01,
  0x8C, 0x00, 0x08, 0x60, 0x00, 0x43, 0x00, 0x06, 0x10, 0x00, 0x30, 0x80,
  0x01, 0x04, 0x00, 0x18, 0x60, 0x01, 0x83, 0x00, 0x1C, 0x18, 0x01, 0xC0,
  0x80, 0x1C, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0xF8, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x0C, 0x00, 0x61, 0x80,
  0x02, 0x10, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x32, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x3F, 0xCC, 0x03, 0xFC, 0xC0, 0x00, 0xC8, 0x00, 0x0C,
  0x80, 0x00, 0xC8, 0x00, 0x08, 0x80, 0x00, 0x8C, 0x00, 0x18, 0xC0, 0x01,
  0x84, 0x00, 0x18, 0x60, 0x03, 0x83, 0x00, 0xF0, 0x1F, 0xFC, 0x00, 0x7E,
  0x00, 0x02, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x30, 0x40, 0x00, 0x60, 0x80, 0x00, 0xC1, 0x00, 0x01, 0x06, 0x00, 0x02,
  0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x20, 0x00, 0x30, 0x40, 0x00, 0x41,
  0x80, 0x00, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0C, 0x00, 0x0C, 0x10,
  0x00, 0x18, 0x20, 0x00, 0x20, 0xC0, 0x00, 0x41, 0x80, 0x00, 0x83, 0x00,
  0x03, 0x04, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x10, 0x60, 0x00,
  0x20, 0xC0, 0x00, 0x41, 0x80, 0x01, 0x82, 0x00, 0x03, 0x04, 0x00, 0x06,
  0x08, 0x00, 0x08, 0x00, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x83, 0x04, 0x08,
  0x10, 0x60, 0xC1, 0x82, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18,
  0x30, 0x60, 0x81, 0x06, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x30, 0x01, 0x88, 0x00, 0x43, 0x00,
  0x30, 0xC0, 0x0C, 0x30, 0x06, 0x04, 0x01, 0x01, 0x81, 0xC0, 0x3D, 0xE0,
  0x07, 0xE0, 0x00, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x18, 0x00, 0xC0,
  0x30, 0x03, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x30, 0x01, 0x00, 0xC0, 0x06,
  0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x20, 0xC0, 0x00, 0x43,
  0x80, 0x01, 0x8E, 0x00, 0x03, 0x38, 0x00, 0x06, 0xF0, 0x00, 0x0F, 0x30,
  0x00, 0x1C, 0x60, 0x00, 0x30, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0,
  0x03, 0x01, 0x80, 0x04, 0x01, 0x80, 0x08, 0x03, 0x00, 0x10, 0x03, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x04, 0x02, 0x00, 0x0C, 0x04,
  0x00, 0x08, 0x08, 0x00, 0x18, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x07, 0xFF,
  0xEF, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x58, 0x00, 0x0D, 0x02, 0xC0, 0x00,
  0x58, 0x16, 0x00, 0x06, 0xC1, 0x90, 0x00, 0x26, 0x0C, 0x80, 0x03, 0x20,
  0x64, 0x00, 0x11, 0x02, 0x30, 0x01, 0x88, 0x11, 0x80, 0x08, 0xC1, 0x8C,
  0x00, 0xC6, 0x0C, 0x20, 0x04, 0x30, 0x61, 0x00, 0x61, 0x03, 0x08, 0x02,
  0x08, 0x10, 0x60, 0x30, 0xC0, 0x83, 0x01, 0x06, 0x0C, 0x18, 0x18, 0x30,
  0x60, 0x40, 0x81, 0x83, 0x02, 0x0C, 0x08, 0x18, 0x10, 0x40, 0x40, 0x80,
  0xC6, 0x06, 0x04, 0x06, 0x60, 0x30, 0x60, 0x13, 0x01, 0x83, 0x00, 0xB0,
  0x0C, 0x18, 0x05, 0x80, 0x40, 0x80, 0x38, 0x02, 0x04, 0x01, 0xC0, 0x30,
  0x20, 0x0C, 0x01, 0x80, 0x02, 0x00, 0x03, 0x07, 0x00, 0x02, 0x07, 0x00,
  0x02, 0x07, 0x80, 0x06, 0x07, 0x80, 0x06, 0x04, 0x80, 0x06, 0x0C, 0xC0,
  0x06, 0x0C, 0xC0, 0x04, 0x0C, 0x40, 0x04, 0x0C, 0x60, 0x0C, 0x08, 0x20,
  0x0C, 0x08, 0x30, 0x0C, 0x18, 0x30, 0x0C, 0x18, 0x10, 0x08, 0x18, 0x18,
  0x08, 0x18, 0x18, 0x18, 0x10, 0x08, 0x18, 0x10, 0x0C, 0x18, 0x30, 0x04,
  0x10, 0x30, 0x06, 0x10, 0x30, 0x06, 0x30, 0x30, 0x02, 0x30, 0x20, 0x03,
  0x30, 0x20, 0x01, 0x30, 0x60, 0x01, 0x20, 0x60, 0x01, 0xA0, 0x60, 0x00,
  0xE0, 0x60, 0x00, 0xE0, 0x40, 0x00, 0xE0, 0x40, 0x00, 0x60, 0x00, 0x7F,
  0x00, 0x0F, 0xFE, 0x00, 0xE0, 0x38, 0x0C, 0x00, 0xC0, 0xC0, 0x03, 0x06,
  0x00, 0x18, 0x60, 0x00, 0x43, 0x00, 0x02, 0x30, 0x00, 0x11, 0x80, 0x00,
  0x8C, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x01, 0x30, 0x00, 0x19, 0x80,
  0x00, 0xCC, 0x00, 0x06, 0x40, 0x00, 0x22, 0x00, 0x01, 0x10, 0x00, 0x19,
  0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x23, 0x00, 0x03, 0x08, 0x00,
  0x18, 0x40, 0x01, 0x83, 0x00, 0x18, 0x0C, 0x01, 0xC0, 0x70, 0x1C, 0x01,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x30, 0x1E, 0x01, 0x80,
  0x18, 0x0C, 0x00, 0x60, 0x40, 0x03, 0x02, 0x00, 0x08, 0x10, 0x00, 0x41,
  0x80, 0x02, 0x0C, 0x00, 0x10, 0x60, 0x00, 0x82, 0x00, 0x0C, 0x10, 0x00,
  0x61, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x03, 0x00, 0x30, 0x1F,
  0x7F, 0x00, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xE0, 0x38, 0x0C, 0x00, 0xC0, 0xC0,
  0x03, 0x06, 0x00, 0x18, 0x60, 0x00, 0x42, 0x00, 0x02, 0x30, 0x00, 0x11,
  0x80, 0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x03, 0x30, 0x00,
  0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x40, 0x00, 0x22, 0x00, 0x01, 0x30,
  0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x23, 0x00, 0x03,
  0x08, 0x00, 0x10, 0x40, 0x01, 0x83, 0x00, 0x18, 0x08, 0x01, 0xC0, 0x70,
  0x1C, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x07, 0xFF, 0x00, 0x30,
  0x3E, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x60, 0x40, 0x03, 0x02, 0x00, 0x08,
  0x30, 0x00, 0x41, 0x80, 0x02, 0x0C, 0x00, 0x10, 0x60, 0x01, 0x82, 0x00,
  0x0C, 0x10, 0x00, 0x41, 0x80, 0x06, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x03,
  0xE1, 0xE0, 0x1F, 0xFC, 0x00, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x60, 0x10, 0x03, 0x00, 0x80, 0x08, 0x04, 0x00, 0x60, 0x60,
  0x03, 0x03, 0x00, 0x08, 0x18, 0x00, 0x60, 0x80, 0x03, 0x04, 0x00, 0x18,
  0x60, 0x00, 0x60, 0x00, 0x7F, 0x00, 0x1F, 0x7C, 0x03, 0x80, 0xE0, 0x60,
  0x06, 0x0C, 0x00, 0x20, 0xC0, 0x03, 0x08, 0x00, 0x31, 0x80, 0x03, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00,
  0xCC, 0x00, 0x08, 0xC0, 0x01, 0x84, 0x00, 0x18, 0x60, 0x03, 0x03, 0x00,
  0xE0, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x08, 0x60, 0x00, 0xC2,
  0x00, 0x06, 0x10, 0x00, 0x30, 0x80, 0x01, 0x8C, 0x00, 0x08, 0x60, 0x00,
  0x43, 0x00, 0x06, 0x10, 0x00, 0x30, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60,
  0x00, 0x43, 0x00, 0x02, 0x18, 0x00, 0x30, 0x80, 0x01, 0x84, 0x00, 0x0C,
  0x60, 0x00, 0x43, 0x00, 0x02, 0x18, 0x00, 0x10, 0xC0, 0x01, 0x84, 0x00,
  0x0C, 0x20, 0x00, 0x61, 0x00, 0x02, 0x08, 0x00, 0x30, 0x40, 0x01, 0x83,
  0x00, 0x18, 0x18, 0x01, 0x80, 0x60, 0x1C, 0x01, 0xFF, 0x80, 0x03, 0xF0,
  0x00, 0x80, 0x00, 0x2C, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0xC0,
  0x00, 0xCC, 0x00, 0x18, 0x40, 0x01, 0x84, 0x00, 0x30, 0x60, 0x03, 0x06,
  0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x40, 0x20, 0x0C, 0x02, 0x00, 0x80,
  0x20, 0x18, 0x03, 0x01, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x60,
  0x01, 0x06, 0x00, 0x10, 0x40, 0x01, 0x0C, 0x00, 0x18, 0x80, 0x01, 0x98,
  0x00, 0x19, 0x00, 0x00, 0xB0, 0x00, 0x0A, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x02, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x05, 0x80, 0x0E, 0x00, 0x6C, 0x00, 0xF0, 0x03, 0x60, 0x04,
  0x80, 0x11, 0x00, 0x64, 0x01, 0x88, 0x02, 0x20, 0x08, 0x40, 0x11, 0x00,
  0xC2, 0x01, 0x88, 0x06, 0x10, 0x08, 0x40, 0x20, 0x80, 0xC2, 0x03, 0x04,
  0x04, 0x18, 0x18, 0x30, 0x20, 0xC0, 0x81, 0x83, 0x06, 0x0C, 0x0C, 0x10,
  0x30, 0x60, 0x61, 0x81, 0x82, 0x03, 0x08, 0x04, 0x30, 0x18, 0x40, 0x21,
  0x00, 0xC6, 0x01, 0x18, 0x06, 0x20, 0x08, 0xC0, 0x33, 0x00, 0x44, 0x01,
  0x90, 0x02, 0x60, 0x04, 0x80, 0x13, 0x00, 0x2C, 0x00, 0xD0, 0x01, 0x40,
  0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x02, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03,
  0x00, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x30, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0x40, 0x00, 0x60, 0xC0, 0x00, 0x61, 0x80, 0x00,
  0x23, 0x00, 0x00, 0x33, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x46, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x83, 0x00, 0x03, 0x03, 0x00, 0x03,
  0x01, 0x00, 0x06, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x18,
  0x00, 0xC0, 0x30, 0x00, 0x40, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0xC0,
  0x00, 0x6C, 0x00, 0x06, 0x40, 0x00, 0xC6, 0x00, 0x18, 0x60, 0x01, 0x82,
  0x00, 0x30, 0x30, 0x06, 0x03, 0x00, 0x60, 0x10, 0x0C, 0x01, 0x80, 0x80,
  0x18, 0x18, 0x00, 0x83, 0x00, 0x08, 0x20, 0x00, 0xC6, 0x00, 0x0C, 0xC0,
  0x00, 0x48, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x00, 0x01, 0xF0, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0F,
  0xC0, 0xC1, 0x04, 0x10, 0x41, 0x86, 0x18, 0x20, 0x82, 0x08, 0x30, 0xC3,
  0x0C, 0x10, 0x41, 0x06, 0x18, 0x61, 0x82, 0x08, 0x20, 0xC3, 0x0C, 0x30,
  0x41, 0x04, 0x01, 0xF0, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C,
  0x0F, 0xC0, 0x00, 0x80, 0x18, 0x01, 0x80, 0x2C, 0x02, 0xC0, 0x64, 0x04,
  0x40, 0xC4, 0x08, 0x41, 0x86, 0x30, 0x63, 0x02, 0x60, 0x26, 0x02, 0xC0,
  0x20, 0xFF, 0xFE, 0xCC, 0x62, 0x31, 0x01, 0xF8, 0x07, 0xFC, 0x0C, 0x06,
  0x18, 0x02, 0x10, 0x03, 0x30, 0x03, 0x30, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x03, 0xFE, 0x1F, 0x06, 0x30, 0x04, 0x60, 0x04, 0xC0, 0x04,
  0xC0, 0x0C, 0x80, 0x0C, 0x80, 0x1C, 0xC0, 0x38, 0xC0, 0x68, 0x7F, 0xC8,
  0x3F, 0x08, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02,
  0x3F, 0x03, 0x3F, 0xC1, 0xE0, 0x30, 0xE0, 0x18, 0x60, 0x04, 0x20, 0x03,
  0x10, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x22, 0x00, 0x11, 0x00,
  0x08, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x10, 0x01, 0x8C,
  0x00, 0x86, 0x00, 0xC6, 0x80, 0xC3, 0x3B, 0xC1, 0x8F, 0xC0, 0x01, 0xF8,
  0x07, 0xBC, 0x0C, 0x06, 0x18, 0x02, 0x10, 0x03, 0x30, 0x03, 0x20, 0x03,
  0x60, 0x03, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x04, 0xC0, 0x04, 0x40, 0x0C, 0x60, 0x18,
  0x30, 0x30, 0x3F, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x3E, 0x10, 0x3D, 0xEC, 0x18, 0x0B, 0x0C,
  0x01, 0xC3, 0x00, 0x31, 0x80, 0x08, 0x60, 0x02, 0x10, 0x01, 0x8C, 0x00,
  0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x08, 0x00, 0x42, 0x00, 0x30,
  0x80, 0x0C, 0x20, 0x03, 0x08, 0x00, 0xC3, 0x00, 0x20, 0xC0, 0x18, 0x18,
  0x1E, 0x07, 0xFD, 0x80, 0x7C, 0x60, 0x01, 0xF8, 0x07, 0xBC, 0x0C, 0x06,
  0x18, 0x02, 0x10, 0x03, 0x30, 0x03, 0x20, 0x03, 0x60, 0x03, 0x60, 0x03,
  0x40, 0x03, 0x7F, 0xFF, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x08, 0x30, 0x18, 0x1E, 0xF0,
  0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x1F, 0xF0, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x00, 0xF8, 0x40, 0xF7, 0x90, 0x60,
  0x2C, 0x30, 0x07, 0x0C, 0x01, 0xC6, 0x00, 0x21, 0x80, 0x08, 0x40, 0x02,
  0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x04, 0x20, 0x01, 0x08,
  0x00, 0x42, 0x00, 0x30, 0x80, 0x0C, 0x20, 0x03, 0x0C, 0x01, 0x83, 0x00,
  0x60, 0x60, 0x68, 0x1F, 0xF6, 0x01, 0xF1, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x83, 0x00, 0x60, 0x60, 0x30, 0x0F,
  0x78, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x7C, 0x19, 0xFE, 0x1B, 0x03, 0x1E, 0x03, 0x1C, 0x03, 0x18, 0x01,
  0x18, 0x01, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x20, 0x02,
  0x20, 0x02, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x04, 0x40, 0x04,
  0x40, 0x04, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x10, 0x20, 0xC1, 0x83, 0x04, 0x08, 0x10, 0x60,
  0xC1, 0x82, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x7C,
  0x03, 0xC0, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x02, 0x00, 0xC3, 0x00, 0xC1, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x20,
  0xC0, 0x10, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x03, 0xF0, 0x01,
  0xC8, 0x00, 0xC6, 0x00, 0xC1, 0x00, 0x60, 0xC0, 0x30, 0x20, 0x10, 0x18,
  0x08, 0x04, 0x04, 0x03, 0x06, 0x00, 0x83, 0x00, 0x61, 0x80, 0x10, 0x02,
  0x0C, 0x18, 0x30, 0x40, 0x81, 0x06, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x06,
  0x0C, 0x10, 0x20, 0x41, 0x83, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x83, 0x04,
  0x08, 0x30, 0x60, 0x08, 0x7C, 0x07, 0xC1, 0x9D, 0xE1, 0xDE, 0x1B, 0x02,
  0x30, 0x21, 0xC0, 0x34, 0x03, 0x14, 0x03, 0xC0, 0x31, 0x80, 0x38, 0x03,
  0x18, 0x03, 0x00, 0x33, 0x00, 0x30, 0x03, 0x30, 0x03, 0x00, 0x33, 0x00,
  0x30, 0x03, 0x20, 0x02, 0x00, 0x22, 0x00, 0x20, 0x02, 0x60, 0x02, 0x00,
  0x26, 0x00, 0x60, 0x06, 0x60, 0x06, 0x00, 0x66, 0x00, 0x60, 0x06, 0x40,
  0x04, 0x00, 0x44, 0x00, 0x40, 0x04, 0xC0, 0x0C, 0x00, 0xCC, 0x00, 0xC0,
  0x0C, 0xC0, 0x0C, 0x00, 0xCC, 0x00, 0x80, 0x0C, 0x08, 0x7C, 0x09, 0xFE,
  0x1B, 0x03, 0x1E, 0x03, 0x1C, 0x03, 0x18, 0x01, 0x18, 0x01, 0x30, 0x03,
  0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x20, 0x02, 0x20, 0x02, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x04, 0x40, 0x04, 0x40, 0x04, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x0C, 0x03, 0xF0, 0x07, 0xBC, 0x1C, 0x0E, 0x18, 0x06,
  0x30, 0x02, 0x60, 0x03, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x06, 0x80, 0x04,
  0x80, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0x60, 0x30, 0x3D, 0xE0, 0x1F, 0x80,
  0x02, 0x3F, 0x00, 0x4F, 0xF0, 0x1E, 0x03, 0x03, 0x80, 0x60, 0x60, 0x04,
  0x08, 0x00, 0xC1, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x08,
  0x30, 0x01, 0x04, 0x00, 0x20, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x30,
  0xC0, 0x04, 0x18, 0x01, 0x83, 0x00, 0x20, 0x60, 0x0C, 0x1A, 0x03, 0x03,
  0x7B, 0xC0, 0x63, 0xF0, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xE1, 0x0F, 0x79, 0x18, 0x0F, 0x30, 0x07, 0x30, 0x03,
  0x60, 0x02, 0x60, 0x02, 0x40, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x0C,
  0xC0, 0x08, 0xC0, 0x18, 0x60, 0x78, 0x7B, 0xD8, 0x1F, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x08, 0xF0, 0x9F, 0x1B, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x30, 0x30, 0xC0, 0x31, 0x00, 0x26, 0x00,
  0x4C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x80, 0x09, 0x80, 0x13, 0x00,
  0x63, 0x01, 0x83, 0xFE, 0x03, 0xF0, 0x00, 0x04, 0x02, 0x01, 0x01, 0x80,
  0xC0, 0x61, 0xFE, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0,
  0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x30,
  0x1F, 0x07, 0x80, 0x10, 0x01, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30,
  0x02, 0x20, 0x02, 0x20, 0x02, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x40,
  0x04, 0x40, 0x04, 0x40, 0x04, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x18, 0xC0, 0x18, 0xC0, 0x28, 0x60, 0x78, 0x7F, 0xD8, 0x1F, 0x18, 0x80,
  0x07, 0x00, 0x1B, 0x00, 0x36, 0x00, 0x4C, 0x01, 0x98, 0x02, 0x10, 0x0C,
  0x20, 0x10, 0x40, 0x60, 0xC0, 0x81, 0x83, 0x03, 0x04, 0x02, 0x18, 0x04,
  0x20, 0x08, 0xC0, 0x19, 0x80, 0x36, 0x00, 0x6C, 0x00, 0x50, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x06, 0xC0,
  0x38, 0x06, 0x40, 0x28, 0x04, 0x40, 0x68, 0x0C, 0x40, 0x48, 0x0C, 0x40,
  0xC8, 0x18, 0x40, 0xC8, 0x18, 0x40, 0x88, 0x10, 0x41, 0x8C, 0x30, 0x61,
  0x0C, 0x20, 0x63, 0x0C, 0x60, 0x62, 0x0C, 0x60, 0x66, 0x0C, 0x40, 0x64,
  0x04, 0xC0, 0x6C, 0x04, 0x80, 0x6C, 0x05, 0x80, 0x68, 0x05, 0x80, 0x38,
  0x05, 0x00, 0x30, 0x07, 0x00, 0x30, 0x06, 0x00, 0x20, 0x06, 0x00, 0x0C,
  0x00, 0xC1, 0x00, 0x60, 0x60, 0x18, 0x08, 0x0C, 0x03, 0x06, 0x00, 0xC3,
  0x00, 0x18, 0xC0, 0x06, 0x60, 0x00, 0xB0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x01, 0xA0, 0x00, 0x4C, 0x00, 0x33, 0x00, 0x18, 0x40, 0x0C,
  0x18, 0x02, 0x02, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x60, 0x06, 0x18, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x60, 0x02, 0x06, 0x00, 0x60, 0x60, 0x04, 0x06,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x20, 0x10, 0x03, 0x03, 0x00,
  0x30, 0x20, 0x03, 0x06, 0x00, 0x30, 0x60, 0x01, 0x0C, 0x00, 0x10, 0xC0,
  0x01, 0x18, 0x00, 0x19, 0x80, 0x01, 0xB0, 0x00, 0x1B, 0x00, 0x01, 0xA0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0xE0, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x06, 0x0C, 0x10, 0x20,
  0x41, 0x83, 0x06, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x06, 0x08, 0x10, 0x20,
  0xC1, 0x83, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x83, 0x04, 0x08, 0x10, 0x60,
  0xC1, 0x83, 0x04, 0x00, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x3C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0E, 0x00, 0x70, 0x01, 0x00, 0x00, 0x0F, 0x00, 0x31, 0xF8, 0x03, 0x30,
  0xC0, 0x26, 0x06, 0x06, 0x60, 0x30, 0x44, 0x01, 0xFC, 0x40, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLightItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 30, 8, 1, -30 },
  { 28, 7, 9, 11, 5, -32 },
  { 36, 21, 30, 20, 1, -30 },
  { 115, 17, 38, 20, 2, -34 },
  { 196, 19, 30, 26, 4, -30 },
  { 268, 19, 30, 22, 1, -30 },
  { 340, 3, 9, 7, 4, -32 },
  { 344, 12, 43, 11, 2, -33 },
  { 409, 11, 43, 12, -2, -33 },
  { 469, 17, 16, 17, 2, -30 },
  { 503, 17, 22, 20, 2, -25 },
  { 550, 5, 9, 8, -1, -3 },
  { 556, 9, 1, 11, 1, -14 },
  { 558, 3, 3, 9, 1, -3 },
  { 560, 18, 33, 14, -2, -30 },
  { 635, 17, 30, 20, 2, -30 },
  { 699, 9, 30, 20, 6, -30 },
  { 733, 17, 30, 20, 1, -30 },
  { 797, 18, 30, 20, 1, -30 },
  { 865, 17, 30, 20, 1, -30 },
  { 929, 17, 30, 20, 3, -30 },
  { 993, 15, 30, 20, 2, -30 },
  { 1050, 17, 30, 20, 3, -30 },
  { 1114, 18, 30, 20, 1, -30 },
  { 1182, 15, 30, 20, 3, -30 },
  { 1239, 6, 22, 8, 1, -22 },
  { 1256, 8, 28, 7, -1, -22 },
  { 1284, 15, 17, 18, 2, -22 },
  { 1316, 16, 11, 20, 2, -19 },
  { 1338, 16, 17, 19, 1, -22 },
  { 1372, 12, 30, 16, 4, -30 },
  { 1417, 29, 38, 32, 1, -29 },
  { 1555, 20, 30, 22, -1, -30 },
  { 1630, 19, 30, 22, 1, -30 },
  { 1702, 20, 30, 23, 2, -30 },
  { 1777, 21, 30, 23, 1, -30 },
  { 1856, 21, 30, 20, 1, -30 },
  { 1935, 21, 30, 20, 1, -30 },
  { 2014, 20, 30, 24, 3, -30 },
  { 2089, 23, 30, 25, 1, -30 },
  { 2176, 7, 30, 10, 2, -30 },
  { 2203, 18, 30, 20, 1, -30 },
  { 2271, 23, 30, 23, 1, -30 },
  { 2358, 15, 30, 19, 1, -30 },
  { 2415, 29, 30, 30, 1, -30 },
  { 2524, 24, 30, 25, 1, -30 },
  { 2614, 21, 30, 24, 2, -30 },
  { 2693, 21, 30, 22, 1, -30 },
  { 2772, 21, 35, 24, 2, -30 },
  { 2864, 21, 30, 23, 1, -30 },
  { 2943, 20, 30, 21, 1, -30 },
  { 3018, 19, 30, 21, 4, -30 },
  { 3090, 21, 30, 24, 2, -30 },
  { 3169, 20, 30, 22, 4, -30 },
  { 3244, 29, 30, 32, 4, -30 },
  { 3353, 24, 30, 22, -1, -30 },
  { 3443, 20, 30, 21, 4, -30 },
  { 3518, 22, 30, 21, 0, -30 },
  { 3601, 12, 40, 9, 0, -34 },
  { 3661, 6, 33, 14, 4, -30 },
  { 3686, 12, 40, 9, -3, -34 },
  { 3746, 12, 15, 15, 2, -30 },
  { 3769, 15, 1, 15, -2, 0 },
  { 3771, 4, 6, 11, 6, -32 },
  { 3774, 16, 22, 19, 1, -22 },
  { 3818, 17, 32, 20, 1, -32 },
  { 3886, 16, 22, 18, 1, -22 },
  { 3930, 18, 32, 20, 2, -32 },
  { 4002, 16, 22, 19, 1, -22 },
  { 4046, 13, 32, 12, 2, -32 },
  { 4098, 18, 31, 20, 0, -22 },
  { 4168, 16, 32, 20, 1, -32 },
  { 4232, 7, 30, 8, 1, -30 },
  { 4259, 13, 39, 8, -5, -30 },
  { 4323, 17, 32, 17, 1, -32 },
  { 4391, 7, 32, 8, 1, -32 },
  { 4419, 28, 22, 31, 1, -22 },
  { 4496, 16, 22, 20, 1, -22 },
  { 4540, 16, 22, 20, 2, -22 },
  { 4584, 19, 31, 20, -1, -22 },
  { 4658, 16, 31, 20, 2, -22 },
  { 4720, 12, 22, 12, 1, -22 },
  { 4753, 15, 22, 18, 1, -22 },
  { 4795, 9, 28, 12, 2, -28 },
  { 4827, 16, 22, 20, 2, -22 },
  { 4871, 15, 22, 17, 3, -22 },
  { 4913, 24, 22, 27, 3, -22 },
  { 4979, 18, 22, 17, -1, -22 },
  { 5029, 20, 31, 17, -2, -22 },
  { 5107, 17, 22, 17, 0, -22 },
  { 5154, 14, 42, 12, 1, -33 },
  { 5228, 7, 36, 9, 1, -30 },
  { 5260, 14, 42, 12, -3, -33 },
  { 5334, 20, 7, 24, 2, -16 },
};

const GFXfont RobotoCondensed_ExtraLightItalic42pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic42pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic42pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC42PT7B_H_
