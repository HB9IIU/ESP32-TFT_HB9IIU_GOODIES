#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC70PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x78, 0x07, 0x00, 0x60, 0x00, 0x30, 0x73, 0x06, 0x30, 0x67, 0x06,
  0x70, 0xE7, 0x0E, 0x60, 0xE6, 0x0C, 0x60, 0xCE, 0x0C, 0xE1, 0xCC, 0x1C,
  0xC1, 0x8C, 0x18, 0xC1, 0x80, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x0E,
  0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3C, 0x03, 0xC0, 0x07,
  0x80, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x30, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x1C, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x70, 0x01, 0x80, 0x1C, 0x38, 0x00, 0xC0,
  0x0C, 0x18, 0x00, 0x60, 0x0E, 0x0C, 0x00, 0x70, 0x0E, 0x06, 0x00, 0x38,
  0x06, 0x03, 0x00, 0x18, 0x07, 0x01, 0x80, 0x0C, 0x07, 0x00, 0xC0, 0x06,
  0x03, 0x00, 0x60, 0x06, 0x03, 0x00, 0x30, 0x03, 0x03, 0x80, 0x1C, 0x03,
  0x81, 0x80, 0x06, 0x03, 0x81, 0x80, 0x03, 0x83, 0x81, 0xC0, 0x00, 0xFF,
  0x80, 0xC0, 0x00, 0x3F, 0x80, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x0F, 0xC0,
  0x00, 0x38, 0x1F, 0xF8, 0x00, 0x18, 0x1E, 0x1C, 0x00, 0x1C, 0x0C, 0x07,
  0x00, 0x1C, 0x0E, 0x01, 0x80, 0x0C, 0x0E, 0x00, 0xE0, 0x0E, 0x06, 0x00,
  0x30, 0x0E, 0x03, 0x00, 0x18, 0x06, 0x03, 0x80, 0x0C, 0x06, 0x01, 0x80,
  0x06, 0x07, 0x00, 0xC0, 0x07, 0x03, 0x00, 0x60, 0x03, 0x83, 0x00, 0x30,
  0x01, 0x83, 0x80, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x00, 0x61, 0x80, 0x06,
  0x00, 0x70, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x60, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x80, 0x01, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x80, 0x00, 0x60, 0x0E,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x01, 0x87, 0x80,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0xC3, 0x80, 0x70, 0x03, 0x8F, 0x00, 0x70, 0x07, 0x1C,
  0x00, 0xE0, 0x0C, 0x70, 0x00, 0xE0, 0x18, 0xE0, 0x01, 0xC0, 0x73, 0x80,
  0x01, 0xC0, 0xC7, 0x00, 0x03, 0x83, 0x8C, 0x00, 0x03, 0x87, 0x18, 0x00,
  0x03, 0x8C, 0x70, 0x00, 0x07, 0x38, 0xE0, 0x00, 0x07, 0xE1, 0xC0, 0x00,
  0x0F, 0xC3, 0x80, 0x00, 0x0F, 0x03, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0x07, 0x38, 0x1E, 0x00, 0x1C,
  0x38, 0x1F, 0x00, 0xF0, 0x70, 0x1F, 0xFF, 0xC0, 0x70, 0x0F, 0xFE, 0x00,
  0xE0, 0x03, 0xE0, 0x00, 0x00, 0x39, 0xCE, 0x73, 0x19, 0xCE, 0x73, 0x18,
  0xCE, 0x73, 0x00, 0x00, 0x00, 0x20, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x2E, 0x00, 0xC0, 0x3F, 0xF0, 0x38, 0x1F, 0x9F, 0x87, 0x1F, 0xC0, 0xFE,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00,
  0xF0, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x70,
  0x70, 0xE0, 0x40, 0x7F, 0xFF, 0xFF, 0xF0, 0x6F, 0xFF, 0x60, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60, 0x38, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07,
  0x18, 0x00, 0x00, 0x71, 0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x06, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0C, 0x07, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x38, 0x03, 0x00, 0x03, 0x80, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0x00, 0x1E, 0x00, 0x7E, 0x01, 0xFE,
  0x0F, 0xCE, 0x3F, 0x0E, 0x7C, 0x0E, 0x60, 0x0C, 0x80, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0x60, 0x38, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x07,
  0x80, 0x0E, 0x00, 0x78, 0x00, 0x78, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x0C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x60, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0xE0, 0x03, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x70, 0x03, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x38,
  0x07, 0x00, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0xFC, 0x00,
  0x01, 0x9F, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x38, 0x06, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x7E, 0x00, 0x70, 0xFF, 0xE0, 0x1C, 0x7E, 0xFE, 0x06, 0x78, 0x07,
  0x81, 0xB8, 0x00, 0x70, 0xEC, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x06, 0x60, 0x00,
  0x01, 0x98, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0C, 0x70,
  0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x07,
  0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x18, 0x03, 0x80, 0x00,
  0xE0, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7C, 0x0F, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80,
  0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x0E, 0x01, 0xE0, 0x01, 0xC0, 0xF0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x1C,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x07,
  0x30, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x07, 0x60, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x98, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x7C, 0x38, 0x00, 0x37, 0x0F, 0x00, 0x3D, 0xC1, 0xE0,
  0x1E, 0x60, 0x3F, 0x7E, 0x18, 0x07, 0xFF, 0x0E, 0x00, 0x7F, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0x80, 0xF0, 0x3C, 0x0F,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x3C, 0x0F, 0x83, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x80, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0x03, 0xC0, 0xE0, 0x07, 0x0E, 0x00,
  0x38, 0xE0, 0x00, 0xC7, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xD8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x7E, 0x00, 0x06, 0x01, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0x01, 0xC0,
  0x01, 0xF1, 0xF0, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0x3C, 0x00, 0xC0, 0xE0,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x60, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x70,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x0E, 0x18,
  0x00, 0xE0, 0x01, 0xC0, 0x06, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x0C,
  0x00, 0x70, 0x00, 0x60, 0x01, 0x86, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC7,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x63, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x31,
  0x80, 0x0C, 0x00, 0x0C, 0x00, 0x38, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0x1C,
  0xE0, 0x07, 0x00, 0x07, 0x00, 0x0C, 0x70, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x30, 0x01, 0x80, 0x01, 0x80, 0x03, 0x18, 0x01, 0xC0, 0x00, 0xC0, 0x03,
  0x8C, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0x86, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xC3, 0x00, 0x30, 0x00, 0x30, 0x00, 0xE1, 0x80, 0x18, 0x00, 0x38, 0x00,
  0x61, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0x30, 0xE0, 0x06, 0x00, 0x1E, 0x00,
  0x30, 0x70, 0x03, 0x00, 0x1F, 0x00, 0x18, 0x38, 0x01, 0x80, 0x0F, 0x80,
  0x18, 0x0C, 0x00, 0xC0, 0x0C, 0xC0, 0x1C, 0x06, 0x00, 0x70, 0x0C, 0x60,
  0x1C, 0x03, 0x00, 0x1C, 0x0E, 0x38, 0x1C, 0x01, 0x80, 0x0F, 0xFC, 0x0F,
  0xFC, 0x00, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x70, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x03, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x60, 0x0F, 0xF0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x07, 0x01, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0xF0, 0x07,
  0x00, 0x03, 0xE0, 0x07, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x06, 0x00, 0x07, 0xC0, 0x0E, 0x00, 0x01, 0xE0, 0x0E,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x1F, 0x00, 0x70, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x1C, 0x30, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0x80, 0x3F, 0xC0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x30, 0x07, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x78, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x70,
  0x07, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xC6, 0x00, 0x0F, 0xFF, 0xC7, 0x00,
  0x07, 0xFF, 0xE3, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F,
  0x80, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0x30, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x03, 0x80, 0x60, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x03, 0x00, 0x00, 0x07, 0x80, 0x18, 0x00, 0x00,
  0x78, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x78, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x03, 0x80, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x3C, 0x00, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x00, 0xE3, 0xE0,
  0x00, 0x00, 0x06, 0x3F, 0x80, 0x00, 0x00, 0x33, 0x9C, 0x00, 0x00, 0x01,
  0xB8, 0x70, 0x00, 0x00, 0x1F, 0x83, 0x80, 0x00, 0x00, 0xF8, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xDC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0xDC, 0x00, 0x00, 0x00, 0xEE, 0x00, 0xDC, 0x00,
  0x00, 0x00, 0xCC, 0x01, 0xCC, 0x00, 0x00, 0x01, 0xCC, 0x01, 0xCC, 0x00,
  0x00, 0x01, 0x9C, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x9C, 0x01, 0x8E, 0x00,
  0x00, 0x03, 0x1C, 0x01, 0x8E, 0x00, 0x00, 0x07, 0x1C, 0x01, 0x86, 0x00,
  0x00, 0x06, 0x18, 0x03, 0x86, 0x00, 0x00, 0x0E, 0x18, 0x03, 0x86, 0x00,
  0x00, 0x0C, 0x38, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x03, 0x07, 0x00,
  0x00, 0x18, 0x38, 0x03, 0x07, 0x00, 0x00, 0x38, 0x30, 0x03, 0x03, 0x00,
  0x00, 0x30, 0x30, 0x07, 0x03, 0x00, 0x00, 0x70, 0x30, 0x07, 0x03, 0x00,
  0x00, 0x60, 0x70, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x06, 0x03, 0x80,
  0x01, 0xC0, 0x70, 0x06, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x06, 0x01, 0x80,
  0x03, 0x80, 0x60, 0x0E, 0x01, 0x80, 0x03, 0x80, 0xE0, 0x0E, 0x01, 0x80,
  0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x1C, 0x00, 0xC0,
  0x1C, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x18, 0x00, 0xE0,
  0x70, 0x01, 0xC0, 0x18, 0x00, 0x60, 0x60, 0x01, 0x80, 0x38, 0x00, 0x60,
  0xE0, 0x01, 0x80, 0x38, 0x00, 0x60, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x71,
  0xC0, 0x03, 0x80, 0x38, 0x00, 0x71, 0x80, 0x03, 0x80, 0x30, 0x00, 0x33,
  0x80, 0x03, 0x80, 0x30, 0x00, 0x33, 0x00, 0x03, 0x00, 0x70, 0x00, 0x37,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x36, 0x00, 0x07, 0x00, 0x70, 0x00, 0x3E,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x07, 0xC0, 0x00, 0x00, 0x60, 0x0F, 0x80, 0x00, 0x00, 0xC0, 0x1F, 0x80,
  0x00, 0x03, 0x80, 0x3B, 0x00, 0x00, 0x07, 0x00, 0x76, 0x00, 0x00, 0x0E,
  0x00, 0xCE, 0x00, 0x00, 0x1C, 0x03, 0x8C, 0x00, 0x00, 0x30, 0x07, 0x1C,
  0x00, 0x00, 0x60, 0x0E, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x30, 0x00, 0x03,
  0x80, 0x30, 0x70, 0x00, 0x07, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x01, 0xC0,
  0xC0, 0x00, 0x18, 0x03, 0x81, 0xC0, 0x00, 0x30, 0x07, 0x01, 0x80, 0x00,
  0xE0, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x18, 0x07, 0x00, 0x03, 0x80, 0x30,
  0x06, 0x00, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x0C, 0x00,
  0x18, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x03, 0x80, 0x70, 0x00, 0xE0,
  0x06, 0x00, 0xE0, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x01, 0x80, 0x70, 0x06, 0x00, 0x03, 0x80, 0xE0, 0x1C, 0x00, 0x07,
  0x01, 0x80, 0x38, 0x00, 0x06, 0x03, 0x00, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0xE0, 0x00, 0x1C, 0x1C, 0x01, 0x80, 0x00, 0x18, 0x38, 0x03, 0x00, 0x00,
  0x38, 0x70, 0x0E, 0x00, 0x00, 0x30, 0xC0, 0x1C, 0x00, 0x00, 0x71, 0x80,
  0x38, 0x00, 0x00, 0xE7, 0x00, 0x70, 0x00, 0x00, 0xCE, 0x00, 0xC0, 0x00,
  0x01, 0xDC, 0x01, 0x80, 0x00, 0x03, 0xB8, 0x07, 0x00, 0x00, 0x03, 0x60,
  0x0E, 0x00, 0x00, 0x07, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x60, 0x00, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x18, 0xE0, 0x00,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x1C,
  0x60, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x06,
  0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x06, 0x00, 0x3F, 0xC0, 0x03, 0x80, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x38,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0x60, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xF0,
  0x06, 0x00, 0x00, 0x78, 0x01, 0x80, 0x00, 0x7C, 0x00, 0x7F, 0xC3, 0xFC,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00,
  0x1C, 0x06, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x3F, 0x80, 0x03, 0x80, 0x00, 0xF8, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x70,
  0x03, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0x60, 0x1C, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0,
  0x06, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x06,
  0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x0E,
  0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0xC0, 0x00, 0x18, 0xE0, 0x00, 0x1C, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x18,
  0xC0, 0x00, 0x38, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x30,
  0xC0, 0x00, 0x70, 0x60, 0x00, 0x70, 0xE0, 0x00, 0x60, 0x60, 0x00, 0x70,
  0xE0, 0x00, 0xE0, 0x60, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0xE0,
  0x60, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0x70, 0x01, 0xC0,
  0x60, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x60, 0x03, 0x80, 0x70, 0x01, 0x80,
  0x60, 0x03, 0x80, 0x70, 0x03, 0x80, 0x60, 0x03, 0x00, 0x70, 0x03, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x70, 0x06, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00,
  0x70, 0x0E, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x1C, 0x00,
  0x30, 0x1C, 0x00, 0x30, 0x1C, 0x00, 0x30, 0x1C, 0x00, 0x30, 0x18, 0x00,
  0x30, 0x38, 0x00, 0x30, 0x38, 0x00, 0x30, 0x38, 0x00, 0x30, 0x30, 0x00,
  0x30, 0x30, 0x00, 0x38, 0x70, 0x00, 0x30, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x30, 0x70, 0x00, 0x38, 0x60, 0x00, 0x30, 0x60, 0x00, 0x38, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x39, 0x80, 0x00,
  0x39, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x19, 0x80, 0x00, 0x3B, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0,
  0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x38, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x07,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x19, 0xC0, 0x03, 0x38, 0x00,
  0xC3, 0x00, 0x18, 0x60, 0x07, 0x0C, 0x00, 0xC1, 0x80, 0x38, 0x38, 0x06,
  0x07, 0x01, 0xC0, 0xE0, 0x30, 0x0C, 0x0E, 0x01, 0x83, 0x80, 0x30, 0x70,
  0x06, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0xE0, 0x01, 0x9C, 0x00, 0x37, 0x00,
  0x06, 0xE0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x70, 0x70,
  0x38, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0x3C,
  0x07, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01,
  0xFE, 0x00, 0xC0, 0x7C, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x07, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x1C, 0x30, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C,
  0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x3E, 0x0E, 0x00,
  0x0F, 0xC1, 0xC0, 0x07, 0xB8, 0x1E, 0x03, 0xC7, 0x01, 0xFF, 0xF0, 0xE0,
  0x1F, 0xF8, 0x1C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x07,
  0x80, 0x03, 0x07, 0xFE, 0x00, 0x63, 0xFF, 0xE0, 0x0C, 0xF0, 0x1E, 0x03,
  0xB8, 0x00, 0xE0, 0x7E, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x38, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C, 0x38,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x1C, 0x60, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0C,
  0x70, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x30, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x30, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0x83, 0xC0, 0x00,
  0x70, 0xEC, 0x00, 0x1C, 0x1D, 0xC0, 0x07, 0x83, 0x9C, 0x03, 0xE0, 0x61,
  0xFF, 0xF0, 0x0C, 0x0F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x78, 0x07, 0x80,
  0x1C, 0x00, 0x78, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x70, 0x00,
  0x0E, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x18, 0x70, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x83, 0x80, 0x00, 0x60, 0x70, 0x00,
  0x1C, 0x07, 0x00, 0x07, 0x00, 0xF0, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x7F,
  0xF0, 0x70, 0x03, 0xFF, 0xE1, 0x80, 0x1E, 0x01, 0xC6, 0x00, 0xE0, 0x03,
  0xB8, 0x07, 0x00, 0x06, 0xE0, 0x38, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x7C, 0x01, 0xE0, 0x03, 0xF0, 0x03, 0xC0, 0x3D, 0xC0, 0x07, 0xFF, 0xC7,
  0x00, 0x0F, 0xFC, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xC0, 0x3C, 0x01, 0xC0,
  0x07, 0x80, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x18, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0x38, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0D, 0xC0, 0x00,
  0x07, 0x70, 0x00, 0x01, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x07, 0x01,
  0xC0, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xFE,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x18, 0x00, 0x7F,
  0xFC, 0x30, 0x01, 0xE0, 0x1C, 0x60, 0x07, 0x00, 0x1D, 0xC0, 0x1C, 0x00,
  0x1B, 0x80, 0x70, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x0C,
  0x07, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x18,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x07, 0x80, 0x1C, 0x00,
  0x1F, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x3C, 0x03, 0xDC, 0x00, 0x3F, 0xFE,
  0x38, 0x00, 0x3F, 0xF8, 0x60, 0x00, 0x1F, 0x80, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x07, 0xC0, 0x03, 0x07, 0xFE, 0x00, 0x61, 0xFF,
  0xE0, 0x0C, 0x70, 0x1E, 0x03, 0x9C, 0x01, 0xE0, 0x76, 0x00, 0x1C, 0x0F,
  0xC0, 0x03, 0x81, 0xB0, 0x00, 0x30, 0x3C, 0x00, 0x06, 0x07, 0x00, 0x00,
  0xC1, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x07, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x0C, 0x18, 0x00, 0x01, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E,
  0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0C, 0x18,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0xE0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x1D, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x1C, 0x03, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0x60, 0x07, 0x00, 0x06, 0x00, 0xE0, 0x00, 0xE0, 0x1C,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x01, 0xDF, 0x80, 0x00, 0x1B, 0xB8, 0x00, 0x01, 0xF1, 0xC0, 0x00,
  0x3E, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x30, 0x07, 0x00, 0x03, 0x00, 0x38, 0x00, 0x70, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0xE0, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x01, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0x87, 0xFF, 0x80,
  0xFF, 0xF8, 0x03, 0x9E, 0x03, 0xC1, 0xE0, 0x3C, 0x03, 0xB8, 0x01, 0xC3,
  0x80, 0x1C, 0x03, 0xB0, 0x00, 0xE7, 0x00, 0x0E, 0x03, 0x60, 0x00, 0xEE,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x06, 0x07, 0x80, 0x00, 0x78, 0x00, 0x06, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x00, 0x78, 0x00,
  0x60, 0x7F, 0xC0, 0x0C, 0x3F, 0xFC, 0x01, 0x8E, 0x03, 0xC0, 0x73, 0x80,
  0x3C, 0x0E, 0xC0, 0x03, 0x81, 0xF8, 0x00, 0x70, 0x3E, 0x00, 0x06, 0x07,
  0x80, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x3C, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x0E, 0x1C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x1C,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x18, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x00, 0x70, 0x0F, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x18, 0x60, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x0E, 0x60, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0C, 0x38, 0x00,
  0x03, 0x83, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x00,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0x83, 0xFF,
  0x00, 0x06, 0x3F, 0xFE, 0x00, 0x19, 0xE0, 0x3C, 0x00, 0xEE, 0x00, 0x38,
  0x03, 0xE0, 0x00, 0xE0, 0x0F, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x70, 0x0F, 0x00, 0x01, 0xC0, 0x7E, 0x00, 0x0E,
  0x01, 0xDC, 0x00, 0x70, 0x07, 0x38, 0x07, 0xC0, 0x18, 0x7F, 0xFC, 0x00,
  0x60, 0xFF, 0xE0, 0x03, 0x80, 0x7C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xFF, 0x06, 0x00, 0xFF, 0xF8, 0x60, 0x1E, 0x01, 0xC6, 0x03, 0x80,
  0x0E, 0xE0, 0x70, 0x00, 0x6E, 0x0E, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x1C,
  0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x18, 0x70, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x18, 0x70, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x3C, 0x07, 0x00, 0x07, 0xC0, 0x78, 0x00, 0xFC, 0x03, 0xC0,
  0x3D, 0xC0, 0x1F, 0xFF, 0x18, 0x00, 0xFF, 0xE1, 0x80, 0x01, 0xF0, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x30, 0xFF, 0x03, 0x1F, 0xF0, 0x33, 0xC0, 0x07, 0x70, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xC0, 0x3C, 0x01, 0xC0,
  0x07, 0x80, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x06,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x03, 0x86, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x03,
  0x80, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x0C, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06,
  0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x18, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x0C, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x3C, 0x30, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x83, 0x80, 0x03, 0xE0, 0xE0, 0x01, 0xF8, 0x1C, 0x00, 0xEE,
  0x07, 0x80, 0xF3, 0x80, 0xFF, 0xF8, 0xC0, 0x1F, 0xF8, 0x30, 0x00, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x03, 0x80,
  0x03, 0x80, 0xE0, 0x00, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x18, 0x01,
  0x80, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x07, 0x00, 0x70,
  0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0xC0, 0x60, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0C, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x06, 0x30, 0x00,
  0x01, 0x9C, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x60, 0x00, 0x38, 0x00,
  0x0E, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x60, 0x00, 0x78, 0x00, 0x1C, 0x60,
  0x00, 0x7C, 0x00, 0x1C, 0x60, 0x00, 0xFC, 0x00, 0x18, 0x70, 0x00, 0xDC,
  0x00, 0x38, 0x70, 0x00, 0xDC, 0x00, 0x38, 0x70, 0x01, 0xDC, 0x00, 0x70,
  0x70, 0x01, 0x8C, 0x00, 0x70, 0x70, 0x03, 0x8C, 0x00, 0x60, 0x70, 0x03,
  0x0C, 0x00, 0xE0, 0x70, 0x07, 0x0C, 0x00, 0xE0, 0x70, 0x07, 0x0C, 0x01,
  0xC0, 0x70, 0x06, 0x0C, 0x01, 0xC0, 0x30, 0x0E, 0x0E, 0x01, 0x80, 0x30,
  0x0C, 0x0E, 0x03, 0x80, 0x30, 0x1C, 0x0E, 0x03, 0x00, 0x30, 0x18, 0x0E,
  0x07, 0x00, 0x30, 0x38, 0x0E, 0x07, 0x00, 0x30, 0x30, 0x06, 0x06, 0x00,
  0x30, 0x70, 0x06, 0x0E, 0x00, 0x38, 0x70, 0x06, 0x0C, 0x00, 0x38, 0x60,
  0x06, 0x1C, 0x00, 0x38, 0xE0, 0x06, 0x1C, 0x00, 0x38, 0xC0, 0x06, 0x38,
  0x00, 0x39, 0xC0, 0x06, 0x38, 0x00, 0x39, 0x80, 0x07, 0x30, 0x00, 0x3B,
  0x80, 0x07, 0x70, 0x00, 0x3B, 0x00, 0x07, 0x70, 0x00, 0x1B, 0x00, 0x03,
  0x60, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xDF, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0x0F,
  0xFE, 0x00, 0x03, 0x1C, 0x0F, 0x00, 0x03, 0x38, 0x07, 0x80, 0x07, 0x30,
  0x03, 0xC0, 0x06, 0x70, 0x01, 0xC0, 0x0E, 0x70, 0x00, 0xE0, 0x0C, 0x60,
  0x00, 0x70, 0x1C, 0xE0, 0x00, 0x3F, 0xF8, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 12, 51, 13, 1, -50 },
  { 78, 12, 15, 18, 8, -53 },
  { 101, 35, 50, 34, 1, -50 },
  { 320, 28, 65, 33, 3, -58 },
  { 548, 33, 52, 44, 6, -51 },
  { 763, 31, 52, 36, 2, -51 },
  { 965, 5, 15, 11, 7, -53 },
  { 975, 20, 72, 19, 3, -56 },
  { 1155, 19, 72, 19, -4, -56 },
  { 1326, 27, 27, 29, 4, -50 },
  { 1418, 28, 37, 34, 3, -42 },
  { 1548, 8, 15, 13, -2, -6 },
  { 1563, 14, 2, 18, 2, -23 },
  { 1567, 4, 5, 15, 2, -4 },
  { 1570, 29, 54, 24, -3, -50 },
  { 1766, 28, 52, 33, 3, -51 },
  { 1948, 16, 50, 33, 9, -50 },
  { 2048, 30, 51, 33, 1, -51 },
  { 2240, 29, 52, 33, 2, -51 },
  { 2429, 30, 50, 33, 1, -50 },
  { 2617, 30, 51, 33, 4, -50 },
  { 2809, 26, 51, 33, 3, -50 },
  { 2975, 28, 50, 33, 6, -50 },
  { 3150, 30, 52, 33, 2, -51 },
  { 3345, 26, 51, 33, 5, -51 },
  { 3511, 10, 37, 13, 1, -36 },
  { 3558, 13, 45, 12, -2, -36 },
  { 3632, 26, 28, 31, 3, -37 },
  { 3723, 26, 18, 33, 4, -32 },
  { 3782, 26, 28, 31, 2, -37 },
  { 3873, 21, 52, 27, 6, -51 },
  { 4010, 49, 63, 54, 2, -48 },
  { 4396, 33, 50, 36, -2, -50 },
  { 4603, 32, 50, 36, 2, -50 },
  { 4803, 33, 52, 38, 4, -51 },
  { 5018, 35, 50, 39, 2, -50 },
  { 5237, 34, 50, 34, 2, -50 },
  { 5450, 34, 50, 34, 2, -50 },
  { 5663, 33, 52, 41, 5, -51 },
  { 5878, 39, 50, 42, 2, -50 },
  { 6122, 12, 50, 16, 3, -50 },
  { 6197, 31, 51, 33, 1, -50 },
  { 6395, 37, 50, 38, 2, -50 },
  { 6627, 24, 50, 31, 2, -50 },
  { 6777, 48, 50, 51, 2, -50 },
  { 7077, 39, 50, 42, 2, -50 },
  { 7321, 34, 52, 40, 4, -51 },
  { 7542, 34, 50, 36, 2, -50 },
  { 7755, 34, 60, 40, 4, -51 },
  { 8010, 34, 50, 38, 2, -50 },
  { 8223, 33, 52, 35, 2, -51 },
  { 8438, 32, 50, 36, 7, -50 },
  { 8638, 35, 51, 39, 4, -50 },
  { 8862, 33, 50, 36, 6, -50 },
  { 9069, 48, 50, 53, 7, -50 },
  { 9369, 39, 50, 36, -1, -50 },
  { 9613, 33, 50, 36, 6, -50 },
  { 9820, 37, 50, 36, 0, -50 },
  { 10052, 19, 68, 14, 1, -57 },
  { 10214, 10, 54, 23, 7, -50 },
  { 10282, 19, 68, 14, -4, -57 },
  { 10444, 19, 25, 25, 4, -50 },
  { 10504, 24, 2, 26, -3, 0 },
  { 10510, 8, 9, 19, 9, -52 },
  { 10519, 27, 39, 32, 1, -38 },
  { 10651, 27, 54, 33, 2, -53 },
  { 10834, 27, 39, 31, 2, -38 },
  { 10966, 30, 54, 33, 3, -53 },
  { 11169, 26, 39, 31, 2, -38 },
  { 11296, 21, 54, 20, 4, -54 },
  { 11438, 31, 52, 33, 0, -38 },
  { 11640, 27, 53, 33, 2, -53 },
  { 11819, 12, 50, 14, 2, -50 },
  { 11894, 23, 64, 14, -9, -50 },
  { 12078, 28, 53, 29, 2, -53 },
  { 12264, 12, 53, 14, 2, -53 },
  { 12344, 48, 38, 52, 1, -38 },
  { 12572, 27, 38, 33, 2, -38 },
  { 12701, 27, 39, 33, 3, -38 },
  { 12833, 30, 52, 33, -1, -38 },
  { 13028, 28, 52, 33, 3, -38 },
  { 13210, 20, 38, 21, 2, -38 },
  { 13305, 26, 39, 30, 1, -38 },
  { 13432, 15, 48, 20, 4, -47 },
  { 13522, 26, 38, 33, 4, -37 },
  { 13646, 26, 37, 29, 4, -37 },
  { 13767, 40, 37, 45, 5, -37 },
  { 13952, 30, 37, 29, -1, -37 },
  { 14091, 33, 51, 29, -3, -37 },
  { 14302, 28, 37, 29, 0, -37 },
  { 14432, 22, 70, 20, 2, -55 },
  { 14625, 12, 59, 14, 1, -50 },
  { 14714, 22, 70, 20, -4, -55 },
  { 14907, 32, 12, 41, 4, -27 },
};

const GFXfont RobotoCondensed_ExtraLightItalic70pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic70pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic70pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC70PT7B_H_
