#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC63PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x01, 0xC0,
  0x78, 0x07, 0x00, 0x00, 0x00, 0x30, 0xE6, 0x18, 0xC3, 0x38, 0x67, 0x0C,
  0xC1, 0x98, 0x73, 0x0C, 0x61, 0x9C, 0x33, 0x06, 0x61, 0xCC, 0x30, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x70, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x70, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x80, 0x60, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x0E, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x0C,
  0x0C, 0x00, 0x03, 0x07, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x30, 0x01,
  0x0C, 0x00, 0xC0, 0x1C, 0x60, 0x06, 0x00, 0xC6, 0x00, 0x70, 0x0C, 0x30,
  0x03, 0x00, 0xE1, 0x80, 0x18, 0x06, 0x0C, 0x00, 0xC0, 0x60, 0x60, 0x06,
  0x07, 0x03, 0x00, 0x30, 0x30, 0x18, 0x03, 0x03, 0x00, 0xC0, 0x18, 0x30,
  0x03, 0x01, 0x83, 0x80, 0x18, 0x1C, 0x18, 0x00, 0x7F, 0xC1, 0x80, 0x01,
  0xFC, 0x1C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x07,
  0xF0, 0x00, 0x30, 0x7F, 0xC0, 0x03, 0x07, 0x03, 0x00, 0x30, 0x30, 0x18,
  0x01, 0x83, 0x00, 0x60, 0x18, 0x18, 0x03, 0x01, 0x81, 0x80, 0x18, 0x1C,
  0x0C, 0x00, 0xC0, 0xC0, 0x60, 0x06, 0x0C, 0x03, 0x00, 0x30, 0xE0, 0x18,
  0x01, 0x86, 0x01, 0x80, 0x1C, 0x60, 0x0C, 0x00, 0xC7, 0x00, 0x60, 0x06,
  0x30, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x38, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x60, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x0C, 0x00,
  0x1C, 0x01, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x06, 0x00,
  0x70, 0xE0, 0x70, 0x06, 0x1C, 0x03, 0x80, 0x63, 0x80, 0x38, 0x06, 0x30,
  0x01, 0xC0, 0xE7, 0x00, 0x0C, 0x0C, 0x60, 0x00, 0xE0, 0xC6, 0x00, 0x06,
  0x1C, 0xE0, 0x00, 0x71, 0x8E, 0x00, 0x03, 0x38, 0xC0, 0x00, 0x3B, 0x0E,
  0x00, 0x01, 0xF0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x1E, 0x07, 0x00, 0x03, 0xF0, 0x38, 0x00, 0x73, 0x03, 0xC0, 0x1C, 0x38,
  0x1F, 0xDF, 0x81, 0x80, 0x7F, 0xE0, 0x1C, 0x00, 0xF8, 0x00, 0x00, 0x39,
  0xCC, 0x63, 0x19, 0xCE, 0x63, 0x18, 0xCC, 0x00, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x18, 0x07, 0xF0, 0x18, 0x1F, 0x7E, 0x18, 0xFE, 0x1F, 0x9B, 0xF0,
  0x03, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xCC, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x06, 0x00, 0x0E, 0x07, 0x00,
  0x0E, 0x03, 0x00, 0x1C, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x70, 0x01, 0xC0,
  0x20, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x1C, 0x38, 0x70, 0xC1,
  0x87, 0x0E, 0x38, 0x71, 0xC7, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0x23, 0xBE,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x38, 0x0E, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x07, 0x00, 0x03, 0x03, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0xE1, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xE0,
  0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x07, 0x18, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x19, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x07,
  0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00,
  0x0C, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0E, 0x00,
  0x03, 0x87, 0x00, 0x01, 0x81, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x70,
  0x00, 0xE0, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0xF0, 0x0F, 0xC1, 0xFF, 0x1F, 0x19, 0xF0, 0x67, 0x01, 0xA0, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x03,
  0x00, 0x70, 0x00, 0x70, 0x0C, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0x60,
  0x00, 0x18, 0x1C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0xE0,
  0x38, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x70, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x60, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x0F, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x73, 0x00, 0x00, 0x1C, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x0C,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x00, 0xC0,
  0x01, 0x80, 0x18, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x00, 0x60, 0x0E, 0x00, 0x0C, 0x01,
  0x80, 0x01, 0x80, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x3F, 0x00, 0x03, 0x3F, 0xF0, 0x00, 0xFE, 0x3E, 0x00, 0x7C,
  0x01, 0xC0, 0x1C, 0x00, 0x38, 0x02, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x0C,
  0x06, 0x00, 0x07, 0x01, 0x80, 0x01, 0x80, 0x70, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x78, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x1F, 0x80, 0x30, 0xFF, 0xC0, 0xE7, 0xC3, 0xC1, 0x9C, 0x01,
  0xC3, 0x70, 0x01, 0xC7, 0x80, 0x03, 0x9F, 0x00, 0x03, 0x3C, 0x00, 0x07,
  0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0D, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x37, 0x00, 0x00, 0xE6, 0x00,
  0x01, 0x8C, 0x00, 0x07, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x38, 0x38, 0x00,
  0xE0, 0x78, 0x03, 0x80, 0x78, 0x0E, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60, 0x38, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x18, 0x01, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x0E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x60, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x30, 0x38, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x86, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x06, 0x07, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x1E, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1E, 0x07, 0x80, 0x70, 0x03,
  0x81, 0xC0, 0x07, 0x07, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x38, 0x00, 0x0C,
  0x60, 0x00, 0x19, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x76, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0D, 0x80,
  0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xD8, 0x00,
  0x03, 0xB0, 0x00, 0x0F, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x78, 0xC0, 0x01,
  0xB1, 0xC0, 0x07, 0x61, 0xC0, 0x3D, 0xC1, 0xE1, 0xE3, 0x01, 0xFF, 0x86,
  0x01, 0xFC, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0x03, 0xC1, 0xE0, 0xF0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0xF0,
  0x20, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70,
  0x0E, 0x00, 0x40, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x08, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x38, 0x1E, 0x1C, 0x03,
  0x8E, 0x00, 0x77, 0x00, 0x1D, 0x80, 0x03, 0x60, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0,
  0x0E, 0x00, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x1F, 0x00, 0x06, 0x03, 0x80, 0x07, 0xFC, 0x00, 0x60, 0x30, 0x01,
  0xE0, 0xE0, 0x06, 0x07, 0x00, 0x38, 0x07, 0x00, 0x60, 0x60, 0x03, 0x00,
  0x30, 0x02, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x20, 0xC0, 0x0E, 0x00, 0x60,
  0x02, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x61, 0x80, 0x18, 0x00, 0x60, 0x06,
  0x18, 0x01, 0x80, 0x06, 0x00, 0x63, 0x80, 0x38, 0x00, 0xC0, 0x06, 0x30,
  0x03, 0x00, 0x0C, 0x00, 0x63, 0x00, 0x70, 0x00, 0xC0, 0x06, 0x30, 0x06,
  0x00, 0x0C, 0x00, 0x67, 0x00, 0x60, 0x01, 0x80, 0x06, 0x60, 0x06, 0x00,
  0x18, 0x00, 0xC6, 0x00, 0xE0, 0x01, 0x80, 0x0C, 0x60, 0x0C, 0x00, 0x18,
  0x00, 0xC6, 0x00, 0xC0, 0x03, 0x80, 0x0C, 0x60, 0x0C, 0x00, 0x30, 0x01,
  0x8C, 0x00, 0xC0, 0x03, 0x00, 0x18, 0xC0, 0x1C, 0x00, 0x30, 0x01, 0x8C,
  0x01, 0x80, 0x07, 0x00, 0x30, 0xC0, 0x18, 0x00, 0x70, 0x03, 0x0C, 0x01,
  0x80, 0x0E, 0x00, 0x30, 0xC0, 0x18, 0x01, 0xE0, 0x06, 0x0C, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0xC0, 0x0C, 0x03, 0x30, 0x1C, 0x0E, 0x00, 0xE0, 0x63,
  0x03, 0x80, 0xE0, 0x0F, 0xBC, 0x3C, 0xF0, 0x06, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x60, 0x01, 0xE0, 0x07, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x03, 0x80, 0x18, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x70, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x01, 0xC0, 0x06, 0x00, 0x07, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06,
  0x38, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x30, 0x03, 0xF0, 0x03, 0x80, 0x03, 0xC0, 0x1C, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x38, 0x1C, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0x80, 0x03, 0xC0, 0x0C, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x60, 0x38, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x1E, 0x03,
  0x00, 0x01, 0xE0, 0x18, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x38, 0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x06, 0x07, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0x83, 0x80, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x0F,
  0x00, 0x0E, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x70,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x07, 0x00, 0x60, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xF0,
  0x01, 0x80, 0x1F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x03, 0x80,
  0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x07, 0xFF, 0xC6, 0x00, 0x1F, 0xFF, 0x18, 0x00, 0x00, 0x1C,
  0x60, 0x00, 0x00, 0x63, 0x80, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x06, 0x38,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x38, 0x06,
  0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x18,
  0x07, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80,
  0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x18, 0x0E,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x07, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x06, 0x00, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0xC0, 0x03, 0x80, 0x00, 0x60, 0x03, 0x80, 0x00, 0x30, 0x03, 0x80,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x01, 0x83, 0xC0,
  0x00, 0x00, 0xC3, 0xC0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x73, 0xF0,
  0x00, 0x00, 0x33, 0xF8, 0x00, 0x00, 0x1B, 0x8E, 0x00, 0x00, 0x0F, 0x87,
  0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x60,
  0x03, 0x80, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x80, 0x03,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x1B, 0x00,
  0x00, 0x00, 0x7C, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x6C, 0x00, 0x00,
  0x03, 0xF0, 0x0D, 0x80, 0x00, 0x00, 0x6E, 0x03, 0xB8, 0x00, 0x00, 0x1D,
  0x80, 0x77, 0x00, 0x00, 0x03, 0x30, 0x0C, 0x60, 0x00, 0x00, 0xE6, 0x01,
  0x8C, 0x00, 0x00, 0x18, 0xC0, 0x31, 0x80, 0x00, 0x07, 0x38, 0x06, 0x30,
  0x00, 0x00, 0xC7, 0x01, 0xC7, 0x00, 0x00, 0x30, 0xC0, 0x38, 0x60, 0x00,
  0x06, 0x18, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x00, 0x70,
  0x60, 0x18, 0x30, 0x00, 0x0C, 0x1C, 0x03, 0x06, 0x00, 0x03, 0x83, 0x00,
  0xE0, 0xE0, 0x00, 0x60, 0x60, 0x1C, 0x0C, 0x00, 0x1C, 0x0C, 0x03, 0x01,
  0x80, 0x03, 0x01, 0x80, 0x60, 0x30, 0x00, 0xE0, 0x70, 0x0C, 0x06, 0x00,
  0x18, 0x0E, 0x01, 0x80, 0xC0, 0x07, 0x01, 0x80, 0x70, 0x1C, 0x00, 0xC0,
  0x30, 0x0E, 0x01, 0x80, 0x38, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x30, 0x07, 0x00, 0xC0,
  0x1C, 0x0E, 0x00, 0xC0, 0x38, 0x01, 0x81, 0x80, 0x18, 0x07, 0x00, 0x30,
  0x70, 0x03, 0x00, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC3, 0x80,
  0x1C, 0x03, 0x00, 0x18, 0x60, 0x03, 0x80, 0x60, 0x03, 0x9C, 0x00, 0x60,
  0x1C, 0x00, 0x33, 0x00, 0x0C, 0x03, 0x80, 0x06, 0xC0, 0x01, 0x80, 0x60,
  0x00, 0xD8, 0x00, 0x30, 0x0C, 0x00, 0x1E, 0x00, 0x0E, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x70, 0x00, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x03, 0x80, 0xF8, 0x00, 0x00, 0x60, 0x1F, 0x00, 0x00, 0x0C,
  0x03, 0x60, 0x00, 0x01, 0x80, 0x6E, 0x00, 0x00, 0x70, 0x0C, 0xC0, 0x00,
  0x0E, 0x03, 0x9C, 0x00, 0x01, 0xC0, 0x71, 0x80, 0x00, 0x30, 0x0E, 0x30,
  0x00, 0x06, 0x01, 0x87, 0x00, 0x00, 0xC0, 0x30, 0x60, 0x00, 0x38, 0x06,
  0x0C, 0x00, 0x07, 0x01, 0xC1, 0xC0, 0x00, 0xC0, 0x38, 0x18, 0x00, 0x18,
  0x07, 0x03, 0x80, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x06, 0x00,
  0x1C, 0x03, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x0C, 0x00, 0x60, 0x1C, 0x01,
  0x80, 0x0C, 0x03, 0x80, 0x38, 0x01, 0x80, 0x60, 0x03, 0x00, 0x70, 0x0C,
  0x00, 0x70, 0x0E, 0x01, 0x80, 0x06, 0x01, 0xC0, 0x70, 0x00, 0xC0, 0x30,
  0x0E, 0x00, 0x1C, 0x06, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x30, 0x00, 0x30,
  0x38, 0x06, 0x00, 0x07, 0x07, 0x00, 0xC0, 0x00, 0x60, 0xE0, 0x38, 0x00,
  0x0E, 0x18, 0x07, 0x00, 0x00, 0xC3, 0x00, 0xC0, 0x00, 0x18, 0x60, 0x18,
  0x00, 0x03, 0x9C, 0x03, 0x00, 0x00, 0x33, 0x80, 0xE0, 0x00, 0x06, 0x70,
  0x1C, 0x00, 0x00, 0xEC, 0x03, 0x80, 0x00, 0x0D, 0x80, 0x60, 0x00, 0x01,
  0xF0, 0x0C, 0x00, 0x00, 0x1E, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x07,
  0x18, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0x70, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x7E, 0x00, 0x70, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x78,
  0x03, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xF0, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x07, 0x18, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x78, 0x07,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x1C, 0x00, 0x7E, 0x00, 0x70, 0x00, 0x3C, 0x01, 0x80, 0x00, 0x70,
  0x06, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x07, 0x03, 0x80, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x78, 0x03, 0x00, 0x0F, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x60, 0x00, 0xE0, 0x01, 0x80, 0x01,
  0x80, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x30,
  0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x18, 0x38, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x07, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x3E, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x30, 0x1C, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x70, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x30, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00,
  0x03, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x38, 0x03, 0x80, 0x00,
  0xE0, 0x0C, 0x00, 0x01, 0x80, 0x70, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1B,
  0x00, 0x00, 0xC6, 0x00, 0x01, 0xB0, 0x00, 0x1C, 0x60, 0x00, 0x33, 0x00,
  0x01, 0x86, 0x00, 0x03, 0x30, 0x00, 0x18, 0x60, 0x00, 0x33, 0x00, 0x03,
  0x86, 0x00, 0x06, 0x30, 0x00, 0x30, 0x60, 0x00, 0x63, 0x00, 0x03, 0x06,
  0x00, 0x0E, 0x30, 0x00, 0x70, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x06, 0x00,
  0x0C, 0x30, 0x00, 0xE0, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x07, 0x00, 0x18,
  0x38, 0x00, 0xC0, 0x70, 0x03, 0x81, 0x80, 0x1C, 0x07, 0x00, 0x30, 0x18,
  0x01, 0x80, 0x70, 0x03, 0x01, 0x80, 0x18, 0x07, 0x00, 0x60, 0x18, 0x03,
  0x80, 0x70, 0x06, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0x30, 0x0C, 0x01, 0x80, 0x70, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x30,
  0x18, 0x01, 0x80, 0xE0, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x30, 0x38,
  0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x1C, 0x1C, 0x00, 0x30, 0x30, 0x00,
  0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC3,
  0x80, 0x03, 0x0E, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC7, 0x00,
  0x03, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x39, 0x80, 0x00, 0xC6, 0x00, 0x03,
  0x98, 0x00, 0x0C, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xCC, 0x00, 0x03, 0xB0,
  0x00, 0x0C, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xE0, 0x00,
  0x0D, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x06, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x60, 0x18, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70,
  0x07, 0x00, 0x03, 0x00, 0x38, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x18, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xE0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0x30, 0x03, 0x98, 0x01,
  0x8C, 0x01, 0xC6, 0x00, 0xC3, 0x00, 0xE1, 0x80, 0x60, 0xE0, 0x70, 0x30,
  0x30, 0x18, 0x38, 0x0C, 0x18, 0x06, 0x1C, 0x03, 0x0C, 0x01, 0xCC, 0x00,
  0x66, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x70, 0x70, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x0E,
  0x03, 0x00, 0x06, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE,
  0x07, 0xE0, 0x0C, 0x0F, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x0C,
  0x70, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0x60, 0x00, 0x18, 0xE0, 0x00, 0x18,
  0xE0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF8,
  0x60, 0x01, 0xF8, 0x70, 0x03, 0xB8, 0x78, 0x0F, 0x38, 0x3F, 0xFC, 0x38,
  0x0F, 0xF8, 0x38, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x1F, 0xE0, 0x06, 0x3F, 0xFC, 0x03, 0x38, 0x0F, 0x01,
  0xB0, 0x03, 0x81, 0xF0, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x70, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0E, 0x00, 0x01,
  0x87, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x18, 0xE0, 0x00, 0x0C, 0x70, 0x00, 0x06, 0x30, 0x00, 0x07, 0x18, 0x00,
  0x03, 0x8C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x71, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x1C, 0x30,
  0x00, 0x0C, 0x3C, 0x00, 0x0E, 0x1F, 0x00, 0x0E, 0x0D, 0xC0, 0x0E, 0x06,
  0x70, 0x0E, 0x03, 0x1F, 0xFE, 0x01, 0x83, 0xFE, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xC0, 0x38,
  0x07, 0x80, 0x1C, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x38, 0x00, 0x06, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x08, 0x07, 0x00, 0x3F, 0xE0, 0xC0,
  0x0F, 0xFF, 0x18, 0x03, 0xC0, 0x73, 0x00, 0xE0, 0x06, 0x60, 0x38, 0x00,
  0x7C, 0x0E, 0x00, 0x07, 0x81, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0C, 0x0C,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x70, 0x00, 0x0E, 0x0C, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x18, 0x30, 0x00, 0x07, 0x06, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x18,
  0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x1C, 0x0C, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0x38, 0x01,
  0xF0, 0x03, 0x80, 0xF6, 0x00, 0x7F, 0xF8, 0xC0, 0x03, 0xFE, 0x18, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x38, 0x00, 0x06, 0x38, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x70, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x20, 0x38, 0x00, 0xF0,
  0x1C, 0x03, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x03, 0x80, 0x03, 0xFC, 0x00, 0xFB, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFF,
  0x06, 0x00, 0x3F, 0xFC, 0x60, 0x07, 0x00, 0xE6, 0x00, 0xE0, 0x06, 0x60,
  0x1C, 0x00, 0x3E, 0x03, 0x80, 0x01, 0xE0, 0x30, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x1C,
  0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x18, 0x1C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x38, 0x18, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x1E, 0x01,
  0xC0, 0x03, 0xE0, 0x0E, 0x00, 0x7C, 0x00, 0xF0, 0x1E, 0xC0, 0x07, 0xFF,
  0x8C, 0x00, 0x1F, 0xF0, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x1F, 0xF0, 0x06, 0x1F, 0xFC, 0x03, 0x38, 0x0E, 0x01, 0xB8, 0x03, 0x81,
  0xD8, 0x00, 0xC0, 0xF8, 0x00, 0x60, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x1C,
  0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01,
  0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00,
  0x03, 0x06, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0x80,
  0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x01, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C,
  0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x08, 0x78, 0x00, 0xFF,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x00,
  0xC0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x06, 0x00, 0xE0,
  0x01, 0x80, 0x70, 0x00, 0x60, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x0C,
  0xF0, 0x00, 0x03, 0x7C, 0x00, 0x01, 0xFB, 0x80, 0x00, 0x7C, 0x60, 0x00,
  0x1C, 0x1C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0xE0, 0x18,
  0x00, 0x38, 0x07, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x38, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0xC0, 0x1C, 0x00, 0x30, 0x07, 0x00, 0x0E, 0x01,
  0x80, 0x01, 0x80, 0x60, 0x00, 0x70, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x60, 0xFF, 0x00, 0x3F, 0xC0, 0x0C,
  0x7F, 0xF8, 0x1F, 0xFE, 0x01, 0x9C, 0x07, 0x07, 0x01, 0xC0, 0x77, 0x00,
  0x71, 0xC0, 0x1C, 0x0F, 0xC0, 0x06, 0x60, 0x01, 0x81, 0xB0, 0x00, 0xDC,
  0x00, 0x30, 0x3C, 0x00, 0x1B, 0x00, 0x06, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x87,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xC0, 0x00,
  0x38, 0x60, 0x00, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE1, 0x80, 0x00, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x00, 0x01, 0x83, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x00, 0x06, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x83, 0xFC, 0x00, 0xC3, 0xFF,
  0x80, 0x67, 0x81, 0xC0, 0x33, 0x00, 0x70, 0x3B, 0x00, 0x18, 0x1F, 0x00,
  0x0C, 0x0D, 0x00, 0x07, 0x07, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC1, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87,
  0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0xE1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x3C, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x30, 0x18, 0x00, 0x1C,
  0x1C, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x86, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x73, 0x00, 0x00, 0x39, 0x80, 0x00, 0x1D, 0xC0, 0x00,
  0x0C, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x73, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x19, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18,
  0x00, 0x07, 0x0C, 0x00, 0x07, 0x07, 0x00, 0x03, 0x01, 0x80, 0x03, 0x80,
  0xE0, 0x03, 0x80, 0x3C, 0x07, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x3F, 0xC0, 0x03,
  0x1F, 0xFE, 0x00, 0x67, 0x01, 0xE0, 0x0F, 0x80, 0x1C, 0x03, 0xE0, 0x01,
  0xC0, 0x78, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x06,
  0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0x70, 0x00,
  0x0E, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0E, 0x06,
  0x00, 0x01, 0x81, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1C, 0x06, 0xE0, 0x07,
  0x00, 0xCE, 0x01, 0xC0, 0x18, 0xFF, 0xF0, 0x03, 0x07, 0xFC, 0x00, 0xE0,
  0x18, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x83, 0x01, 0xFF, 0xE3, 0x03, 0xC0, 0x73, 0x07, 0x00, 0x33, 0x0E, 0x00,
  0x1F, 0x1C, 0x00, 0x0F, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00,
  0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0xF0, 0x70, 0x03, 0xE0, 0x78, 0x0F, 0x60, 0x3F, 0xFC, 0x60, 0x0F, 0xF8,
  0x60, 0x01, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x61, 0xFC, 0x0C, 0x7F, 0x01,
  0x9C, 0x00, 0x36, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0x01,
  0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x01, 0xC1, 0x80, 0x01, 0x87, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0x86, 0x00, 0x07,
  0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x1E, 0x01, 0xE0, 0x1F, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x01, 0xFF, 0xF7,
  0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x1C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0x60, 0x00, 0xF0, 0x60, 0x01,
  0xE0, 0x70, 0x03, 0x60, 0x38, 0x0E, 0x60, 0x3F, 0xFC, 0x60, 0x0F, 0xF8,
  0xE0, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x1B, 0x80, 0x00,
  0x77, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x1C,
  0x30, 0x00, 0x30, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0x80, 0xC0, 0x07, 0x01,
  0x80, 0x0C, 0x03, 0x00, 0x38, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x1C,
  0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0,
  0xE0, 0x01, 0x81, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x38,
  0x00, 0x0C, 0x60, 0x00, 0x19, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0x70, 0x00, 0xF0, 0x00, 0xEE, 0x00, 0x1E, 0x00,
  0x19, 0xC0, 0x06, 0xC0, 0x07, 0x38, 0x00, 0xD8, 0x00, 0xE7, 0x00, 0x33,
  0x00, 0x18, 0x60, 0x06, 0x60, 0x07, 0x0C, 0x01, 0xCC, 0x00, 0xC1, 0x80,
  0x31, 0x80, 0x38, 0x30, 0x0E, 0x38, 0x06, 0x06, 0x01, 0x87, 0x00, 0xC0,
  0xC0, 0x30, 0x60, 0x38, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x81,
  0xC0, 0x60, 0x70, 0x30, 0x30, 0x0C, 0x0C, 0x06, 0x0E, 0x01, 0x83, 0x80,
  0xC1, 0xC0, 0x38, 0x60, 0x18, 0x30, 0x07, 0x1C, 0x03, 0x0E, 0x00, 0xE3,
  0x00, 0x61, 0x80, 0x1C, 0x60, 0x0E, 0x70, 0x01, 0x98, 0x00, 0xCC, 0x00,
  0x33, 0x00, 0x19, 0x80, 0x06, 0xE0, 0x03, 0x70, 0x00, 0xD8, 0x00, 0x6C,
  0x00, 0x1B, 0x00, 0x0D, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x06,
  0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x1C,
  0x00, 0x38, 0x03, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x07, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x30, 0x70, 0x00, 0x0E, 0x06,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x0C, 0x00, 0x18, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x06,
  0x03, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x70, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00,
  0x38, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x07, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x06,
  0x38, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x00, 0x00, 0x20, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xC7, 0x9E, 0x00, 0x0C, 0x70, 0x38, 0x00, 0x67, 0x00,
  0xE0, 0x03, 0x30, 0x03, 0x80, 0x39, 0x80, 0x0E, 0x01, 0x9C, 0x00, 0x78,
  0x18, 0xC0, 0x01, 0xE3, 0xC6, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoCondensed_ExtraLightItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 11, 46, 12, 1, -45 },
  { 65, 11, 13, 16, 7, -47 },
  { 83, 32, 45, 30, 1, -45 },
  { 263, 26, 59, 30, 2, -52 },
  { 455, 29, 47, 39, 6, -46 },
  { 626, 28, 47, 33, 2, -46 },
  { 791, 5, 13, 10, 6, -47 },
  { 800, 17, 64, 17, 3, -50 },
  { 936, 18, 64, 17, -4, -50 },
  { 1080, 24, 25, 26, 4, -45 },
  { 1155, 25, 32, 30, 3, -37 },
  { 1255, 7, 13, 12, -2, -5 },
  { 1267, 12, 2, 16, 2, -21 },
  { 1270, 5, 5, 14, 1, -4 },
  { 1274, 26, 49, 21, -2, -45 },
  { 1434, 25, 47, 30, 3, -46 },
  { 1581, 14, 45, 30, 8, -45 },
  { 1660, 27, 46, 30, 1, -46 },
  { 1816, 26, 47, 30, 2, -46 },
  { 1969, 27, 45, 30, 1, -45 },
  { 2121, 26, 46, 30, 4, -45 },
  { 2271, 23, 46, 30, 3, -45 },
  { 2404, 25, 45, 30, 5, -45 },
  { 2545, 28, 47, 30, 1, -46 },
  { 2710, 23, 46, 30, 5, -46 },
  { 2843, 9, 34, 12, 1, -33 },
  { 2882, 12, 41, 11, -2, -33 },
  { 2944, 23, 25, 28, 3, -33 },
  { 3016, 24, 15, 30, 3, -28 },
  { 3061, 23, 25, 28, 2, -33 },
  { 3133, 18, 47, 24, 6, -46 },
  { 3239, 44, 58, 49, 2, -44 },
  { 3558, 30, 45, 33, -2, -45 },
  { 3727, 29, 45, 33, 2, -45 },
  { 3891, 29, 47, 35, 4, -46 },
  { 4062, 31, 45, 35, 2, -45 },
  { 4237, 31, 45, 31, 2, -45 },
  { 4412, 31, 45, 30, 2, -45 },
  { 4587, 30, 47, 37, 4, -46 },
  { 4764, 35, 45, 38, 2, -45 },
  { 4961, 10, 45, 15, 3, -45 },
  { 5018, 28, 46, 30, 1, -45 },
  { 5179, 33, 45, 34, 2, -45 },
  { 5365, 21, 45, 28, 2, -45 },
  { 5484, 43, 45, 46, 2, -45 },
  { 5726, 35, 45, 38, 2, -45 },
  { 5923, 31, 47, 36, 3, -46 },
  { 6106, 30, 45, 33, 2, -45 },
  { 6275, 31, 54, 36, 3, -46 },
  { 6485, 30, 45, 34, 2, -45 },
  { 6654, 30, 47, 32, 2, -46 },
  { 6831, 29, 45, 32, 6, -45 },
  { 6995, 31, 46, 35, 4, -45 },
  { 7174, 30, 45, 33, 5, -45 },
  { 7343, 44, 45, 48, 6, -45 },
  { 7591, 35, 45, 32, -1, -45 },
  { 7788, 29, 45, 32, 6, -45 },
  { 7952, 33, 45, 32, 0, -45 },
  { 8138, 18, 61, 13, 0, -51 },
  { 8276, 10, 49, 21, 6, -45 },
  { 8338, 17, 61, 13, -4, -51 },
  { 8468, 17, 22, 23, 3, -45 },
  { 8515, 22, 2, 23, -3, 0 },
  { 8521, 8, 8, 17, 8, -47 },
  { 8529, 24, 35, 29, 1, -34 },
  { 8634, 25, 48, 30, 1, -47 },
  { 8784, 24, 35, 28, 2, -34 },
  { 8889, 27, 48, 30, 3, -47 },
  { 9051, 24, 35, 28, 2, -34 },
  { 9156, 19, 48, 18, 4, -48 },
  { 9270, 28, 47, 30, 0, -34 },
  { 9435, 25, 47, 29, 1, -47 },
  { 9582, 10, 45, 12, 2, -45 },
  { 9639, 20, 58, 13, -8, -45 },
  { 9784, 26, 47, 26, 1, -47 },
  { 9937, 10, 47, 12, 2, -47 },
  { 9996, 43, 34, 47, 1, -34 },
  { 10179, 25, 34, 30, 1, -34 },
  { 10286, 25, 35, 30, 2, -34 },
  { 10396, 27, 47, 30, -1, -34 },
  { 10555, 24, 47, 30, 3, -34 },
  { 10696, 19, 34, 18, 1, -34 },
  { 10777, 23, 35, 27, 1, -34 },
  { 10878, 14, 43, 18, 3, -42 },
  { 10954, 24, 34, 29, 3, -33 },
  { 11056, 23, 33, 26, 4, -33 },
  { 11151, 35, 33, 40, 5, -33 },
  { 11296, 27, 33, 26, -1, -33 },
  { 11408, 30, 46, 26, -3, -33 },
  { 11581, 25, 33, 26, 0, -33 },
  { 11685, 20, 62, 18, 2, -49 },
  { 11840, 11, 53, 13, 1, -45 },
  { 11913, 20, 62, 18, -4, -49 },
  { 12068, 29, 11, 37, 4, -24 },
};

const GFXfont RobotoCondensed_ExtraLightItalic63pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic63pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic63pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC63PT7B_H_
