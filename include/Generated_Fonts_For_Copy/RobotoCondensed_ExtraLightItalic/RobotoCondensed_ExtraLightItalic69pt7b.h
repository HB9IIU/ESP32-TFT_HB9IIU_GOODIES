#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC69PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x07,
  0x80, 0x70, 0x06, 0x00, 0x18, 0x31, 0x83, 0x38, 0x73, 0x87, 0x38, 0x73,
  0x06, 0x30, 0x63, 0x06, 0x70, 0xE7, 0x0E, 0x60, 0xC6, 0x0C, 0x60, 0xCE,
  0x0C, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xE0, 0x18, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x60, 0x30, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x07, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x38, 0x03, 0x00, 0x08, 0x30, 0x03, 0x00,
  0x0C, 0x70, 0x03, 0x80, 0x18, 0x60, 0x03, 0x80, 0x38, 0x60, 0x03, 0x00,
  0x70, 0x60, 0x03, 0x00, 0x60, 0x60, 0x03, 0x00, 0xE0, 0x60, 0x03, 0x01,
  0xC0, 0x60, 0x03, 0x01, 0x80, 0x60, 0x07, 0x03, 0x80, 0x60, 0x06, 0x07,
  0x00, 0x60, 0x0E, 0x06, 0x00, 0x60, 0x0C, 0x0C, 0x00, 0x70, 0x1C, 0x1C,
  0x00, 0x38, 0x78, 0x18, 0x00, 0x1F, 0xF0, 0x30, 0x00, 0x0F, 0xC0, 0x70,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x03,
  0xF8, 0x00, 0x0E, 0x07, 0xFC, 0x00, 0x0C, 0x0E, 0x0E, 0x00, 0x1C, 0x1C,
  0x06, 0x00, 0x38, 0x18, 0x07, 0x00, 0x30, 0x38, 0x03, 0x00, 0x60, 0x30,
  0x03, 0x00, 0xE0, 0x70, 0x03, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x60,
  0x03, 0x03, 0x80, 0x60, 0x03, 0x03, 0x00, 0x60, 0x03, 0x06, 0x00, 0xE0,
  0x03, 0x0E, 0x00, 0xE0, 0x07, 0x0C, 0x00, 0xC0, 0x06, 0x18, 0x00, 0xE0,
  0x06, 0x38, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x60, 0x01, 0xC0, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x06, 0x00,
  0x07, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00,
  0xC0, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x9C,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xE0, 0x38,
  0x01, 0x83, 0x80, 0x70, 0x03, 0x0E, 0x00, 0x70, 0x06, 0x38, 0x00, 0xE0,
  0x1C, 0x70, 0x00, 0xE0, 0x39, 0xC0, 0x01, 0xC0, 0x63, 0x80, 0x01, 0xC1,
  0xC6, 0x00, 0x01, 0x83, 0x8C, 0x00, 0x03, 0x8E, 0x38, 0x00, 0x03, 0x9C,
  0x70, 0x00, 0x07, 0x70, 0xE0, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0x0F, 0x81,
  0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xFC, 0x07,
  0x00, 0x03, 0x9C, 0x0F, 0x00, 0x0E, 0x38, 0x0F, 0x00, 0x78, 0x38, 0x0F,
  0xFF, 0xE0, 0x70, 0x07, 0xFF, 0x00, 0x70, 0x01, 0xF0, 0x00, 0x00, 0x39,
  0xCE, 0x63, 0x39, 0xCE, 0x63, 0x19, 0xCC, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x1C, 0x03, 0x80, 0x7F, 0xC0, 0xE0, 0xFC, 0xFC, 0x30,
  0xFE, 0x0F, 0xED, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x30, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x81, 0x80, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x01, 0x00,
  0x02, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x70,
  0x70, 0xE0, 0x40, 0xFF, 0xFF, 0xFF, 0xE0, 0x6F, 0xFF, 0x60, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xC0,
  0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E, 0x30,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0E, 0x06, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0x30, 0x00, 0x38,
  0x03, 0x80, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x3C, 0x01, 0xF8, 0x1F, 0xF0, 0xFC, 0xEF, 0xC1, 0x9E, 0x03, 0x70,
  0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x70, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0xE0,
  0x1E, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x38,
  0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x0C,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0xE0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x60, 0x07, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x18, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x70, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x87, 0xF0, 0x00, 0x0C, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x70, 0x03, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x07,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x03, 0xF8, 0x01,
  0xC3, 0xFF, 0x80, 0x73, 0xF3, 0xF0, 0x19, 0xE0, 0x1E, 0x06, 0xE0, 0x03,
  0xC3, 0xF0, 0x00, 0x70, 0xF8, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0x60, 0x00,
  0x03, 0x98, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x71, 0x80, 0x00, 0x1C, 0x70,
  0x00, 0x0E, 0x1C, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x70,
  0x3C, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x1E, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x3C, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0xF0, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x1E, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3C, 0x07, 0x80,
  0x3C, 0x00, 0xE0, 0x38, 0x00, 0x78, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x06,
  0x1C, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0D, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0x30, 0x00, 0x07, 0x9C, 0x00, 0x07, 0xCE,
  0x00, 0x07, 0xE3, 0x80, 0x07, 0x61, 0xC0, 0x07, 0x30, 0x70, 0x07, 0x38,
  0x1F, 0xBF, 0x1C, 0x07, 0xFF, 0x0C, 0x01, 0xFC, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x3C, 0x0F, 0x83, 0xC0, 0x60, 0x00, 0x00,
  0x30, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x20, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0x04, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0xF0, 0x1E, 0x03, 0xC1, 0xE0, 0x0E, 0x0E, 0x00, 0x38, 0xE0,
  0x01, 0xC6, 0x00, 0x06, 0x70, 0x00, 0x33, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x7E, 0x00, 0x06, 0x01, 0xC0, 0x01, 0xFF, 0x80, 0x06, 0x01, 0x80, 0x03,
  0xE3, 0xC0, 0x06, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x03, 0x03, 0x00, 0x0E,
  0x00, 0x60, 0x03, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x0C, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x1C, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x18, 0x00, 0xC0, 0x01, 0xC0, 0x07, 0x18, 0x01, 0xC0,
  0x01, 0x80, 0x06, 0x38, 0x01, 0xC0, 0x01, 0x80, 0x06, 0x30, 0x01, 0x80,
  0x03, 0x80, 0x06, 0x30, 0x03, 0x80, 0x03, 0x80, 0x06, 0x30, 0x03, 0x80,
  0x03, 0x00, 0x06, 0x70, 0x03, 0x00, 0x03, 0x00, 0x0E, 0x60, 0x03, 0x00,
  0x03, 0x00, 0x0C, 0x60, 0x07, 0x00, 0x07, 0x00, 0x0C, 0x60, 0x07, 0x00,
  0x06, 0x00, 0x0C, 0x60, 0x06, 0x00, 0x06, 0x00, 0x1C, 0x60, 0x06, 0x00,
  0x06, 0x00, 0x18, 0x60, 0x06, 0x00, 0x0E, 0x00, 0x18, 0xE0, 0x06, 0x00,
  0x0C, 0x00, 0x38, 0xE0, 0x06, 0x00, 0x1C, 0x00, 0x30, 0xE0, 0x06, 0x00,
  0x1C, 0x00, 0x70, 0xE0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0xE0, 0x06, 0x00,
  0x6C, 0x00, 0xE0, 0xE0, 0x06, 0x00, 0x6C, 0x00, 0xC0, 0x60, 0x07, 0x00,
  0xCE, 0x01, 0x80, 0x60, 0x07, 0x03, 0x86, 0x07, 0x00, 0x60, 0x03, 0xFF,
  0x07, 0xFF, 0x00, 0x60, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x70, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x10, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x30, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00,
  0x19, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xE0,
  0x0F, 0xF0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0xF0, 0x07, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x07, 0xC0, 0x0E, 0x00,
  0x01, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x1F, 0x00, 0x60, 0x01, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x06,
  0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0E, 0x00,
  0xFF, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38,
  0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0xF0, 0x0C, 0x00, 0x00, 0x38, 0x03,
  0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x1C, 0x00, 0x0F, 0x80, 0x06, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18, 0x70, 0x00,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x07, 0xFF, 0xE3, 0x80, 0x03, 0xFF, 0xF1, 0xC0, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0E,
  0x18, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x18, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30,
  0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x1C,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x03, 0x00, 0x07, 0x80, 0x00, 0x18, 0x00,
  0x78, 0x00, 0x00, 0xC0, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x07, 0x80, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x18, 0x07, 0x80,
  0x00, 0x00, 0xC0, 0x78, 0x00, 0x00, 0x06, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x00, 0x1C, 0x7C, 0x00, 0x00,
  0x00, 0xC7, 0xE0, 0x00, 0x00, 0x06, 0x7B, 0x80, 0x00, 0x00, 0x77, 0x9C,
  0x00, 0x00, 0x03, 0xF8, 0x70, 0x00, 0x00, 0x1F, 0x83, 0x80, 0x00, 0x00,
  0xF8, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x30, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x30, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x38, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x1B, 0x00,
  0x00, 0x00, 0x0D, 0x80, 0x36, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x6E, 0x00,
  0x00, 0x00, 0x6E, 0x01, 0xDC, 0x00, 0x00, 0x01, 0xDC, 0x03, 0xB8, 0x00,
  0x00, 0x03, 0x30, 0x07, 0x30, 0x00, 0x00, 0x0E, 0x60, 0x0C, 0x60, 0x00,
  0x00, 0x18, 0xC0, 0x18, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x31, 0xC0, 0x00,
  0x01, 0xC7, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x8E, 0x01, 0xC3, 0x00, 0x00,
  0x0E, 0x18, 0x03, 0x86, 0x00, 0x00, 0x1C, 0x30, 0x06, 0x0C, 0x00, 0x00,
  0x70, 0x60, 0x0C, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x18, 0x38, 0x00, 0x03,
  0x83, 0x80, 0x70, 0x70, 0x00, 0x06, 0x07, 0x00, 0xE0, 0x60, 0x00, 0x1C,
  0x0C, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x18, 0x03, 0x01, 0x80, 0x00, 0xE0,
  0x70, 0x06, 0x03, 0x80, 0x01, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0x07, 0x01,
  0xC0, 0x38, 0x06, 0x00, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x00, 0x38, 0x06,
  0x00, 0xE0, 0x18, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x01, 0xC0, 0x38,
  0x03, 0x00, 0x70, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x01, 0x80, 0x70, 0x03, 0x00,
  0x70, 0x03, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x06, 0x03, 0x80, 0x1C, 0x01,
  0x80, 0x0E, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x0C, 0x1C, 0x00, 0x70, 0x0E,
  0x00, 0x18, 0x70, 0x00, 0xC0, 0x1C, 0x00, 0x30, 0xE0, 0x01, 0x80, 0x30,
  0x00, 0x63, 0x80, 0x03, 0x00, 0x60, 0x00, 0xE7, 0x00, 0x0E, 0x00, 0xC0,
  0x01, 0xDC, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xB0, 0x00, 0x38, 0x07, 0x00,
  0x03, 0xE0, 0x00, 0x60, 0x0E, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x18, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0x00,
  0xF8, 0x00, 0x00, 0x1C, 0x03, 0xF0, 0x00, 0x00, 0x70, 0x0D, 0xC0, 0x00,
  0x01, 0x80, 0x33, 0x00, 0x00, 0x06, 0x01, 0xCE, 0x00, 0x00, 0x38, 0x07,
  0x18, 0x00, 0x00, 0xE0, 0x1C, 0x60, 0x00, 0x03, 0x80, 0x71, 0xC0, 0x00,
  0x0C, 0x01, 0x83, 0x00, 0x00, 0x30, 0x06, 0x0E, 0x00, 0x00, 0xC0, 0x38,
  0x38, 0x00, 0x07, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x03, 0x81, 0xC0, 0x00,
  0x70, 0x0E, 0x03, 0x00, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x06, 0x00, 0xC0,
  0x38, 0x00, 0x38, 0x07, 0x00, 0x60, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x03,
  0x80, 0x70, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x0C, 0x00, 0x30, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x38, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x30, 0x00,
  0x38, 0x06, 0x00, 0xC0, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x01, 0x80, 0xE0,
  0x1C, 0x00, 0x07, 0x03, 0x80, 0x70, 0x00, 0x0C, 0x0E, 0x01, 0xC0, 0x00,
  0x38, 0x38, 0x06, 0x00, 0x00, 0xE0, 0xC0, 0x18, 0x00, 0x01, 0x87, 0x00,
  0xE0, 0x00, 0x07, 0x1C, 0x03, 0x80, 0x00, 0x0C, 0x70, 0x0E, 0x00, 0x00,
  0x31, 0xC0, 0x38, 0x00, 0x00, 0xE6, 0x00, 0xC0, 0x00, 0x01, 0x98, 0x03,
  0x00, 0x00, 0x07, 0xE0, 0x1C, 0x00, 0x00, 0x1F, 0x80, 0x70, 0x00, 0x00,
  0x3E, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0x80,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x38, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x38, 0x00, 0xFE, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x78, 0x03, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0xF0, 0x07,
  0x00, 0x00, 0xF0, 0x03, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xDE, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x38, 0x00, 0xFE, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x0E, 0x00, 0x01, 0xE0, 0x06, 0x00, 0x00, 0x78, 0x03, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0xE0, 0x06, 0x00,
  0x01, 0xE0, 0x07, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x06, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x03,
  0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x30, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x07,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x38, 0x0C, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x18, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x01, 0xC0, 0x06, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x18, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x00, 0x30, 0x70, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x0D, 0xC0, 0x00,
  0x38, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x19, 0xC0, 0x00,
  0x30, 0xE0, 0x00, 0x18, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x70, 0xC0, 0x00,
  0xE0, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x60, 0xC0, 0x00,
  0xC0, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x01,
  0x80, 0x60, 0x01, 0xC0, 0xC0, 0x03, 0x80, 0x70, 0x01, 0x80, 0xE0, 0x03,
  0x80, 0x70, 0x01, 0x80, 0xE0, 0x03, 0x00, 0x70, 0x03, 0x80, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0x70, 0x0E, 0x00, 0x60, 0x1C, 0x00, 0x70, 0x0C, 0x00, 0x60, 0x1C,
  0x00, 0x70, 0x1C, 0x00, 0x60, 0x18, 0x00, 0x70, 0x18, 0x00, 0x60, 0x38,
  0x00, 0x30, 0x18, 0x00, 0x70, 0x38, 0x00, 0x30, 0x38, 0x00, 0x70, 0x30,
  0x00, 0x30, 0x30, 0x00, 0x70, 0x70, 0x00, 0x30, 0x70, 0x00, 0x70, 0x70,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0xE0,
  0x00, 0x30, 0xE0, 0x00, 0x30, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x31, 0xC0,
  0x00, 0x39, 0xC0, 0x00, 0x31, 0xC0, 0x00, 0x39, 0x80, 0x00, 0x31, 0x80,
  0x00, 0x39, 0x80, 0x00, 0x33, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x33, 0x80,
  0x00, 0x3B, 0x00, 0x00, 0x33, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x03,
  0x00, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80,
  0xE0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0,
  0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x36, 0x00, 0x1D, 0x80, 0x06, 0x60, 0x03, 0x98, 0x00, 0xC7,
  0x00, 0x70, 0xC0, 0x18, 0x30, 0x0E, 0x0C, 0x03, 0x03, 0x01, 0xC0, 0xC0,
  0x60, 0x38, 0x38, 0x0E, 0x0C, 0x01, 0x87, 0x00, 0x61, 0x80, 0x18, 0xE0,
  0x06, 0x70, 0x01, 0xDC, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x06,
  0x07, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x7C, 0x03, 0xC0, 0x1E, 0x00, 0x38, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFC, 0x01, 0xC0, 0x78, 0x00, 0x30,
  0x3C, 0x00, 0x06, 0x07, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x18, 0x70, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x87, 0x00, 0x01,
  0xF0, 0x60, 0x00, 0x6E, 0x0E, 0x00, 0x3D, 0xC0, 0xE0, 0x1E, 0x38, 0x1F,
  0xFF, 0x87, 0x00, 0xFF, 0xC0, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x0F, 0x80, 0x03, 0x07, 0xFE, 0x00, 0x63, 0xFF, 0xE0, 0x1C,
  0xE0, 0x1E, 0x03, 0xB8, 0x01, 0xE0, 0x7C, 0x00, 0x1C, 0x0F, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0x86, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E,
  0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x18, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0C, 0x38,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x03,
  0x87, 0xC0, 0x00, 0xE0, 0xEE, 0x00, 0x38, 0x18, 0xE0, 0x1E, 0x03, 0x0F,
  0xFF, 0x80, 0x60, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x07, 0x00, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x38, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07,
  0x38, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x07, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x01,
  0xE0, 0x1E, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x03, 0xE0,
  0x18, 0x00, 0x7F, 0xE0, 0xE0, 0x03, 0xFF, 0xE3, 0x80, 0x3E, 0x01, 0xCE,
  0x00, 0xE0, 0x03, 0x30, 0x07, 0x00, 0x06, 0xC0, 0x38, 0x00, 0x0F, 0x00,
  0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x03, 0x03, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x70, 0x06, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0xDC, 0x00, 0xF0, 0x0E, 0x60, 0x01, 0xFF, 0xF1, 0x80,
  0x03, 0xFF, 0x06, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x07,
  0x00, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x38, 0x00, 0x06, 0x0E, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x71, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07,
  0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE6, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x18, 0x0F, 0x00, 0x0E, 0x01, 0xE0,
  0x0F, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x30, 0x01, 0xFF, 0xF1, 0xC0, 0x1F, 0x01, 0xE7, 0x00,
  0xF0, 0x01, 0x9C, 0x03, 0x80, 0x03, 0x60, 0x1C, 0x00, 0x07, 0x80, 0x60,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x38, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x1C, 0x06, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0x80, 0x70, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x6E, 0x00, 0x78, 0x07, 0x30, 0x00, 0xFF, 0xF8, 0xC0, 0x01,
  0xFF, 0x87, 0x00, 0x00, 0xF8, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x40, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x03, 0xC0,
  0x03, 0x07, 0xFE, 0x00, 0xC3, 0xFF, 0xC0, 0x71, 0xC0, 0x78, 0x1C, 0xC0,
  0x0E, 0x07, 0x60, 0x01, 0xC1, 0xB0, 0x00, 0x70, 0x68, 0x00, 0x1C, 0x1E,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x1C, 0x70, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x1C, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00,
  0x03, 0x86, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0C, 0x38,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x06, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x80, 0x70, 0x00, 0xF0, 0x07,
  0x00, 0x1E, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x78, 0x00, 0x60, 0x0F,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0xC0, 0xF0, 0x00, 0x0C, 0x1E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x70,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0x1D, 0xF0, 0x00, 0x01, 0xBB, 0x80, 0x00,
  0x1F, 0x38, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x00, 0x70, 0x00, 0x30, 0x07, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x70, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0xC0, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xE0, 0x0E, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x03, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0E, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x1C, 0xE0, 0x1E, 0x0E, 0x01, 0xC0, 0x3B, 0x80, 0x1C,
  0x38, 0x01, 0xC0, 0x6E, 0x00, 0x18, 0xE0, 0x03, 0x80, 0xD8, 0x00, 0x3B,
  0x00, 0x03, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x30, 0x00, 0x03, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x30, 0x00, 0x07, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x18, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0xC1, 0xFF, 0x80, 0x30, 0xFF, 0xF0, 0x1C, 0x70, 0x1E,
  0x07, 0x30, 0x03, 0x81, 0xD8, 0x00, 0x70, 0x6C, 0x00, 0x1C, 0x1A, 0x00,
  0x07, 0x07, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0x30, 0xF0, 0x00, 0x0C, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x1C,
  0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x38, 0x60, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x30, 0xE0, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x06, 0x1C, 0x00, 0x01,
  0x86, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x38,
  0x00, 0x06, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C,
  0xE0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x73, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x0E, 0x38, 0x00,
  0x03, 0x8E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x0E,
  0x00, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0x83, 0xFF, 0x00,
  0x06, 0x3F, 0xFE, 0x00, 0x39, 0xC0, 0x3C, 0x00, 0xEC, 0x00, 0x78, 0x03,
  0xE0, 0x00, 0xE0, 0x0F, 0x00, 0x01, 0x80, 0x38, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x18, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0x70, 0x1F, 0x00, 0x03, 0x80, 0x76, 0x00, 0x1C, 0x01,
  0xCE, 0x01, 0xE0, 0x06, 0x1F, 0xFF, 0x00, 0x18, 0x3F, 0xF8, 0x00, 0x60,
  0x1F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFC, 0x0C, 0x03,
  0xFF, 0xE3, 0x81, 0xF0, 0x0E, 0x70, 0x38, 0x00, 0xEC, 0x0E, 0x00, 0x0D,
  0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x07,
  0x03, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x7C, 0x0E, 0x00, 0x1F, 0x00, 0xF0,
  0x0E, 0x60, 0x0F, 0xFF, 0x8C, 0x00, 0xFF, 0xC3, 0x80, 0x03, 0xE0, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x30, 0xFF, 0x03, 0x1F, 0xE0, 0x73, 0xC0, 0x07, 0x70, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x07, 0xC0, 0x3C, 0x01, 0xC0, 0x07, 0x00, 0xE0,
  0x00, 0xE0, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x70, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x1E, 0x01, 0xE0, 0x1F, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0xF8, 0x07, 0xF0,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x30, 0x70, 0x00, 0x06, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x03,
  0x06, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0x30, 0x00,
  0x0E, 0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x1F, 0x03,
  0x80, 0x07, 0xE0, 0x38, 0x01, 0xD8, 0x07, 0x80, 0xF3, 0x00, 0x7F, 0xFC,
  0xE0, 0x07, 0xFE, 0x1C, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xB0,
  0x00, 0x01, 0xD8, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x71, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x38, 0x30, 0x00, 0x18,
  0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x06,
  0x01, 0xC0, 0x07, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01,
  0x80, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x00, 0xC0,
  0x70, 0x00, 0x60, 0x30, 0x00, 0x30, 0x38, 0x00, 0x18, 0x18, 0x00, 0x0E,
  0x1C, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0xC0, 0x00, 0x70, 0x00, 0x19, 0x80,
  0x01, 0xE0, 0x00, 0x73, 0x00, 0x03, 0xC0, 0x00, 0xE6, 0x00, 0x07, 0x80,
  0x03, 0x8C, 0x00, 0x1B, 0x00, 0x07, 0x18, 0x00, 0x36, 0x00, 0x0C, 0x30,
  0x00, 0xEC, 0x00, 0x38, 0x70, 0x01, 0x9C, 0x00, 0x60, 0xE0, 0x07, 0x38,
  0x01, 0xC1, 0xC0, 0x0C, 0x70, 0x03, 0x83, 0x80, 0x38, 0xE0, 0x0E, 0x07,
  0x00, 0x71, 0xC0, 0x1C, 0x0E, 0x00, 0xC1, 0x80, 0x30, 0x1C, 0x03, 0x83,
  0x00, 0xE0, 0x38, 0x06, 0x06, 0x01, 0xC0, 0x30, 0x1C, 0x0C, 0x07, 0x00,
  0x60, 0x30, 0x18, 0x0E, 0x00, 0xC0, 0xE0, 0x30, 0x18, 0x01, 0x81, 0x80,
  0x70, 0x70, 0x03, 0x07, 0x00, 0xE0, 0xC0, 0x06, 0x0E, 0x01, 0xC3, 0x80,
  0x0C, 0x18, 0x03, 0x87, 0x00, 0x18, 0x70, 0x03, 0x0C, 0x00, 0x38, 0xC0,
  0x06, 0x38, 0x00, 0x73, 0x80, 0x0C, 0x60, 0x00, 0xE6, 0x00, 0x19, 0xC0,
  0x01, 0xDC, 0x00, 0x33, 0x80, 0x03, 0xB0, 0x00, 0x66, 0x00, 0x07, 0x60,
  0x00, 0xDC, 0x00, 0x0F, 0xC0, 0x01, 0xB0, 0x00, 0x0F, 0x00, 0x03, 0x60,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x30, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01,
  0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0xC0,
  0x07, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x9E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xC0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0x0F, 0xFE, 0x00, 0x07, 0x1C, 0x0F, 0x00, 0x06, 0x38, 0x07,
  0x00, 0x06, 0x30, 0x03, 0x80, 0x0E, 0x70, 0x01, 0xC0, 0x0C, 0x60, 0x00,
  0xE0, 0x1C, 0x60, 0x00, 0x70, 0x38, 0xE0, 0x00, 0x7F, 0xF0, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 12, 50, 13, 1, -49 },
  { 76, 12, 14, 18, 7, -52 },
  { 97, 35, 49, 33, 1, -49 },
  { 312, 28, 63, 32, 3, -56 },
  { 533, 32, 51, 43, 6, -50 },
  { 737, 31, 51, 36, 2, -50 },
  { 935, 5, 14, 11, 7, -52 },
  { 944, 19, 71, 19, 3, -55 },
  { 1113, 19, 71, 19, -4, -55 },
  { 1282, 26, 27, 28, 4, -49 },
  { 1370, 28, 37, 33, 3, -42 },
  { 1500, 8, 15, 13, -2, -6 },
  { 1515, 14, 2, 18, 2, -23 },
  { 1519, 4, 5, 15, 2, -4 },
  { 1522, 29, 53, 23, -3, -49 },
  { 1715, 28, 51, 32, 3, -50 },
  { 1894, 15, 49, 32, 9, -49 },
  { 1986, 29, 50, 32, 1, -50 },
  { 2168, 29, 51, 32, 2, -50 },
  { 2353, 29, 49, 32, 1, -49 },
  { 2531, 29, 50, 32, 4, -49 },
  { 2713, 26, 50, 32, 3, -49 },
  { 2876, 27, 49, 32, 6, -49 },
  { 3042, 29, 51, 32, 2, -50 },
  { 3227, 25, 50, 32, 5, -50 },
  { 3384, 10, 37, 13, 1, -36 },
  { 3431, 13, 45, 12, -2, -36 },
  { 3505, 26, 28, 30, 3, -36 },
  { 3596, 26, 16, 33, 4, -30 },
  { 3648, 26, 28, 30, 2, -36 },
  { 3739, 21, 51, 26, 6, -50 },
  { 3873, 48, 63, 53, 2, -48 },
  { 4251, 33, 49, 36, -2, -49 },
  { 4454, 32, 49, 36, 2, -49 },
  { 4650, 33, 51, 38, 4, -50 },
  { 4861, 34, 49, 38, 2, -49 },
  { 5070, 34, 49, 33, 2, -49 },
  { 5279, 34, 49, 33, 2, -49 },
  { 5488, 33, 51, 40, 4, -50 },
  { 5699, 38, 49, 41, 2, -49 },
  { 5932, 11, 49, 16, 3, -49 },
  { 6000, 31, 50, 32, 1, -49 },
  { 6194, 37, 49, 37, 2, -49 },
  { 6421, 24, 49, 31, 2, -49 },
  { 6568, 47, 49, 50, 2, -49 },
  { 6856, 38, 49, 41, 2, -49 },
  { 7089, 33, 51, 39, 4, -50 },
  { 7300, 33, 49, 36, 2, -49 },
  { 7503, 33, 59, 39, 4, -50 },
  { 7747, 33, 49, 38, 2, -49 },
  { 7950, 33, 51, 35, 2, -50 },
  { 8161, 31, 49, 35, 7, -49 },
  { 8351, 34, 50, 39, 4, -49 },
  { 8564, 33, 49, 36, 6, -49 },
  { 8767, 48, 49, 52, 7, -49 },
  { 9061, 38, 49, 35, -1, -49 },
  { 9294, 33, 49, 35, 6, -49 },
  { 9497, 36, 49, 35, 0, -49 },
  { 9718, 18, 67, 14, 1, -56 },
  { 9869, 10, 53, 23, 7, -49 },
  { 9936, 19, 67, 14, -4, -56 },
  { 10096, 18, 24, 25, 4, -49 },
  { 10150, 24, 2, 25, -3, 0 },
  { 10156, 8, 9, 18, 9, -52 },
  { 10165, 27, 38, 31, 1, -37 },
  { 10294, 27, 53, 32, 2, -52 },
  { 10473, 26, 38, 30, 2, -37 },
  { 10597, 30, 53, 33, 3, -52 },
  { 10796, 26, 38, 30, 2, -37 },
  { 10920, 21, 53, 20, 4, -53 },
  { 11060, 30, 51, 32, 0, -37 },
  { 11252, 26, 52, 32, 2, -52 },
  { 11421, 12, 49, 13, 2, -49 },
  { 11495, 23, 63, 14, -9, -49 },
  { 11677, 28, 52, 29, 2, -52 },
  { 11859, 12, 52, 13, 2, -52 },
  { 11937, 47, 37, 52, 1, -37 },
  { 12155, 26, 37, 32, 2, -37 },
  { 12276, 26, 38, 33, 3, -37 },
  { 12400, 30, 51, 32, -1, -37 },
  { 12592, 27, 51, 33, 3, -37 },
  { 12765, 20, 37, 20, 2, -37 },
  { 12858, 26, 38, 30, 1, -37 },
  { 12982, 15, 47, 19, 4, -46 },
  { 13071, 27, 37, 32, 3, -36 },
  { 13196, 25, 36, 28, 4, -36 },
  { 13309, 39, 36, 44, 5, -36 },
  { 13485, 30, 36, 29, -1, -36 },
  { 13620, 33, 50, 28, -3, -36 },
  { 13827, 28, 36, 29, 0, -36 },
  { 13953, 22, 68, 20, 2, -54 },
  { 14140, 12, 58, 14, 1, -49 },
  { 14227, 21, 68, 20, -4, -54 },
  { 14406, 32, 12, 40, 4, -27 },
};

const GFXfont RobotoCondensed_ExtraLightItalic69pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic69pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic69pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC69PT7B_H_
