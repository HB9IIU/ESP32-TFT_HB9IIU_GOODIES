#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC30PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x10, 0x84, 0x21, 0x08, 0x84, 0x21, 0x08, 0x44, 0x21, 0x08, 0x00,
  0x00, 0x08, 0x40, 0x4A, 0x52, 0x9C, 0xC8, 0x00, 0x84, 0x02, 0x10, 0x04,
  0x20, 0x08, 0x40, 0x21, 0x00, 0x42, 0x0F, 0xFF, 0x82, 0x10, 0x04, 0x20,
  0x08, 0x40, 0x21, 0x00, 0x42, 0x00, 0x84, 0x02, 0x18, 0x04, 0x20, 0x7F,
  0xF8, 0x10, 0x80, 0x42, 0x00, 0x84, 0x01, 0x08, 0x04, 0x20, 0x08, 0x40,
  0x00, 0x00, 0x80, 0x08, 0x00, 0x80, 0x3C, 0x0C, 0x20, 0x81, 0x10, 0x11,
  0x01, 0x30, 0x12, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x28, 0x02, 0x80, 0x6C, 0x04, 0x40, 0xC6,
  0x18, 0x1F, 0x00, 0x80, 0x08, 0x00, 0x80, 0x3C, 0x01, 0x90, 0x04, 0x20,
  0x20, 0x84, 0x82, 0x12, 0x08, 0x88, 0x44, 0x21, 0x10, 0x88, 0x81, 0xC4,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x70, 0x32, 0x20, 0x98, 0x44, 0x41, 0x31,
  0x04, 0x84, 0x24, 0x10, 0x80, 0x42, 0x01, 0x10, 0x03, 0x80, 0x03, 0xC0,
  0x23, 0x02, 0x08, 0x10, 0x41, 0x82, 0x0C, 0x30, 0x61, 0x01, 0x10, 0x0B,
  0x00, 0x30, 0x03, 0x00, 0x24, 0x02, 0x20, 0xB0, 0x85, 0x04, 0x70, 0x12,
  0x80, 0xD4, 0x03, 0x20, 0x19, 0x81, 0xC6, 0x1B, 0x1F, 0x08, 0x57, 0xA0,
  0x00, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08,
  0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x02, 0x02, 0x02, 0x00, 0x02, 0x00,
  0x40, 0x18, 0x02, 0x0C, 0x46, 0xEF, 0x03, 0x80, 0x60, 0x12, 0x04, 0x61,
  0x84, 0x20, 0x80, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x0F, 0xFF, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0x22, 0x26, 0x48, 0xFC, 0xF0, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x08, 0x00, 0x03, 0xC0, 0x42, 0x08, 0x31,
  0x01, 0x10, 0x12, 0x01, 0x20, 0x12, 0x01, 0x60, 0x14, 0x01, 0x40, 0x14,
  0x03, 0x40, 0x24, 0x02, 0x40, 0x2C, 0x02, 0x40, 0x64, 0x04, 0x40, 0xC4,
  0x08, 0x21, 0x01, 0xE0, 0x06, 0x3B, 0x94, 0x20, 0x40, 0x83, 0x04, 0x08,
  0x10, 0x20, 0x41, 0x82, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x00,
  0x07, 0xC0, 0xC6, 0x10, 0x33, 0x01, 0x20, 0x12, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x0F, 0xFC, 0x03, 0xC0, 0xC2,
  0x18, 0x11, 0x01, 0x20, 0x12, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x0C,
  0x0F, 0x00, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x80, 0x28, 0x06,
  0x80, 0x44, 0x0C, 0x61, 0x81, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x60, 0x0A,
  0x01, 0xA0, 0x12, 0x02, 0x20, 0x46, 0x04, 0x40, 0x84, 0x10, 0x43, 0x04,
  0x20, 0x44, 0x0C, 0xC0, 0x8F, 0xFF, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x0F, 0xF1, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x2F, 0x03, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x80, 0x48, 0x04, 0x80, 0x8C, 0x18, 0x63, 0x03, 0xE0,
  0x00, 0xE0, 0x60, 0x18, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x27,
  0x8F, 0x09, 0x40, 0xB0, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x28,
  0x0D, 0x01, 0x30, 0x63, 0x18, 0x3C, 0x00, 0x7F, 0xF0, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x03, 0xC0, 0x61, 0x06, 0x04, 0x20, 0x23, 0x01,
  0x10, 0x08, 0x80, 0x44, 0x02, 0x10, 0x20, 0xC6, 0x03, 0xE0, 0x61, 0x86,
  0x06, 0x20, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x20, 0x11, 0x81,
  0x86, 0x18, 0x1F, 0x00, 0x0F, 0x83, 0x18, 0xC1, 0x10, 0x14, 0x02, 0x80,
  0x50, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xE0, 0x34, 0x0C, 0xC6, 0x8F,
  0x90, 0x04, 0x00, 0x80, 0x20, 0x04, 0x03, 0x00, 0xC0, 0xE0, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x18, 0x0C, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x08, 0x21, 0x84, 0x20,
  0x00, 0x20, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x20, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x00, 0x1E, 0x31, 0x90, 0x50,
  0x28, 0x18, 0x08, 0x04, 0x02, 0x02, 0x03, 0x03, 0x01, 0x01, 0x01, 0x00,
  0x80, 0x40, 0x00, 0x00, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x3F, 0x00,
  0x06, 0x06, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x40, 0x40, 0x01, 0x04, 0x00,
  0x08, 0x40, 0xF0, 0x42, 0x08, 0x41, 0x20, 0x82, 0x09, 0x0C, 0x10, 0x50,
  0x40, 0x82, 0x82, 0x08, 0x14, 0x20, 0x41, 0x21, 0x02, 0x0A, 0x08, 0x10,
  0x50, 0x81, 0x02, 0x84, 0x08, 0x24, 0x20, 0xC1, 0x21, 0x06, 0x11, 0x04,
  0x51, 0x88, 0x3C, 0x70, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0xC0, 0x05, 0x00, 0x14, 0x00, 0x90, 0x02, 0x40, 0x11, 0x00,
  0x46, 0x03, 0x08, 0x08, 0x20, 0x60, 0x81, 0x02, 0x04, 0x08, 0x20, 0x20,
  0x80, 0x87, 0xFF, 0x10, 0x04, 0x80, 0x12, 0x00, 0x50, 0x01, 0x40, 0x07,
  0x00, 0x10, 0x0F, 0xE0, 0x60, 0x41, 0x00, 0x84, 0x02, 0x10, 0x0C, 0x40,
  0x21, 0x00, 0x8C, 0x02, 0x20, 0x10, 0x81, 0x83, 0xFC, 0x08, 0x08, 0x20,
  0x11, 0x80, 0x44, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x44, 0x03, 0x30,
  0x18, 0x80, 0xC3, 0xFE, 0x00, 0x03, 0xE0, 0x30, 0x41, 0x80, 0x8C, 0x02,
  0x20, 0x0C, 0x80, 0x14, 0x00, 0x50, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x04, 0x80, 0x12, 0x00,
  0xC8, 0x02, 0x10, 0x10, 0x61, 0x80, 0x7C, 0x00, 0x0F, 0xE0, 0x30, 0x60,
  0x40, 0x20, 0x80, 0x21, 0x00, 0x42, 0x00, 0x84, 0x01, 0x98, 0x02, 0x20,
  0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x4C, 0x01, 0x90, 0x02,
  0x20, 0x04, 0x40, 0x08, 0x80, 0x21, 0x00, 0xC6, 0x03, 0x08, 0x1C, 0x1F,
  0xE0, 0x00, 0x0F, 0xFC, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0xFF, 0xC1, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xFF, 0xC1, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xE0, 0x38, 0x61, 0x80, 0xC4, 0x01, 0x20, 0x04, 0x80,
  0x16, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x81,
  0xFA, 0x00, 0x28, 0x00, 0xA0, 0x06, 0x80, 0x12, 0x00, 0x44, 0x01, 0x10,
  0x0C, 0x30, 0xE0, 0x7E, 0x00, 0x08, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10,
  0x01, 0x10, 0x01, 0x10, 0x03, 0x10, 0x02, 0x30, 0x02, 0x20, 0x02, 0x20,
  0x02, 0x3F, 0xFE, 0x20, 0x06, 0x20, 0x04, 0x60, 0x04, 0x40, 0x04, 0x40,
  0x04, 0x40, 0x04, 0x40, 0x0C, 0x40, 0x08, 0xC0, 0x08, 0x80, 0x08, 0x80,
  0x08, 0x08, 0x42, 0x11, 0x88, 0x42, 0x10, 0x8C, 0x42, 0x10, 0x84, 0x62,
  0x10, 0x84, 0x20, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x80, 0x44, 0x06, 0x20, 0x21, 0x03, 0x04,
  0x30, 0x1E, 0x00, 0x08, 0x02, 0x18, 0x04, 0x10, 0x0C, 0x10, 0x18, 0x10,
  0x30, 0x10, 0x60, 0x10, 0xC0, 0x31, 0x80, 0x23, 0x00, 0x26, 0x00, 0x2E,
  0x00, 0x3A, 0x00, 0x31, 0x00, 0x61, 0x00, 0x40, 0x80, 0x40, 0x80, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x20, 0xC0, 0x20, 0x80, 0x10, 0x80, 0x10, 0x08,
  0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00,
  0x80, 0x3F, 0xF0, 0x08, 0x00, 0x11, 0x80, 0x03, 0x14, 0x00, 0x31, 0x40,
  0x05, 0x14, 0x00, 0x71, 0x40, 0x0A, 0x14, 0x01, 0xA3, 0x40, 0x12, 0x22,
  0x03, 0x22, 0x20, 0x22, 0x22, 0x06, 0x62, 0x20, 0x44, 0x22, 0x0C, 0x46,
  0x20, 0x84, 0x41, 0x18, 0x44, 0x11, 0x04, 0x41, 0x30, 0xC4, 0x12, 0x08,
  0x41, 0x60, 0x8C, 0x14, 0x08, 0x80, 0xC0, 0x88, 0x08, 0x08, 0x08, 0x01,
  0x8C, 0x00, 0x87, 0x00, 0x42, 0x80, 0x21, 0x60, 0x10, 0x90, 0x08, 0x48,
  0x0C, 0x66, 0x04, 0x31, 0x02, 0x10, 0x81, 0x08, 0x20, 0x84, 0x10, 0x42,
  0x08, 0x63, 0x02, 0x21, 0x01, 0x10, 0x80, 0xC8, 0x40, 0x24, 0x20, 0x16,
  0x10, 0x07, 0x18, 0x03, 0x08, 0x01, 0x84, 0x00, 0x40, 0x03, 0xE0, 0x30,
  0x41, 0x80, 0x8C, 0x03, 0x20, 0x05, 0x80, 0x14, 0x00, 0x50, 0x01, 0x40,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0,
  0x06, 0x80, 0x12, 0x00, 0x48, 0x02, 0x10, 0x18, 0x61, 0xC0, 0x7C, 0x00,
  0x0F, 0xF0, 0x60, 0x61, 0x00, 0xC4, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00,
  0x4C, 0x01, 0x20, 0x0C, 0x80, 0x22, 0x01, 0x88, 0x0C, 0x3F, 0xC1, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x00, 0x03, 0xE0, 0x30, 0x41, 0x80, 0x8C, 0x03, 0x20, 0x05,
  0x80, 0x14, 0x00, 0x50, 0x01, 0x40, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x02,
  0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x06, 0x80, 0x12, 0x00, 0x48, 0x02,
  0x10, 0x18, 0x61, 0x80, 0x7C, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x0F, 0xF0, 0x60, 0x61, 0x00, 0xC4, 0x01, 0x10, 0x04, 0x40, 0x11,
  0x00, 0x4C, 0x01, 0x20, 0x0C, 0x80, 0x22, 0x01, 0x88, 0x0C, 0x3F, 0xC1,
  0x83, 0x04, 0x04, 0x10, 0x10, 0x40, 0x61, 0x00, 0x84, 0x02, 0x30, 0x0C,
  0x80, 0x12, 0x00, 0x40, 0x03, 0xE0, 0x38, 0x61, 0x80, 0x84, 0x03, 0x30,
  0x04, 0x80, 0x12, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x80, 0x12, 0x00, 0x48,
  0x03, 0x30, 0x18, 0x60, 0xC0, 0x7C, 0x00, 0xFF, 0xF8, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x30, 0x06,
  0x40, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x44, 0x00, 0x98, 0x03, 0x20,
  0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x4C, 0x01, 0x90, 0x02,
  0x20, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x42, 0x00, 0x86, 0x02, 0x06,
  0x18, 0x07, 0xE0, 0x00, 0x80, 0x0E, 0x00, 0x28, 0x01, 0xA0, 0x04, 0x80,
  0x13, 0x00, 0x84, 0x02, 0x10, 0x10, 0x40, 0x41, 0x03, 0x04, 0x08, 0x10,
  0x60, 0x61, 0x00, 0x84, 0x02, 0x20, 0x08, 0x80, 0x24, 0x00, 0x90, 0x02,
  0xC0, 0x0E, 0x00, 0x18, 0x00, 0x40, 0x00, 0x80, 0x20, 0x1C, 0x03, 0x00,
  0xA0, 0x18, 0x05, 0x01, 0x40, 0x48, 0x0A, 0x02, 0x40, 0x50, 0x12, 0x04,
  0x81, 0x18, 0x22, 0x08, 0xC3, 0x10, 0x46, 0x10, 0x84, 0x10, 0x84, 0x20,
  0x88, 0x23, 0x04, 0x41, 0x10, 0x22, 0x08, 0x81, 0x20, 0x4C, 0x09, 0x02,
  0x40, 0x50, 0x12, 0x02, 0x80, 0xA0, 0x14, 0x05, 0x00, 0xC0, 0x28, 0x06,
  0x00, 0x80, 0x30, 0x04, 0x00, 0x18, 0x01, 0x08, 0x02, 0x08, 0x06, 0x0C,
  0x0C, 0x04, 0x08, 0x04, 0x10, 0x02, 0x30, 0x02, 0x20, 0x03, 0x40, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x06, 0x40, 0x04, 0x40, 0x08,
  0x60, 0x18, 0x20, 0x10, 0x20, 0x20, 0x10, 0x60, 0x10, 0x40, 0x18, 0x80,
  0x08, 0x80, 0x0B, 0x00, 0x64, 0x01, 0x10, 0x0C, 0x40, 0x21, 0x81, 0x02,
  0x0C, 0x08, 0x20, 0x31, 0x00, 0x4C, 0x01, 0x20, 0x05, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x0F, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF, 0xF0,
  0x07, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40,
  0x40, 0x40, 0x40, 0xC0, 0xF0, 0x88, 0x84, 0x44, 0x44, 0x44, 0x22, 0x22,
  0x22, 0x23, 0x11, 0x11, 0x11, 0x07, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0xF0, 0x04, 0x0C,
  0x0C, 0x14, 0x12, 0x22, 0x22, 0x42, 0x42, 0x82, 0x81, 0xFF, 0xC0, 0xC9,
  0x90, 0x07, 0xC0, 0xC2, 0x10, 0x31, 0x01, 0x20, 0x10, 0x01, 0x00, 0x20,
  0xFE, 0x38, 0x26, 0x02, 0x40, 0x24, 0x02, 0x40, 0x44, 0x0C, 0x63, 0x43,
  0xE4, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02,
  0x7C, 0x2C, 0x63, 0x02, 0x20, 0x22, 0x03, 0x60, 0x34, 0x03, 0x40, 0x24,
  0x02, 0x40, 0x24, 0x02, 0xC0, 0x68, 0x04, 0xC0, 0xCA, 0x18, 0x9E, 0x00,
  0x0F, 0x83, 0x08, 0x81, 0xB0, 0x14, 0x02, 0x80, 0x70, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x28, 0x0D, 0x81, 0x18, 0x41, 0xF0, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x41, 0xF2, 0x18,
  0x51, 0x81, 0x88, 0x0C, 0x80, 0x44, 0x02, 0x20, 0x11, 0x00, 0x98, 0x04,
  0x80, 0x64, 0x02, 0x20, 0x11, 0x00, 0x84, 0x0C, 0x31, 0xA0, 0xF2, 0x00,
  0x0F, 0x83, 0x08, 0xC1, 0xB0, 0x14, 0x02, 0x80, 0x70, 0x0F, 0xFF, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x18, 0x60, 0xF0, 0x07, 0x86,
  0x02, 0x02, 0x01, 0x00, 0x80, 0xC1, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x06,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x00,
  0x07, 0xC8, 0x61, 0x46, 0x06, 0x20, 0x32, 0x01, 0x10, 0x08, 0x80, 0x44,
  0x02, 0x60, 0x12, 0x01, 0x90, 0x08, 0x80, 0x44, 0x02, 0x10, 0x30, 0xC6,
  0x83, 0xC8, 0x00, 0x40, 0x02, 0x00, 0x11, 0x01, 0x06, 0x10, 0x1F, 0x00,
  0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x1E, 0x2C,
  0x65, 0x04, 0xC0, 0x90, 0x16, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x48,
  0x0B, 0x01, 0x40, 0x28, 0x05, 0x01, 0xA0, 0x20, 0x18, 0xC0, 0x00, 0x00,
  0x44, 0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x31, 0x08, 0x40, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x01, 0x83, 0x80, 0x18, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x02, 0x20, 0x42, 0x08,
  0x21, 0x02, 0x20, 0x64, 0x04, 0x80, 0x58, 0x06, 0xC0, 0x44, 0x04, 0x60,
  0xC2, 0x08, 0x30, 0x81, 0x08, 0x18, 0x80, 0x80, 0x08, 0x44, 0x21, 0x08,
  0x46, 0x21, 0x08, 0x42, 0x31, 0x08, 0x42, 0x11, 0x88, 0x42, 0x00, 0x23,
  0xC3, 0xC2, 0xC6, 0x42, 0x30, 0x28, 0x33, 0x03, 0x01, 0x20, 0x30, 0x16,
  0x02, 0x01, 0x40, 0x20, 0x34, 0x02, 0x02, 0x40, 0x60, 0x24, 0x04, 0x02,
  0x40, 0x40, 0x2C, 0x04, 0x02, 0x80, 0x40, 0x48, 0x04, 0x04, 0x80, 0xC0,
  0x48, 0x08, 0x04, 0x23, 0xC5, 0x8C, 0xA0, 0x98, 0x12, 0x02, 0xC0, 0x50,
  0x0A, 0x01, 0x40, 0x28, 0x09, 0x01, 0x60, 0x28, 0x05, 0x00, 0xA0, 0x34,
  0x04, 0x07, 0x81, 0x86, 0x30, 0x22, 0x02, 0x40, 0x34, 0x01, 0x40, 0x1C,
  0x03, 0x80, 0x28, 0x02, 0x80, 0x28, 0x06, 0xC0, 0x44, 0x08, 0x61, 0x83,
  0xE0, 0x13, 0xE0, 0xA1, 0x86, 0x04, 0x20, 0x21, 0x01, 0x98, 0x0C, 0x80,
  0x64, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04, 0xC0, 0x64, 0x02, 0x30, 0x31,
  0x43, 0x09, 0xE0, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x00, 0x0F, 0x91, 0x85, 0x30, 0x32, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24,
  0x02, 0xC0, 0x28, 0x04, 0x80, 0x48, 0x04, 0x80, 0x44, 0x0C, 0x63, 0x43,
  0xE8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x27, 0x2C,
  0x30, 0x30, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80,
  0x80, 0x80, 0x0F, 0x82, 0x18, 0x81, 0x30, 0x34, 0x00, 0x40, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x02, 0x00, 0x48, 0x09, 0x01, 0x30, 0xC1, 0xF0,
  0x10, 0x41, 0x08, 0xFC, 0x82, 0x08, 0x61, 0x04, 0x10, 0x41, 0x0C, 0x20,
  0x82, 0x0C, 0x1C, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x24, 0x05, 0x80, 0xA0,
  0x14, 0x02, 0x80, 0xD0, 0x12, 0x02, 0x40, 0x48, 0x19, 0x03, 0x31, 0xE3,
  0xC8, 0x80, 0x50, 0x0A, 0x03, 0x60, 0x44, 0x18, 0x82, 0x10, 0x42, 0x10,
  0x42, 0x08, 0x81, 0x90, 0x14, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x80, 0xC0,
  0x80, 0xE0, 0x40, 0xD0, 0x60, 0x48, 0x38, 0x24, 0x24, 0x22, 0x12, 0x11,
  0x19, 0x10, 0x88, 0x88, 0x44, 0x44, 0x24, 0x24, 0x12, 0x12, 0x0A, 0x0A,
  0x05, 0x05, 0x03, 0x02, 0x81, 0x81, 0x80, 0xC0, 0x40, 0x18, 0x08, 0x40,
  0x82, 0x0C, 0x08, 0x40, 0x44, 0x01, 0x40, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x28, 0x03, 0x20, 0x11, 0x01, 0x0C, 0x18, 0x20, 0x81, 0x88, 0x04, 0x10,
  0x0C, 0x40, 0x21, 0x01, 0x86, 0x04, 0x08, 0x30, 0x20, 0x80, 0x82, 0x02,
  0x10, 0x08, 0x40, 0x22, 0x00, 0x48, 0x01, 0x40, 0x05, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x30, 0x03,
  0x80, 0x00, 0x1F, 0xF0, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18, 0x03,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0,
  0x0F, 0xFC, 0x00, 0x80, 0x80, 0x80, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x02, 0x01, 0x01, 0x03, 0x00, 0xC0, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x02, 0x00, 0x80, 0x18,
  0x84, 0x21, 0x08, 0xC4, 0x21, 0x08, 0x42, 0x31, 0x08, 0x42, 0x10, 0x8C,
  0x42, 0x10, 0x84, 0x00, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x08, 0x0C,
  0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04,
  0x03, 0x01, 0x80, 0x80, 0x00, 0x38, 0x05, 0x18, 0x2C, 0x20, 0xA0, 0x44,
  0x80, 0xE0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 22, 6, 1, -22 },
  { 15, 5, 6, 8, 3, -23 },
  { 19, 15, 22, 14, 1, -22 },
  { 61, 12, 28, 14, 1, -25 },
  { 103, 14, 22, 19, 3, -22 },
  { 142, 13, 22, 16, 1, -22 },
  { 178, 2, 6, 5, 3, -23 },
  { 180, 9, 31, 8, 1, -24 },
  { 215, 9, 31, 8, -2, -24 },
  { 250, 11, 12, 12, 2, -22 },
  { 267, 12, 15, 14, 1, -17 },
  { 290, 4, 6, 6, -1, -2 },
  { 293, 6, 1, 8, 1, -10 },
  { 294, 2, 2, 7, 1, -2 },
  { 295, 12, 24, 10, -1, -22 },
  { 331, 12, 22, 14, 1, -22 },
  { 364, 7, 22, 14, 4, -22 },
  { 384, 12, 22, 14, 1, -22 },
  { 417, 12, 22, 14, 1, -22 },
  { 450, 12, 22, 14, 1, -22 },
  { 483, 12, 22, 14, 2, -22 },
  { 516, 11, 22, 14, 1, -22 },
  { 547, 12, 22, 14, 2, -22 },
  { 580, 13, 22, 14, 1, -22 },
  { 616, 11, 22, 14, 2, -22 },
  { 647, 5, 16, 6, 0, -16 },
  { 657, 6, 20, 5, -1, -16 },
  { 672, 11, 12, 13, 1, -16 },
  { 689, 11, 7, 14, 2, -13 },
  { 699, 11, 12, 13, 1, -16 },
  { 716, 9, 22, 12, 3, -22 },
  { 741, 21, 28, 23, 1, -21 },
  { 815, 14, 22, 16, -1, -22 },
  { 854, 14, 22, 16, 1, -22 },
  { 893, 14, 22, 17, 2, -22 },
  { 932, 15, 22, 17, 1, -22 },
  { 974, 15, 22, 15, 1, -22 },
  { 1016, 15, 22, 15, 1, -22 },
  { 1058, 14, 22, 17, 2, -22 },
  { 1097, 16, 22, 18, 1, -22 },
  { 1141, 5, 22, 7, 1, -22 },
  { 1155, 13, 22, 14, 1, -22 },
  { 1191, 16, 22, 16, 1, -22 },
  { 1235, 10, 22, 13, 1, -22 },
  { 1263, 20, 22, 22, 1, -22 },
  { 1318, 17, 22, 18, 1, -22 },
  { 1365, 14, 22, 17, 2, -22 },
  { 1404, 14, 22, 16, 1, -22 },
  { 1443, 14, 26, 17, 2, -22 },
  { 1489, 14, 22, 16, 1, -22 },
  { 1528, 14, 22, 15, 1, -22 },
  { 1567, 14, 22, 15, 3, -22 },
  { 1606, 15, 22, 17, 2, -22 },
  { 1648, 14, 22, 16, 3, -22 },
  { 1687, 21, 22, 23, 3, -22 },
  { 1745, 16, 22, 15, 0, -22 },
  { 1789, 14, 22, 15, 3, -22 },
  { 1828, 16, 22, 15, 0, -22 },
  { 1872, 8, 29, 6, 0, -24 },
  { 1901, 4, 24, 10, 3, -22 },
  { 1913, 8, 29, 6, -2, -24 },
  { 1942, 8, 11, 11, 2, -22 },
  { 1953, 10, 1, 11, -1, 0 },
  { 1955, 3, 4, 8, 4, -23 },
  { 1957, 12, 16, 14, 0, -16 },
  { 1981, 12, 23, 14, 1, -23 },
  { 2016, 11, 16, 13, 1, -16 },
  { 2038, 13, 23, 14, 1, -23 },
  { 2076, 11, 16, 13, 1, -16 },
  { 2098, 9, 23, 9, 2, -23 },
  { 2124, 13, 22, 14, 0, -16 },
  { 2160, 11, 23, 14, 1, -23 },
  { 2192, 5, 22, 6, 1, -22 },
  { 2206, 10, 28, 6, -4, -22 },
  { 2241, 12, 23, 12, 1, -23 },
  { 2276, 5, 23, 6, 1, -23 },
  { 2291, 20, 16, 22, 1, -16 },
  { 2331, 11, 16, 14, 1, -16 },
  { 2353, 12, 16, 14, 1, -16 },
  { 2377, 13, 22, 14, 0, -16 },
  { 2413, 12, 22, 14, 1, -16 },
  { 2446, 8, 16, 9, 1, -16 },
  { 2462, 11, 16, 13, 1, -16 },
  { 2484, 6, 20, 8, 2, -20 },
  { 2499, 11, 16, 14, 2, -16 },
  { 2521, 11, 16, 12, 2, -16 },
  { 2543, 17, 16, 19, 2, -16 },
  { 2577, 13, 16, 12, -1, -16 },
  { 2603, 14, 22, 12, -1, -16 },
  { 2642, 12, 16, 12, 0, -16 },
  { 2666, 9, 29, 9, 1, -23 },
  { 2699, 5, 26, 6, 1, -22 },
  { 2716, 10, 29, 9, -2, -23 },
  { 2753, 14, 5, 17, 2, -11 },
};

const GFXfont RobotoCondensed_ExtraLightItalic30pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic30pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic30pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC30PT7B_H_
