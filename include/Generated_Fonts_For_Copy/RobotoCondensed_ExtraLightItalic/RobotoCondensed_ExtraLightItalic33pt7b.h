#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC33PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x46, 0x21, 0x08, 0x42, 0x31, 0x08, 0x42, 0x31, 0x08, 0x00,
  0x00, 0x00, 0x62, 0x00, 0x4E, 0x73, 0x19, 0xCA, 0x40, 0x00, 0xC2, 0x00,
  0x82, 0x00, 0x84, 0x01, 0x84, 0x01, 0x04, 0x01, 0x08, 0x03, 0x08, 0x3F,
  0xFF, 0x02, 0x10, 0x06, 0x10, 0x04, 0x10, 0x04, 0x20, 0x0C, 0x20, 0x08,
  0x20, 0x08, 0x40, 0xFF, 0xFC, 0x10, 0x40, 0x10, 0x80, 0x10, 0x80, 0x20,
  0x80, 0x21, 0x00, 0x21, 0x00, 0x41, 0x00, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x78, 0x06, 0x30, 0x30, 0x21, 0x80, 0x84, 0x03, 0x10, 0x04, 0x40,
  0x11, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x30, 0x04, 0xC0, 0x13, 0x00, 0xC4, 0x02, 0x18,
  0x18, 0x31, 0xC0, 0x7C, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x1C, 0x00,
  0x44, 0x01, 0x04, 0x02, 0x08, 0x2C, 0x10, 0x90, 0x21, 0x20, 0x84, 0x41,
  0x10, 0x82, 0x60, 0x88, 0x80, 0xE2, 0x00, 0x08, 0x00, 0x33, 0xC0, 0x4C,
  0xC1, 0x10, 0x84, 0x41, 0x18, 0x82, 0x21, 0x04, 0x82, 0x0A, 0x04, 0x10,
  0x08, 0x40, 0x19, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x0C, 0x60, 0x10, 0x40,
  0x60, 0x80, 0x81, 0x01, 0x02, 0x02, 0x08, 0x04, 0x20, 0x0C, 0x80, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x01, 0x30, 0x44, 0x20, 0x98, 0x21, 0x20, 0x66,
  0xC0, 0x49, 0x00, 0xF2, 0x00, 0xC6, 0x01, 0x84, 0x05, 0x0E, 0x31, 0x07,
  0xC3, 0x00, 0x69, 0x24, 0xA0, 0x00, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40,
  0x40, 0x20, 0x30, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x00, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02,
  0x02, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x00, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x08, 0x21, 0x39, 0x78, 0x7E, 0x00, 0xC0,
  0x0A, 0x00, 0xC8, 0x0C, 0x60, 0xC1, 0x04, 0x08, 0x00, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0xFF,
  0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x33, 0x22, 0x64, 0x80, 0xFC, 0xF0, 0x00, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x03, 0xC0, 0x63, 0x06, 0x04, 0x20, 0x22, 0x01, 0x10, 0x0D,
  0x80, 0x68, 0x03, 0x40, 0x12, 0x00, 0xB0, 0x05, 0x00, 0x28, 0x01, 0x40,
  0x1A, 0x00, 0x90, 0x04, 0x80, 0x24, 0x03, 0x20, 0x11, 0x01, 0x8C, 0x18,
  0x31, 0x80, 0xF8, 0x00, 0x03, 0x0E, 0x72, 0xC2, 0x02, 0x06, 0x06, 0x04,
  0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10,
  0x10, 0x10, 0x30, 0x03, 0xE0, 0x31, 0x82, 0x06, 0x20, 0x11, 0x00, 0x90,
  0x04, 0x80, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x03, 0xFF, 0xC0, 0x03, 0xE0, 0x18, 0xC0, 0x80, 0x84, 0x02,
  0x10, 0x0C, 0x80, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x0E,
  0x01, 0xE0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x80, 0x12, 0x00,
  0x48, 0x03, 0x30, 0x08, 0x60, 0x60, 0xC7, 0x01, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0xA0, 0x0D, 0x00, 0x48, 0x04, 0x40, 0x66, 0x06,
  0x30, 0x21, 0x02, 0x08, 0x30, 0x41, 0x02, 0x10, 0x31, 0x01, 0x18, 0x08,
  0xFF, 0xF8, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x0F, 0xFC, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x27, 0x80, 0xE3, 0x02, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x80, 0x22, 0x00, 0x88, 0x02, 0x30, 0x10, 0x40,
  0xC0, 0xC6, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x38, 0x06, 0x00, 0x80, 0x10,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x47, 0x85, 0x8C, 0x60, 0x6C, 0x02, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x28, 0x02, 0x80, 0x6C, 0x04, 0x40,
  0xC6, 0x38, 0x3E, 0x00, 0xFF, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x18, 0xE0, 0xC0, 0x86,
  0x03, 0x10, 0x04, 0x40, 0x13, 0x00, 0xCC, 0x02, 0x10, 0x08, 0x40, 0x40,
  0xC6, 0x03, 0xE0, 0x18, 0x60, 0x80, 0xC4, 0x01, 0x30, 0x04, 0x80, 0x12,
  0x00, 0x48, 0x01, 0x20, 0x08, 0x40, 0x61, 0xC7, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0xC6, 0x10, 0x32, 0x01, 0x60, 0x14, 0x01, 0x40, 0x14, 0x01, 0xC0,
  0x1C, 0x01, 0x40, 0x34, 0x03, 0x60, 0x73, 0x1A, 0x1F, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0xE0, 0x78, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x0C, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x08, 0x20, 0x86, 0x10,
  0x80, 0x00, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x02, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x20, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x10, 0x06, 0x01, 0x80,
  0xE0, 0x38, 0x0E, 0x00, 0x80, 0x00, 0x1F, 0x0C, 0x66, 0x09, 0x03, 0xC0,
  0xE0, 0x30, 0x08, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x02,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xE0, 0xE0, 0x06, 0x00, 0x60, 0x18, 0x00, 0x40, 0x60,
  0x00, 0x40, 0x80, 0x00, 0x82, 0x00, 0x01, 0x0C, 0x0F, 0x01, 0x10, 0x31,
  0x82, 0x60, 0x81, 0x04, 0x83, 0x04, 0x09, 0x04, 0x08, 0x14, 0x18, 0x10,
  0x28, 0x20, 0x20, 0xD0, 0x40, 0x81, 0x21, 0x81, 0x02, 0x82, 0x02, 0x05,
  0x04, 0x0C, 0x1A, 0x08, 0x10, 0x24, 0x10, 0x60, 0x48, 0x20, 0xC1, 0x10,
  0x66, 0x44, 0x30, 0x78, 0xF0, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x28, 0x00, 0x28, 0x00, 0x48,
  0x00, 0x48, 0x00, 0x88, 0x00, 0x8C, 0x01, 0x04, 0x01, 0x04, 0x02, 0x04,
  0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x06, 0x0F, 0xFE, 0x18, 0x02,
  0x10, 0x02, 0x30, 0x02, 0x20, 0x02, 0x60, 0x02, 0x40, 0x03, 0xC0, 0x03,
  0x0F, 0xF0, 0x10, 0x38, 0x20, 0x10, 0x40, 0x31, 0x80, 0x22, 0x00, 0x44,
  0x01, 0x88, 0x03, 0x10, 0x04, 0x20, 0x10, 0xC0, 0xC1, 0xFF, 0x02, 0x01,
  0x84, 0x01, 0x08, 0x03, 0x30, 0x02, 0x60, 0x04, 0x80, 0x19, 0x00, 0x22,
  0x00, 0xC4, 0x03, 0x18, 0x0C, 0x3F, 0xE0, 0x00, 0x01, 0xF0, 0x0C, 0x38,
  0x30, 0x10, 0xC0, 0x33, 0x00, 0x24, 0x00, 0x48, 0x00, 0xB0, 0x01, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x06, 0x80, 0x09, 0x00, 0x13, 0x00, 0x62, 0x00, 0x86, 0x02, 0x06,
  0x18, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x08, 0x1C, 0x08, 0x06, 0x08, 0x02,
  0x18, 0x03, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01,
  0x30, 0x03, 0x20, 0x03, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x60, 0x06,
  0x60, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x18, 0x40, 0x30, 0xC0, 0xE0,
  0xFF, 0x80, 0x0F, 0xFF, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x3F, 0xF8, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x3F, 0xF8,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x01, 0xF8,
  0x07, 0x0C, 0x0C, 0x06, 0x18, 0x02, 0x10, 0x03, 0x30, 0x01, 0x20, 0x01,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0xFE,
  0xC0, 0x06, 0xC0, 0x04, 0x80, 0x04, 0x80, 0x04, 0xC0, 0x04, 0xC0, 0x0C,
  0x40, 0x0C, 0x60, 0x18, 0x30, 0x70, 0x0F, 0x80, 0x08, 0x00, 0x42, 0x00,
  0x10, 0x80, 0x04, 0x20, 0x03, 0x18, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08,
  0x40, 0x02, 0x10, 0x01, 0x84, 0x00, 0x63, 0x00, 0x10, 0xFF, 0xFC, 0x20,
  0x01, 0x08, 0x00, 0x42, 0x00, 0x31, 0x80, 0x08, 0x60, 0x02, 0x10, 0x00,
  0x84, 0x00, 0x21, 0x00, 0x08, 0x40, 0x06, 0x30, 0x01, 0x08, 0x00, 0x40,
  0x08, 0xC4, 0x21, 0x08, 0xC6, 0x21, 0x08, 0x46, 0x31, 0x08, 0x42, 0x31,
  0x08, 0x42, 0x00, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x80, 0x22, 0x00, 0x88, 0x06,
  0x20, 0x10, 0xC0, 0x81, 0x8C, 0x03, 0xE0, 0x00, 0x08, 0x01, 0x82, 0x00,
  0xC0, 0x80, 0x60, 0x20, 0x30, 0x18, 0x18, 0x04, 0x0C, 0x01, 0x06, 0x00,
  0x43, 0x00, 0x10, 0x80, 0x04, 0x40, 0x03, 0x60, 0x00, 0xB4, 0x00, 0x39,
  0x00, 0x0C, 0x20, 0x02, 0x0C, 0x01, 0x81, 0x00, 0x60, 0x60, 0x10, 0x08,
  0x04, 0x03, 0x01, 0x00, 0x40, 0x40, 0x18, 0x30, 0x02, 0x08, 0x00, 0xC0,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x3F, 0xF8, 0x0C, 0x00, 0x04, 0x18,
  0x00, 0x18, 0x30, 0x00, 0x70, 0x60, 0x00, 0xA1, 0xE0, 0x03, 0xC2, 0x40,
  0x05, 0x84, 0x80, 0x1A, 0x09, 0x00, 0x24, 0x12, 0x00, 0xC8, 0x26, 0x01,
  0x10, 0xC4, 0x04, 0x61, 0x08, 0x08, 0x82, 0x10, 0x21, 0x04, 0x20, 0x42,
  0x08, 0x41, 0x04, 0x30, 0xC2, 0x08, 0x60, 0x88, 0x30, 0x81, 0x30, 0x41,
  0x02, 0x40, 0x82, 0x05, 0x81, 0x04, 0x0A, 0x02, 0x18, 0x0C, 0x0C, 0x30,
  0x10, 0x18, 0x00, 0x0C, 0x00, 0x43, 0x00, 0x10, 0xC0, 0x04, 0x28, 0x03,
  0x1A, 0x00, 0xC6, 0xC0, 0x21, 0x10, 0x08, 0x44, 0x02, 0x10, 0x80, 0x84,
  0x20, 0x63, 0x0C, 0x18, 0x81, 0x04, 0x20, 0x41, 0x08, 0x18, 0x42, 0x02,
  0x11, 0x80, 0x8C, 0x60, 0x12, 0x10, 0x04, 0x84, 0x01, 0xA1, 0x00, 0x28,
  0x40, 0x0E, 0x30, 0x01, 0x8C, 0x00, 0x40, 0x01, 0xF0, 0x07, 0x0C, 0x0C,
  0x06, 0x18, 0x02, 0x30, 0x02, 0x20, 0x03, 0x20, 0x03, 0x60, 0x03, 0x40,
  0x03, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0x80, 0x06, 0x80,
  0x06, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08, 0xC0, 0x10, 0x60,
  0x30, 0x30, 0xE0, 0x1F, 0x80, 0x0F, 0xF8, 0x08, 0x0C, 0x08, 0x02, 0x08,
  0x03, 0x18, 0x03, 0x10, 0x01, 0x10, 0x03, 0x10, 0x02, 0x10, 0x02, 0x10,
  0x06, 0x30, 0x0C, 0x20, 0x38, 0x3F, 0xE0, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x01, 0xF0, 0x07, 0x0C, 0x0C, 0x06, 0x10, 0x02, 0x30,
  0x02, 0x20, 0x03, 0x60, 0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x02, 0x40,
  0x02, 0xC0, 0x02, 0xC0, 0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x0C, 0x80, 0x08, 0xC0, 0x10, 0x40, 0x30, 0x30, 0xE0, 0x1F,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x0F, 0xF8, 0x08,
  0x0C, 0x08, 0x06, 0x08, 0x02, 0x18, 0x03, 0x10, 0x03, 0x10, 0x03, 0x10,
  0x02, 0x10, 0x02, 0x30, 0x06, 0x30, 0x0C, 0x20, 0x38, 0x3F, 0xE0, 0x20,
  0x60, 0x20, 0x20, 0x60, 0x20, 0x40, 0x30, 0x40, 0x10, 0x40, 0x10, 0x40,
  0x18, 0x40, 0x08, 0xC0, 0x08, 0x80, 0x0C, 0x01, 0xF0, 0x07, 0x0C, 0x0C,
  0x06, 0x18, 0x02, 0x10, 0x02, 0x10, 0x02, 0x30, 0x02, 0x10, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x08, 0xC0, 0x18, 0x60,
  0x30, 0x30, 0xE0, 0x1F, 0x80, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x30, 0x03, 0x20, 0x03, 0x20,
  0x02, 0x20, 0x02, 0x20, 0x02, 0x60, 0x02, 0x60, 0x06, 0x40, 0x04, 0x40,
  0x04, 0x40, 0x04, 0x40, 0x04, 0xC0, 0x04, 0x80, 0x0C, 0x80, 0x08, 0x80,
  0x08, 0x80, 0x18, 0xC0, 0x10, 0x40, 0x30, 0x30, 0xE0, 0x1F, 0x80, 0x80,
  0x02, 0x80, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0x40, 0x08, 0x40, 0x08, 0x40,
  0x10, 0x40, 0x10, 0x40, 0x30, 0x60, 0x20, 0x60, 0x60, 0x20, 0x40, 0x20,
  0xC0, 0x20, 0x80, 0x21, 0x80, 0x21, 0x00, 0x33, 0x00, 0x12, 0x00, 0x12,
  0x00, 0x14, 0x00, 0x14, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x10, 0x03,
  0x80, 0x60, 0x0F, 0x00, 0xE0, 0x16, 0x01, 0x40, 0x64, 0x04, 0x80, 0x88,
  0x09, 0x01, 0x10, 0x32, 0x06, 0x20, 0x44, 0x08, 0x40, 0x88, 0x10, 0x82,
  0x10, 0x61, 0x04, 0x20, 0x82, 0x18, 0x43, 0x04, 0x20, 0x84, 0x08, 0x41,
  0x08, 0x11, 0x03, 0x30, 0x22, 0x02, 0x40, 0x4C, 0x04, 0x80, 0xD0, 0x0B,
  0x01, 0xA0, 0x14, 0x03, 0x80, 0x28, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x00, 0x04, 0x00, 0x60, 0x80, 0x18, 0x18, 0x02, 0x01,
  0x00, 0x80, 0x30, 0x30, 0x02, 0x0C, 0x00, 0x41, 0x00, 0x04, 0x40, 0x00,
  0x98, 0x00, 0x1A, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03,
  0x40, 0x00, 0x44, 0x00, 0x10, 0x80, 0x06, 0x18, 0x01, 0x81, 0x00, 0x20,
  0x30, 0x0C, 0x02, 0x03, 0x00, 0x40, 0x40, 0x0C, 0x10, 0x00, 0x80, 0xC0,
  0x02, 0x80, 0x0D, 0x00, 0x33, 0x00, 0x42, 0x01, 0x04, 0x06, 0x08, 0x08,
  0x18, 0x20, 0x10, 0xC0, 0x21, 0x00, 0x64, 0x00, 0x58, 0x00, 0xA0, 0x01,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0x82, 0x01, 0x00,
  0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60,
  0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0xE0, 0xC2, 0x10, 0x84, 0x21,
  0x8C, 0x21, 0x08, 0x42, 0x18, 0xC2, 0x10, 0x84, 0x21, 0x84, 0x21, 0x08,
  0x07, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x60, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x41, 0xE0,
  0x06, 0x03, 0x03, 0x81, 0x41, 0xA0, 0x98, 0xC4, 0x42, 0x61, 0x20, 0xB0,
  0x50, 0x30, 0x7F, 0xF0, 0x46, 0x21, 0x03, 0xE0, 0x71, 0x82, 0x06, 0x20,
  0x11, 0x00, 0x80, 0x04, 0x00, 0x60, 0xFF, 0x18, 0x11, 0x00, 0x98, 0x04,
  0x80, 0x24, 0x03, 0x20, 0x31, 0x03, 0x8C, 0x34, 0x3E, 0x20, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x13,
  0xE1, 0xA1, 0x8A, 0x04, 0x60, 0x32, 0x00, 0x90, 0x04, 0x80, 0x2C, 0x03,
  0x40, 0x1A, 0x00, 0x90, 0x04, 0x80, 0x24, 0x03, 0x60, 0x12, 0x81, 0x96,
  0x38, 0x8F, 0x00, 0x07, 0xC1, 0xC6, 0x30, 0x32, 0x01, 0x60, 0x14, 0x01,
  0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x02, 0x80, 0x2C, 0x04,
  0x40, 0xC6, 0x18, 0x1F, 0x00, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x07, 0xC8, 0x38, 0xD0,
  0x40, 0x61, 0x00, 0xC2, 0x01, 0x8C, 0x02, 0x10, 0x04, 0x20, 0x08, 0x40,
  0x11, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x0C, 0x02, 0x08, 0x04, 0x10, 0x18,
  0x30, 0xF0, 0x3E, 0x60, 0x07, 0xC0, 0xC6, 0x10, 0x32, 0x01, 0x60, 0x14,
  0x01, 0x40, 0x1F, 0xFF, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x47, 0x1C, 0x1F, 0x00, 0x03, 0xC1, 0x80, 0xC0, 0x20, 0x18,
  0x04, 0x01, 0x00, 0x40, 0xFF, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00,
  0x80, 0x00, 0x03, 0xE4, 0x38, 0xD0, 0x80, 0xC4, 0x03, 0x10, 0x0C, 0xC0,
  0x22, 0x00, 0x88, 0x02, 0x20, 0x09, 0x80, 0x26, 0x01, 0x98, 0x04, 0x60,
  0x10, 0x80, 0x42, 0x03, 0x0C, 0x34, 0x1F, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x63, 0x03, 0x06, 0x18, 0x07, 0xC0, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x11, 0xE3, 0x63, 0x28,
  0x13, 0x01, 0x30, 0x12, 0x01, 0x20, 0x16, 0x01, 0x40, 0x14, 0x03, 0x40,
  0x34, 0x02, 0x40, 0x2C, 0x02, 0x80, 0x28, 0x06, 0x80, 0x40, 0x08, 0x20,
  0x00, 0x00, 0x01, 0x04, 0x10, 0xC2, 0x08, 0x20, 0x86, 0x18, 0x41, 0x04,
  0x10, 0xC2, 0x08, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x01, 0x01, 0xC0, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x19, 0x81, 0x88, 0x18, 0x41, 0x02, 0x10, 0x11, 0x00, 0x90, 0x0D, 0x80,
  0x54, 0x03, 0x30, 0x10, 0x80, 0x86, 0x04, 0x10, 0x60, 0xC2, 0x02, 0x10,
  0x18, 0x80, 0x40, 0x08, 0x42, 0x11, 0x8C, 0x42, 0x10, 0x8C, 0x42, 0x10,
  0x84, 0x62, 0x10, 0x84, 0x23, 0x10, 0x80, 0x13, 0xE0, 0xF0, 0xD8, 0xCC,
  0x62, 0x81, 0x60, 0xCC, 0x05, 0x01, 0x30, 0x18, 0x04, 0x80, 0x60, 0x16,
  0x01, 0x00, 0xD8, 0x04, 0x02, 0x40, 0x10, 0x09, 0x00, 0xC0, 0x24, 0x02,
  0x00, 0x90, 0x08, 0x02, 0xC0, 0x20, 0x1B, 0x00, 0x80, 0x48, 0x02, 0x01,
  0x20, 0x18, 0x04, 0x80, 0x40, 0x10, 0x13, 0xE1, 0x63, 0x38, 0x13, 0x01,
  0x30, 0x12, 0x01, 0x20, 0x16, 0x01, 0x60, 0x14, 0x03, 0x40, 0x34, 0x02,
  0x40, 0x2C, 0x02, 0x80, 0x28, 0x06, 0x80, 0x40, 0x07, 0xC0, 0x61, 0x84,
  0x04, 0x60, 0x32, 0x00, 0xB0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x1E, 0x00,
  0xF0, 0x05, 0x80, 0x2C, 0x03, 0x20, 0x11, 0x01, 0x06, 0x38, 0x1F, 0x00,
  0x09, 0xF0, 0x68, 0x61, 0xC0, 0x86, 0x03, 0x10, 0x04, 0x40, 0x11, 0x00,
  0x4C, 0x03, 0x30, 0x0C, 0x80, 0x22, 0x00, 0x88, 0x02, 0x20, 0x19, 0x80,
  0x46, 0x03, 0x16, 0x38, 0x47, 0x81, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x07, 0xC8, 0xE3, 0x44, 0x06, 0x40,
  0x32, 0x01, 0xB0, 0x09, 0x00, 0x48, 0x02, 0x40, 0x16, 0x00, 0xB0, 0x0D,
  0x80, 0x4C, 0x02, 0x20, 0x11, 0x01, 0x8C, 0x34, 0x3E, 0x60, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x13, 0x8B, 0x0E,
  0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06,
  0x02, 0x01, 0x00, 0x80, 0x00, 0x07, 0xC1, 0x86, 0x30, 0x22, 0x03, 0x20,
  0x32, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x40, 0x04, 0x80,
  0x48, 0x04, 0xC0, 0xC6, 0x18, 0x3E, 0x00, 0x18, 0x20, 0x40, 0x81, 0x1F,
  0xCC, 0x10, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0x41, 0x83, 0x06,
  0x04, 0x0E, 0x00, 0x20, 0x16, 0x01, 0x60, 0x14, 0x01, 0x40, 0x34, 0x02,
  0x40, 0x2C, 0x02, 0x80, 0x28, 0x06, 0x80, 0x68, 0x04, 0x80, 0x48, 0x0C,
  0x81, 0x4C, 0x3C, 0x3C, 0x80, 0x80, 0x3C, 0x02, 0xC0, 0x24, 0x04, 0x40,
  0x44, 0x08, 0x40, 0x84, 0x10, 0x61, 0x02, 0x20, 0x22, 0x02, 0x40, 0x24,
  0x02, 0xC0, 0x38, 0x01, 0x80, 0x10, 0x00, 0x80, 0x80, 0xE0, 0x20, 0x28,
  0x1C, 0x0A, 0x07, 0x06, 0x82, 0x41, 0x20, 0x90, 0xC8, 0x64, 0x22, 0x11,
  0x08, 0x8C, 0x44, 0x22, 0x11, 0x08, 0x84, 0xC3, 0x41, 0x20, 0xD0, 0x58,
  0x18, 0x14, 0x06, 0x03, 0x01, 0x00, 0xC0, 0x40, 0x20, 0x00, 0x08, 0x04,
  0x10, 0x18, 0x10, 0x60, 0x20, 0x80, 0x62, 0x00, 0x4C, 0x00, 0xF0, 0x00,
  0xC0, 0x01, 0x00, 0x05, 0x00, 0x1A, 0x00, 0x26, 0x00, 0x84, 0x03, 0x0C,
  0x0C, 0x08, 0x10, 0x18, 0x40, 0x10, 0x18, 0x02, 0x30, 0x08, 0x20, 0x10,
  0x40, 0x40, 0x80, 0x81, 0x02, 0x02, 0x04, 0x04, 0x18, 0x0C, 0x20, 0x08,
  0xC0, 0x11, 0x00, 0x26, 0x00, 0x48, 0x00, 0xB0, 0x01, 0x40, 0x03, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x00, 0x1F, 0xF8, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00,
  0x10, 0x01, 0x80, 0x18, 0x00, 0xFF, 0xE0, 0x00, 0x40, 0x20, 0x10, 0x08,
  0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06,
  0x01, 0x01, 0x80, 0xC0, 0x08, 0x03, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x60, 0x08,
  0x00, 0x08, 0x42, 0x31, 0x08, 0x42, 0x11, 0x88, 0x42, 0x10, 0x8C, 0x62,
  0x10, 0x84, 0x63, 0x10, 0x84, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x02, 0x00, 0xC0, 0x40, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x03, 0x00, 0x80, 0x20, 0x18, 0x04, 0x03, 0x01, 0x80, 0x80, 0x00,
  0x1C, 0x02, 0x4C, 0x05, 0x0C, 0x1A, 0x0C, 0x28, 0x0C, 0xD0, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLightItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 23, 6, 1, -23 },
  { 16, 5, 7, 9, 4, -25 },
  { 21, 16, 23, 16, 1, -23 },
  { 67, 14, 29, 16, 1, -26 },
  { 118, 15, 23, 21, 3, -23 },
  { 162, 15, 23, 17, 1, -23 },
  { 206, 3, 7, 5, 3, -25 },
  { 209, 9, 34, 9, 2, -26 },
  { 248, 9, 34, 9, -2, -26 },
  { 287, 13, 13, 13, 2, -23 },
  { 309, 14, 17, 16, 1, -19 },
  { 339, 4, 7, 6, -1, -3 },
  { 343, 7, 1, 8, 1, -11 },
  { 344, 2, 2, 7, 1, -2 },
  { 345, 13, 25, 11, -1, -23 },
  { 386, 13, 23, 16, 2, -23 },
  { 424, 8, 23, 16, 4, -23 },
  { 447, 13, 23, 16, 1, -23 },
  { 485, 14, 23, 16, 1, -23 },
  { 526, 13, 23, 16, 1, -23 },
  { 564, 14, 23, 16, 2, -23 },
  { 605, 12, 23, 16, 2, -23 },
  { 640, 13, 23, 16, 3, -23 },
  { 678, 14, 23, 16, 1, -23 },
  { 719, 12, 23, 16, 2, -23 },
  { 754, 5, 17, 6, 0, -17 },
  { 765, 6, 21, 6, -1, -17 },
  { 781, 13, 13, 14, 1, -17 },
  { 803, 12, 7, 16, 2, -14 },
  { 814, 12, 13, 15, 1, -17 },
  { 834, 10, 23, 13, 3, -23 },
  { 863, 23, 30, 26, 1, -23 },
  { 950, 16, 23, 17, -1, -23 },
  { 996, 15, 23, 17, 1, -23 },
  { 1040, 15, 23, 18, 2, -23 },
  { 1084, 16, 23, 18, 1, -23 },
  { 1130, 16, 23, 16, 1, -23 },
  { 1176, 16, 23, 16, 1, -23 },
  { 1222, 16, 23, 19, 2, -23 },
  { 1268, 18, 23, 20, 1, -23 },
  { 1320, 5, 23, 8, 2, -23 },
  { 1335, 14, 23, 15, 1, -23 },
  { 1376, 18, 23, 18, 1, -23 },
  { 1428, 11, 23, 15, 1, -23 },
  { 1460, 23, 23, 24, 1, -23 },
  { 1527, 18, 23, 20, 1, -23 },
  { 1579, 16, 23, 19, 2, -23 },
  { 1625, 16, 23, 17, 1, -23 },
  { 1671, 16, 27, 19, 2, -23 },
  { 1725, 16, 23, 18, 1, -23 },
  { 1771, 16, 23, 17, 1, -23 },
  { 1817, 15, 23, 17, 3, -23 },
  { 1861, 16, 23, 19, 2, -23 },
  { 1907, 16, 23, 17, 3, -23 },
  { 1953, 23, 23, 25, 3, -23 },
  { 2020, 19, 23, 17, -1, -23 },
  { 2075, 15, 23, 17, 3, -23 },
  { 2119, 17, 23, 17, 0, -23 },
  { 2168, 9, 32, 7, 0, -27 },
  { 2204, 5, 25, 11, 3, -23 },
  { 2220, 9, 32, 7, -2, -27 },
  { 2256, 9, 12, 12, 2, -23 },
  { 2270, 12, 1, 12, -2, 0 },
  { 2272, 4, 4, 9, 4, -24 },
  { 2274, 13, 17, 15, 0, -17 },
  { 2302, 13, 25, 16, 1, -25 },
  { 2343, 12, 17, 14, 1, -17 },
  { 2369, 15, 25, 16, 1, -25 },
  { 2416, 12, 17, 15, 1, -17 },
  { 2442, 10, 25, 9, 2, -25 },
  { 2474, 14, 24, 16, 0, -17 },
  { 2516, 12, 25, 15, 1, -25 },
  { 2554, 6, 23, 6, 1, -23 },
  { 2572, 11, 30, 7, -4, -23 },
  { 2614, 13, 25, 14, 1, -25 },
  { 2655, 5, 25, 6, 1, -25 },
  { 2671, 22, 17, 25, 1, -17 },
  { 2718, 12, 17, 15, 1, -17 },
  { 2744, 13, 17, 16, 1, -17 },
  { 2772, 14, 24, 16, 0, -17 },
  { 2814, 13, 24, 16, 1, -17 },
  { 2853, 9, 17, 10, 1, -17 },
  { 2873, 12, 17, 14, 1, -17 },
  { 2899, 7, 22, 9, 2, -22 },
  { 2919, 12, 17, 15, 2, -17 },
  { 2945, 12, 17, 14, 2, -17 },
  { 2971, 18, 17, 21, 3, -17 },
  { 3010, 15, 17, 14, -1, -17 },
  { 3042, 15, 24, 13, -1, -17 },
  { 3087, 13, 17, 14, 0, -17 },
  { 3115, 10, 33, 9, 1, -26 },
  { 3157, 5, 27, 7, 1, -23 },
  { 3174, 10, 33, 9, -2, -26 },
  { 3216, 15, 6, 19, 2, -13 },
};

const GFXfont RobotoCondensed_ExtraLightItalic33pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic33pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic33pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC33PT7B_H_
