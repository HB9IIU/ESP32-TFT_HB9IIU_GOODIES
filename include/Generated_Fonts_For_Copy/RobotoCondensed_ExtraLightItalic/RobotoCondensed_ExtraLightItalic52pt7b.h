#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC52PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x61, 0xB1, 0x98, 0xCC,
  0x66, 0x32, 0x1B, 0x0D, 0x84, 0xC6, 0x63, 0x21, 0x80, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x08, 0x00, 0x04,
  0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x20, 0x30, 0x00,
  0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x00, 0x30, 0x18, 0x00, 0x08, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x08, 0x00,
  0x04, 0x06, 0x00, 0x03, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC0, 0x18, 0x0C, 0x00, 0x06, 0x02, 0x00, 0x01, 0x01, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x10, 0x00, 0x08, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x40, 0x60, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x01, 0xFF, 0x00, 0x1E, 0x3C, 0x01, 0xC0, 0x70, 0x1C, 0x01,
  0x81, 0xC0, 0x0E, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x86, 0x00, 0x0C, 0x30,
  0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x66, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x30,
  0x00, 0xE1, 0x80, 0x06, 0x0E, 0x00, 0x60, 0x38, 0x07, 0x00, 0xF1, 0xF0,
  0x03, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x1C, 0xE0, 0x00, 0x30, 0x20, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30,
  0x04, 0x40, 0x30, 0x0C, 0xC0, 0x30, 0x18, 0xC0, 0x30, 0x10, 0xC0, 0x30,
  0x30, 0xC0, 0x30, 0x60, 0xC0, 0x20, 0xC0, 0xC0, 0x60, 0xC0, 0xC0, 0x61,
  0x80, 0x40, 0xC3, 0x00, 0x63, 0x83, 0x00, 0x3F, 0x06, 0x00, 0x08, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0xFC, 0x00, 0xC1, 0x8E, 0x00, 0x83, 0x06, 0x01, 0x86,
  0x03, 0x03, 0x06, 0x03, 0x06, 0x0C, 0x03, 0x06, 0x0C, 0x03, 0x0C, 0x0C,
  0x03, 0x18, 0x0C, 0x03, 0x18, 0x08, 0x02, 0x30, 0x08, 0x06, 0x60, 0x0C,
  0x06, 0x20, 0x0C, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x39,
  0xE0, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0x30, 0x01, 0x80, 0x30, 0x01, 0x80, 0x30, 0x01, 0x80, 0x60, 0x01, 0x80,
  0x60, 0x01, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x83, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0x38, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x0C,
  0x02, 0x18, 0x0C, 0x06, 0x38, 0x06, 0x06, 0x30, 0x06, 0x06, 0x70, 0x03,
  0x0C, 0x60, 0x03, 0x8C, 0x60, 0x01, 0x8C, 0x60, 0x01, 0xD8, 0x60, 0x00,
  0xD8, 0x60, 0x00, 0x70, 0x60, 0x00, 0x60, 0x60, 0x00, 0xF0, 0x30, 0x01,
  0xB0, 0x38, 0x03, 0x18, 0x1F, 0x1E, 0x1C, 0x07, 0xF8, 0x0C, 0x00, 0xC0,
  0x00, 0x33, 0x32, 0x66, 0x66, 0x4C, 0xC0, 0x00, 0x04, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x1F, 0x06, 0x0F, 0x7C, 0x67, 0xC0,
  0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0xB0, 0x00, 0x33, 0x00,
  0x06, 0x18, 0x00, 0xC1, 0x80, 0x1C, 0x0C, 0x03, 0x80, 0xE0, 0x70, 0x06,
  0x02, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x30, 0xC3, 0x1C, 0x61, 0x8C, 0x71, 0x84, 0x00, 0xFF,
  0xFF, 0xF0, 0x6F, 0xE4, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xE3, 0xC0, 0x38, 0x0C, 0x07,
  0x00, 0x60, 0x60, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0x31,
  0x80, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03,
  0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x06, 0x60, 0x00,
  0x64, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00,
  0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xC8, 0x00, 0x18, 0x80,
  0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x0C,
  0x00, 0x60, 0x60, 0x0C, 0x07, 0x01, 0x80, 0x3C, 0x70, 0x01, 0xFE, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x20, 0x3C, 0x1F, 0x9F, 0x3F, 0x87, 0x80, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0x1E, 0x00, 0x70, 0x1C, 0x03, 0x80, 0x38, 0x0C, 0x00, 0x60, 0x60,
  0x01, 0x81, 0x80, 0x07, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x01,
  0x83, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x03, 0xFC, 0x00, 0x3C, 0xF8, 0x07,
  0x00, 0xC0, 0x30, 0x03, 0x03, 0x00, 0x18, 0x38, 0x00, 0x61, 0x80, 0x03,
  0x0C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x03,
  0x18, 0x00, 0x18, 0xC0, 0x01, 0x87, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0x60,
  0x1C, 0x03, 0xE3, 0xC0, 0x07, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x36, 0x00, 0x00, 0xF0,
  0x00, 0x06, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x30, 0x00,
  0x30, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x30, 0x60, 0x01, 0x81,
  0x80, 0x0E, 0x06, 0x00, 0x30, 0x10, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00,
  0x30, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x70, 0x06, 0x01, 0x80,
  0x18, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x8F, 0xC0, 0x06, 0xFF, 0xC0,
  0x1F, 0x07, 0x80, 0x70, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3,
  0x00, 0x03, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x03, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0xE0, 0x07, 0x8F, 0x00, 0x0F, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x03, 0xF8, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x61, 0xF8, 0x0C, 0xFF,
  0xC3, 0x38, 0x1C, 0x6C, 0x01, 0x8F, 0x00, 0x39, 0xC0, 0x03, 0x30, 0x00,
  0x6E, 0x00, 0x0D, 0x80, 0x00, 0xB0, 0x00, 0x16, 0x00, 0x02, 0xC0, 0x00,
  0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x03,
  0x30, 0x00, 0x66, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0xC0, 0xC0, 0x30,
  0x0F, 0x3C, 0x00, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x01, 0xE3, 0xC0, 0x07, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x70, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x04,
  0x0C, 0x00, 0x18, 0x10, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC0,
  0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x18, 0x03, 0x00, 0x60, 0x03,
  0x03, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x78, 0x38, 0x01, 0xC0,
  0x18, 0x07, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x08, 0x00, 0x06,
  0x10, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0x80,
  0xC0, 0x06, 0x01, 0xC0, 0x38, 0x01, 0xF1, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0x3C, 0x07, 0x01,
  0xC0, 0xC0, 0x1C, 0x30, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x60, 0x00,
  0x6C, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x07,
  0x60, 0x00, 0xEE, 0x00, 0x3C, 0xC0, 0x0D, 0x1C, 0x03, 0x61, 0xC1, 0xCC,
  0x1F, 0xF1, 0x81, 0xF8, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x03, 0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x06, 0x1C,
  0x38, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x61, 0xC3, 0x80, 0x00, 0x00,
  0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06,
  0x03, 0x01, 0xC0, 0x60, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x7F, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x7C, 0xE1, 0xC0, 0x63, 0x00, 0xCC, 0x00, 0xD8, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x38, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x60, 0x03, 0xE0, 0x02, 0x06, 0x00, 0xFF, 0x80, 0x20, 0xC0, 0x1C,
  0x1C, 0x02, 0x0C, 0x03, 0x80, 0xC0, 0x21, 0x80, 0x30, 0x0C, 0x03, 0x18,
  0x06, 0x00, 0xC0, 0x33, 0x00, 0xC0, 0x18, 0x02, 0x30, 0x0C, 0x01, 0x80,
  0x22, 0x01, 0x80, 0x18, 0x02, 0x60, 0x18, 0x01, 0x80, 0x26, 0x01, 0x80,
  0x10, 0x06, 0x60, 0x30, 0x03, 0x00, 0x64, 0x03, 0x00, 0x30, 0x06, 0xC0,
  0x30, 0x03, 0x00, 0x4C, 0x02, 0x00, 0x20, 0x0C, 0xC0, 0x60, 0x06, 0x00,
  0xCC, 0x06, 0x00, 0x60, 0x0C, 0xC0, 0x60, 0x06, 0x00, 0x8C, 0x06, 0x00,
  0xC0, 0x18, 0xC0, 0x60, 0x1C, 0x01, 0x0C, 0x06, 0x01, 0x40, 0x30, 0xC0,
  0x60, 0x34, 0x06, 0x0C, 0x06, 0x06, 0x60, 0xE0, 0xC0, 0x39, 0xC7, 0x1C,
  0x0C, 0x03, 0xF8, 0x3F, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x08, 0x00, 0x01, 0x86, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x08, 0x00, 0x30, 0x04, 0x00, 0x18, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03,
  0x00, 0x04, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0xC0,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x18, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x0C, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0xC0, 0x00,
  0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83,
  0x00, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0xE0, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0xC0, 0x07, 0x01, 0x80, 0x07, 0x02, 0x00, 0x06, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00,
  0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x38, 0x60, 0x00, 0x61, 0x80, 0x03, 0x83, 0x00, 0x0E, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0x3E, 0x00, 0x38, 0x03, 0x80, 0x38, 0x00, 0x60, 0x38, 0x00,
  0x30, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x01,
  0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x70, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x07, 0x00, 0x70, 0x01, 0xF1,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x01, 0x80, 0x60, 0x00, 0x60,
  0x30, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x01,
  0x82, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x10, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x30, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86,
  0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xE0,
  0x60, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0x30, 0x01, 0xE0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x1C, 0x01, 0xC0, 0x18, 0x00, 0x70,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0x86, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x3F, 0xF1, 0x80, 0x1F, 0xF8, 0xC0, 0x00, 0x0C, 0x60,
  0x00, 0x06, 0x20, 0x00, 0x03, 0x10, 0x00, 0x01, 0x98, 0x00, 0x01, 0x84,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18,
  0x70, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x3E,
  0x00, 0xF8, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x40, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x81, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x0C, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x01, 0xC0, 0x60, 0x03,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x38, 0x01, 0xF3, 0xE0, 0x01, 0xFF, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x0C,
  0x00, 0x0E, 0x01, 0x80, 0x03, 0x80, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x38,
  0x01, 0x80, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x06, 0x00, 0xE0, 0x00, 0x80,
  0x38, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0x60, 0x00,
  0x18, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x41, 0x80, 0x00, 0x18, 0x60,
  0x00, 0x03, 0x1E, 0x00, 0x00, 0x66, 0xC0, 0x00, 0x0D, 0x9C, 0x00, 0x01,
  0xE1, 0x80, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x03, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x30,
  0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x06, 0x03, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x07, 0x81, 0x40, 0x00, 0x00, 0xA0, 0x6C, 0x00,
  0x00, 0x3C, 0x0D, 0x80, 0x00, 0x0D, 0x81, 0xB0, 0x00, 0x01, 0xB0, 0x36,
  0x00, 0x00, 0x66, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x88, 0x00, 0x03, 0x30,
  0x31, 0x80, 0x00, 0x66, 0x06, 0x30, 0x00, 0x18, 0xC0, 0xC6, 0x00, 0x03,
  0x18, 0x18, 0xC0, 0x00, 0xC3, 0x03, 0x18, 0x00, 0x18, 0x60, 0x41, 0x00,
  0x06, 0x18, 0x18, 0x30, 0x00, 0xC3, 0x03, 0x06, 0x00, 0x30, 0x60, 0x60,
  0xC0, 0x06, 0x0C, 0x0C, 0x18, 0x01, 0x81, 0x81, 0x81, 0x00, 0x30, 0x20,
  0x20, 0x30, 0x0C, 0x0C, 0x0C, 0x06, 0x01, 0x81, 0x81, 0x80, 0xC0, 0x60,
  0x30, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x20,
  0xE0, 0x30, 0x30, 0x06, 0x18, 0x06, 0x06, 0x00, 0xC6, 0x00, 0xC0, 0xC0,
  0x18, 0xC0, 0x18, 0x18, 0x03, 0x30, 0x03, 0x03, 0x00, 0x26, 0x00, 0x60,
  0x60, 0x05, 0x80, 0x18, 0x18, 0x00, 0xF0, 0x03, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x60, 0x03, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x60, 0x6C, 0x00, 0x03, 0x03, 0x60, 0x00, 0x18, 0x19, 0x80, 0x01, 0x80,
  0xCC, 0x00, 0x0C, 0x06, 0x60, 0x00, 0x60, 0x31, 0x80, 0x03, 0x03, 0x0C,
  0x00, 0x18, 0x18, 0x30, 0x00, 0xC0, 0xC1, 0x80, 0x0C, 0x06, 0x0C, 0x00,
  0x60, 0x30, 0x30, 0x03, 0x01, 0x81, 0x80, 0x18, 0x18, 0x0C, 0x00, 0xC0,
  0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x30, 0x06, 0x03, 0x01, 0x80,
  0x30, 0x18, 0x1C, 0x01, 0x80, 0xC0, 0xC0, 0x06, 0x06, 0x06, 0x00, 0x30,
  0x60, 0x30, 0x00, 0x83, 0x01, 0x80, 0x06, 0x18, 0x0C, 0x00, 0x30, 0xC0,
  0xC0, 0x00, 0xC6, 0x06, 0x00, 0x06, 0x30, 0x30, 0x00, 0x33, 0x01, 0x80,
  0x00, 0xD8, 0x0C, 0x00, 0x06, 0xC0, 0x60, 0x00, 0x16, 0x06, 0x00, 0x00,
  0xF0, 0x30, 0x00, 0x07, 0x81, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x38,
  0x03, 0x80, 0x38, 0x00, 0x60, 0x38, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x01, 0x98, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x70, 0x60, 0x00, 0x30, 0x30, 0x00, 0x30, 0x0C,
  0x00, 0x30, 0x07, 0x00, 0x70, 0x01, 0xF9, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xC0, 0x07,
  0x00, 0x60, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x30, 0x00, 0x18, 0x18, 0x00,
  0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x18, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x06,
  0x00, 0x0E, 0x03, 0x00, 0x1E, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x38, 0x03, 0x80,
  0x38, 0x00, 0x60, 0x38, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x37, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x01, 0xF9, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0xC0, 0x07, 0x00, 0x40, 0x01, 0xC0, 0x60, 0x00, 0x60,
  0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03,
  0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x18, 0x00,
  0x1C, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x1C, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x08, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06,
  0x00, 0x0C, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0,
  0x40, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x07,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0x1F, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x38,
  0x00, 0x18, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x38, 0x00, 0xF8, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x18,
  0x00, 0x01, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C,
  0x18, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x18, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x0C, 0x00,
  0x03, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x1C, 0x00, 0x30, 0x03,
  0x80, 0x38, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x60, 0x00,
  0x60, 0x60, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x30, 0x01,
  0x80, 0x30, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x18, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x20,
  0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x05, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x6C, 0x00, 0x0E, 0x00, 0x06, 0xC0, 0x01,
  0xA0, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x0C, 0x40, 0x01, 0x30, 0x00, 0xC6,
  0x00, 0x33, 0x00, 0x18, 0x60, 0x03, 0x30, 0x01, 0x86, 0x00, 0x63, 0x00,
  0x18, 0x60, 0x06, 0x30, 0x03, 0x06, 0x00, 0x43, 0x00, 0x30, 0x60, 0x0C,
  0x30, 0x07, 0x06, 0x00, 0xC1, 0x00, 0x60, 0x60, 0x18, 0x10, 0x06, 0x06,
  0x01, 0x81, 0x00, 0xC0, 0x60, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x18, 0x06, 0x06, 0x01, 0x81, 0x80, 0x60, 0x60,
  0x18, 0x18, 0x06, 0x04, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x02,
  0x0C, 0x01, 0x86, 0x00, 0x31, 0x80, 0x18, 0x60, 0x03, 0x18, 0x00, 0x86,
  0x00, 0x31, 0x00, 0x08, 0xC0, 0x03, 0x30, 0x00, 0x8C, 0x00, 0x33, 0x00,
  0x0C, 0xC0, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03,
  0x40, 0x00, 0xD0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x18, 0x01, 0x80, 0x01, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x06, 0x07, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x38, 0x03, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x80, 0x1C,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x06,
  0x60, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x30, 0x00, 0x38,
  0x30, 0x00, 0x30, 0x30, 0x00, 0x60, 0x38, 0x00, 0xE0, 0x18, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x0C, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0x0C, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x38, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0xC0, 0x40, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x20, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x02, 0x03, 0x03, 0x03, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x68, 0x01, 0xA0, 0x0C, 0xC0, 0x33, 0x01, 0x8C, 0x06, 0x30,
  0x30, 0x40, 0xC1, 0x06, 0x06, 0x18, 0x18, 0xC0, 0x63, 0x01, 0x98, 0x02,
  0x40, 0x0F, 0x00, 0x30, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xE1, 0x87, 0x0C,
  0x18, 0x60, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0xE3, 0xC0, 0x70,
  0x0E, 0x0E, 0x00, 0x60, 0xC0, 0x06, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x0F, 0xFE, 0x07, 0xFF, 0xC1, 0xE0, 0x0C, 0x38, 0x00, 0xC7, 0x00, 0x0C,
  0x60, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03,
  0x8C, 0x00, 0x38, 0xC0, 0x0D, 0x86, 0x01, 0xD8, 0x78, 0xF1, 0x83, 0xFE,
  0x18, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x63, 0xFC, 0x03, 0x78, 0xF0, 0x36, 0x01, 0xC1, 0xE0, 0x06, 0x0E, 0x00,
  0x30, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x10, 0x00, 0x31, 0x80, 0x01, 0x8C,
  0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0x80, 0x01,
  0x8C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0,
  0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x06, 0x1C, 0x00, 0x30,
  0xF0, 0x03, 0x06, 0xC0, 0x30, 0x63, 0x8F, 0x03, 0x0F, 0xF0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0x1E, 0x07, 0x00, 0xE0, 0xC0,
  0x0C, 0x30, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x6C, 0x00,
  0x0D, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0xC6, 0x00, 0x18, 0x60, 0x06,
  0x0E, 0x01, 0xC0, 0xF1, 0xE0, 0x0F, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x80, 0xC0, 0x1F, 0xE1, 0x80,
  0x78, 0xE2, 0x01, 0x80, 0x6C, 0x06, 0x00, 0x78, 0x18, 0x00, 0x70, 0x30,
  0x00, 0xE0, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x01,
  0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x20, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x01,
  0x80, 0x0E, 0x03, 0x00, 0x3C, 0x07, 0x00, 0xD0, 0x07, 0x8F, 0x60, 0x07,
  0xF8, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xE3,
  0xC0, 0x30, 0x0E, 0x06, 0x00, 0x60, 0xC0, 0x03, 0x1C, 0x00, 0x31, 0x80,
  0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x32, 0x00, 0x03, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x01, 0x03, 0x80, 0x30, 0x1F, 0x1E,
  0x00, 0x7F, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0xF2,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x7F, 0xF0, 0x7F, 0xF0,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0x0C, 0x03, 0xC7, 0x10, 0x0C,
  0x03, 0x60, 0x30, 0x03, 0xC0, 0xC0, 0x03, 0x81, 0x80, 0x07, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00,
  0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83,
  0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x70, 0x18,
  0x01, 0xE0, 0x38, 0x06, 0xC0, 0x3C, 0x7B, 0x00, 0x3F, 0xC6, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x01, 0x00, 0x0C, 0x03, 0x00, 0x30, 0x03, 0x81, 0xC0,
  0x03, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x20, 0x06, 0x3F, 0xC0, 0x67, 0x1E, 0x0C, 0xC0, 0x60, 0xD8, 0x03, 0x0F,
  0x00, 0x30, 0xE0, 0x03, 0x0E, 0x00, 0x30, 0xC0, 0x03, 0x1C, 0x00, 0x31,
  0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x21, 0x00, 0x06,
  0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00,
  0xC2, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00,
  0x0C, 0x60, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x80, 0x03, 0x07, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x0C, 0x0C, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60,
  0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x00, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x01,
  0xF8, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x03, 0x83, 0x00, 0x38, 0x30, 0x03, 0x81, 0x80, 0x38, 0x0C, 0x03,
  0x80, 0x60, 0x38, 0x03, 0x03, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x0C,
  0x30, 0x00, 0x63, 0x00, 0x03, 0x30, 0x00, 0x1B, 0xC0, 0x00, 0xB6, 0x00,
  0x0F, 0x18, 0x00, 0x70, 0xC0, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0,
  0x60, 0x04, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80,
  0xC0, 0x0C, 0x06, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x06, 0x00, 0x03,
  0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0xC7, 0xF8, 0x0F, 0xF0, 0x31,
  0xC7, 0x87, 0x8F, 0x06, 0x60, 0x31, 0xC0, 0x60, 0xD8, 0x03, 0x60, 0x0E,
  0x1E, 0x00, 0x68, 0x00, 0xC3, 0x80, 0x0F, 0x00, 0x18, 0x60, 0x01, 0xC0,
  0x03, 0x1C, 0x00, 0x38, 0x00, 0x63, 0x00, 0x06, 0x00, 0x0C, 0x60, 0x00,
  0xC0, 0x01, 0x8C, 0x00, 0x18, 0x00, 0x31, 0x80, 0x03, 0x00, 0x0C, 0x30,
  0x00, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0x00, 0x31, 0x80, 0x03, 0x00, 0x06,
  0x30, 0x00, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x00, 0x18, 0xC0, 0x01, 0x00,
  0x06, 0x10, 0x00, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x00, 0x18, 0xC0, 0x01,
  0x80, 0x03, 0x18, 0x00, 0x30, 0x00, 0x63, 0x00, 0x06, 0x00, 0x0C, 0x60,
  0x00, 0x80, 0x03, 0x18, 0x00, 0x30, 0x00, 0x63, 0x00, 0x06, 0x00, 0x0C,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x02, 0x00, 0x63, 0xFC, 0x06, 0x71,
  0xE0, 0x4C, 0x06, 0x0D, 0x80, 0x30, 0xF0, 0x03, 0x0E, 0x00, 0x30, 0xE0,
  0x03, 0x0C, 0x00, 0x31, 0xC0, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18,
  0x00, 0x31, 0x80, 0x02, 0x18, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x63,
  0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x04, 0x20, 0x00, 0xC6, 0x00, 0x0C,
  0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x01,
  0x8C, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0F, 0xF0, 0x03, 0xC7, 0xC0, 0x70,
  0x0C, 0x0E, 0x00, 0x61, 0xC0, 0x06, 0x18, 0x00, 0x33, 0x00, 0x03, 0x30,
  0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01,
  0x86, 0x00, 0x38, 0x60, 0x07, 0x03, 0x00, 0xE0, 0x1E, 0x3C, 0x00, 0xFF,
  0x80, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x1F, 0xE0, 0x06, 0xF1,
  0xE0, 0x1B, 0x00, 0xE0, 0x3C, 0x00, 0xC0, 0x70, 0x01, 0x80, 0xC0, 0x01,
  0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60,
  0x00, 0xC0, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x0E, 0x00,
  0x38, 0x1C, 0x00, 0x60, 0x36, 0x01, 0x80, 0x4F, 0x1E, 0x01, 0x87, 0xF8,
  0x03, 0x01, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x0F, 0xF0, 0xC0, 0xF1, 0xC4, 0x0C, 0x03, 0x60, 0xC0, 0x0F, 0x0C, 0x00,
  0x38, 0x60, 0x01, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x21, 0x80, 0x03, 0x18,
  0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x03,
  0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80,
  0x01, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x70,
  0x60, 0x07, 0x83, 0x80, 0x68, 0x0F, 0x1E, 0xC0, 0x3F, 0xC6, 0x00, 0x20,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x7C, 0x1B, 0xE0, 0x2E, 0x00,
  0xD0, 0x01, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x0F, 0x1E, 0x03, 0x80, 0xE0, 0xC0, 0x0E, 0x18, 0x00, 0xC6,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x19, 0x80,
  0x03, 0x30, 0x00, 0x66, 0x00, 0x18, 0x60, 0x07, 0x0E, 0x01, 0xC0, 0xF1,
  0xF0, 0x07, 0xF8, 0x00, 0x10, 0x00, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x00, 0x60, 0xFF, 0xFF, 0xFC, 0x30, 0x06, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0E, 0x40, 0xF8, 0x04, 0x00, 0x18, 0x00, 0x31, 0x80,
  0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30,
  0x00, 0x43, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6,
  0x00, 0x0C, 0x60, 0x00, 0x84, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18,
  0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x70, 0xC0, 0x0F, 0x0C, 0x00, 0xB0, 0x60, 0x3E, 0x07, 0x8F,
  0x60, 0x3F, 0xC6, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x19, 0x80,
  0x03, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00,
  0x30, 0x20, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01,
  0x80, 0x60, 0x30, 0x04, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x03, 0x0C,
  0x00, 0x63, 0x00, 0x0C, 0x60, 0x00, 0x98, 0x00, 0x13, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x1E, 0x00, 0x38, 0x01, 0xF0, 0x01, 0xC0, 0x0D, 0x80, 0x1E,
  0x00, 0x6C, 0x00, 0xF0, 0x06, 0x60, 0x0D, 0x80, 0x31, 0x00, 0x6C, 0x03,
  0x08, 0x06, 0x60, 0x18, 0x60, 0x33, 0x00, 0xC3, 0x01, 0x18, 0x0C, 0x18,
  0x18, 0x40, 0x60, 0xC0, 0xC2, 0x06, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60,
  0xC3, 0x81, 0x86, 0x06, 0x18, 0x0C, 0x30, 0x30, 0xC0, 0x63, 0x01, 0x8C,
  0x03, 0x18, 0x0C, 0x60, 0x19, 0x80, 0x66, 0x00, 0xCC, 0x03, 0x30, 0x06,
  0x40, 0x09, 0x80, 0x16, 0x00, 0x58, 0x00, 0xB0, 0x02, 0xC0, 0x07, 0x00,
  0x14, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x0C, 0x0E, 0x00, 0x30, 0x0C, 0x00, 0xE0, 0x18, 0x01,
  0x80, 0x18, 0x06, 0x00, 0x30, 0x18, 0x00, 0x30, 0x70, 0x00, 0x60, 0xC0,
  0x00, 0x63, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xB8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x36, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x30, 0x00, 0x60,
  0x30, 0x01, 0xC0, 0x60, 0x07, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x30, 0x01,
  0xC0, 0xE0, 0x01, 0x83, 0x80, 0x03, 0x00, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x07, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x0C, 0x03, 0x00,
  0x0C, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x01, 0x80, 0x30, 0x01, 0x80,
  0x30, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0xC0, 0x01, 0x80,
  0xC0, 0x00, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x00, 0x01, 0x80, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x00, 0x80,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xE0, 0x03,
  0x38, 0x70, 0x03, 0x30, 0x38, 0x02, 0x60, 0x18, 0x06, 0x60, 0x0C, 0x06,
  0xC0, 0x06, 0x0C, 0xC0, 0x03, 0xF8, 0x00, 0x01, 0xF0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 9, 38, 10, 1, -37 },
  { 44, 9, 11, 14, 6, -39 },
  { 57, 26, 37, 25, 1, -37 },
  { 178, 21, 49, 24, 2, -43 },
  { 307, 24, 39, 33, 5, -38 },
  { 424, 24, 39, 27, 1, -38 },
  { 541, 4, 11, 8, 5, -39 },
  { 547, 14, 53, 14, 3, -41 },
  { 640, 14, 53, 14, -3, -41 },
  { 733, 20, 20, 21, 3, -37 },
  { 783, 21, 27, 25, 2, -30 },
  { 854, 6, 11, 10, -2, -4 },
  { 863, 10, 2, 13, 2, -18 },
  { 866, 4, 4, 11, 1, -3 },
  { 868, 21, 40, 18, -2, -37 },
  { 973, 20, 39, 24, 3, -38 },
  { 1071, 11, 37, 24, 7, -37 },
  { 1122, 22, 38, 24, 1, -38 },
  { 1227, 21, 39, 24, 2, -38 },
  { 1330, 22, 37, 24, 1, -37 },
  { 1432, 22, 38, 24, 3, -37 },
  { 1537, 19, 38, 24, 3, -37 },
  { 1628, 21, 37, 24, 4, -37 },
  { 1726, 23, 39, 24, 1, -38 },
  { 1839, 19, 38, 24, 4, -38 },
  { 1930, 7, 28, 10, 1, -27 },
  { 1955, 10, 34, 9, -2, -27 },
  { 1998, 20, 21, 23, 2, -27 },
  { 2051, 19, 12, 25, 3, -23 },
  { 2080, 20, 21, 23, 1, -27 },
  { 2133, 15, 39, 20, 5, -38 },
  { 2207, 36, 48, 40, 2, -36 },
  { 2423, 25, 37, 27, -2, -37 },
  { 2539, 23, 37, 27, 2, -37 },
  { 2646, 25, 39, 29, 3, -38 },
  { 2768, 25, 37, 29, 2, -37 },
  { 2884, 25, 37, 25, 2, -37 },
  { 3000, 25, 37, 25, 2, -37 },
  { 3116, 25, 39, 30, 3, -38 },
  { 3238, 28, 37, 31, 2, -37 },
  { 3368, 9, 37, 12, 2, -37 },
  { 3410, 23, 38, 24, 1, -37 },
  { 3520, 27, 37, 28, 2, -37 },
  { 3645, 17, 37, 23, 2, -37 },
  { 3724, 35, 37, 38, 2, -37 },
  { 3886, 29, 37, 31, 2, -37 },
  { 4021, 25, 39, 30, 3, -38 },
  { 4143, 25, 37, 27, 2, -37 },
  { 4259, 25, 45, 30, 3, -38 },
  { 4400, 25, 37, 28, 2, -37 },
  { 4516, 25, 39, 26, 1, -38 },
  { 4638, 24, 37, 26, 5, -37 },
  { 4749, 26, 38, 29, 3, -37 },
  { 4873, 24, 37, 27, 5, -37 },
  { 4984, 36, 37, 39, 5, -37 },
  { 5151, 29, 37, 27, -1, -37 },
  { 5286, 24, 37, 26, 5, -37 },
  { 5397, 27, 37, 26, 0, -37 },
  { 5522, 15, 50, 11, 0, -42 },
  { 5616, 8, 40, 17, 5, -37 },
  { 5656, 14, 50, 11, -3, -42 },
  { 5744, 14, 18, 19, 3, -37 },
  { 5776, 19, 2, 19, -3, 0 },
  { 5781, 6, 7, 14, 7, -39 },
  { 5787, 20, 29, 24, 1, -28 },
  { 5860, 21, 40, 24, 1, -39 },
  { 5965, 19, 29, 23, 2, -28 },
  { 6034, 23, 40, 25, 2, -39 },
  { 6149, 20, 29, 23, 1, -28 },
  { 6222, 16, 40, 15, 3, -40 },
  { 6302, 23, 39, 24, 0, -28 },
  { 6415, 20, 39, 24, 1, -39 },
  { 6513, 8, 37, 10, 2, -37 },
  { 6550, 17, 48, 10, -7, -37 },
  { 6652, 21, 39, 22, 1, -39 },
  { 6755, 8, 39, 10, 2, -39 },
  { 6794, 35, 28, 39, 1, -28 },
  { 6917, 20, 28, 24, 1, -28 },
  { 6987, 20, 29, 25, 2, -28 },
  { 7060, 23, 39, 24, -1, -28 },
  { 7173, 21, 39, 25, 2, -28 },
  { 7276, 15, 28, 15, 1, -28 },
  { 7329, 19, 29, 22, 1, -28 },
  { 7398, 11, 36, 15, 3, -35 },
  { 7448, 20, 28, 24, 3, -27 },
  { 7518, 19, 27, 21, 3, -27 },
  { 7583, 29, 27, 33, 4, -27 },
  { 7681, 23, 27, 22, -1, -27 },
  { 7759, 24, 38, 21, -2, -27 },
  { 7873, 21, 27, 22, 0, -27 },
  { 7944, 16, 52, 15, 2, -41 },
  { 8048, 9, 44, 11, 1, -37 },
  { 8098, 16, 52, 15, -3, -41 },
  { 8202, 24, 9, 30, 3, -20 },
};

const GFXfont RobotoCondensed_ExtraLightItalic52pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic52pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic52pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC52PT7B_H_
