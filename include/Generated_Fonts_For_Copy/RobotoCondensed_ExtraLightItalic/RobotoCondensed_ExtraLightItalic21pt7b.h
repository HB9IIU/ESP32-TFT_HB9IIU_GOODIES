#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC21PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x12, 0x22, 0x22, 0x24, 0x40, 0x00, 0xC0, 0x55, 0x9A, 0x02,
  0x40, 0x88, 0x11, 0x02, 0x43, 0xFE, 0x11, 0x02, 0x40, 0x48, 0x11, 0x02,
  0x43, 0xFE, 0x11, 0x02, 0x40, 0x48, 0x11, 0x00, 0x04, 0x04, 0x1E, 0x21,
  0x21, 0x41, 0x40, 0x40, 0x20, 0x18, 0x06, 0x02, 0x02, 0x82, 0x82, 0x84,
  0x78, 0x10, 0x20, 0x70, 0x12, 0x08, 0x8A, 0x24, 0x8A, 0x24, 0x86, 0x40,
  0x20, 0x0B, 0x85, 0x12, 0x45, 0x11, 0x44, 0x41, 0x20, 0x30, 0x0E, 0x09,
  0x08, 0x44, 0x42, 0x21, 0x20, 0x60, 0x60, 0x48, 0xC4, 0x61, 0x50, 0x68,
  0x24, 0x29, 0xE4, 0x6A, 0x04, 0x21, 0x04, 0x20, 0x84, 0x10, 0x41, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x10, 0x40, 0x80, 0x10, 0x20, 0x82,
  0x08, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0x10, 0x42, 0x10,
  0x42, 0x00, 0x08, 0x08, 0x08, 0x6F, 0x18, 0x28, 0x24, 0x44, 0x08, 0x08,
  0x08, 0x08, 0x08, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x25, 0x40, 0xF0,
  0xC0, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08,
  0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x1E, 0x21, 0x21, 0x41, 0x41,
  0x41, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x84, 0x78, 0x1F, 0x11,
  0x11, 0x22, 0x22, 0x22, 0x44, 0x40, 0x0F, 0x08, 0x48, 0x24, 0x10, 0x08,
  0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x01, 0xFC, 0x1E,
  0x21, 0x41, 0x41, 0x01, 0x01, 0x02, 0x1C, 0x02, 0x02, 0x02, 0x82, 0x82,
  0x84, 0x78, 0x00, 0x80, 0xC0, 0xA0, 0xA0, 0x50, 0x48, 0x44, 0x22, 0x21,
  0x21, 0x1F, 0xE0, 0x40, 0x20, 0x10, 0x08, 0x1F, 0x88, 0x08, 0x04, 0x02,
  0x02, 0xE1, 0x88, 0x02, 0x01, 0x00, 0x80, 0x50, 0x48, 0x22, 0x20, 0xE0,
  0x07, 0x18, 0x20, 0x20, 0x40, 0x5C, 0x62, 0xC1, 0x81, 0x81, 0x81, 0x82,
  0x82, 0x44, 0x38, 0xFF, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x40, 0x40, 0x80, 0x80, 0x0F, 0x04, 0x21, 0x08, 0x81, 0x20,
  0x88, 0x21, 0x10, 0x38, 0x31, 0x10, 0x44, 0x0A, 0x04, 0x41, 0x10, 0x83,
  0xC0, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x86, 0xF8, 0x10, 0x20,
  0x82, 0x38, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x02, 0x44, 0x80, 0x03, 0x0C, 0x30, 0xC0, 0xC0, 0x30, 0x08, 0x04, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x40, 0x60, 0x30, 0x10, 0x63, 0x18, 0x40,
  0x39, 0x18, 0x61, 0x04, 0x10, 0x84, 0x21, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x03, 0xE0, 0x10, 0x61, 0x80, 0x84, 0x01, 0x21, 0xC5, 0x09, 0x14, 0x44,
  0x52, 0x11, 0x88, 0x46, 0x21, 0x19, 0x08, 0x64, 0x22, 0x90, 0x8A, 0x46,
  0x48, 0xE6, 0x20, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x01,
  0x00, 0x60, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x88, 0x21, 0x10, 0x44, 0x11,
  0xFC, 0x81, 0x40, 0x50, 0x14, 0x04, 0x3F, 0x10, 0x48, 0x24, 0x14, 0x0A,
  0x05, 0x04, 0xFC, 0x41, 0x20, 0xA0, 0x30, 0x28, 0x14, 0x13, 0xF0, 0x0F,
  0x04, 0x22, 0x05, 0x01, 0x40, 0x50, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x0A, 0x02, 0x81, 0x10, 0x83, 0xC0, 0x3F, 0x08, 0x22, 0x04, 0x81, 0x40,
  0x50, 0x14, 0x05, 0x01, 0x40, 0x90, 0x28, 0x0A, 0x02, 0x81, 0x20, 0x8F,
  0xC0, 0x3F, 0xC8, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0xFC, 0x40,
  0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xE0, 0x3F, 0xC8, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x01, 0xFC, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x00, 0x0F, 0x84, 0x12, 0x04, 0x81, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x47, 0xE0, 0x18, 0x0A, 0x02, 0x40, 0x90, 0x63, 0xE0, 0x20, 0x24,
  0x04, 0x80, 0x90, 0x14, 0x02, 0x80, 0x90, 0x13, 0xFE, 0x40, 0x48, 0x0A,
  0x01, 0x40, 0x48, 0x09, 0x01, 0x20, 0x20, 0x24, 0x92, 0x52, 0x49, 0x49,
  0x20, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x12, 0x04, 0x82, 0x10, 0x83, 0xC0, 0x20, 0x44, 0x10, 0x84,
  0x11, 0x04, 0x40, 0x90, 0x16, 0x03, 0x40, 0x48, 0x08, 0x82, 0x10, 0x41,
  0x08, 0x21, 0x02, 0x20, 0x40, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x82, 0x04, 0x08, 0x10, 0x3F, 0x80, 0x20, 0x04, 0xC0, 0x33, 0x01,
  0x4C, 0x06, 0x50, 0x29, 0x40, 0xA4, 0x84, 0x92, 0x12, 0x48, 0x89, 0x22,
  0x48, 0x91, 0x22, 0x44, 0x86, 0x12, 0x18, 0x48, 0x41, 0x00, 0x20, 0x26,
  0x04, 0xC0, 0x94, 0x14, 0x82, 0x90, 0x91, 0x12, 0x22, 0x44, 0x48, 0x4A,
  0x09, 0x40, 0xC8, 0x19, 0x03, 0x20, 0x20, 0x0F, 0x04, 0x22, 0x05, 0x01,
  0x40, 0x50, 0x14, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x81, 0x10,
  0xC3, 0xC0, 0x3F, 0x08, 0x22, 0x04, 0x81, 0x40, 0x50, 0x14, 0x09, 0x04,
  0x7E, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x0F, 0x04, 0x22,
  0x05, 0x01, 0x40, 0x50, 0x14, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02,
  0x81, 0x10, 0xC3, 0xC0, 0x08, 0x02, 0x00, 0x40, 0x3F, 0x08, 0x22, 0x04,
  0x81, 0x40, 0x50, 0x24, 0x09, 0x04, 0x7E, 0x10, 0x88, 0x22, 0x08, 0x81,
  0x20, 0x48, 0x10, 0x1F, 0x08, 0x22, 0x09, 0x02, 0x40, 0x10, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x12, 0x04, 0x81, 0x20, 0x87, 0xC0, 0xFF, 0x82,
  0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x20, 0x24, 0x04, 0x81, 0x20, 0x24, 0x04,
  0x80, 0x90, 0x12, 0x04, 0x40, 0x90, 0x12, 0x02, 0x40, 0x48, 0x10, 0x84,
  0x0F, 0x00, 0x80, 0x60, 0x28, 0x0A, 0x04, 0x81, 0x10, 0x84, 0x21, 0x10,
  0x44, 0x11, 0x04, 0x81, 0x20, 0x30, 0x0C, 0x02, 0x00, 0x81, 0x03, 0x06,
  0x0A, 0x0C, 0x14, 0x28, 0x48, 0x50, 0x90, 0xA1, 0x22, 0x44, 0x44, 0x48,
  0x90, 0x90, 0xA1, 0x41, 0x42, 0x83, 0x06, 0x06, 0x0C, 0x08, 0x18, 0x10,
  0x20, 0x00, 0x20, 0x22, 0x08, 0x41, 0x04, 0x40, 0x90, 0x14, 0x01, 0x80,
  0x20, 0x0A, 0x01, 0x40, 0x48, 0x10, 0x84, 0x10, 0x81, 0x20, 0x20, 0x80,
  0xA0, 0x24, 0x11, 0x04, 0x42, 0x09, 0x02, 0x40, 0xA0, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x1F, 0xE0, 0x08, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00,
  0x80, 0x3F, 0xE0, 0x1C, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82, 0x10,
  0x41, 0x04, 0x10, 0x42, 0x08, 0x38, 0x92, 0x24, 0x92, 0x48, 0x92, 0x49,
  0x18, 0x42, 0x10, 0x84, 0x22, 0x10, 0x84, 0x21, 0x10, 0x84, 0x21, 0x09,
  0x80, 0x08, 0x62, 0x8A, 0x49, 0x18, 0x40, 0xFE, 0x94, 0x1E, 0x21, 0x21,
  0x01, 0x01, 0x3F, 0x41, 0x81, 0x82, 0x86, 0x7A, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x01, 0x78, 0xC2, 0x41, 0x20, 0xA0, 0x50, 0x28, 0x14, 0x12, 0x09,
  0x09, 0x78, 0x3C, 0x42, 0x41, 0x81, 0x80, 0x80, 0x80, 0x82, 0x84, 0x84,
  0x78, 0x00, 0x80, 0x40, 0x20, 0x10, 0x11, 0xE9, 0x0C, 0x82, 0x81, 0x41,
  0x20, 0x90, 0x48, 0x24, 0x12, 0x18, 0xF8, 0x3C, 0x42, 0x41, 0x81, 0xFE,
  0x80, 0x80, 0x80, 0x80, 0x84, 0x78, 0x0E, 0x20, 0x81, 0x02, 0x0F, 0x08,
  0x10, 0x40, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x1E, 0x90, 0xC8, 0x28,
  0x14, 0x12, 0x09, 0x04, 0x82, 0x41, 0x21, 0x8F, 0x80, 0x40, 0x24, 0x21,
  0xE0, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x78, 0xC4, 0x41, 0x20, 0xA0,
  0x90, 0x48, 0x24, 0x12, 0x09, 0x05, 0x04, 0x20, 0x04, 0x92, 0x52, 0x49,
  0x20, 0x02, 0x00, 0x00, 0x00, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x08, 0x10, 0x23, 0x80, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01,
  0x08, 0x88, 0x48, 0x28, 0x28, 0x1A, 0x09, 0x04, 0x42, 0x21, 0x09, 0x04,
  0x24, 0x94, 0x92, 0x4A, 0x49, 0x24, 0x2F, 0x3C, 0x62, 0x88, 0x82, 0x09,
  0x04, 0x14, 0x10, 0x48, 0x20, 0x90, 0x41, 0x20, 0x82, 0x41, 0x04, 0x82,
  0x0A, 0x08, 0x20, 0x2F, 0x18, 0x88, 0x24, 0x14, 0x12, 0x09, 0x04, 0x82,
  0x41, 0x20, 0xA0, 0x80, 0x1E, 0x22, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82,
  0x82, 0x84, 0x78, 0x2F, 0x18, 0x48, 0x24, 0x14, 0x0A, 0x05, 0x02, 0x82,
  0x41, 0x21, 0x2F, 0x10, 0x08, 0x04, 0x02, 0x00, 0x3D, 0x43, 0x41, 0x81,
  0x82, 0x82, 0x82, 0x82, 0x82, 0x84, 0x7C, 0x04, 0x04, 0x04, 0x04, 0x2E,
  0x60, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x00, 0x1E, 0x21, 0x21,
  0x20, 0x30, 0x0C, 0x02, 0x02, 0x82, 0x42, 0x3C, 0x21, 0x09, 0xF2, 0x21,
  0x08, 0x42, 0x11, 0x08, 0x30, 0x41, 0x41, 0x41, 0x41, 0x82, 0x82, 0x82,
  0x82, 0x82, 0x84, 0x7C, 0x81, 0x82, 0x42, 0x44, 0x44, 0x48, 0x48, 0x50,
  0x30, 0x20, 0x20, 0x84, 0x30, 0x86, 0x31, 0x4A, 0x29, 0x45, 0x29, 0x28,
  0xA5, 0x18, 0xC3, 0x18, 0x42, 0x08, 0x00, 0x21, 0x10, 0x84, 0x82, 0x81,
  0x80, 0x40, 0x60, 0x48, 0x44, 0x21, 0x20, 0x80, 0x20, 0x48, 0x21, 0x08,
  0x44, 0x11, 0x04, 0x81, 0x20, 0x50, 0x0C, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x08, 0x0C, 0x00, 0x3F, 0x01, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40,
  0x40, 0xFE, 0x04, 0x21, 0x04, 0x10, 0x82, 0x08, 0x42, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x08, 0x11, 0x12, 0x22, 0x22, 0x22, 0x44, 0x44,
  0x44, 0x88, 0x10, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x10, 0x84, 0x10,
  0x41, 0x08, 0x20, 0x84, 0x20, 0x30, 0x52, 0x18, 0x4A, 0x0C,
};

const GFXglyph RobotoCondensed_ExtraLightItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 15, 4, 0, -15 },
  { 9, 4, 4, 5, 2, -16 },
  { 11, 11, 15, 10, 0, -15 },
  { 32, 8, 19, 10, 1, -17 },
  { 51, 10, 15, 13, 2, -15 },
  { 70, 9, 15, 11, 1, -15 },
  { 87, 2, 4, 3, 2, -16 },
  { 88, 6, 22, 6, 1, -17 },
  { 105, 6, 22, 6, -1, -17 },
  { 122, 8, 8, 9, 1, -15 },
  { 130, 8, 11, 10, 1, -13 },
  { 141, 3, 4, 4, -1, -2 },
  { 143, 4, 1, 5, 1, -7 },
  { 144, 2, 1, 5, 0, -1 },
  { 145, 9, 16, 7, -1, -15 },
  { 163, 8, 15, 10, 1, -15 },
  { 178, 4, 15, 10, 3, -15 },
  { 186, 9, 15, 10, 0, -15 },
  { 203, 8, 15, 10, 1, -15 },
  { 218, 9, 15, 10, 0, -15 },
  { 235, 9, 15, 10, 1, -15 },
  { 252, 8, 15, 10, 1, -15 },
  { 267, 8, 15, 10, 2, -15 },
  { 282, 10, 15, 10, 0, -15 },
  { 301, 7, 15, 10, 2, -15 },
  { 315, 3, 11, 4, 0, -11 },
  { 320, 4, 13, 4, -1, -11 },
  { 327, 8, 8, 9, 1, -11 },
  { 335, 8, 6, 10, 1, -10 },
  { 341, 7, 8, 9, 1, -11 },
  { 348, 6, 15, 8, 2, -15 },
  { 360, 14, 20, 16, 1, -15 },
  { 395, 10, 15, 11, -1, -15 },
  { 414, 9, 15, 11, 1, -15 },
  { 431, 10, 15, 12, 1, -15 },
  { 450, 10, 15, 12, 1, -15 },
  { 469, 10, 15, 10, 1, -15 },
  { 488, 10, 15, 10, 1, -15 },
  { 507, 10, 15, 12, 1, -15 },
  { 526, 11, 15, 13, 1, -15 },
  { 547, 3, 15, 5, 1, -15 },
  { 553, 10, 15, 10, 0, -15 },
  { 572, 11, 15, 11, 1, -15 },
  { 593, 7, 15, 9, 1, -15 },
  { 607, 14, 15, 15, 1, -15 },
  { 634, 11, 15, 13, 1, -15 },
  { 655, 10, 15, 12, 1, -15 },
  { 674, 10, 15, 11, 1, -15 },
  { 693, 10, 18, 12, 1, -15 },
  { 716, 10, 15, 11, 1, -15 },
  { 735, 10, 15, 11, 1, -15 },
  { 754, 10, 15, 11, 2, -15 },
  { 773, 11, 15, 12, 1, -15 },
  { 794, 10, 15, 11, 2, -15 },
  { 813, 15, 15, 16, 2, -15 },
  { 842, 11, 15, 11, 0, -15 },
  { 863, 10, 15, 11, 2, -15 },
  { 882, 11, 15, 11, 0, -15 },
  { 903, 6, 20, 4, 0, -17 },
  { 918, 3, 16, 7, 2, -15 },
  { 924, 5, 20, 4, -1, -17 },
  { 937, 6, 7, 8, 1, -15 },
  { 943, 7, 1, 8, -1, 0 },
  { 944, 2, 3, 6, 3, -16 },
  { 945, 8, 11, 10, 0, -11 },
  { 956, 9, 16, 10, 0, -16 },
  { 974, 8, 11, 9, 1, -11 },
  { 985, 9, 16, 10, 1, -16 },
  { 1003, 8, 11, 9, 1, -11 },
  { 1014, 7, 16, 6, 1, -16 },
  { 1028, 9, 15, 10, 0, -11 },
  { 1045, 9, 16, 10, 0, -16 },
  { 1063, 3, 15, 4, 1, -15 },
  { 1069, 7, 19, 4, -3, -15 },
  { 1086, 9, 16, 9, 0, -16 },
  { 1104, 3, 16, 4, 1, -16 },
  { 1110, 15, 11, 16, 0, -11 },
  { 1131, 9, 11, 10, 0, -11 },
  { 1144, 8, 11, 10, 1, -11 },
  { 1155, 9, 15, 10, 0, -11 },
  { 1172, 8, 15, 10, 1, -11 },
  { 1187, 7, 11, 6, 0, -11 },
  { 1197, 8, 11, 9, 0, -11 },
  { 1208, 5, 14, 6, 1, -14 },
  { 1217, 8, 11, 10, 1, -11 },
  { 1228, 8, 11, 9, 1, -11 },
  { 1239, 11, 11, 13, 2, -11 },
  { 1255, 9, 11, 9, 0, -11 },
  { 1268, 10, 15, 9, -1, -11 },
  { 1287, 8, 11, 9, 0, -11 },
  { 1298, 6, 20, 6, 1, -16 },
  { 1313, 4, 18, 4, 0, -15 },
  { 1322, 6, 20, 6, -1, -16 },
  { 1337, 10, 4, 12, 1, -8 },
};

const GFXfont RobotoCondensed_ExtraLightItalic21pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic21pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC21PT7B_H_
