#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC40PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0xC3, 0x0C, 0x20, 0x82, 0x18, 0x61, 0x84, 0x10, 0x43,
  0x0C, 0x20, 0x82, 0x08, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x30, 0x22, 0xC5,
  0x9B, 0x34, 0x48, 0x91, 0x62, 0x00, 0x30, 0x60, 0x02, 0x04, 0x00, 0x20,
  0xC0, 0x06, 0x0C, 0x00, 0x40, 0x80, 0x04, 0x18, 0x00, 0xC1, 0x80, 0x0C,
  0x10, 0x1F, 0xFF, 0xF0, 0x18, 0x30, 0x01, 0x82, 0x00, 0x10, 0x20, 0x01,
  0x06, 0x00, 0x30, 0x40, 0x02, 0x04, 0x00, 0x20, 0xC0, 0x06, 0x08, 0x00,
  0x40, 0x80, 0x04, 0x18, 0x0F, 0xFF, 0xF8, 0x08, 0x10, 0x00, 0x83, 0x00,
  0x18, 0x20, 0x01, 0x02, 0x00, 0x10, 0x60, 0x03, 0x04, 0x00, 0x20, 0x40,
  0x02, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x0F, 0xC0, 0x0E, 0x70, 0x0C, 0x0C, 0x0C, 0x02, 0x0C, 0x01, 0x84, 0x00,
  0xC2, 0x00, 0x61, 0x00, 0x31, 0x80, 0x18, 0x40, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x40, 0x06, 0x20, 0x03, 0x10, 0x01,
  0x88, 0x01, 0x86, 0x00, 0xC1, 0x80, 0xC0, 0x73, 0xC0, 0x1F, 0x80, 0x03,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x1E, 0x00, 0x0C, 0xC0,
  0x06, 0x18, 0x01, 0x02, 0x00, 0xC0, 0x81, 0xA0, 0x20, 0xC8, 0x08, 0x22,
  0x06, 0x10, 0x81, 0x8C, 0x20, 0x42, 0x0C, 0x31, 0x01, 0x98, 0xC0, 0x3C,
  0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x3C, 0x03, 0x19, 0x80, 0x8C,
  0x30, 0x42, 0x04, 0x31, 0x81, 0x08, 0x60, 0x44, 0x10, 0x13, 0x04, 0x05,
  0x81, 0x03, 0x40, 0x40, 0x80, 0x18, 0x60, 0x03, 0x30, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x77, 0x00, 0x30, 0x60, 0x08, 0x18, 0x06, 0x02, 0x01, 0x81,
  0x80, 0x40, 0x60, 0x10, 0x10, 0x06, 0x08, 0x01, 0x86, 0x00, 0x26, 0x00,
  0x0F, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xC8, 0x00, 0x63, 0x03, 0x30,
  0x40, 0xC8, 0x18, 0x26, 0x03, 0x09, 0x00, 0xC6, 0xC0, 0x19, 0x30, 0x02,
  0xCC, 0x00, 0xE3, 0x00, 0x10, 0x60, 0x0E, 0x18, 0x04, 0xC3, 0xCE, 0x30,
  0x3E, 0x06, 0x6D, 0xA5, 0xB4, 0x00, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x08, 0x00, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0x80, 0x30, 0x04, 0x01, 0x00, 0x60, 0x18, 0x06, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x40, 0x83, 0xF1,
  0x9E, 0x1F, 0xF8, 0x03, 0xC0, 0x03, 0x80, 0x06, 0x80, 0x0C, 0xC0, 0x18,
  0x60, 0x10, 0x60, 0x30, 0x30, 0x20, 0x10, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x13, 0x33, 0x26, 0xC8, 0xFF, 0x5F, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00,
  0x01, 0xF8, 0x03, 0x9C, 0x06, 0x06, 0x0C, 0x06, 0x18, 0x02, 0x10, 0x03,
  0x10, 0x03, 0x30, 0x03, 0x20, 0x03, 0x20, 0x03, 0x60, 0x03, 0x60, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x04,
  0xC0, 0x04, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x08, 0xC0, 0x18, 0xC0, 0x10,
  0x40, 0x30, 0x60, 0x60, 0x39, 0xC0, 0x1F, 0x00, 0x00, 0x83, 0xC7, 0x6E,
  0x38, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30,
  0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18,
  0x0C, 0x04, 0x02, 0x00, 0x00, 0xF8, 0x01, 0xCF, 0x01, 0x81, 0x81, 0x80,
  0x60, 0x80, 0x10, 0xC0, 0x08, 0x40, 0x04, 0x20, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xF8, 0x01, 0xEF, 0x01, 0x80, 0xC0, 0x80,
  0x20, 0xC0, 0x10, 0xC0, 0x0C, 0x60, 0x06, 0x20, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07, 0x80, 0x1F, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0xCC, 0x00,
  0x66, 0x00, 0x33, 0x00, 0x10, 0x80, 0x18, 0x60, 0x18, 0x18, 0x18, 0x0F,
  0x38, 0x01, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0A,
  0x00, 0x1A, 0x00, 0x32, 0x00, 0x26, 0x00, 0x66, 0x00, 0xC6, 0x00, 0x84,
  0x01, 0x04, 0x03, 0x04, 0x06, 0x0C, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x08,
  0x10, 0x08, 0x30, 0x18, 0x60, 0x18, 0xC0, 0x18, 0xFF, 0xFF, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x03, 0xFF, 0x83, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0xF8, 0x03,
  0xEF, 0x01, 0x81, 0xC0, 0x80, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x8C, 0x00, 0x42, 0x00, 0x61, 0x00,
  0x30, 0x80, 0x10, 0x60, 0x18, 0x18, 0x18, 0x07, 0x38, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x01, 0xF0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x8F, 0x83, 0x3B, 0xC7, 0x81,
  0x8A, 0x01, 0x98, 0x01, 0x20, 0x02, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x14,
  0x00, 0x2C, 0x00, 0x58, 0x01, 0xB0, 0x02, 0x20, 0x0C, 0x60, 0x10, 0xC0,
  0x60, 0xF7, 0x80, 0x7C, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x00, 0xFC, 0x01, 0xE7, 0x01, 0xC0, 0xC0, 0xC0, 0x30, 0xC0, 0x18,
  0x40, 0x0C, 0x60, 0x02, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x82, 0x00,
  0xC1, 0x80, 0xC0, 0x73, 0x80, 0x3F, 0x80, 0x30, 0x60, 0x30, 0x18, 0x20,
  0x06, 0x30, 0x03, 0x10, 0x00, 0x98, 0x00, 0x4C, 0x00, 0x26, 0x00, 0x33,
  0x00, 0x19, 0x80, 0x18, 0x40, 0x08, 0x30, 0x1C, 0x0F, 0x38, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x1E, 0xF0, 0x60, 0x61, 0x80, 0x63, 0x00, 0x4C, 0x00,
  0x90, 0x01, 0x20, 0x03, 0xC0, 0x07, 0x80, 0x0A, 0x00, 0x14, 0x00, 0x28,
  0x00, 0xD8, 0x01, 0xB0, 0x07, 0x20, 0x1E, 0x60, 0x68, 0x73, 0x90, 0x7C,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x41, 0x83, 0x06, 0x08, 0x30, 0xC1, 0x00,
  0x00, 0x02, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x08, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x10, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0x40, 0x00, 0x0F, 0x83, 0xDC, 0x60, 0x66, 0x02, 0xC0, 0x28, 0x02,
  0x80, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x04, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xF9, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x40, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x02, 0x04, 0x03, 0xE0, 0x30, 0xC0, 0x67, 0x03, 0x08, 0x08, 0x18, 0x11,
  0x81, 0x81, 0x01, 0x10, 0x30, 0x10, 0x13, 0x02, 0x03, 0x01, 0x20, 0x60,
  0x30, 0x32, 0x04, 0x02, 0x03, 0x60, 0x40, 0x20, 0x36, 0x0C, 0x02, 0x02,
  0x40, 0x80, 0x60, 0x24, 0x08, 0x04, 0x02, 0x40, 0x80, 0x40, 0x64, 0x08,
  0x0C, 0x04, 0xC1, 0x80, 0xC0, 0x4C, 0x18, 0x1C, 0x08, 0xC0, 0x81, 0xC1,
  0x8C, 0x08, 0x24, 0x10, 0xC0, 0xEC, 0x66, 0x04, 0x07, 0x83, 0xC0, 0x40,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x05, 0x80, 0x01, 0xB0, 0x00, 0x26, 0x00, 0x0C, 0x40,
  0x01, 0x08, 0x00, 0x61, 0x00, 0x08, 0x20, 0x03, 0x04, 0x00, 0x40, 0xC0,
  0x18, 0x18, 0x02, 0x03, 0x00, 0xC0, 0x20, 0x10, 0x04, 0x06, 0x00, 0x80,
  0xC0, 0x10, 0x30, 0x03, 0x07, 0xFF, 0xE1, 0x80, 0x0C, 0x30, 0x00, 0x84,
  0x00, 0x11, 0x80, 0x02, 0x20, 0x00, 0x4C, 0x00, 0x0D, 0x00, 0x01, 0xE0,
  0x00, 0x30, 0x07, 0xFE, 0x00, 0xC1, 0xF0, 0x10, 0x06, 0x02, 0x00, 0x60,
  0x40, 0x04, 0x18, 0x00, 0x83, 0x00, 0x10, 0x60, 0x02, 0x08, 0x00, 0xC1,
  0x00, 0x18, 0x60, 0x06, 0x0C, 0x01, 0x81, 0x81, 0xE0, 0x3F, 0xF8, 0x04,
  0x01, 0x80, 0x80, 0x18, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x10,
  0x00, 0xC2, 0x00, 0x18, 0x40, 0x03, 0x18, 0x00, 0x43, 0x00, 0x18, 0x60,
  0x06, 0x08, 0x01, 0x81, 0x01, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x3C, 0xF0, 0x0C, 0x03, 0x03, 0x00, 0x60, 0xC0, 0x06, 0x30, 0x00, 0xC6,
  0x00, 0x18, 0x80, 0x01, 0x30, 0x00, 0x24, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0xCC, 0x00, 0x18, 0x80,
  0x02, 0x10, 0x00, 0xC3, 0x00, 0x10, 0x60, 0x06, 0x06, 0x01, 0x80, 0x79,
  0xE0, 0x07, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x60, 0xF8, 0x04, 0x01, 0xC0,
  0x40, 0x0C, 0x04, 0x00, 0x60, 0xC0, 0x02, 0x0C, 0x00, 0x20, 0x80, 0x03,
  0x08, 0x00, 0x30, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x02, 0x18, 0x00,
  0x21, 0x00, 0x02, 0x10, 0x00, 0x61, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00,
  0x04, 0x30, 0x00, 0x42, 0x00, 0x0C, 0x20, 0x00, 0xC2, 0x00, 0x18, 0x60,
  0x01, 0x86, 0x00, 0x30, 0x60, 0x06, 0x04, 0x01, 0xC0, 0x40, 0xF8, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFF,
  0xF0, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xF0, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x79, 0xE0, 0x18, 0x06, 0x06, 0x00, 0x61, 0x80, 0x04, 0x20, 0x00,
  0x8C, 0x00, 0x19, 0x00, 0x03, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x03, 0xFC,
  0xC0, 0x01, 0x90, 0x00, 0x32, 0x00, 0x06, 0x40, 0x00, 0xC8, 0x00, 0x11,
  0x00, 0x02, 0x30, 0x00, 0xC6, 0x00, 0x18, 0x60, 0x07, 0x0E, 0x01, 0xC0,
  0xFB, 0xE0, 0x07, 0xF0, 0x00, 0x06, 0x00, 0x04, 0x18, 0x00, 0x10, 0x40,
  0x00, 0xC1, 0x00, 0x03, 0x04, 0x00, 0x0C, 0x30, 0x00, 0x20, 0xC0, 0x00,
  0x82, 0x00, 0x06, 0x08, 0x00, 0x18, 0x20, 0x00, 0x61, 0x80, 0x01, 0x06,
  0x00, 0x04, 0x18, 0x00, 0x10, 0x7F, 0xFF, 0xC1, 0x00, 0x03, 0x04, 0x00,
  0x0C, 0x30, 0x00, 0x20, 0xC0, 0x00, 0x83, 0x00, 0x02, 0x08, 0x00, 0x18,
  0x20, 0x00, 0x60, 0x80, 0x01, 0x86, 0x00, 0x04, 0x18, 0x00, 0x10, 0x60,
  0x00, 0xC1, 0x00, 0x03, 0x04, 0x00, 0x0C, 0x30, 0x00, 0x20, 0x04, 0x10,
  0xC3, 0x0C, 0x20, 0x82, 0x18, 0x61, 0x84, 0x10, 0xC3, 0x0C, 0x20, 0x82,
  0x18, 0x61, 0x84, 0x10, 0x43, 0x0C, 0x30, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x88, 0x00, 0xC4, 0x00, 0x42, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x30,
  0x30, 0x30, 0x1E, 0x70, 0x03, 0xE0, 0x00, 0x06, 0x00, 0x18, 0x30, 0x01,
  0x81, 0x00, 0x18, 0x08, 0x01, 0x80, 0x40, 0x18, 0x06, 0x01, 0x80, 0x30,
  0x18, 0x01, 0x01, 0x80, 0x08, 0x18, 0x00, 0x41, 0x80, 0x06, 0x18, 0x00,
  0x31, 0x80, 0x01, 0x98, 0x00, 0x09, 0xE0, 0x00, 0x5B, 0x00, 0x03, 0x8C,
  0x00, 0x38, 0x60, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x40, 0x30, 0x02,
  0x00, 0x80, 0x10, 0x06, 0x01, 0x80, 0x10, 0x0C, 0x00, 0xC0, 0x60, 0x02,
  0x02, 0x00, 0x18, 0x10, 0x00, 0x41, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0x06, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70,
  0x50, 0x00, 0x1E, 0x1A, 0x00, 0x06, 0xC3, 0x40, 0x00, 0xD0, 0x4C, 0x00,
  0x32, 0x09, 0x80, 0x04, 0x41, 0x10, 0x01, 0x98, 0x62, 0x00, 0x23, 0x0C,
  0x40, 0x0C, 0x41, 0x8C, 0x01, 0x08, 0x21, 0x80, 0x61, 0x04, 0x30, 0x08,
  0x60, 0x82, 0x03, 0x0C, 0x30, 0x40, 0x41, 0x86, 0x08, 0x18, 0x20, 0xC1,
  0x82, 0x04, 0x10, 0x30, 0xC0, 0x82, 0x02, 0x10, 0x30, 0x40, 0x46, 0x06,
  0x18, 0x09, 0x80, 0xC3, 0x01, 0x20, 0x10, 0x60, 0x3C, 0x02, 0x08, 0x07,
  0x00, 0xC1, 0x00, 0x60, 0x18, 0x60, 0x08, 0x03, 0x00, 0x06, 0x00, 0x04,
  0x18, 0x00, 0x10, 0x70, 0x00, 0xC1, 0x40, 0x03, 0x05, 0x80, 0x0C, 0x36,
  0x00, 0x30, 0xC8, 0x00, 0x83, 0x30, 0x02, 0x08, 0x40, 0x18, 0x21, 0x00,
  0x61, 0x86, 0x01, 0x86, 0x08, 0x04, 0x18, 0x30, 0x10, 0x60, 0x40, 0x41,
  0x01, 0x03, 0x04, 0x06, 0x0C, 0x30, 0x08, 0x30, 0xC0, 0x30, 0x83, 0x00,
  0xC2, 0x08, 0x01, 0x18, 0x20, 0x06, 0x60, 0x80, 0x09, 0x86, 0x00, 0x26,
  0x18, 0x00, 0xD0, 0x60, 0x01, 0x41, 0x00, 0x07, 0x04, 0x00, 0x0C, 0x30,
  0x00, 0x30, 0x00, 0x7E, 0x00, 0x1E, 0x78, 0x03, 0x00, 0xC0, 0x60, 0x04,
  0x0C, 0x00, 0x61, 0x80, 0x02, 0x10, 0x00, 0x23, 0x00, 0x02, 0x30, 0x00,
  0x22, 0x00, 0x02, 0x20, 0x00, 0x26, 0x00, 0x02, 0x60, 0x00, 0x66, 0x00,
  0x06, 0x40, 0x00, 0x64, 0x00, 0x04, 0x40, 0x00, 0x4C, 0x00, 0x04, 0xC0,
  0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x8C, 0x00, 0x18, 0x40, 0x01, 0x06,
  0x00, 0x30, 0x60, 0x06, 0x03, 0x00, 0xC0, 0x1E, 0x78, 0x00, 0x7E, 0x00,
  0x07, 0xFF, 0x00, 0x60, 0x78, 0x04, 0x00, 0xC0, 0x40, 0x06, 0x04, 0x00,
  0x60, 0xC0, 0x02, 0x0C, 0x00, 0x20, 0xC0, 0x02, 0x08, 0x00, 0x20, 0x80,
  0x06, 0x18, 0x00, 0x61, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x00, 0x38, 0x10,
  0x1E, 0x01, 0xFF, 0x80, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x3C, 0xF0, 0x0C, 0x03, 0x03, 0x00, 0x20, 0xC0, 0x06, 0x30, 0x00,
  0x44, 0x00, 0x09, 0x80, 0x01, 0x30, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00,
  0xB0, 0x00, 0x16, 0x00, 0x06, 0xC0, 0x00, 0xD0, 0x00, 0x1A, 0x00, 0x02,
  0x40, 0x00, 0x58, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x4C, 0x00, 0x09,
  0x80, 0x03, 0x10, 0x00, 0x42, 0x00, 0x18, 0x60, 0x06, 0x06, 0x01, 0x80,
  0x7B, 0xE0, 0x03, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x07, 0xFE, 0x00, 0x80, 0xF0, 0x10, 0x03,
  0x02, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0x43, 0x00, 0x08, 0x40, 0x01,
  0x08, 0x00, 0x21, 0x00, 0x0C, 0x60, 0x01, 0x0C, 0x00, 0x61, 0x80, 0x18,
  0x20, 0x06, 0x04, 0x07, 0x80, 0xFF, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x00,
  0xC0, 0x30, 0x10, 0x06, 0x02, 0x00, 0x40, 0xC0, 0x0C, 0x18, 0x01, 0x83,
  0x00, 0x10, 0x40, 0x03, 0x08, 0x00, 0x61, 0x00, 0x04, 0x60, 0x00, 0xC0,
  0x00, 0x7E, 0x00, 0x3C, 0xF0, 0x1C, 0x07, 0x03, 0x00, 0x60, 0xC0, 0x06,
  0x10, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xCC,
  0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x46, 0x00, 0x18, 0x60, 0x06, 0x06,
  0x01, 0x80, 0x79, 0xE0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x10, 0x80, 0x03, 0x08, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x21, 0x80,
  0x02, 0x10, 0x00, 0x21, 0x00, 0x06, 0x10, 0x00, 0x63, 0x00, 0x06, 0x30,
  0x00, 0x43, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x0C, 0x60, 0x00, 0xC6,
  0x00, 0x0C, 0x60, 0x00, 0x84, 0x00, 0x08, 0x40, 0x01, 0x84, 0x00, 0x18,
  0xC0, 0x01, 0x8C, 0x00, 0x10, 0x40, 0x03, 0x04, 0x00, 0x20, 0x60, 0x06,
  0x03, 0x00, 0xC0, 0x1E, 0x78, 0x00, 0xFE, 0x00, 0x40, 0x00, 0x28, 0x00,
  0x0D, 0x00, 0x01, 0x30, 0x00, 0x66, 0x00, 0x08, 0xC0, 0x03, 0x18, 0x00,
  0x41, 0x00, 0x18, 0x20, 0x02, 0x04, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x20, 0x10, 0x04, 0x06, 0x00, 0x80, 0x80, 0x10, 0x30,
  0x03, 0x04, 0x00, 0x61, 0x80, 0x0C, 0x20, 0x00, 0x8C, 0x00, 0x11, 0x00,
  0x02, 0x60, 0x00, 0x48, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x2C, 0x00, 0xE0, 0x06, 0xC0, 0x0E,
  0x00, 0x6C, 0x00, 0xA0, 0x04, 0xC0, 0x1A, 0x00, 0xCC, 0x01, 0x20, 0x0C,
  0xC0, 0x32, 0x00, 0x8C, 0x02, 0x20, 0x18, 0xC0, 0x22, 0x01, 0x04, 0x06,
  0x20, 0x10, 0x40, 0x42, 0x03, 0x04, 0x0C, 0x30, 0x20, 0x40, 0x83, 0x06,
  0x04, 0x08, 0x30, 0x60, 0x41, 0x83, 0x04, 0x04, 0x10, 0x10, 0xC0, 0x43,
  0x01, 0x08, 0x04, 0x20, 0x10, 0x80, 0x62, 0x01, 0x18, 0x06, 0x60, 0x11,
  0x00, 0x64, 0x01, 0x30, 0x06, 0xC0, 0x13, 0x00, 0x68, 0x01, 0x20, 0x06,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x01,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x0C,
  0x00, 0x60, 0x08, 0x01, 0x80, 0x18, 0x02, 0x00, 0x30, 0x0C, 0x00, 0x20,
  0x30, 0x00, 0x60, 0xC0, 0x00, 0x41, 0x80, 0x00, 0xC6, 0x00, 0x00, 0x98,
  0x00, 0x01, 0x20, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x88, 0x00, 0x06, 0x18, 0x00,
  0x08, 0x30, 0x00, 0x30, 0x20, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x60, 0x01, 0x01, 0x80, 0x03, 0x03, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x24, 0x00, 0x19, 0x80, 0x0C, 0x60,
  0x02, 0x18, 0x01, 0x82, 0x00, 0xC0, 0xC0, 0x20, 0x30, 0x18, 0x04, 0x0C,
  0x01, 0x82, 0x00, 0x61, 0x80, 0x08, 0xC0, 0x03, 0x20, 0x00, 0xD8, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x60, 0x08, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x3E,
  0x00, 0xC3, 0x0C, 0x10, 0x41, 0x04, 0x18, 0x61, 0x82, 0x08, 0x20, 0xC3,
  0x0C, 0x10, 0x41, 0x04, 0x18, 0x61, 0x82, 0x08, 0x20, 0x83, 0x0C, 0x30,
  0x07, 0xC0, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x3E, 0x00, 0x01, 0x80, 0x30, 0x0A, 0x01, 0x40,
  0x48, 0x09, 0x02, 0x30, 0xC6, 0x10, 0x46, 0x08, 0x81, 0x30, 0x24, 0x07,
  0x80, 0xC0, 0xFF, 0xFC, 0x43, 0x0C, 0x21, 0x80, 0x01, 0xF0, 0x0E, 0x78,
  0x30, 0x30, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x0F, 0xF8, 0x78, 0x31, 0x80, 0x66, 0x00, 0xD8, 0x01, 0x20, 0x02,
  0x40, 0x0C, 0x80, 0x19, 0x00, 0x73, 0x03, 0x63, 0xBC, 0xC3, 0xE1, 0x80,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0xF8, 0x1B, 0xDC, 0x1E, 0x06,
  0x1C, 0x02, 0x18, 0x03, 0x10, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x20, 0x03, 0x20, 0x02, 0x20, 0x02, 0x60, 0x02, 0x60, 0x06, 0x40, 0x06,
  0x40, 0x04, 0x40, 0x0C, 0x60, 0x08, 0xF0, 0x38, 0xDC, 0xF0, 0x87, 0xC0,
  0x01, 0xF0, 0x0E, 0x78, 0x30, 0x30, 0xC0, 0x33, 0x00, 0x24, 0x00, 0x48,
  0x00, 0xB0, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x03, 0x60, 0x04, 0x40, 0x18, 0x80, 0x21, 0x80, 0xC1,
  0xEF, 0x00, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x03,
  0xF1, 0x03, 0x9C, 0x83, 0x03, 0x43, 0x00, 0xE1, 0x00, 0x31, 0x80, 0x18,
  0x80, 0x08, 0x40, 0x04, 0x60, 0x02, 0x30, 0x03, 0x10, 0x01, 0x88, 0x00,
  0x84, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10, 0x80, 0x18, 0x40, 0x0C, 0x30,
  0x0C, 0x18, 0x0E, 0x07, 0xB9, 0x01, 0xF8, 0x80, 0x01, 0xF0, 0x0E, 0x78,
  0x30, 0x30, 0xC0, 0x33, 0x00, 0x64, 0x00, 0x58, 0x00, 0xB0, 0x01, 0x40,
  0x06, 0xFF, 0xFD, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0xC0, 0x61, 0xE7, 0x00, 0xFC, 0x00,
  0x00, 0xF0, 0x1D, 0x03, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x07, 0xFC, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x01, 0xF8, 0x81,
  0xCE, 0x41, 0x81, 0xA1, 0x80, 0x70, 0x80, 0x18, 0xC0, 0x0C, 0x40, 0x04,
  0x20, 0x02, 0x30, 0x01, 0x18, 0x01, 0x88, 0x00, 0xC4, 0x00, 0x62, 0x00,
  0x21, 0x00, 0x10, 0x80, 0x18, 0x40, 0x0C, 0x20, 0x06, 0x18, 0x06, 0x0C,
  0x07, 0x03, 0xDC, 0x80, 0xFC, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x20, 0x08, 0x18, 0x0C, 0x07, 0x3C, 0x01, 0xF8, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x31, 0xF0, 0x67, 0x70, 0xD0, 0x31, 0x40, 0x23,
  0x00, 0x46, 0x00, 0x98, 0x01, 0x30, 0x02, 0x60, 0x04, 0x80, 0x19, 0x00,
  0x32, 0x00, 0x4C, 0x00, 0x98, 0x01, 0x30, 0x06, 0x40, 0x0C, 0x80, 0x19,
  0x00, 0x26, 0x00, 0x4C, 0x00, 0x98, 0x03, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x08, 0x30, 0x60,
  0x81, 0x02, 0x0C, 0x18, 0x30, 0x40, 0x81, 0x06, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x03, 0x01, 0x70, 0x0F, 0x00, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x03, 0x18, 0x06, 0x18, 0x0C, 0x10,
  0x38, 0x10, 0x60, 0x10, 0xC0, 0x31, 0x80, 0x33, 0x00, 0x36, 0x00, 0x2E,
  0x00, 0x3B, 0x00, 0x33, 0x00, 0x61, 0x80, 0x61, 0x80, 0x60, 0xC0, 0x40,
  0xC0, 0x40, 0x60, 0x40, 0x60, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x18, 0x06,
  0x0C, 0x10, 0x20, 0x41, 0x83, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x83, 0x04,
  0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x18, 0x30, 0x60, 0x81, 0x02, 0x0C,
  0x18, 0x00, 0x18, 0xF8, 0x1F, 0x03, 0x73, 0x87, 0x78, 0x78, 0x19, 0x83,
  0x0A, 0x03, 0x40, 0x21, 0x80, 0x38, 0x06, 0x70, 0x06, 0x00, 0xCC, 0x00,
  0x80, 0x19, 0x80, 0x10, 0x03, 0x20, 0x06, 0x00, 0x44, 0x00, 0xC0, 0x08,
  0x80, 0x18, 0x03, 0x30, 0x02, 0x00, 0x66, 0x00, 0x40, 0x0C, 0xC0, 0x08,
  0x01, 0x10, 0x03, 0x00, 0x22, 0x00, 0x60, 0x04, 0x40, 0x08, 0x01, 0x98,
  0x01, 0x00, 0x33, 0x00, 0x20, 0x06, 0x60, 0x04, 0x00, 0x88, 0x01, 0x80,
  0x10, 0x18, 0xF8, 0x33, 0xB8, 0x68, 0x18, 0xA0, 0x11, 0x80, 0x23, 0x00,
  0x4C, 0x00, 0x98, 0x01, 0x30, 0x02, 0x40, 0x0C, 0x80, 0x19, 0x00, 0x26,
  0x00, 0x4C, 0x00, 0x98, 0x03, 0x20, 0x06, 0x40, 0x0C, 0x80, 0x13, 0x00,
  0x26, 0x00, 0x4C, 0x01, 0x80, 0x03, 0xF0, 0x1E, 0x70, 0x60, 0x31, 0x80,
  0x22, 0x00, 0x6C, 0x00, 0xD0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x28, 0x00, 0x50, 0x01, 0xA0, 0x03, 0x40, 0x04, 0x80,
  0x19, 0x80, 0x61, 0x81, 0x83, 0xCE, 0x01, 0xF8, 0x00, 0x0C, 0x7C, 0x06,
  0xF7, 0x03, 0xC0, 0xC1, 0x80, 0x20, 0xC0, 0x18, 0x40, 0x0C, 0x60, 0x06,
  0x30, 0x03, 0x18, 0x01, 0x88, 0x00, 0xC4, 0x00, 0x42, 0x00, 0x23, 0x00,
  0x11, 0x80, 0x18, 0xC0, 0x0C, 0x40, 0x04, 0x20, 0x06, 0x18, 0x06, 0x1E,
  0x07, 0x0D, 0xCF, 0x04, 0x3E, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0x07,
  0xE2, 0x1C, 0xE4, 0x60, 0x69, 0x80, 0x72, 0x00, 0x6C, 0x00, 0x90, 0x01,
  0x20, 0x02, 0xC0, 0x05, 0x80, 0x1A, 0x00, 0x34, 0x00, 0x48, 0x00, 0x90,
  0x01, 0x20, 0x06, 0x40, 0x0C, 0x80, 0x19, 0x80, 0x63, 0x01, 0xC3, 0xDC,
  0x83, 0xF3, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0xF1, 0xBE, 0x1E, 0x01, 0x40,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x00, 0x03, 0xF0, 0x1E, 0x70, 0x60, 0x30, 0x80, 0x23, 0x00, 0x46,
  0x00, 0x8C, 0x00, 0x08, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x40, 0x0C, 0x80, 0x19, 0x80, 0x21,
  0x81, 0xC3, 0xDF, 0x01, 0xF8, 0x00, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80,
  0x43, 0xFE, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40,
  0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3A, 0x0F,
  0x00, 0x30, 0x02, 0x60, 0x04, 0xC0, 0x09, 0x00, 0x32, 0x00, 0x64, 0x00,
  0x98, 0x01, 0x30, 0x02, 0x60, 0x0C, 0x80, 0x19, 0x00, 0x32, 0x00, 0x4C,
  0x00, 0x98, 0x01, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x39, 0x80, 0x61, 0x01,
  0x43, 0x9C, 0x83, 0xF3, 0x00, 0x40, 0x06, 0x80, 0x09, 0x00, 0x33, 0x00,
  0x46, 0x01, 0x8C, 0x02, 0x08, 0x0C, 0x10, 0x10, 0x20, 0x60, 0x40, 0xC0,
  0xC1, 0x01, 0x86, 0x03, 0x08, 0x02, 0x30, 0x04, 0x40, 0x09, 0x80, 0x12,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x60, 0x00, 0x80, 0x00, 0xC0, 0x30, 0x05,
  0x80, 0x60, 0x1B, 0x00, 0xC0, 0x36, 0x02, 0x80, 0xCC, 0x05, 0x01, 0x88,
  0x1A, 0x02, 0x10, 0x26, 0x0C, 0x20, 0xCC, 0x10, 0x41, 0x18, 0x60, 0x86,
  0x30, 0xC1, 0x08, 0x21, 0x02, 0x10, 0x46, 0x04, 0x60, 0x88, 0x08, 0x81,
  0x30, 0x1B, 0x02, 0x60, 0x34, 0x04, 0x80, 0x78, 0x0B, 0x00, 0xE0, 0x14,
  0x01, 0xC0, 0x28, 0x03, 0x80, 0x60, 0x02, 0x00, 0xC0, 0x00, 0x0C, 0x01,
  0x81, 0x00, 0x40, 0x60, 0x30, 0x18, 0x18, 0x02, 0x0C, 0x00, 0xC3, 0x00,
  0x11, 0x80, 0x06, 0xC0, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0x60, 0x00, 0xC8, 0x00, 0x63, 0x00, 0x30, 0x40, 0x08, 0x18,
  0x06, 0x06, 0x03, 0x00, 0x81, 0x80, 0x30, 0x60, 0x04, 0x00, 0x04, 0x00,
  0x60, 0x80, 0x08, 0x18, 0x03, 0x03, 0x00, 0x40, 0x60, 0x18, 0x0C, 0x02,
  0x00, 0x80, 0xC0, 0x10, 0x18, 0x02, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x30,
  0x01, 0x86, 0x00, 0x31, 0x80, 0x02, 0x30, 0x00, 0x44, 0x00, 0x09, 0x80,
  0x01, 0xA0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x08, 0x00, 0x04, 0x10, 0x43, 0x0C, 0x30, 0x82, 0x08,
  0x61, 0x86, 0x18, 0x41, 0x0C, 0x30, 0xC3, 0x08, 0x20, 0x86, 0x18, 0x61,
  0x04, 0x10, 0xC3, 0x0C, 0x20, 0x80, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x70, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x0E, 0x00, 0x80, 0x00, 0x0F, 0x00, 0x63, 0xF0, 0x0C, 0x83, 0x01,
  0x30, 0x30, 0x64, 0x02, 0x08, 0x80, 0x77, 0x30, 0x03, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 28, 8, 1, -28 },
  { 22, 7, 8, 10, 4, -30 },
  { 29, 20, 28, 19, 1, -28 },
  { 99, 17, 36, 19, 1, -32 },
  { 176, 18, 28, 25, 4, -28 },
  { 239, 18, 28, 21, 1, -28 },
  { 302, 3, 8, 7, 4, -30 },
  { 305, 11, 41, 11, 2, -32 },
  { 362, 11, 41, 11, -2, -32 },
  { 419, 16, 16, 16, 2, -28 },
  { 451, 16, 21, 19, 2, -24 },
  { 493, 4, 8, 7, -1, -3 },
  { 497, 8, 1, 10, 1, -13 },
  { 498, 3, 3, 9, 1, -3 },
  { 500, 17, 30, 14, -2, -28 },
  { 564, 16, 28, 19, 2, -28 },
  { 620, 9, 28, 19, 5, -28 },
  { 652, 17, 28, 19, 1, -28 },
  { 712, 17, 28, 19, 1, -28 },
  { 772, 16, 28, 19, 1, -28 },
  { 828, 17, 28, 19, 2, -28 },
  { 888, 15, 28, 19, 2, -28 },
  { 941, 16, 28, 19, 3, -28 },
  { 997, 17, 28, 19, 1, -28 },
  { 1057, 15, 28, 19, 3, -28 },
  { 1110, 7, 21, 7, 0, -21 },
  { 1129, 7, 26, 7, -1, -21 },
  { 1152, 15, 16, 18, 2, -21 },
  { 1182, 15, 8, 19, 2, -17 },
  { 1197, 15, 16, 18, 1, -21 },
  { 1227, 12, 28, 15, 4, -28 },
  { 1269, 28, 37, 31, 1, -28 },
  { 1399, 19, 28, 21, -1, -28 },
  { 1466, 19, 28, 21, 1, -28 },
  { 1533, 19, 28, 22, 2, -28 },
  { 1600, 20, 28, 22, 1, -28 },
  { 1670, 20, 28, 19, 1, -28 },
  { 1740, 20, 28, 19, 1, -28 },
  { 1810, 19, 28, 23, 3, -28 },
  { 1877, 22, 28, 24, 1, -28 },
  { 1954, 6, 28, 9, 2, -28 },
  { 1975, 17, 28, 19, 1, -28 },
  { 2035, 21, 28, 21, 1, -28 },
  { 2109, 14, 28, 18, 1, -28 },
  { 2158, 27, 28, 29, 1, -28 },
  { 2253, 22, 28, 24, 1, -28 },
  { 2330, 20, 28, 23, 2, -28 },
  { 2400, 20, 28, 21, 1, -28 },
  { 2470, 19, 33, 23, 2, -28 },
  { 2549, 19, 28, 22, 1, -28 },
  { 2616, 19, 28, 20, 1, -28 },
  { 2683, 18, 28, 20, 4, -28 },
  { 2746, 20, 28, 22, 2, -28 },
  { 2816, 19, 28, 21, 3, -28 },
  { 2883, 28, 28, 30, 4, -28 },
  { 2981, 23, 28, 21, -1, -28 },
  { 3062, 18, 28, 20, 4, -28 },
  { 3125, 21, 28, 20, 0, -28 },
  { 3199, 11, 39, 8, 0, -33 },
  { 3253, 6, 30, 13, 4, -28 },
  { 3276, 11, 39, 8, -2, -33 },
  { 3330, 11, 14, 14, 2, -28 },
  { 3350, 14, 1, 15, -2, 0 },
  { 3352, 5, 5, 11, 5, -30 },
  { 3356, 15, 21, 18, 1, -21 },
  { 3396, 16, 30, 19, 1, -30 },
  { 3456, 15, 21, 18, 1, -21 },
  { 3496, 17, 30, 19, 2, -30 },
  { 3560, 15, 21, 18, 1, -21 },
  { 3600, 12, 30, 11, 2, -30 },
  { 3645, 17, 29, 19, 0, -21 },
  { 3707, 15, 30, 19, 1, -30 },
  { 3764, 7, 29, 8, 1, -29 },
  { 3790, 13, 37, 8, -5, -29 },
  { 3851, 16, 30, 17, 1, -30 },
  { 3911, 7, 30, 8, 1, -30 },
  { 3938, 27, 21, 30, 1, -21 },
  { 4009, 15, 21, 19, 1, -21 },
  { 4049, 15, 21, 19, 2, -21 },
  { 4089, 17, 29, 19, 0, -21 },
  { 4151, 15, 29, 19, 2, -21 },
  { 4206, 12, 21, 12, 1, -21 },
  { 4238, 15, 21, 17, 1, -21 },
  { 4278, 9, 27, 11, 2, -27 },
  { 4309, 15, 21, 19, 2, -21 },
  { 4349, 15, 21, 16, 2, -21 },
  { 4389, 23, 21, 26, 3, -21 },
  { 4450, 18, 21, 17, -1, -21 },
  { 4498, 19, 29, 16, -2, -21 },
  { 4567, 16, 21, 17, 0, -21 },
  { 4609, 13, 39, 11, 1, -31 },
  { 4673, 6, 33, 8, 1, -28 },
  { 4698, 12, 39, 11, -2, -31 },
  { 4757, 19, 7, 23, 2, -16 },
};

const GFXfont RobotoCondensed_ExtraLightItalic40pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic40pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic40pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC40PT7B_H_
