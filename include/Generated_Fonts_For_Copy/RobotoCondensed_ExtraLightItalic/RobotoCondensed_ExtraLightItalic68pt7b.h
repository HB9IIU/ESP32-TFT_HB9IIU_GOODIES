#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC68PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x00, 0x18, 0x33, 0x87, 0x38, 0x73, 0x87, 0x30, 0x63, 0x06,
  0x30, 0x67, 0x0E, 0x70, 0xE6, 0x0C, 0x60, 0xC6, 0x0C, 0x60, 0xCE, 0x1C,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x18,
  0x03, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00,
  0xC0, 0x1C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x38, 0x03,
  0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x60,
  0x0E, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x03, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x18, 0x70, 0x03, 0x00,
  0x38, 0x60, 0x03, 0x00, 0x30, 0x60, 0x03, 0x00, 0x60, 0x60, 0x03, 0x00,
  0xE0, 0x60, 0x03, 0x00, 0xC0, 0xE0, 0x03, 0x01, 0x80, 0xE0, 0x06, 0x03,
  0x80, 0xE0, 0x06, 0x07, 0x00, 0x60, 0x06, 0x06, 0x00, 0x60, 0x0C, 0x0E,
  0x00, 0x60, 0x1C, 0x1C, 0x00, 0x70, 0x18, 0x18, 0x00, 0x38, 0x78, 0x30,
  0x00, 0x1F, 0xF0, 0x70, 0x00, 0x0F, 0xC0, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x07, 0x03, 0xF0, 0x00, 0x0E, 0x07, 0xFC, 0x00, 0x0C, 0x0E,
  0x1C, 0x00, 0x1C, 0x1C, 0x0E, 0x00, 0x38, 0x38, 0x06, 0x00, 0x30, 0x30,
  0x06, 0x00, 0x60, 0x70, 0x03, 0x00, 0xE0, 0x60, 0x03, 0x00, 0xC0, 0x60,
  0x03, 0x01, 0x80, 0xE0, 0x03, 0x03, 0x80, 0xE0, 0x07, 0x03, 0x00, 0xC0,
  0x06, 0x06, 0x00, 0xC0, 0x06, 0x0E, 0x00, 0xC0, 0x06, 0x1C, 0x00, 0xC0,
  0x06, 0x18, 0x00, 0xC0, 0x0E, 0x38, 0x00, 0xC0, 0x0C, 0x10, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x03, 0x80, 0x06, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x3C,
  0x00, 0x01, 0x81, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x0C, 0x38, 0x07,
  0x00, 0x71, 0xC0, 0x1C, 0x01, 0xCE, 0x00, 0x38, 0x06, 0x38, 0x00, 0xE0,
  0x19, 0xC0, 0x01, 0xC0, 0xE7, 0x00, 0x03, 0x03, 0x18, 0x00, 0x0E, 0x1C,
  0x60, 0x00, 0x1C, 0x73, 0x80, 0x00, 0x71, 0x8E, 0x00, 0x00, 0xEE, 0x38,
  0x00, 0x03, 0xF0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x1D, 0xC0, 0xF0, 0x00,
  0xE3, 0x81, 0xE0, 0x0F, 0x0E, 0x03, 0xFF, 0xF0, 0x1C, 0x07, 0xFF, 0x00,
  0x70, 0x01, 0xE0, 0x00, 0x00, 0x39, 0x8C, 0x63, 0x39, 0xCC, 0x63, 0x39,
  0xCC, 0x60, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x58, 0x03, 0x80, 0x7F, 0xC0, 0xC0, 0xFD,
  0xFC, 0x31, 0xFC, 0x0F, 0xED, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x39, 0x80, 0x00, 0x1C,
  0x70, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC0, 0x70, 0x00,
  0xE0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x1E, 0x00, 0x1C,
  0x01, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x06, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0C, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0x40, 0xFF, 0xFB, 0xFF,
  0xE0, 0x33, 0xDE, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0C, 0x00, 0x06, 0x03, 0x80,
  0x00, 0xE0, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x07, 0x38, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x07,
  0x18, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x1C, 0x0C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x03,
  0x80, 0x0F, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x3C,
  0x03, 0xF8, 0x1F, 0xE1, 0xF8, 0xCF, 0xC1, 0xBE, 0x07, 0x60, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x30, 0x1C,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xC0, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0xE0, 0x1C, 0x00, 0x06, 0x03, 0x80, 0x00, 0x70, 0x30, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x1C, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x1C,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x38, 0x01, 0x80, 0x01, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x0E, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0xE0, 0x06, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x07,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x87, 0xF0, 0x00, 0x1C, 0xFF,
  0xE0, 0x00, 0xDF, 0xFF, 0x80, 0x07, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x60, 0x70, 0x00, 0x03, 0x03, 0x80, 0x00, 0x38, 0x0C, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x07, 0xF0, 0x07, 0x0F, 0xFE, 0x03, 0x1F,
  0x9F, 0x81, 0x9C, 0x01, 0xE1, 0xDC, 0x00, 0x70, 0xFC, 0x00, 0x1C, 0x7C,
  0x00, 0x0E, 0x3C, 0x00, 0x03, 0x1C, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06,
  0xC0, 0x00, 0x07, 0x60, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x73, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x18, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0x70, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x30,
  0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38,
  0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x03,
  0x80, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x70,
  0x0E, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0E,
  0x18, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x3C, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x3C, 0x07, 0x80, 0x38, 0x01, 0xE0, 0x38, 0x00, 0x70,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x1C, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x1D, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x30,
  0x00, 0x0F, 0x1C, 0x00, 0x0D, 0x8E, 0x00, 0x0E, 0xC3, 0x80, 0x0E, 0xE0,
  0xE0, 0x1E, 0x70, 0x7E, 0x7E, 0x30, 0x1F, 0xFC, 0x38, 0x03, 0xF8, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0x80,
  0x00, 0x20, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF8, 0x08, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x07, 0xFF,
  0xC0, 0xF0, 0x1C, 0x1E, 0x00, 0xE1, 0xC0, 0x06, 0x38, 0x00, 0x77, 0x00,
  0x07, 0x70, 0x00, 0x36, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x1F,
  0x80, 0x03, 0x80, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0x03, 0x80, 0x07, 0xC7,
  0xC0, 0x06, 0x07, 0x00, 0x1E, 0x03, 0xC0, 0x0C, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x61, 0xC0, 0x0E, 0x00, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x00, 0x70,
  0x01, 0x8E, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x18, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x30, 0x03, 0x80, 0x03, 0x00, 0x0C, 0xE0, 0x06, 0x00, 0x0E, 0x00,
  0x19, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x73, 0x00, 0x38, 0x00, 0x30, 0x00,
  0xC6, 0x00, 0x60, 0x00, 0x60, 0x01, 0x9C, 0x00, 0xC0, 0x01, 0xC0, 0x03,
  0x30, 0x03, 0x80, 0x03, 0x00, 0x06, 0x60, 0x07, 0x00, 0x06, 0x00, 0x1C,
  0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x31, 0x80, 0x18, 0x00, 0x38, 0x00, 0x63,
  0x00, 0x30, 0x00, 0x70, 0x01, 0xC6, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x1C,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x38, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x70,
  0x07, 0x00, 0x1E, 0x00, 0x30, 0xE0, 0x0E, 0x00, 0x3C, 0x00, 0xE1, 0xC0,
  0x1C, 0x00, 0xD8, 0x01, 0x83, 0x80, 0x18, 0x03, 0x30, 0x07, 0x07, 0x00,
  0x30, 0x0E, 0x60, 0x1C, 0x06, 0x00, 0x70, 0x38, 0xE0, 0x70, 0x0C, 0x00,
  0x7F, 0xE0, 0xF7, 0xC0, 0x18, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x40, 0x00, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x06, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x30,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0x80, 0x3F, 0xC0, 0x07, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x18,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00,
  0x70, 0x0C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x0E, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x01, 0xE0, 0x0C, 0x00, 0x3F,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x07, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x07, 0x80, 0x38, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x38, 0x03, 0xFC, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0C, 0x00,
  0x03, 0xC0, 0x06, 0x00, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x01, 0xE0, 0x1C, 0x00,
  0x01, 0xE0, 0x0E, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x03, 0xE0, 0x03, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0x87, 0x00, 0x0F, 0xFF, 0xC3, 0x80,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x18, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x03, 0x80, 0x60, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x0E, 0x00, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x0C,
  0x00, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x38, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x70, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x06, 0x1F, 0x00, 0x00, 0x00, 0x63, 0xF0, 0x00, 0x00,
  0x0E, 0x73, 0x80, 0x00, 0x00, 0xEE, 0x38, 0x00, 0x00, 0x0F, 0xC1, 0xC0,
  0x00, 0x00, 0xF8, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x03,
  0x60, 0x00, 0x00, 0x03, 0xE0, 0x0D, 0x80, 0x00, 0x00, 0x1D, 0x80, 0x76,
  0x00, 0x00, 0x00, 0x76, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xB8, 0x06, 0x70,
  0x00, 0x00, 0x0E, 0xE0, 0x18, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x63, 0x00,
  0x00, 0x01, 0x8C, 0x01, 0x8C, 0x00, 0x00, 0x0E, 0x30, 0x0E, 0x30, 0x00,
  0x00, 0x30, 0xC0, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x00,
  0x06, 0x1C, 0x03, 0x06, 0x00, 0x00, 0x38, 0x70, 0x0C, 0x18, 0x00, 0x00,
  0xC1, 0x80, 0x30, 0x60, 0x00, 0x07, 0x06, 0x01, 0xC1, 0xC0, 0x00, 0x18,
  0x38, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x00, 0x03, 0x03,
  0x80, 0x60, 0x30, 0x00, 0x1C, 0x0C, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30,
  0x0E, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00,
  0xE0, 0x38, 0x00, 0x70, 0x1C, 0x03, 0x00, 0x60, 0x03, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0x70, 0x06, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x30, 0x03, 0x80, 0x60, 0x03, 0x01, 0xC0, 0x0E, 0x01, 0x80, 0x0C,
  0x06, 0x00, 0x30, 0x06, 0x00, 0x30, 0x38, 0x00, 0xC0, 0x38, 0x00, 0xC0,
  0xC0, 0x07, 0x00, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x03, 0x80, 0x06, 0x18,
  0x00, 0x70, 0x0C, 0x00, 0x18, 0xE0, 0x01, 0xC0, 0x30, 0x00, 0x63, 0x00,
  0x06, 0x00, 0xC0, 0x01, 0x9C, 0x00, 0x18, 0x07, 0x00, 0x07, 0x60, 0x00,
  0xE0, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0xF0, 0x00, 0x30, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x3E, 0x00, 0x00,
  0x06, 0x00, 0xF8, 0x00, 0x00, 0x18, 0x03, 0x60, 0x00, 0x00, 0xE0, 0x0D,
  0xC0, 0x00, 0x03, 0x80, 0x73, 0x00, 0x00, 0x0E, 0x01, 0xCC, 0x00, 0x00,
  0x30, 0x07, 0x38, 0x00, 0x00, 0xC0, 0x1C, 0x60, 0x00, 0x07, 0x00, 0x61,
  0xC0, 0x00, 0x1C, 0x01, 0x83, 0x00, 0x00, 0x70, 0x0E, 0x0C, 0x00, 0x01,
  0xC0, 0x38, 0x38, 0x00, 0x06, 0x00, 0xE0, 0x60, 0x00, 0x18, 0x03, 0x81,
  0xC0, 0x00, 0xE0, 0x0C, 0x07, 0x00, 0x03, 0x80, 0x30, 0x0C, 0x00, 0x0E,
  0x01, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x60, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x03, 0x00, 0x60, 0x07, 0x00, 0x1C, 0x01, 0x80, 0x0C, 0x00, 0x70,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0x0C, 0x03, 0x80,
  0x30, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x01,
  0x80, 0xC0, 0x1C, 0x00, 0x07, 0x03, 0x00, 0x70, 0x00, 0x0C, 0x1C, 0x01,
  0x80, 0x00, 0x30, 0x70, 0x06, 0x00, 0x00, 0xE1, 0xC0, 0x38, 0x00, 0x01,
  0x87, 0x00, 0xE0, 0x00, 0x07, 0x18, 0x03, 0x80, 0x00, 0x1C, 0x60, 0x0C,
  0x00, 0x00, 0x33, 0x80, 0x30, 0x00, 0x00, 0xEE, 0x00, 0xC0, 0x00, 0x01,
  0xB8, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x01, 0x80, 0x00, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00,
  0x06, 0x38, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x1C, 0x60, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x03, 0x86, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0xFE, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x0E, 0x00, 0x01, 0xE0, 0x06, 0x00, 0x00, 0x70, 0x03, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x70, 0x18,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x01, 0xE0, 0x0C, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x03, 0xE0, 0x07, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00,
  0x18, 0x70, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x06, 0x38, 0x00,
  0x00, 0x07, 0x18, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x38, 0x00, 0xFE, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x0C, 0x00, 0x01, 0xC0,
  0x06, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00,
  0x18, 0x0E, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x01, 0xE0, 0x0C, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x01, 0xE0, 0x07, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x30, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x03, 0x00, 0x18, 0x00, 0x07, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xB0, 0x00, 0x07, 0x38, 0x00, 0x07,
  0x60, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x19,
  0x80, 0x00, 0x71, 0xC0, 0x00, 0x73, 0x00, 0x00, 0xC3, 0x80, 0x00, 0xC6,
  0x00, 0x03, 0x87, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x1C,
  0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x38, 0x18, 0x00, 0x38, 0x30,
  0x00, 0x60, 0x30, 0x00, 0x60, 0x60, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0xC0,
  0x03, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x03, 0x00,
  0x1C, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x38, 0x06, 0x00, 0x30, 0x0C, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C,
  0x00, 0xE0, 0x18, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0x70, 0x01, 0x80, 0xE0,
  0x03, 0x80, 0xC0, 0x03, 0x01, 0xC0, 0x07, 0x01, 0x80, 0x06, 0x03, 0x00,
  0x0E, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x38, 0x00, 0x30, 0x70, 0x00, 0x30, 0x60, 0x00, 0x60, 0xE0, 0x00,
  0x61, 0xC0, 0x00, 0xC1, 0x80, 0x00, 0xC3, 0x80, 0x01, 0xC7, 0x00, 0x01,
  0x86, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x06,
  0x30, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x37, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0,
  0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x38, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x07,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x36, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00,
  0x61, 0x80, 0x18, 0x70, 0x0C, 0x0C, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0,
  0x30, 0x30, 0x0C, 0x1C, 0x03, 0x86, 0x00, 0xE3, 0x80, 0x18, 0xC0, 0x06,
  0x70, 0x01, 0x98, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1C, 0x0E, 0x06, 0x07,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xC0,
  0x3C, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x06, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xE0, 0x0C, 0x0F, 0x80, 0x03, 0x07, 0x80, 0x01, 0xC1,
  0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x06, 0x1C, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x63, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00,
  0x07, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xF0, 0x60, 0x00, 0xEC, 0x1C,
  0x00, 0x73, 0x03, 0x80, 0x79, 0xC0, 0xFF, 0xFC, 0x70, 0x0F, 0xFC, 0x0C,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x78, 0x00, 0x18, 0x7F, 0xF0, 0x03, 0x1F,
  0xFF, 0x00, 0xEF, 0x00, 0xF0, 0x1F, 0x80, 0x0E, 0x03, 0xE0, 0x00, 0xE0,
  0x78, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0x70, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x18, 0x60, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x07, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x38, 0x3E, 0x00, 0x07, 0x07, 0x60, 0x03, 0xC0, 0xC7, 0x00,
  0xF0, 0x18, 0x7F, 0xFC, 0x03, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x38, 0x38,
  0x00, 0x0E, 0x0C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18,
  0xE0, 0x00, 0x06, 0x38, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x63, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0C, 0x18, 0x00,
  0x03, 0x06, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x0E,
  0x00, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3E, 0x03, 0x80, 0x0F,
  0xFC, 0x1C, 0x01, 0xFF, 0xF0, 0xE0, 0x1E, 0x01, 0xC6, 0x01, 0xE0, 0x03,
  0x30, 0x0E, 0x00, 0x0D, 0x80, 0xE0, 0x00, 0x7C, 0x06, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30, 0x38, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x1E, 0x01, 0xC0, 0x01, 0xE0, 0x0E, 0x00, 0x3B, 0x00, 0x3C, 0x07,
  0x98, 0x00, 0xFF, 0xF9, 0xC0, 0x03, 0xFF, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07,
  0xC0, 0x38, 0x03, 0xC0, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x38,
  0x38, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x18, 0xE0, 0x00, 0x06, 0x38, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x06, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE6,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x18,
  0x0F, 0x00, 0x0E, 0x01, 0xE0, 0x0F, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x70, 0x03, 0xFF, 0xE1, 0x80, 0x1E, 0x01,
  0xC6, 0x00, 0xF0, 0x01, 0x98, 0x03, 0x80, 0x03, 0xE0, 0x1C, 0x00, 0x0F,
  0x80, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x03, 0x01, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xE0, 0x0E, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0xEC, 0x00, 0x78, 0x0F, 0x30, 0x00, 0xFF, 0xF9,
  0xC0, 0x01, 0xFF, 0x87, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x0F, 0x00, 0x0C,
  0x1F, 0xF8, 0x03, 0x1F, 0xFF, 0x01, 0xCF, 0x01, 0xC0, 0x77, 0x00, 0x38,
  0x1D, 0x80, 0x0E, 0x06, 0xC0, 0x01, 0x81, 0xE0, 0x00, 0x70, 0x78, 0x00,
  0x1C, 0x3C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xC0,
  0x00, 0x1C, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x38, 0x60, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x86, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x0C, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x06, 0x1C,
  0x00, 0x01, 0x87, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x38, 0x60, 0x00, 0x0E,
  0x18, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0xE0, 0x00,
  0x1C, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x3C, 0x07,
  0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x6F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x0F, 0x03, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x1C,
  0x00, 0x3C, 0x03, 0x80, 0x0F, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0xE0,
  0x01, 0x80, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0,
  0xE0, 0x00, 0x30, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x38, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xCF, 0x80, 0x00, 0x1B, 0xB0,
  0x00, 0x03, 0xE7, 0x00, 0x00, 0xF8, 0x60, 0x00, 0x1E, 0x0E, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x38,
  0x00, 0x70, 0x03, 0x00, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0xE0, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x18,
  0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x18, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x0E, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x38, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xE7, 0x00, 0xE0, 0xF0,
  0x1E, 0x03, 0x38, 0x01, 0xC7, 0x00, 0x38, 0x0D, 0xC0, 0x07, 0x38, 0x00,
  0x60, 0x36, 0x00, 0x0C, 0xC0, 0x01, 0xC1, 0xF0, 0x00, 0x36, 0x00, 0x07,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x87, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0xC1, 0xFF, 0x80, 0x30, 0xFF, 0xF0, 0x1C, 0xF0, 0x1C,
  0x07, 0x70, 0x03, 0x81, 0xD8, 0x00, 0xE0, 0x6C, 0x00, 0x18, 0x1E, 0x00,
  0x07, 0x0F, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x18,
  0x70, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x86, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x38, 0x60, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x70, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x0E, 0x18, 0x00, 0x03,
  0x86, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x38, 0x00,
  0x03, 0x0E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0x80,
  0x78, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x63, 0x80, 0x00, 0x1C,
  0xE0, 0x00, 0x07, 0x30, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x0E,
  0x00, 0x3C, 0x03, 0xC0, 0x3E, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0x87, 0xFE, 0x00,
  0x06, 0x3F, 0xFE, 0x00, 0x3B, 0xC0, 0x38, 0x00, 0xFC, 0x00, 0x70, 0x03,
  0x60, 0x00, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x38, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x18, 0x07, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0xE0, 0x1F, 0x00, 0x07, 0x80, 0x76, 0x00, 0x3C, 0x01,
  0xCE, 0x01, 0xE0, 0x06, 0x1F, 0xFF, 0x00, 0x18, 0x3F, 0xF0, 0x00, 0xE0,
  0x1F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFC, 0x1C, 0x07,
  0xFF, 0xC3, 0x01, 0xE0, 0x1C, 0x60, 0x78, 0x00, 0xCC, 0x0E, 0x00, 0x0F,
  0x83, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x30, 0xE0, 0x00, 0x06, 0x1C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07,
  0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x3B, 0x00, 0xF0,
  0x0E, 0xE0, 0x0F, 0xFF, 0x9C, 0x00, 0xFF, 0xC3, 0x80, 0x03, 0xC0, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x61, 0xFC, 0x0C, 0x7F, 0x83, 0x9C, 0x00, 0x76, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3E,
  0x01, 0xC0, 0x3C, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0C,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x87, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0F,
  0x00, 0x78, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0xC0, 0x07, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x3C, 0x00, 0x06, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x07, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x1C, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0C,
  0x1C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x0C, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x30, 0x70, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x38, 0x30, 0x00, 0x07, 0x06, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x18, 0x38, 0x00, 0x03, 0x07, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x1C, 0x18,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x06, 0x00, 0x03, 0xC0, 0xC0,
  0x00, 0x78, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x06, 0xC0, 0x38, 0x01, 0xD8,
  0x07, 0x80, 0xF7, 0x00, 0x7F, 0xFC, 0xE0, 0x07, 0xFE, 0x18, 0x00, 0x3E,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x98, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x30, 0x30, 0x00, 0x38, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x1C,
  0x07, 0x00, 0x0C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x01, 0xC0, 0x07, 0x00,
  0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x70, 0x00, 0x30,
  0x30, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x07, 0x1C, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x67, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1F,
  0x80, 0x00, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x80, 0x01, 0x98, 0x00, 0x1E,
  0x00, 0x0E, 0x60, 0x00, 0xF8, 0x00, 0x39, 0x80, 0x03, 0x60, 0x01, 0xC6,
  0x00, 0x1D, 0x80, 0x07, 0x18, 0x00, 0x66, 0x00, 0x18, 0x60, 0x03, 0x98,
  0x00, 0xE1, 0x80, 0x0E, 0x60, 0x03, 0x07, 0x00, 0x31, 0x80, 0x1C, 0x1C,
  0x01, 0xC6, 0x00, 0x70, 0x70, 0x06, 0x1C, 0x01, 0x81, 0xC0, 0x38, 0x70,
  0x0E, 0x07, 0x00, 0xC1, 0xC0, 0x30, 0x1C, 0x07, 0x07, 0x01, 0xC0, 0x70,
  0x18, 0x1C, 0x07, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x03, 0x03, 0x80, 0xC0,
  0xE0, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0x30, 0x70, 0x0C, 0x1C, 0x00, 0xC1,
  0x80, 0x30, 0x70, 0x03, 0x0E, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x03, 0x0E,
  0x00, 0x31, 0xC0, 0x0E, 0x30, 0x00, 0xC7, 0x00, 0x39, 0xC0, 0x03, 0x98,
  0x00, 0xE6, 0x00, 0x0E, 0xE0, 0x01, 0x98, 0x00, 0x3B, 0x00, 0x06, 0xE0,
  0x00, 0xFC, 0x00, 0x1B, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x0C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x03, 0x80, 0x01,
  0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x70, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x60, 0x00, 0x38, 0x00, 0x60, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x30, 0x03, 0x80, 0x00, 0x30, 0x03,
  0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x38, 0x06,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x1C, 0x30,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x0D, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x4F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x08, 0x00, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x0C, 0x7F, 0xF8, 0x00, 0x18, 0xE0, 0x78, 0x00, 0x73, 0x80, 0x78, 0x00,
  0xCE, 0x00, 0x70, 0x01, 0x98, 0x00, 0x70, 0x06, 0x30, 0x00, 0x70, 0x1C,
  0xE0, 0x00, 0x7D, 0xF1, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLightItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 12, 49, 13, 1, -48 },
  { 75, 12, 14, 18, 7, -51 },
  { 96, 34, 48, 33, 1, -48 },
  { 300, 28, 62, 32, 3, -55 },
  { 517, 32, 50, 43, 6, -49 },
  { 717, 30, 50, 35, 2, -49 },
  { 905, 5, 14, 11, 7, -51 },
  { 914, 19, 70, 19, 3, -54 },
  { 1081, 19, 70, 19, -4, -54 },
  { 1248, 26, 27, 28, 4, -48 },
  { 1336, 28, 35, 33, 3, -40 },
  { 1459, 8, 14, 12, -2, -6 },
  { 1473, 14, 2, 17, 2, -23 },
  { 1477, 5, 5, 15, 1, -4 },
  { 1481, 28, 52, 23, -3, -48 },
  { 1663, 27, 50, 32, 3, -49 },
  { 1832, 15, 48, 32, 9, -48 },
  { 1922, 29, 49, 32, 1, -49 },
  { 2100, 28, 50, 32, 2, -49 },
  { 2275, 29, 48, 32, 1, -48 },
  { 2449, 29, 49, 32, 4, -48 },
  { 2627, 25, 49, 32, 3, -48 },
  { 2781, 27, 48, 32, 6, -48 },
  { 2943, 29, 50, 32, 2, -49 },
  { 3125, 25, 49, 32, 5, -49 },
  { 3279, 10, 36, 13, 1, -35 },
  { 3324, 13, 43, 12, -2, -35 },
  { 3394, 25, 28, 30, 3, -36 },
  { 3482, 25, 15, 32, 4, -30 },
  { 3529, 25, 28, 30, 2, -36 },
  { 3617, 20, 50, 26, 6, -49 },
  { 3742, 47, 62, 53, 2, -47 },
  { 4107, 32, 48, 35, -2, -48 },
  { 4299, 31, 48, 35, 2, -48 },
  { 4485, 32, 50, 37, 4, -49 },
  { 4685, 33, 48, 38, 2, -48 },
  { 4883, 33, 48, 33, 2, -48 },
  { 5081, 33, 48, 33, 2, -48 },
  { 5279, 33, 50, 39, 4, -49 },
  { 5486, 38, 48, 41, 2, -48 },
  { 5714, 11, 48, 16, 3, -48 },
  { 5780, 30, 49, 32, 1, -48 },
  { 5964, 36, 48, 36, 2, -48 },
  { 6180, 23, 48, 30, 2, -48 },
  { 6318, 46, 48, 49, 2, -48 },
  { 6594, 38, 48, 41, 2, -48 },
  { 6822, 33, 50, 39, 4, -49 },
  { 7029, 33, 48, 35, 2, -48 },
  { 7227, 33, 58, 39, 4, -49 },
  { 7467, 33, 48, 37, 2, -48 },
  { 7665, 32, 50, 34, 2, -49 },
  { 7865, 30, 48, 35, 7, -48 },
  { 8045, 34, 49, 38, 4, -48 },
  { 8254, 32, 48, 35, 6, -48 },
  { 8446, 47, 48, 51, 7, -48 },
  { 8728, 38, 48, 35, -1, -48 },
  { 8956, 32, 48, 35, 6, -48 },
  { 9148, 36, 48, 35, 0, -48 },
  { 9364, 18, 65, 14, 1, -55 },
  { 9511, 10, 52, 23, 7, -48 },
  { 9576, 18, 65, 14, -4, -55 },
  { 9723, 18, 24, 24, 4, -48 },
  { 9777, 24, 2, 25, -3, 0 },
  { 9783, 8, 9, 18, 9, -51 },
  { 9792, 26, 38, 31, 1, -37 },
  { 9916, 27, 52, 32, 2, -51 },
  { 10092, 26, 38, 30, 2, -37 },
  { 10216, 29, 52, 32, 3, -51 },
  { 10405, 26, 38, 30, 2, -37 },
  { 10529, 21, 52, 19, 4, -52 },
  { 10666, 30, 51, 32, 0, -37 },
  { 10858, 26, 51, 32, 2, -51 },
  { 11024, 11, 49, 13, 2, -49 },
  { 11092, 22, 63, 14, -9, -49 },
  { 11266, 27, 51, 28, 2, -51 },
  { 11439, 11, 51, 13, 2, -51 },
  { 11510, 46, 37, 51, 1, -37 },
  { 11723, 26, 37, 32, 2, -37 },
  { 11844, 26, 38, 32, 3, -37 },
  { 11968, 30, 51, 32, -1, -37 },
  { 12160, 27, 51, 32, 3, -37 },
  { 12333, 19, 37, 20, 2, -37 },
  { 12421, 25, 38, 29, 1, -37 },
  { 12540, 14, 46, 19, 4, -45 },
  { 12621, 27, 37, 32, 3, -36 },
  { 12746, 25, 36, 28, 4, -36 },
  { 12859, 38, 36, 43, 5, -36 },
  { 13030, 29, 36, 28, -1, -36 },
  { 13161, 32, 50, 28, -3, -36 },
  { 13361, 28, 36, 28, 0, -36 },
  { 13487, 21, 67, 19, 2, -53 },
  { 13663, 12, 57, 14, 1, -48 },
  { 13749, 21, 67, 19, -4, -53 },
  { 13925, 31, 11, 40, 4, -25 },
};

const GFXfont RobotoCondensed_ExtraLightItalic68pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic68pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic68pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC68PT7B_H_
