#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC20PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x22, 0x22, 0x24, 0x44, 0x00, 0x0C, 0x59, 0xAA, 0x04, 0x41,
  0x20, 0x48, 0x22, 0x3F, 0xC2, 0x40, 0x90, 0x44, 0x12, 0x3F, 0xE2, 0x20,
  0x90, 0x24, 0x11, 0x00, 0x04, 0x04, 0x1E, 0x21, 0x41, 0x41, 0x40, 0x20,
  0x10, 0x0C, 0x02, 0x02, 0x82, 0x82, 0x84, 0x78, 0x20, 0x20, 0x70, 0x44,
  0x22, 0x51, 0x29, 0x24, 0xA1, 0xA0, 0x16, 0x14, 0x92, 0x52, 0x29, 0x10,
  0x88, 0x38, 0x1C, 0x22, 0x22, 0x22, 0x24, 0x28, 0x30, 0x50, 0x89, 0x85,
  0x85, 0x82, 0x86, 0x79, 0xF0, 0x04, 0x21, 0x08, 0x21, 0x04, 0x10, 0x42,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x10, 0x20, 0x10, 0x82, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x42, 0x11, 0x10, 0x88, 0x00, 0x08,
  0x08, 0x08, 0x76, 0x18, 0x28, 0x44, 0x44, 0x08, 0x08, 0x08, 0x08, 0x08,
  0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x29, 0x40, 0xF0, 0xC0, 0x01, 0x01,
  0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40,
  0x80, 0x1E, 0x21, 0x41, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82,
  0x84, 0x84, 0x78, 0x3D, 0x11, 0x22, 0x22, 0x22, 0x44, 0x44, 0x0F, 0x08,
  0x88, 0x24, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x03, 0xF8, 0x1E, 0x21, 0x41, 0x41, 0x01, 0x02, 0x1C, 0x04, 0x02, 0x02,
  0x82, 0x82, 0x84, 0x78, 0x01, 0x00, 0x80, 0xC0, 0xA0, 0x90, 0x88, 0x48,
  0x44, 0x42, 0x3F, 0xC0, 0x80, 0x40, 0x40, 0x20, 0x1F, 0x90, 0x08, 0x04,
  0x02, 0x03, 0xE1, 0x08, 0x04, 0x02, 0x01, 0x20, 0x90, 0x44, 0x41, 0xC0,
  0x0E, 0x20, 0x82, 0x04, 0x0F, 0xB0, 0xC1, 0x83, 0x06, 0x0C, 0x14, 0x4F,
  0x00, 0xFF, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40,
  0x40, 0x80, 0x80, 0x0F, 0x08, 0x48, 0x24, 0x12, 0x09, 0x08, 0x78, 0x44,
  0x41, 0x20, 0xA0, 0x48, 0x24, 0x21, 0xE0, 0x1C, 0x22, 0x41, 0x41, 0x81,
  0x81, 0x82, 0x46, 0x3A, 0x02, 0x04, 0x04, 0x08, 0x70, 0x20, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0x00, 0x24, 0x48, 0x02, 0x08, 0x63, 0x08, 0x08,
  0x0C, 0x04, 0x04, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x40, 0x40, 0x60, 0x20,
  0x21, 0x8C, 0x20, 0x80, 0x7A, 0x18, 0x41, 0x08, 0x21, 0x08, 0x41, 0x00,
  0x00, 0x02, 0x00, 0x03, 0xE0, 0x60, 0x84, 0x02, 0x40, 0x12, 0x38, 0xA2,
  0x25, 0x21, 0x31, 0x11, 0x88, 0x8C, 0x84, 0x64, 0x23, 0x22, 0x29, 0x11,
  0x47, 0x72, 0x00, 0x10, 0x00, 0x40, 0x01, 0xF0, 0x00, 0x01, 0x00, 0xC0,
  0x28, 0x12, 0x04, 0x82, 0x20, 0x88, 0x42, 0x10, 0x87, 0xE2, 0x04, 0x81,
  0x40, 0x50, 0x10, 0x3E, 0x10, 0x88, 0x28, 0x14, 0x12, 0x09, 0xF8, 0x84,
  0x41, 0x40, 0xA0, 0x50, 0x28, 0x27, 0xE0, 0x0F, 0x04, 0x22, 0x09, 0x01,
  0x40, 0x50, 0x04, 0x02, 0x00, 0x80, 0x20, 0x28, 0x12, 0x04, 0x42, 0x0F,
  0x00, 0x3E, 0x10, 0xC8, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x40, 0xC0,
  0x60, 0x50, 0x28, 0x27, 0xE0, 0x3F, 0x90, 0x08, 0x08, 0x04, 0x02, 0x01,
  0xF8, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x07, 0xF0, 0x3F, 0x90, 0x08,
  0x08, 0x04, 0x02, 0x01, 0xF8, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x00, 0x0F, 0x04, 0x22, 0x05, 0x01, 0x40, 0x10, 0x04, 0x01, 0x1E, 0x80,
  0xA0, 0x28, 0x0A, 0x02, 0x41, 0x0F, 0x80, 0x20, 0x24, 0x04, 0x81, 0x20,
  0x24, 0x04, 0x80, 0x9F, 0xF2, 0x04, 0x40, 0x90, 0x12, 0x02, 0x40, 0x48,
  0x09, 0x02, 0x00, 0x24, 0x94, 0x92, 0x4A, 0x49, 0x00, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xA0, 0x90, 0x44, 0x41,
  0xC0, 0x20, 0x48, 0x22, 0x11, 0x08, 0x44, 0x12, 0x05, 0x01, 0xA0, 0x48,
  0x21, 0x08, 0x42, 0x08, 0x82, 0x20, 0x40, 0x20, 0x82, 0x10, 0x41, 0x04,
  0x10, 0x42, 0x08, 0x20, 0x83, 0xF0, 0x20, 0x09, 0x00, 0xCC, 0x06, 0xA0,
  0x55, 0x02, 0xA8, 0x29, 0x41, 0x49, 0x12, 0x48, 0x94, 0x48, 0xA2, 0x45,
  0x14, 0x48, 0x42, 0x42, 0x10, 0x20, 0x24, 0x04, 0xC1, 0x28, 0x24, 0x84,
  0x90, 0x91, 0x12, 0x22, 0x44, 0x90, 0x52, 0x0A, 0x41, 0x48, 0x19, 0x02,
  0x00, 0x0F, 0x04, 0x22, 0x05, 0x01, 0x40, 0x50, 0x18, 0x06, 0x02, 0x80,
  0xA0, 0x28, 0x0A, 0x04, 0x42, 0x0F, 0x00, 0x3F, 0x10, 0x48, 0x28, 0x14,
  0x0A, 0x05, 0x04, 0xFC, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x0F,
  0x04, 0x22, 0x05, 0x01, 0x40, 0x50, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x28,
  0x0A, 0x04, 0x42, 0x0F, 0x00, 0x40, 0x08, 0x01, 0x00, 0x3F, 0x10, 0x48,
  0x28, 0x14, 0x0A, 0x05, 0x04, 0xFC, 0x84, 0x41, 0x20, 0x90, 0x48, 0x24,
  0x08, 0x0F, 0x04, 0x22, 0x04, 0x81, 0x20, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x28, 0x09, 0x02, 0x41, 0x0F, 0x80, 0xFF, 0x84, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x20,
  0x48, 0x14, 0x05, 0x01, 0x40, 0x90, 0x24, 0x09, 0x02, 0x80, 0xA0, 0x28,
  0x12, 0x04, 0x42, 0x0F, 0x00, 0x80, 0xC0, 0x60, 0x50, 0x28, 0x24, 0x11,
  0x10, 0x88, 0x48, 0x24, 0x14, 0x0A, 0x06, 0x01, 0x00, 0x82, 0x06, 0x08,
  0x28, 0x50, 0xA1, 0x42, 0x85, 0x12, 0x24, 0x48, 0x92, 0x24, 0x48, 0x91,
  0x22, 0x45, 0x0A, 0x14, 0x18, 0x50, 0x40, 0x81, 0x02, 0x00, 0x20, 0x22,
  0x08, 0x42, 0x08, 0x80, 0x90, 0x14, 0x01, 0x00, 0x60, 0x0A, 0x02, 0x40,
  0x88, 0x20, 0x84, 0x11, 0x01, 0x00, 0x80, 0xC0, 0x90, 0x48, 0x44, 0x42,
  0x20, 0xA0, 0x60, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x1F, 0xC0,
  0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x40, 0x3F, 0xC0, 0x1C, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20, 0x84,
  0x10, 0x41, 0x04, 0x10, 0x82, 0x0E, 0x00, 0x92, 0x44, 0x92, 0x49, 0x12,
  0x48, 0x18, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x22, 0x10, 0x84, 0x21,
  0x30, 0x10, 0xCA, 0x54, 0xA6, 0x20, 0xFE, 0xA4, 0x1E, 0x21, 0x21, 0x01,
  0x01, 0x3E, 0x42, 0x82, 0x82, 0x86, 0x7A, 0x10, 0x10, 0x20, 0x20, 0x2E,
  0x31, 0x21, 0x21, 0x41, 0x41, 0x41, 0x41, 0x41, 0x42, 0xBC, 0x3C, 0x85,
  0x0C, 0x18, 0x10, 0x20, 0x40, 0x85, 0x09, 0xE0, 0x00, 0x80, 0x80, 0x40,
  0x23, 0xD2, 0x19, 0x09, 0x04, 0x82, 0x41, 0x20, 0x90, 0x48, 0x44, 0x21,
  0xF0, 0x3C, 0x85, 0x0C, 0x1F, 0xF0, 0x20, 0x40, 0x81, 0x09, 0xE0, 0x0C,
  0x42, 0x08, 0xF8, 0x84, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x00, 0x1E,
  0x90, 0x88, 0x48, 0x24, 0x12, 0x09, 0x04, 0x82, 0x42, 0x21, 0x0F, 0x80,
  0x40, 0x24, 0x21, 0xE0, 0x10, 0x10, 0x20, 0x20, 0x2E, 0x31, 0x21, 0x21,
  0x41, 0x41, 0x41, 0x41, 0x42, 0x42, 0x82, 0x20, 0x04, 0x92, 0x52, 0x49,
  0x20, 0x02, 0x00, 0x00, 0x00, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x04, 0x08, 0x10, 0x21, 0x80, 0x10, 0x08, 0x08, 0x04, 0x02, 0x11,
  0x10, 0x90, 0x50, 0x50, 0x38, 0x12, 0x09, 0x04, 0x42, 0x22, 0x08, 0x24,
  0xA4, 0x92, 0x52, 0x49, 0x20, 0x2E, 0x38, 0xC5, 0x12, 0x18, 0x48, 0x41,
  0x41, 0x05, 0x04, 0x14, 0x10, 0x90, 0x42, 0x42, 0x09, 0x08, 0x28, 0x20,
  0x80, 0x2E, 0x31, 0x21, 0x21, 0x41, 0x41, 0x41, 0x41, 0x42, 0x42, 0x82,
  0x3C, 0x85, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x09, 0xE0, 0x2E, 0x31,
  0x21, 0x41, 0x41, 0x41, 0x41, 0x41, 0x41, 0x42, 0xBC, 0x80, 0x80, 0x80,
  0x80, 0x3D, 0x42, 0x42, 0x82, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x7C,
  0x04, 0x04, 0x04, 0x08, 0x2C, 0xC2, 0x08, 0x41, 0x04, 0x10, 0x41, 0x08,
  0x00, 0x1E, 0x21, 0x41, 0x20, 0x30, 0x08, 0x06, 0x02, 0x82, 0x44, 0x38,
  0x22, 0xF2, 0x44, 0x44, 0x48, 0x88, 0x60, 0x41, 0x41, 0x42, 0x42, 0x82,
  0x82, 0x82, 0x84, 0x84, 0x8C, 0x74, 0x83, 0x06, 0x12, 0x24, 0x49, 0x12,
  0x28, 0x50, 0x40, 0x80, 0x84, 0x31, 0x8A, 0x31, 0x4A, 0x49, 0x49, 0x49,
  0x29, 0x45, 0x28, 0xC5, 0x18, 0x42, 0x08, 0x00, 0x21, 0x22, 0x22, 0x14,
  0x18, 0x08, 0x18, 0x28, 0x44, 0x44, 0x82, 0x20, 0x88, 0x21, 0x10, 0x44,
  0x11, 0x04, 0x81, 0x20, 0x50, 0x14, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08,
  0x0C, 0x00, 0x3F, 0x02, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40,
  0xFE, 0x04, 0x21, 0x04, 0x20, 0x82, 0x08, 0x42, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x08, 0x11, 0x22, 0x22, 0x22, 0x24, 0x44, 0x44, 0x48,
  0x80, 0x10, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x10, 0x84, 0x10, 0x42,
  0x08, 0x20, 0x84, 0x20, 0x70, 0xA4, 0x61, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 14, 4, 0, -14 },
  { 8, 4, 4, 5, 2, -15 },
  { 10, 10, 14, 10, 0, -14 },
  { 28, 8, 18, 9, 1, -16 },
  { 46, 9, 14, 13, 2, -14 },
  { 62, 8, 14, 10, 1, -14 },
  { 76, 1, 4, 3, 2, -15 },
  { 77, 6, 21, 5, 1, -16 },
  { 93, 5, 21, 6, -1, -16 },
  { 107, 8, 8, 8, 1, -14 },
  { 115, 8, 11, 10, 1, -12 },
  { 126, 3, 4, 4, -1, -2 },
  { 128, 4, 1, 5, 1, -7 },
  { 129, 2, 1, 4, 0, -1 },
  { 130, 8, 15, 7, -1, -14 },
  { 145, 8, 14, 9, 1, -14 },
  { 159, 4, 14, 9, 3, -14 },
  { 166, 9, 14, 9, 0, -14 },
  { 182, 8, 14, 9, 1, -14 },
  { 196, 9, 14, 9, 0, -14 },
  { 212, 9, 14, 9, 1, -14 },
  { 228, 7, 14, 9, 1, -14 },
  { 241, 8, 14, 9, 2, -14 },
  { 255, 9, 14, 9, 0, -14 },
  { 271, 8, 14, 9, 1, -14 },
  { 285, 3, 10, 4, 0, -10 },
  { 289, 4, 12, 4, -1, -10 },
  { 295, 7, 9, 9, 1, -11 },
  { 303, 8, 5, 9, 1, -9 },
  { 308, 7, 9, 9, 1, -11 },
  { 316, 6, 14, 8, 2, -14 },
  { 327, 13, 18, 15, 1, -14 },
  { 357, 10, 14, 10, -1, -14 },
  { 375, 9, 14, 10, 1, -14 },
  { 391, 10, 14, 11, 1, -14 },
  { 409, 9, 14, 11, 1, -14 },
  { 425, 9, 14, 10, 1, -14 },
  { 441, 9, 14, 10, 1, -14 },
  { 457, 10, 14, 12, 1, -14 },
  { 475, 11, 14, 12, 1, -14 },
  { 495, 3, 14, 5, 1, -14 },
  { 501, 9, 14, 9, 0, -14 },
  { 517, 10, 14, 11, 1, -14 },
  { 535, 6, 14, 9, 1, -14 },
  { 546, 13, 14, 15, 1, -14 },
  { 569, 11, 14, 12, 1, -14 },
  { 589, 10, 14, 11, 1, -14 },
  { 607, 9, 14, 10, 1, -14 },
  { 623, 10, 17, 11, 1, -14 },
  { 645, 9, 14, 11, 1, -14 },
  { 661, 10, 14, 10, 0, -14 },
  { 679, 9, 14, 10, 2, -14 },
  { 695, 10, 14, 11, 1, -14 },
  { 713, 9, 14, 10, 2, -14 },
  { 729, 14, 14, 15, 2, -14 },
  { 754, 11, 14, 10, 0, -14 },
  { 774, 9, 14, 10, 2, -14 },
  { 790, 10, 14, 10, 0, -14 },
  { 808, 6, 19, 4, 0, -16 },
  { 823, 3, 15, 7, 2, -14 },
  { 829, 5, 19, 4, -1, -16 },
  { 841, 5, 7, 7, 1, -14 },
  { 846, 7, 1, 7, -1, 0 },
  { 847, 2, 3, 5, 3, -15 },
  { 848, 8, 11, 9, 0, -11 },
  { 859, 8, 15, 9, 0, -15 },
  { 874, 7, 11, 9, 1, -11 },
  { 884, 9, 15, 9, 1, -15 },
  { 901, 7, 11, 9, 1, -11 },
  { 911, 6, 15, 6, 1, -15 },
  { 923, 9, 15, 9, 0, -11 },
  { 940, 8, 15, 9, 0, -15 },
  { 955, 3, 15, 4, 1, -15 },
  { 961, 7, 19, 4, -3, -15 },
  { 978, 9, 15, 8, 0, -15 },
  { 995, 3, 15, 4, 1, -15 },
  { 1001, 14, 11, 15, 0, -11 },
  { 1021, 8, 11, 9, 0, -11 },
  { 1032, 7, 11, 9, 1, -11 },
  { 1042, 8, 15, 9, 0, -11 },
  { 1057, 8, 15, 9, 1, -11 },
  { 1072, 6, 11, 6, 0, -11 },
  { 1081, 8, 11, 9, 0, -11 },
  { 1092, 4, 13, 6, 1, -13 },
  { 1099, 8, 11, 9, 1, -11 },
  { 1110, 7, 11, 8, 1, -11 },
  { 1120, 11, 11, 13, 2, -11 },
  { 1136, 8, 11, 8, 0, -11 },
  { 1147, 10, 15, 8, -1, -11 },
  { 1166, 8, 11, 8, 0, -11 },
  { 1177, 6, 20, 6, 1, -16 },
  { 1192, 4, 17, 4, 0, -14 },
  { 1201, 6, 20, 6, -1, -16 },
  { 1216, 9, 3, 12, 1, -7 },
};

const GFXfont RobotoCondensed_ExtraLightItalic20pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic20pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic20pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC20PT7B_H_
