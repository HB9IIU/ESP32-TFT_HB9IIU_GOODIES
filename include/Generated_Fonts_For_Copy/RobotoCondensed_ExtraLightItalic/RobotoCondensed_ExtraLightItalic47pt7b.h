#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC47PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xC0, 0x23, 0x63,
  0x63, 0x63, 0x62, 0x42, 0x46, 0xC6, 0xC6, 0xC6, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x20, 0x20, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x02,
  0x02, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x20, 0x20, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x02, 0x02, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x20, 0x20, 0x00, 0x40, 0xC0, 0x01, 0x81, 0x80, 0x02, 0x02, 0x00,
  0x04, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x20, 0x00, 0x40, 0xC0, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x04, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x20, 0x00, 0x40, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x02, 0x00, 0x04, 0x04,
  0x00, 0x18, 0x18, 0x00, 0x30, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0x00, 0xE0, 0x60,
  0x38, 0x06, 0x06, 0x00, 0x41, 0x80, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x31,
  0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x60,
  0x00, 0xCC, 0x00, 0x19, 0x80, 0x02, 0x30, 0x00, 0xC6, 0x00, 0x18, 0x60,
  0x06, 0x0C, 0x01, 0xC0, 0xC0, 0x70, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0x86, 0x00, 0x0C, 0x08, 0x00, 0x60, 0x20, 0x11, 0x80,
  0x80, 0xC4, 0x02, 0x02, 0x10, 0x08, 0x18, 0x40, 0x20, 0xC3, 0x01, 0x82,
  0x0C, 0x06, 0x10, 0x10, 0x10, 0xC0, 0x40, 0xC6, 0x01, 0x86, 0x10, 0x03,
  0xF0, 0xC0, 0x07, 0x86, 0x00, 0x00, 0x30, 0x00, 0x00, 0x87, 0xC0, 0x06,
  0x3F, 0x80, 0x31, 0x82, 0x00, 0x84, 0x0C, 0x06, 0x30, 0x10, 0x30, 0x80,
  0x41, 0x82, 0x01, 0x04, 0x18, 0x0C, 0x30, 0x60, 0x31, 0x81, 0x80, 0xCC,
  0x06, 0x02, 0x20, 0x18, 0x18, 0x00, 0x60, 0x60, 0x00, 0xC3, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x30, 0x60,
  0x03, 0x01, 0x80, 0x18, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60,
  0x10, 0x03, 0x01, 0x80, 0x18, 0x18, 0x00, 0xC1, 0xC0, 0x06, 0x1C, 0x00,
  0x19, 0x80, 0x00, 0xD8, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x60,
  0x00, 0x33, 0x00, 0x03, 0x0C, 0x06, 0x30, 0x20, 0x33, 0x01, 0x81, 0x98,
  0x06, 0x09, 0x80, 0x30, 0xCC, 0x00, 0xC6, 0x40, 0x06, 0x62, 0x00, 0x1B,
  0x10, 0x00, 0xF0, 0xC0, 0x03, 0x06, 0x00, 0x1C, 0x38, 0x03, 0xE0, 0xE0,
  0x31, 0x83, 0xFF, 0x0C, 0x07, 0xE0, 0x30, 0x6D, 0xB5, 0xB6, 0xD0, 0x00,
  0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x0E, 0x0C, 0x1F, 0xE3, 0x3E, 0x1E, 0xFC, 0x00, 0xF8, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x06, 0x60, 0x03, 0x08, 0x01, 0x83, 0x00, 0xC0, 0x60, 0x60,
  0x18, 0x18, 0x02, 0x00, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x0C, 0x30, 0xC6, 0x18, 0x63, 0x0C, 0x61, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0x80, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0xE0, 0x0E, 0x06, 0x01, 0x80, 0x60, 0x60, 0x0C, 0x18, 0x00, 0x83, 0x00,
  0x18, 0xC0, 0x03, 0x18, 0x00, 0x62, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00,
  0x33, 0x00, 0x06, 0x40, 0x00, 0x88, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00,
  0xCC, 0x00, 0x19, 0x80, 0x03, 0x20, 0x00, 0x44, 0x00, 0x19, 0x80, 0x03,
  0x30, 0x00, 0x66, 0x00, 0x08, 0xC0, 0x03, 0x18, 0x00, 0x61, 0x00, 0x18,
  0x20, 0x03, 0x06, 0x00, 0xC0, 0xC0, 0x38, 0x0C, 0x0E, 0x00, 0xFF, 0x80,
  0x0F, 0xC0, 0x00, 0x00, 0x60, 0x78, 0x3F, 0x1E, 0x6E, 0x0D, 0x01, 0x80,
  0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01, 0x81, 0xC0, 0x30, 0x0E, 0x06,
  0x00, 0x60, 0x40, 0x06, 0x0C, 0x00, 0x20, 0xC0, 0x02, 0x18, 0x00, 0x21,
  0x80, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01, 0x80, 0xC0, 0x30, 0x06, 0x06, 0x00,
  0x60, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC4, 0x00, 0x0C,
  0xC0, 0x00, 0xC4, 0x00, 0x08, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60, 0x03,
  0x03, 0x00, 0x60, 0x38, 0x0C, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x34, 0x00, 0x03, 0xC0,
  0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x08,
  0x00, 0x61, 0x80, 0x04, 0x18, 0x00, 0xC1, 0x80, 0x18, 0x18, 0x03, 0x01,
  0x00, 0x30, 0x10, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x03, 0x01, 0x80,
  0x30, 0x30, 0x02, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x03, 0xFF,
  0xF0, 0x3F, 0xFE, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x19, 0xF0, 0x01, 0x7F, 0xC0, 0x3C, 0x0E, 0x03,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x30, 0xC0, 0x02, 0x0C, 0x00, 0x60, 0x40, 0x0C, 0x06, 0x00,
  0xC0, 0x30, 0x38, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x0F, 0xE0, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x43, 0xE0,
  0x33, 0xFE, 0x0D, 0x81, 0xC2, 0xC0, 0x31, 0xE0, 0x06, 0x70, 0x01, 0x98,
  0x00, 0x66, 0x00, 0x09, 0x80, 0x02, 0x40, 0x00, 0x90, 0x00, 0x2C, 0x00,
  0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x44, 0x00, 0x31, 0x80, 0x0C,
  0x60, 0x06, 0x0C, 0x03, 0x03, 0x81, 0x80, 0x7F, 0xC0, 0x07, 0xE0, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC,
  0x01, 0xC0, 0xE0, 0x30, 0x06, 0x07, 0x00, 0x30, 0x60, 0x03, 0x04, 0x00,
  0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0,
  0x06, 0x0C, 0x00, 0x60, 0x60, 0x0C, 0x03, 0x03, 0x80, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x70, 0x70, 0x1C, 0x03, 0x83, 0x80, 0x18, 0x30, 0x00, 0xC6,
  0x00, 0x0C, 0x60, 0x00, 0xC4, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C,
  0xC0, 0x01, 0x84, 0x00, 0x18, 0x60, 0x03, 0x07, 0x00, 0x70, 0x38, 0x0E,
  0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x60,
  0x70, 0x30, 0x0C, 0x18, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x08, 0x80, 0x03,
  0x60, 0x00, 0xD8, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x02, 0xC0, 0x00, 0xB0,
  0x00, 0x64, 0x00, 0x19, 0x00, 0x0E, 0x60, 0x03, 0x98, 0x01, 0xE3, 0x00,
  0xD0, 0xE0, 0x6C, 0x1F, 0xF3, 0x03, 0xF0, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x3C, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x3C, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x70, 0xC0, 0x01, 0x80, 0xE0, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x40, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x10, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00,
  0x03, 0xE0, 0x3F, 0xC1, 0x81, 0x8C, 0x03, 0x60, 0x0D, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x02, 0x0C, 0x00, 0xF8, 0x03, 0x08, 0x03, 0xFC, 0x03, 0x18, 0x07,
  0x06, 0x03, 0x10, 0x0C, 0x02, 0x03, 0x30, 0x08, 0x06, 0x03, 0x30, 0x18,
  0x06, 0x03, 0x60, 0x30, 0x04, 0x03, 0x60, 0x30, 0x04, 0x03, 0x60, 0x20,
  0x0C, 0x03, 0x40, 0x60, 0x0C, 0x02, 0xC0, 0x60, 0x08, 0x02, 0xC0, 0x40,
  0x08, 0x06, 0xC0, 0xC0, 0x18, 0x06, 0x80, 0xC0, 0x18, 0x04, 0x80, 0xC0,
  0x30, 0x0C, 0x80, 0xC0, 0x30, 0x0C, 0x80, 0xC0, 0x70, 0x08, 0x80, 0xC0,
  0x70, 0x18, 0x80, 0xC0, 0xF0, 0x30, 0x80, 0xC1, 0x90, 0x60, 0x80, 0x7F,
  0x1F, 0xC0, 0xC0, 0x3C, 0x0F, 0x80, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x02, 0x40,
  0x00, 0x19, 0x00, 0x00, 0x44, 0x00, 0x03, 0x18, 0x00, 0x08, 0x60, 0x00,
  0x61, 0x80, 0x01, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x20, 0x20, 0x01, 0x80,
  0x80, 0x04, 0x02, 0x00, 0x30, 0x0C, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x10, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x10, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01,
  0x8C, 0x00, 0x02, 0x30, 0x00, 0x09, 0x80, 0x00, 0x36, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0C, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0x80,
  0x38, 0x0C, 0x00, 0x60, 0x40, 0x03, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x61,
  0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x82, 0x00, 0x0C, 0x30, 0x00,
  0x61, 0x80, 0x06, 0x0C, 0x00, 0x60, 0x60, 0x07, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x01, 0x80, 0x1C, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x06,
  0x10, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00,
  0x03, 0x18, 0x00, 0x30, 0x80, 0x01, 0x8C, 0x00, 0x18, 0x60, 0x01, 0xC3,
  0x00, 0x1C, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x80, 0x38, 0x07, 0x01, 0xC0, 0x0C, 0x06, 0x00, 0x18, 0x30, 0x00,
  0x61, 0x80, 0x00, 0x86, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x02, 0x30,
  0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x60, 0x60, 0x01, 0x81, 0xC0, 0x0C, 0x03, 0x80, 0xE0, 0x07, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x18, 0x01, 0x80,
  0x30, 0x01, 0x80, 0x40, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x03, 0x06,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x20, 0x00, 0x10, 0xC0,
  0x00, 0x21, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x08, 0x00,
  0x06, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x61, 0x80, 0x00,
  0xC3, 0x00, 0x01, 0x84, 0x00, 0x03, 0x18, 0x00, 0x04, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x82, 0x00, 0x06, 0x0C,
  0x00, 0x18, 0x18, 0x00, 0x60, 0x30, 0x03, 0x80, 0x7F, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0x01,
  0xC0, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x81, 0x80, 0x01, 0x83, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x04, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x3F, 0xF1, 0x00, 0x7F, 0xE2, 0x00,
  0x00, 0xCC, 0x00, 0x01, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x61, 0x00, 0x01, 0x83, 0x00, 0x03,
  0x06, 0x00, 0x06, 0x06, 0x00, 0x38, 0x06, 0x01, 0xE0, 0x07, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x18, 0x60, 0x00, 0x08, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x82, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x41, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60,
  0x00, 0x18, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x18, 0x00, 0x02, 0x0C,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x20, 0xC0, 0x00, 0x10, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x06, 0x08, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x01,
  0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x03, 0x02, 0x06, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x0C,
  0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x20, 0x60, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x20, 0xC0,
  0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0xC0,
  0x30, 0x06, 0x01, 0xC0, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x06,
  0x00, 0x07, 0x06, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x04,
  0x00, 0x30, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x0C,
  0x03, 0x00, 0x0C, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x11, 0xC0, 0x00, 0x13,
  0x60, 0x00, 0x36, 0x60, 0x00, 0x3C, 0x30, 0x00, 0x38, 0x30, 0x00, 0x30,
  0x18, 0x00, 0x20, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x40, 0x03, 0x80, 0xC0,
  0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x80,
  0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x38, 0x28, 0x00, 0x00, 0xF0, 0x58, 0x00, 0x01, 0x61,
  0xB0, 0x00, 0x06, 0x83, 0x60, 0x00, 0x09, 0x06, 0xC0, 0x00, 0x36, 0x0C,
  0x80, 0x00, 0x4C, 0x11, 0x00, 0x01, 0x98, 0x23, 0x00, 0x06, 0x30, 0xC6,
  0x00, 0x0C, 0x41, 0x8C, 0x00, 0x30, 0x83, 0x18, 0x00, 0x63, 0x06, 0x10,
  0x01, 0x86, 0x08, 0x20, 0x03, 0x0C, 0x10, 0x60, 0x0C, 0x18, 0x60, 0xC0,
  0x18, 0x20, 0xC1, 0x80, 0x60, 0xC1, 0x81, 0x00, 0xC1, 0x83, 0x02, 0x03,
  0x03, 0x04, 0x06, 0x04, 0x06, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x18, 0x20,
  0x10, 0x60, 0x30, 0xC0, 0x60, 0xC0, 0x21, 0x00, 0xC1, 0x80, 0x46, 0x01,
  0x82, 0x00, 0xD8, 0x03, 0x0C, 0x01, 0xB0, 0x04, 0x18, 0x03, 0xC0, 0x08,
  0x30, 0x03, 0x80, 0x30, 0x60, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x81, 0xC0, 0x00, 0x20, 0x70, 0x00, 0x18, 0x1C, 0x00,
  0x06, 0x07, 0x80, 0x01, 0x83, 0x20, 0x00, 0x60, 0xCC, 0x00, 0x10, 0x33,
  0x00, 0x0C, 0x0C, 0x40, 0x03, 0x03, 0x18, 0x00, 0xC0, 0x86, 0x00, 0x30,
  0x60, 0xC0, 0x0C, 0x18, 0x30, 0x02, 0x06, 0x04, 0x01, 0x81, 0x81, 0x80,
  0x60, 0x60, 0x60, 0x18, 0x10, 0x0C, 0x06, 0x0C, 0x03, 0x01, 0x83, 0x00,
  0x40, 0x40, 0xC0, 0x18, 0x30, 0x30, 0x06, 0x0C, 0x08, 0x00, 0x83, 0x06,
  0x00, 0x30, 0xC1, 0x80, 0x0C, 0x20, 0x60, 0x01, 0x98, 0x18, 0x00, 0x66,
  0x06, 0x00, 0x09, 0x81, 0x00, 0x03, 0x60, 0xC0, 0x00, 0xD8, 0x30, 0x00,
  0x1C, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3C, 0x07, 0x01, 0xC0, 0x0E, 0x06,
  0x00, 0x18, 0x30, 0x00, 0x21, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x32, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D,
  0x80, 0x00, 0x36, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x40, 0x00, 0x1B, 0x00,
  0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1A, 0x00, 0x00,
  0x48, 0x00, 0x03, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x23, 0x00, 0x01, 0x8C,
  0x00, 0x04, 0x30, 0x00, 0x30, 0x60, 0x01, 0x81, 0x80, 0x0C, 0x03, 0x80,
  0xE0, 0x07, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x60, 0x07, 0x01, 0x80, 0x06, 0x04, 0x00, 0x18, 0x30, 0x00, 0x30,
  0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x80,
  0x00, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0xE1, 0x80, 0x03,
  0x04, 0x00, 0x18, 0x10, 0x01, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0x00, 0xE0, 0x1C,
  0x00, 0xE0, 0x70, 0x00, 0xC0, 0xC0, 0x00, 0x83, 0x00, 0x01, 0x86, 0x00,
  0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x40, 0x00, 0x19, 0x80, 0x00,
  0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x90, 0x00, 0x02,
  0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66,
  0x00, 0x00, 0xC8, 0x00, 0x03, 0x10, 0x00, 0x06, 0x20, 0x00, 0x0C, 0x40,
  0x00, 0x10, 0xC0, 0x00, 0x61, 0x80, 0x01, 0x83, 0x00, 0x03, 0x03, 0x00,
  0x0C, 0x06, 0x00, 0x30, 0x07, 0x01, 0xC0, 0x07, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x60, 0x07, 0x01, 0x80, 0x06, 0x04, 0x00, 0x18, 0x30, 0x00, 0x30,
  0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x30, 0x80,
  0x00, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0xC1, 0x80, 0x03,
  0x04, 0x00, 0x18, 0x30, 0x01, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0C,
  0x01, 0x00, 0x30, 0x06, 0x00, 0x80, 0x18, 0x06, 0x00, 0x20, 0x18, 0x00,
  0xC0, 0x60, 0x03, 0x01, 0x80, 0x04, 0x04, 0x00, 0x18, 0x10, 0x00, 0x60,
  0xC0, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x80,
  0x00, 0x60, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0x00, 0xE0, 0x1C,
  0x00, 0xC0, 0x70, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00,
  0x02, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00,
  0x0C, 0x06, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0x07, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x06, 0x18,
  0x00, 0x0C, 0x20, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x43, 0x00,
  0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x60, 0x00,
  0x10, 0xC0, 0x00, 0x21, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x84, 0x00, 0x03,
  0x08, 0x00, 0x06, 0x30, 0x00, 0x08, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61,
  0x80, 0x00, 0xC2, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x04, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x83, 0x00,
  0x03, 0x06, 0x00, 0x06, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x0E, 0x03,
  0x80, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0x90, 0x00, 0x06, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6,
  0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0xC0, 0x80, 0x03, 0x02, 0x00,
  0x08, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x30,
  0x0C, 0x01, 0x80, 0x10, 0x06, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x06,
  0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x00, 0x83, 0x00, 0x02, 0x08,
  0x00, 0x0C, 0x60, 0x00, 0x31, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00,
  0x0D, 0x80, 0x00, 0x16, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x03,
  0x80, 0x06, 0xC0, 0x02, 0x80, 0x06, 0xC0, 0x06, 0x80, 0x04, 0xC0, 0x04,
  0x80, 0x0C, 0xC0, 0x0C, 0x80, 0x0C, 0xC0, 0x0C, 0x80, 0x08, 0xC0, 0x08,
  0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x10, 0xC0, 0x30, 0xC0, 0x30,
  0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x20, 0xC0, 0x20, 0xC0, 0x60, 0xC0, 0x60,
  0xC0, 0x60, 0x40, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x40, 0xC0, 0x40, 0xC0,
  0x40, 0xC0, 0x60, 0x80, 0x41, 0x80, 0x61, 0x80, 0x41, 0x80, 0x61, 0x00,
  0x61, 0x00, 0x63, 0x00, 0x63, 0x00, 0x63, 0x00, 0x63, 0x00, 0x62, 0x00,
  0x62, 0x00, 0x66, 0x00, 0x66, 0x00, 0x64, 0x00, 0x66, 0x00, 0x6C, 0x00,
  0x6C, 0x00, 0x6C, 0x00, 0x2C, 0x00, 0x68, 0x00, 0x28, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x06, 0x00, 0x06,
  0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x1C, 0x00, 0x18,
  0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x10,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x60, 0x08, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x03, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x66,
  0x00, 0x01, 0x98, 0x00, 0x0C, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00,
  0x0C, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x00, 0xC0, 0x60,
  0x03, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x10, 0x60, 0x00, 0x61, 0x80, 0x01,
  0x8C, 0x00, 0x02, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0xC1,
  0x83, 0x06, 0x0C, 0x08, 0x10, 0x30, 0x60, 0xC1, 0x83, 0x02, 0x04, 0x0C,
  0x18, 0x30, 0x60, 0xC0, 0x81, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x40,
  0xC1, 0x83, 0x06, 0x0C, 0x08, 0x10, 0x30, 0x01, 0xF8, 0x0F, 0xC0, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x01, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x40, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x12, 0x01, 0x90, 0x08, 0x80, 0xC6, 0x04, 0x30,
  0x61, 0x82, 0x0C, 0x30, 0x21, 0x01, 0x18, 0x0C, 0xC0, 0x6C, 0x03, 0x60,
  0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0x61, 0x83, 0x0C, 0x18, 0x20, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0x70, 0x38, 0x30, 0x06, 0x18, 0x00, 0x86, 0x00, 0x31,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x07,
  0xFE, 0x0F, 0xFF, 0x87, 0x00, 0x43, 0x00, 0x31, 0x80, 0x0C, 0xC0, 0x03,
  0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x0E, 0x30, 0x07, 0x86,
  0x07, 0x61, 0xFF, 0x98, 0x1F, 0x86, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0xF8, 0x06, 0x7F, 0xC0,
  0xD8, 0x1C, 0x1C, 0x01, 0x83, 0x00, 0x10, 0xE0, 0x03, 0x18, 0x00, 0x63,
  0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x00, 0x06, 0x60, 0x00, 0x8C,
  0x00, 0x11, 0x80, 0x06, 0x30, 0x00, 0xC4, 0x00, 0x18, 0x80, 0x03, 0x30,
  0x00, 0xC6, 0x00, 0x18, 0xC0, 0x02, 0x18, 0x00, 0xC2, 0x80, 0x30, 0x58,
  0x0E, 0x19, 0xFF, 0x03, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0x70, 0x38, 0x30, 0x06, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x0C, 0xC0,
  0x03, 0x30, 0x00, 0xD8, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x44,
  0x00, 0x31, 0x80, 0x0C, 0x60, 0x06, 0x18, 0x03, 0x83, 0x81, 0xC0, 0x7F,
  0xE0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x01, 0xF8, 0x40, 0x7F, 0xC4, 0x0E, 0x06,
  0xC1, 0xC0, 0x3C, 0x18, 0x01, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0x86, 0x00,
  0x08, 0x60, 0x01, 0x86, 0x00, 0x18, 0x40, 0x01, 0x8C, 0x00, 0x18, 0xC0,
  0x01, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0x20, 0xC0, 0x02, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x06, 0x00, 0xE0,
  0x70, 0x36, 0x03, 0xFE, 0x40, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x70, 0x38, 0x30, 0x06, 0x0C, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x0C,
  0xC0, 0x03, 0x20, 0x00, 0xD8, 0x00, 0x37, 0xFF, 0xFD, 0xFF, 0xFF, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x83, 0x80, 0xE0,
  0x7F, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x38, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x0F, 0xFE,
  0x3F, 0xF8, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7E, 0x10, 0x0F, 0xF8,
  0x80, 0xE0, 0x6C, 0x0E, 0x01, 0xE0, 0x60, 0x07, 0x06, 0x00, 0x38, 0x30,
  0x00, 0x83, 0x00, 0x04, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x04, 0x00, 0x18,
  0x60, 0x00, 0xC3, 0x00, 0x04, 0x18, 0x00, 0x20, 0xC0, 0x03, 0x06, 0x00,
  0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x20, 0x60, 0x03, 0x03,
  0x00, 0x18, 0x0C, 0x01, 0xC0, 0x70, 0x36, 0x01, 0xFF, 0x30, 0x07, 0xE1,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x01, 0x00, 0x18, 0x18, 0x01, 0x80, 0x70, 0x18, 0x01, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0xC3, 0xE0, 0x33, 0xFE, 0x0D, 0x81, 0x83, 0xC0, 0x30, 0xA0,
  0x0C, 0x70, 0x03, 0x1C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03,
  0x10, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x08, 0xC0, 0x06, 0x30, 0x01, 0x8C,
  0x00, 0x62, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x18, 0x00, 0xC6, 0x00,
  0x31, 0x00, 0x0C, 0x40, 0x03, 0x30, 0x00, 0x8C, 0x00, 0x20, 0x03, 0x07,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x0C, 0x0C, 0x0C, 0x0C,
  0x08, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x30,
  0x20, 0x60, 0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x03, 0x86, 0x00, 0xE0,
  0xC0, 0x38, 0x18, 0x0E, 0x02, 0x03, 0x80, 0xC0, 0xE0, 0x18, 0x30, 0x03,
  0x0C, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x01, 0x30, 0x00, 0x6F, 0x00, 0x0F,
  0x60, 0x01, 0xC6, 0x00, 0x30, 0xC0, 0x04, 0x0C, 0x00, 0x81, 0x80, 0x30,
  0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x02, 0x00, 0x60, 0x40,
  0x0C, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x00, 0x03, 0x03, 0x03, 0x03, 0x02,
  0x02, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x08,
  0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x30, 0x20, 0x20,
  0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0x0C, 0x3E, 0x01, 0xF8, 0x0C, 0xFF,
  0x87, 0xFC, 0x0D, 0x81, 0x8E, 0x0E, 0x0B, 0x00, 0xD8, 0x06, 0x1A, 0x00,
  0xD0, 0x02, 0x1C, 0x00, 0xF0, 0x02, 0x1C, 0x00, 0xE0, 0x02, 0x18, 0x00,
  0xC0, 0x02, 0x18, 0x00, 0xC0, 0x02, 0x10, 0x00, 0xC0, 0x06, 0x30, 0x00,
  0xC0, 0x06, 0x30, 0x00, 0x80, 0x06, 0x30, 0x00, 0x80, 0x06, 0x30, 0x01,
  0x80, 0x06, 0x30, 0x01, 0x80, 0x04, 0x20, 0x01, 0x80, 0x0C, 0x60, 0x01,
  0x80, 0x0C, 0x60, 0x01, 0x00, 0x0C, 0x60, 0x03, 0x00, 0x0C, 0x60, 0x03,
  0x00, 0x0C, 0x40, 0x03, 0x00, 0x08, 0x40, 0x03, 0x00, 0x18, 0xC0, 0x03,
  0x00, 0x18, 0xC0, 0x02, 0x00, 0x18, 0xC0, 0x06, 0x00, 0x18, 0x0C, 0x3E,
  0x03, 0x3F, 0xE0, 0xD8, 0x18, 0x3C, 0x03, 0x0A, 0x00, 0xC7, 0x00, 0x31,
  0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x00, 0x0C, 0xC0,
  0x03, 0x30, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x18, 0x80, 0x06, 0x20, 0x01,
  0x98, 0x00, 0x66, 0x00, 0x11, 0x80, 0x0C, 0x60, 0x03, 0x10, 0x00, 0xC4,
  0x00, 0x33, 0x00, 0x08, 0xC0, 0x02, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80,
  0xE0, 0x30, 0x30, 0x06, 0x18, 0x01, 0x8C, 0x00, 0x33, 0x00, 0x0D, 0x80,
  0x03, 0x60, 0x00, 0xD8, 0x00, 0x34, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xB0, 0x00, 0x2C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0xCC,
  0x00, 0x33, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x03, 0x07, 0x01, 0x80, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0x03, 0x0F, 0x80, 0x19, 0xFF, 0x00, 0xD8, 0x1C,
  0x05, 0x00, 0x60, 0x30, 0x01, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0,
  0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x00, 0x06, 0x18, 0x00, 0x20,
  0xC0, 0x01, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x00, 0x06, 0x08, 0x00,
  0x30, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0x81, 0x80, 0x0C, 0x0A,
  0x00, 0xC0, 0x58, 0x0E, 0x06, 0x7F, 0xC0, 0x30, 0xFC, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xF8, 0x40, 0xFF, 0x88, 0x38, 0x1B, 0x0E, 0x01, 0xE1, 0x80, 0x1C,
  0x60, 0x01, 0x8C, 0x00, 0x23, 0x00, 0x04, 0x60, 0x01, 0x8C, 0x00, 0x31,
  0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x11, 0x80, 0x02, 0x30, 0x00, 0xC6,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x08, 0x60, 0x03, 0x0C,
  0x00, 0x60, 0xC0, 0x1C, 0x18, 0x0D, 0x81, 0xFF, 0x30, 0x1F, 0x84, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x7C, 0x33, 0xF0, 0xD8, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x01, 0xFF,
  0x03, 0x80, 0xC1, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x40, 0x06, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x30, 0x01,
  0x98, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x61, 0xC0, 0x60, 0x7F, 0xE0, 0x0F,
  0xC0, 0x00, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFF,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08,
  0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x1F, 0x03, 0xC0, 0x18, 0x00, 0x46, 0x00, 0x31, 0x80, 0x0C,
  0x40, 0x03, 0x10, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x08, 0xC0, 0x06, 0x30,
  0x01, 0x88, 0x00, 0x66, 0x00, 0x19, 0x80, 0x04, 0x60, 0x01, 0x18, 0x00,
  0xC6, 0x00, 0x31, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x8C, 0x00, 0x63,
  0x00, 0x18, 0x40, 0x0E, 0x18, 0x07, 0x87, 0x03, 0x60, 0xFF, 0x90, 0x1F,
  0x84, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xC4, 0x00,
  0x63, 0x00, 0x21, 0x80, 0x30, 0xC0, 0x10, 0x60, 0x18, 0x30, 0x0C, 0x08,
  0x0C, 0x04, 0x06, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC3, 0x00, 0x61, 0x80,
  0x30, 0x80, 0x08, 0xC0, 0x04, 0x40, 0x03, 0x60, 0x01, 0xA0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x0C, 0x00, 0xF0,
  0x07, 0x00, 0x6C, 0x01, 0xC0, 0x1B, 0x00, 0x70, 0x06, 0xC0, 0x3C, 0x03,
  0x30, 0x0B, 0x00, 0xCC, 0x06, 0xC0, 0x63, 0x01, 0x90, 0x18, 0xC0, 0xC4,
  0x06, 0x30, 0x31, 0x03, 0x0C, 0x18, 0x40, 0xC3, 0x06, 0x18, 0x60, 0x41,
  0x06, 0x18, 0x10, 0xC1, 0x84, 0x04, 0x20, 0x63, 0x01, 0x18, 0x18, 0xC0,
  0x46, 0x06, 0x60, 0x1B, 0x00, 0x98, 0x06, 0xC0, 0x24, 0x01, 0xA0, 0x0B,
  0x00, 0x78, 0x02, 0xC0, 0x1C, 0x00, 0xA0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x06, 0x00, 0x30, 0x60, 0x06, 0x06,
  0x00, 0x60, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x18, 0x30, 0x01, 0x83, 0x00,
  0x08, 0x60, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xD0, 0x00, 0x19, 0x80, 0x03, 0x18,
  0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0xC0, 0x60, 0x1C, 0x06, 0x01, 0x80,
  0x60, 0x30, 0x03, 0x06, 0x00, 0x30, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x18, 0x00, 0x20, 0x60, 0x01, 0x80, 0x80, 0x06, 0x02, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x0C, 0x03,
  0x00, 0x10, 0x18, 0x00, 0x40, 0x60, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00,
  0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x8C, 0x00, 0x02, 0x30, 0x00, 0x08,
  0x80, 0x00, 0x36, 0x00, 0x00, 0xD0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x00, 0x04,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x20, 0x00, 0x03, 0x03, 0x02,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x08,
  0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x20, 0x60, 0x60, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0,
  0x01, 0x00, 0x03, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFE, 0x00, 0x5C, 0x38,
  0x02, 0xC0, 0xC0, 0x3C, 0x03, 0x01, 0x60, 0x0C, 0x1A, 0x00, 0x3F, 0x80,
  0x00, 0xF8,
};

const GFXglyph RobotoCondensed_ExtraLightItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 33, 9, 1, -33 },
  { 34, 8, 10, 12, 5, -35 },
  { 44, 23, 33, 23, 1, -33 },
  { 139, 19, 41, 22, 2, -37 },
  { 237, 22, 33, 29, 4, -33 },
  { 328, 21, 33, 24, 1, -33 },
  { 415, 3, 10, 8, 5, -35 },
  { 419, 13, 48, 13, 2, -37 },
  { 497, 13, 48, 13, -3, -37 },
  { 575, 18, 18, 19, 3, -33 },
  { 616, 19, 24, 23, 2, -28 },
  { 673, 6, 10, 9, -2, -4 },
  { 681, 9, 2, 12, 2, -16 },
  { 684, 3, 3, 10, 1, -3 },
  { 686, 20, 36, 16, -2, -33 },
  { 776, 19, 33, 22, 2, -33 },
  { 855, 11, 33, 22, 6, -33 },
  { 901, 20, 33, 22, 1, -33 },
  { 984, 20, 33, 22, 1, -33 },
  { 1067, 20, 33, 22, 1, -33 },
  { 1150, 20, 33, 22, 3, -33 },
  { 1233, 18, 33, 22, 2, -33 },
  { 1308, 19, 33, 22, 4, -33 },
  { 1387, 20, 33, 22, 1, -33 },
  { 1470, 18, 33, 22, 3, -33 },
  { 1545, 7, 25, 9, 1, -25 },
  { 1567, 10, 31, 8, -2, -25 },
  { 1606, 18, 19, 21, 2, -25 },
  { 1649, 17, 11, 22, 3, -21 },
  { 1673, 18, 19, 21, 1, -25 },
  { 1716, 14, 33, 18, 4, -33 },
  { 1774, 32, 42, 36, 2, -32 },
  { 1942, 22, 33, 24, -1, -33 },
  { 2033, 21, 33, 24, 2, -33 },
  { 2120, 22, 33, 26, 3, -33 },
  { 2211, 23, 33, 26, 2, -33 },
  { 2306, 22, 33, 23, 2, -33 },
  { 2397, 22, 33, 23, 2, -33 },
  { 2488, 23, 33, 27, 3, -33 },
  { 2583, 25, 33, 28, 2, -33 },
  { 2687, 8, 33, 11, 2, -33 },
  { 2720, 21, 33, 22, 1, -33 },
  { 2807, 24, 33, 25, 2, -33 },
  { 2906, 15, 33, 21, 2, -33 },
  { 2968, 31, 33, 34, 2, -33 },
  { 3096, 26, 33, 28, 2, -33 },
  { 3204, 22, 33, 27, 3, -33 },
  { 3295, 22, 33, 24, 2, -33 },
  { 3386, 23, 39, 27, 2, -33 },
  { 3499, 22, 33, 26, 2, -33 },
  { 3590, 23, 33, 24, 1, -33 },
  { 3685, 22, 33, 24, 4, -33 },
  { 3776, 23, 33, 26, 3, -33 },
  { 3871, 22, 33, 24, 4, -33 },
  { 3962, 32, 33, 36, 5, -33 },
  { 4094, 27, 33, 24, -1, -33 },
  { 4206, 22, 33, 24, 4, -33 },
  { 4297, 25, 33, 24, 0, -33 },
  { 4401, 13, 45, 10, 0, -38 },
  { 4475, 7, 36, 16, 5, -33 },
  { 4507, 13, 45, 10, -3, -38 },
  { 4581, 13, 17, 17, 2, -33 },
  { 4609, 16, 2, 17, -2, 0 },
  { 4613, 6, 6, 12, 6, -35 },
  { 4618, 18, 25, 21, 1, -25 },
  { 4675, 19, 35, 22, 1, -35 },
  { 4759, 18, 25, 21, 1, -25 },
  { 4816, 20, 35, 22, 2, -35 },
  { 4904, 18, 25, 21, 1, -25 },
  { 4961, 14, 35, 13, 3, -35 },
  { 5023, 21, 35, 22, 0, -25 },
  { 5115, 18, 35, 22, 1, -35 },
  { 5194, 8, 34, 9, 1, -34 },
  { 5228, 15, 44, 9, -6, -34 },
  { 5311, 19, 35, 19, 1, -35 },
  { 5395, 8, 35, 9, 1, -35 },
  { 5430, 32, 25, 35, 1, -25 },
  { 5530, 18, 25, 22, 1, -25 },
  { 5587, 18, 25, 22, 2, -25 },
  { 5644, 21, 35, 22, -1, -25 },
  { 5736, 19, 35, 22, 2, -25 },
  { 5820, 14, 25, 14, 1, -25 },
  { 5864, 17, 25, 20, 1, -25 },
  { 5918, 10, 31, 13, 3, -31 },
  { 5957, 18, 25, 22, 2, -25 },
  { 6014, 17, 25, 19, 3, -25 },
  { 6068, 26, 25, 30, 4, -25 },
  { 6150, 20, 25, 19, -1, -25 },
  { 6213, 22, 35, 19, -2, -25 },
  { 6310, 19, 25, 19, 0, -25 },
  { 6370, 14, 47, 13, 2, -37 },
  { 6453, 8, 39, 10, 1, -33 },
  { 6492, 15, 47, 13, -3, -37 },
  { 6581, 21, 8, 27, 3, -18 },
};

const GFXfont RobotoCondensed_ExtraLightItalic47pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic47pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic47pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC47PT7B_H_
