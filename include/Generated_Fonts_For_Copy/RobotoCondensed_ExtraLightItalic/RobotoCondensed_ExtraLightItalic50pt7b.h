#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC50PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x06, 0x04,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10,
  0x30, 0x30, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0,
  0xE0, 0x31, 0x98, 0xCC, 0x64, 0x26, 0x33, 0x19, 0x8C, 0xC6, 0x42, 0x61,
  0x00, 0x00, 0x06, 0x02, 0x00, 0x03, 0x03, 0x00, 0x01, 0x01, 0x80, 0x01,
  0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x60, 0x30, 0x00,
  0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x18, 0x0C, 0x03, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF0, 0x02, 0x03, 0x00, 0x03, 0x01, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x80, 0xC0, 0x00, 0xC0, 0x40, 0x00, 0x60, 0x60, 0x00, 0x20, 0x30,
  0x00, 0x30, 0x10, 0x00, 0x18, 0x18, 0x00, 0x08, 0x0C, 0x00, 0x0C, 0x04,
  0x00, 0x06, 0x06, 0x00, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x01, 0x81,
  0x80, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x40, 0x00, 0x60, 0x60, 0x00, 0x20,
  0x30, 0x00, 0x30, 0x10, 0x00, 0x18, 0x08, 0x00, 0x08, 0x0C, 0x00, 0x04,
  0x06, 0x00, 0x06, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xC0,
  0x1C, 0x0E, 0x03, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x30, 0x80, 0x03, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0xCC,
  0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x86, 0x00, 0x18,
  0x60, 0x03, 0x07, 0x00, 0x70, 0x38, 0x1E, 0x01, 0xFF, 0x80, 0x07, 0xE0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xC1, 0x80, 0x03, 0x03, 0x00,
  0x06, 0x02, 0x00, 0x08, 0x04, 0x03, 0x30, 0x08, 0x0C, 0x60, 0x10, 0x18,
  0xC0, 0x20, 0x61, 0x00, 0xC1, 0x82, 0x01, 0x82, 0x04, 0x03, 0x0C, 0x0C,
  0x0C, 0x30, 0x18, 0x18, 0xC0, 0x10, 0x61, 0x80, 0x3F, 0x86, 0x00, 0x3E,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x07, 0x80, 0x04,
  0x3F, 0x80, 0x18, 0xE1, 0x80, 0x61, 0x81, 0x01, 0x86, 0x03, 0x03, 0x0C,
  0x06, 0x0C, 0x10, 0x0C, 0x30, 0x60, 0x18, 0x40, 0xC0, 0x31, 0x81, 0x80,
  0x46, 0x03, 0x00, 0x88, 0x06, 0x03, 0x30, 0x0C, 0x06, 0x00, 0x08, 0x18,
  0x00, 0x18, 0x60, 0x00, 0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0x83, 0x00, 0x06, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06,
  0x01, 0x80, 0x0C, 0x06, 0x00, 0x08, 0x1C, 0x00, 0x18, 0x70, 0x00, 0x31,
  0xC0, 0x00, 0x36, 0x00, 0x00, 0x78, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0xC0, 0x00, 0x39, 0x80, 0x00, 0xE1, 0x80, 0x63, 0x83, 0x00,
  0x86, 0x03, 0x03, 0x18, 0x07, 0x06, 0x30, 0x06, 0x0C, 0xC0, 0x06, 0x31,
  0x80, 0x0C, 0x63, 0x00, 0x0D, 0x86, 0x00, 0x1B, 0x0C, 0x00, 0x1C, 0x18,
  0x00, 0x30, 0x30, 0x00, 0x70, 0x70, 0x01, 0xF0, 0x70, 0x0E, 0x60, 0x78,
  0x70, 0x60, 0x7F, 0xC0, 0xC0, 0x08, 0x00, 0x00, 0x32, 0x66, 0x66, 0x4C,
  0xCC, 0x00, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x40, 0x00, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x0F, 0x03, 0x0F, 0x7C, 0x47, 0xC1,
  0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x06, 0x60, 0x01,
  0x8C, 0x00, 0x60, 0xC0, 0x18, 0x18, 0x06, 0x01, 0x81, 0xC0, 0x30, 0x10,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x0C, 0x30, 0xC3, 0x18, 0x61,
  0x8C, 0x71, 0x84, 0x00, 0xFF, 0xFF, 0xC0, 0x6E, 0xE0, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01, 0xC0, 0xC0,
  0x38, 0x06, 0x03, 0x00, 0x60, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x08, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x30, 0x00,
  0x33, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x22, 0x00,
  0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60,
  0x00, 0x44, 0x00, 0x0C, 0x40, 0x00, 0xCC, 0x00, 0x0C, 0x40, 0x01, 0x84,
  0x00, 0x18, 0x40, 0x01, 0x86, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x60,
  0x30, 0x0C, 0x03, 0x81, 0x80, 0x1F, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x60,
  0x38, 0x3F, 0x1E, 0x6F, 0x0D, 0x81, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x70, 0x38, 0x07, 0x00, 0xE0, 0x30,
  0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18,
  0x60, 0x00, 0xC6, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0x80, 0x03, 0xFE, 0x00, 0x78, 0x18, 0x03, 0x00, 0x60, 0x30, 0x03,
  0x03, 0x00, 0x0C, 0x18, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x18, 0x00, 0x18, 0x80, 0x00,
  0xC6, 0x00, 0x04, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0E, 0x00, 0x30, 0x30,
  0x03, 0x00, 0xE0, 0x70, 0x03, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0x60, 0x00, 0x1B, 0x00,
  0x01, 0xB0, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x0C, 0x60, 0x00, 0xC3,
  0x00, 0x06, 0x10, 0x00, 0x61, 0x80, 0x06, 0x0C, 0x00, 0x60, 0x60, 0x03,
  0x03, 0x00, 0x30, 0x18, 0x03, 0x00, 0x80, 0x18, 0x0C, 0x01, 0x80, 0x60,
  0x18, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x04, 0x0C, 0x00,
  0x60, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x7C, 0x00, 0x6F, 0xF8,
  0x03, 0xC0, 0xE0, 0x18, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00,
  0x18, 0x60, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x03,
  0xF8, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x87, 0xC0, 0x23, 0xFE, 0x0D, 0xC0, 0xE1, 0xE0, 0x0C, 0x38, 0x00,
  0xC6, 0x00, 0x19, 0xC0, 0x03, 0x30, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00,
  0xD8, 0x00, 0x1B, 0x00, 0x03, 0x40, 0x00, 0x48, 0x00, 0x19, 0x00, 0x03,
  0x20, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xC1, 0x80, 0x18,
  0x30, 0x06, 0x03, 0x83, 0x80, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x0E, 0x07,
  0x00, 0x60, 0x0E, 0x03, 0x00, 0x18, 0x1C, 0x00, 0x60, 0x60, 0x00, 0x81,
  0x80, 0x03, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00,
  0x06, 0x0C, 0x00, 0x30, 0x18, 0x01, 0xC0, 0x70, 0x0E, 0x00, 0xE0, 0x70,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x70, 0x38, 0x03, 0x00, 0x70, 0x18,
  0x00, 0xC0, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00,
  0x61, 0x80, 0x01, 0x84, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x61,
  0x00, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x30, 0x03, 0x00, 0xE0,
  0x38, 0x00, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x80,
  0xE0, 0x70, 0x70, 0x0E, 0x18, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x0D, 0x80,
  0x03, 0x60, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0xEC,
  0x00, 0x39, 0x80, 0x1E, 0x60, 0x0D, 0x8C, 0x0E, 0xC3, 0xFF, 0x30, 0x3F,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x0F,
  0xE0, 0x03, 0xE0, 0x00, 0x0E, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0xE1, 0x80, 0x01, 0xC0, 0x70, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01,
  0x80, 0x60, 0x18, 0x0C, 0x07, 0x01, 0x80, 0x40, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFC,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x00,
  0x03, 0xF0, 0x0F, 0xF0, 0x70, 0x30, 0xC0, 0x73, 0x00, 0x6E, 0x00, 0xD8,
  0x01, 0xB0, 0x03, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x10, 0x06, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x00, 0x20, 0x60, 0x07, 0xC0, 0x0C, 0x18, 0x03, 0xFC, 0x03, 0x0C,
  0x01, 0x81, 0x80, 0xC2, 0x00, 0xC0, 0x60, 0x31, 0x80, 0x60, 0x18, 0x04,
  0x60, 0x30, 0x04, 0x01, 0x30, 0x0C, 0x03, 0x00, 0x4C, 0x06, 0x00, 0xC0,
  0x32, 0x01, 0x80, 0x30, 0x0D, 0x80, 0xC0, 0x08, 0x03, 0x60, 0x30, 0x02,
  0x00, 0xD0, 0x0C, 0x01, 0x80, 0x34, 0x02, 0x00, 0x60, 0x0B, 0x01, 0x80,
  0x18, 0x06, 0xC0, 0x60, 0x04, 0x01, 0xB0, 0x18, 0x03, 0x00, 0x6C, 0x04,
  0x00, 0xC0, 0x12, 0x01, 0x00, 0x30, 0x0C, 0x80, 0x40, 0x18, 0x03, 0x20,
  0x10, 0x06, 0x01, 0x88, 0x04, 0x03, 0x80, 0x62, 0x01, 0x01, 0xA0, 0x30,
  0xC0, 0x60, 0xCC, 0x18, 0x30, 0x1C, 0x63, 0x8C, 0x0C, 0x03, 0xF0, 0x7E,
  0x03, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x64, 0x00, 0x00, 0x88, 0x00, 0x03, 0x18, 0x00,
  0x04, 0x30, 0x00, 0x18, 0x60, 0x00, 0x20, 0xC0, 0x00, 0xC1, 0x80, 0x01,
  0x83, 0x00, 0x06, 0x02, 0x00, 0x0C, 0x04, 0x00, 0x30, 0x0C, 0x00, 0x60,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x00,
  0x80, 0x60, 0x01, 0x00, 0xC0, 0x03, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x08, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x61, 0x80, 0x00, 0x43,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x60, 0x07, 0x01, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30,
  0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x20, 0x00, 0xC1, 0x80,
  0x07, 0x06, 0x00, 0x78, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0x80, 0x1C,
  0x04, 0x00, 0x18, 0x30, 0x00, 0x70, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C,
  0x00, 0x04, 0x30, 0x00, 0x10, 0x80, 0x00, 0x46, 0x00, 0x03, 0x18, 0x00,
  0x0C, 0x60, 0x00, 0x31, 0x80, 0x01, 0x86, 0x00, 0x06, 0x10, 0x00, 0x30,
  0xC0, 0x01, 0x83, 0x00, 0x1E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0x80, 0xE0, 0x1C, 0x00, 0xE0, 0x70,
  0x00, 0xC0, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x18, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x33, 0x00, 0x00, 0x46, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x08, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x60, 0x30, 0x01, 0x80, 0x38, 0x0E,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x06, 0x00, 0x78, 0x06, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x06, 0x00,
  0x06, 0x06, 0x00, 0x06, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x08, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x02, 0x18, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x18, 0x00, 0x06, 0x10, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00,
  0x08, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60, 0x00,
  0x70, 0x60, 0x00, 0x60, 0x40, 0x00, 0xC0, 0xC0, 0x03, 0x80, 0xC0, 0x0F,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x0F, 0xFC, 0x60, 0x0F, 0xFC, 0x60, 0x00,
  0x0C, 0x40, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x30, 0x00, 0x30, 0x38, 0x00, 0xE0, 0x1C, 0x03,
  0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C,
  0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x20, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x18, 0x10, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x08, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x60, 0x00, 0x0C, 0x08,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x04, 0x0C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x18, 0x30, 0x00, 0x02, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18,
  0x18, 0x00, 0x03, 0x02, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x18, 0x01,
  0x80, 0x60, 0x0C, 0x00, 0xC0, 0x70, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x18, 0x00,
  0x38, 0x06, 0x00, 0x1C, 0x01, 0x80, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x10,
  0x03, 0x80, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x00, 0xC0, 0x30, 0x00,
  0x30, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x06, 0x78, 0x00, 0x01, 0xB3,
  0x00, 0x00, 0x58, 0xC0, 0x00, 0x3C, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x06, 0x00, 0x08, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00,
  0x60, 0x06, 0x00, 0x0C, 0x01, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x30,
  0x00, 0x1C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81,
  0xA0, 0x00, 0x03, 0x60, 0x68, 0x00, 0x00, 0xD8, 0x13, 0x00, 0x00, 0x6C,
  0x0C, 0xC0, 0x00, 0x1B, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0xCC, 0x00, 0x03,
  0x30, 0x31, 0x00, 0x01, 0x8C, 0x0C, 0x60, 0x00, 0x42, 0x02, 0x18, 0x00,
  0x31, 0x81, 0x86, 0x00, 0x08, 0x60, 0x61, 0x80, 0x06, 0x18, 0x18, 0x60,
  0x03, 0x06, 0x06, 0x08, 0x00, 0xC1, 0x81, 0x83, 0x00, 0x60, 0x40, 0x40,
  0xC0, 0x18, 0x30, 0x30, 0x30, 0x0C, 0x0C, 0x0C, 0x0C, 0x03, 0x03, 0x03,
  0x01, 0x01, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x30, 0x30, 0x18, 0x30, 0x08,
  0x08, 0x06, 0x0C, 0x06, 0x06, 0x01, 0x86, 0x01, 0x81, 0x80, 0x61, 0x80,
  0x60, 0x60, 0x08, 0xC0, 0x18, 0x18, 0x02, 0x30, 0x06, 0x06, 0x00, 0xD8,
  0x03, 0x01, 0x00, 0x36, 0x00, 0xC0, 0xC0, 0x0F, 0x00, 0x30, 0x30, 0x03,
  0xC0, 0x0C, 0x0C, 0x00, 0x60, 0x03, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x1E, 0x00, 0x01, 0x83, 0xC0, 0x00,
  0x30, 0x68, 0x00, 0x06, 0x0D, 0x80, 0x01, 0x81, 0xB0, 0x00, 0x30, 0x33,
  0x00, 0x06, 0x0C, 0x60, 0x00, 0xC1, 0x8C, 0x00, 0x18, 0x30, 0xC0, 0x03,
  0x06, 0x18, 0x00, 0xC0, 0xC1, 0x00, 0x18, 0x18, 0x30, 0x03, 0x06, 0x06,
  0x00, 0x60, 0xC0, 0x60, 0x0C, 0x18, 0x0C, 0x01, 0x83, 0x01, 0x80, 0x60,
  0x60, 0x18, 0x0C, 0x0C, 0x03, 0x01, 0x83, 0x00, 0x20, 0x30, 0x60, 0x06,
  0x06, 0x0C, 0x00, 0xC0, 0xC1, 0x80, 0x0C, 0x30, 0x30, 0x01, 0x86, 0x04,
  0x00, 0x30, 0xC1, 0x80, 0x03, 0x18, 0x30, 0x00, 0x63, 0x06, 0x00, 0x04,
  0x40, 0xC0, 0x00, 0xD8, 0x18, 0x00, 0x1B, 0x02, 0x00, 0x01, 0xE0, 0xC0,
  0x00, 0x3C, 0x18, 0x00, 0x07, 0x83, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x38, 0x03, 0x80,
  0x1C, 0x07, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x1C, 0x00,
  0x02, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x02, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x60, 0x60, 0x00,
  0xC0, 0x30, 0x01, 0x80, 0x1C, 0x07, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x06, 0x00, 0x38, 0x06, 0x00,
  0x0C, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x0C, 0x00,
  0x06, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x1C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x38, 0x03, 0x80,
  0x1C, 0x07, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x00,
  0x02, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x10, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x60, 0x60, 0x00,
  0xC0, 0x30, 0x01, 0x80, 0x3C, 0x07, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x06, 0x00, 0x38, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00,
  0x06, 0x06, 0x00, 0x06, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00,
  0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x00,
  0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x18, 0x00, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x30, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x01,
  0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x60, 0x00,
  0xC0, 0x40, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x06, 0x07, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x18, 0x60, 0x00,
  0x30, 0x60, 0x00, 0x30, 0x70, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x1C, 0x03,
  0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF8, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x18, 0x60, 0x00,
  0x0C, 0x30, 0x00, 0x04, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x82, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x20, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x06, 0x18,
  0x00, 0x03, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x08,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x01, 0x80, 0x03, 0x80, 0xC0, 0x01, 0x80, 0x70, 0x03, 0x80, 0x1C, 0x03,
  0x80, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x1C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x30, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x30,
  0x00, 0xC0, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x08,
  0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x10, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x60, 0x00, 0x04,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xD8, 0x00, 0x18, 0x00, 0x1B, 0x00, 0x07, 0x00, 0x03, 0x60, 0x00, 0xE0,
  0x00, 0xCC, 0x00, 0x16, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x03, 0x30, 0x00,
  0xD8, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x06, 0x60, 0x06, 0x18,
  0x00, 0x8C, 0x00, 0xC1, 0x00, 0x31, 0x80, 0x18, 0x30, 0x06, 0x30, 0x06,
  0x06, 0x01, 0x82, 0x00, 0xC0, 0xC0, 0x30, 0x40, 0x18, 0x18, 0x04, 0x08,
  0x06, 0x03, 0x01, 0x81, 0x00, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C,
  0x06, 0x06, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x30, 0x20, 0x18, 0x10, 0x06,
  0x0C, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x18, 0x60, 0x0C, 0x30,
  0x03, 0x0C, 0x01, 0x86, 0x00, 0x61, 0x00, 0x10, 0xC0, 0x0C, 0x60, 0x02,
  0x30, 0x01, 0x8C, 0x00, 0x46, 0x00, 0x13, 0x00, 0x0C, 0x80, 0x02, 0x60,
  0x01, 0xB0, 0x00, 0x48, 0x00, 0x36, 0x00, 0x0B, 0x00, 0x06, 0x80, 0x01,
  0x60, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x1C,
  0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x07, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x38,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xCE, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x03, 0x98, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x01, 0xC0,
  0x01, 0x80, 0x18, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1B, 0x80, 0x00,
  0x63, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x18,
  0x18, 0x00, 0x60, 0x30, 0x01, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x38, 0x00, 0x80, 0x60, 0x01, 0x81, 0x80, 0x03, 0x07, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x19, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x03,
  0xF0, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0xC1,
  0x83, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x81, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x20, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x80, 0x01, 0xFC,
  0x07, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x3F, 0x00, 0xFC, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x78, 0x03, 0xC0, 0x36, 0x01, 0xB0, 0x18, 0x80,
  0xC4, 0x0C, 0x30, 0x61, 0x86, 0x0C, 0x30, 0x63, 0x01, 0x18, 0x09, 0x80,
  0x6C, 0x03, 0xC0, 0x1E, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC7,
  0x18, 0x63, 0x0C, 0x60, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1E, 0x07, 0x03,
  0x00, 0x60, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x38,
  0x01, 0x8E, 0x00, 0x23, 0x00, 0x0C, 0x60, 0x01, 0x98, 0x00, 0x33, 0x00,
  0x06, 0x60, 0x01, 0xCC, 0x00, 0x31, 0x80, 0x0E, 0x30, 0x07, 0xC3, 0x01,
  0xD8, 0x3F, 0xE3, 0x03, 0xF0, 0x60, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x3F, 0x00, 0xCF, 0xFC, 0x0D, 0xC0, 0xE0, 0xF0, 0x06, 0x0E, 0x00,
  0x30, 0xC0, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80,
  0x03, 0x18, 0x00, 0x31, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x02, 0x30,
  0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x62, 0x00, 0x06, 0x60, 0x00, 0xC6,
  0x00, 0x0C, 0x60, 0x01, 0x87, 0x00, 0x18, 0x78, 0x03, 0x04, 0xC0, 0xE0,
  0xC7, 0xFC, 0x0C, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xE0, 0x38,
  0x30, 0x06, 0x18, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x03, 0x60,
  0x00, 0xD8, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x48, 0x00, 0x33,
  0x00, 0x0C, 0xC0, 0x06, 0x30, 0x01, 0x86, 0x00, 0xC1, 0xC0, 0xE0, 0x3F,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0xF8, 0x30, 0x0F, 0xF8, 0x80, 0x70, 0x36, 0x03, 0x00, 0x78,
  0x18, 0x00, 0xE0, 0x60, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x10, 0x60,
  0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x40, 0x00,
  0xC3, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83,
  0x00, 0x06, 0x0C, 0x00, 0x10, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x01, 0x00,
  0x1C, 0x06, 0x00, 0xF0, 0x1C, 0x0E, 0xC0, 0x3F, 0xF2, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0E, 0x07, 0x03, 0x00, 0x60, 0xC0,
  0x06, 0x30, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x64, 0x00,
  0x0D, 0x80, 0x01, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0xC0, 0x70, 0x0F, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0x08, 0x00, 0xFC, 0x03, 0x88, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x0F, 0xFE, 0x1F, 0xF8, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3E, 0x0C, 0x03, 0xFE, 0x30, 0x1C,
  0x0C, 0x80, 0xC0, 0x1E, 0x06, 0x00, 0x38, 0x18, 0x00, 0xE0, 0xC0, 0x01,
  0x83, 0x00, 0x06, 0x18, 0x00, 0x10, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x06,
  0x00, 0x0C, 0x10, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x10,
  0x30, 0x00, 0xC0, 0x40, 0x07, 0x01, 0x80, 0x3C, 0x07, 0x03, 0xB0, 0x0F,
  0xFC, 0xC0, 0x0F, 0xC2, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x10, 0x01, 0xC0, 0x60, 0x06, 0x01,
  0xC0, 0x70, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x41, 0xF0, 0x18, 0xFF, 0x83, 0x30, 0x30, 0x6C, 0x03, 0x0F, 0x00,
  0x61, 0xC0, 0x0C, 0x70, 0x01, 0x8E, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00,
  0xC6, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x00, 0x66, 0x00, 0x08, 0xC0, 0x03,
  0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x98, 0x00, 0x33, 0x00, 0x04,
  0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x20, 0x00, 0xCC, 0x00, 0x19,
  0x80, 0x02, 0x00, 0x03, 0x81, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x70, 0xC0, 0x0E,
  0x0C, 0x01, 0xC0, 0xC0, 0x38, 0x0C, 0x07, 0x00, 0xC0, 0xE0, 0x18, 0x1C,
  0x01, 0x83, 0x80, 0x18, 0x70, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x01, 0xB8,
  0x00, 0x36, 0xC0, 0x03, 0xCC, 0x00, 0x38, 0x60, 0x03, 0x06, 0x00, 0x30,
  0x30, 0x02, 0x03, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x06,
  0x00, 0xC0, 0x60, 0x06, 0x04, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x00, 0x0C, 0x1F, 0x00, 0x7C, 0x03,
  0x1F, 0xF0, 0x7F, 0xC0, 0xCC, 0x0C, 0x30, 0x38, 0x36, 0x01, 0x98, 0x06,
  0x0F, 0x00, 0x6C, 0x01, 0x83, 0x80, 0x1E, 0x00, 0x31, 0xC0, 0x07, 0x00,
  0x0C, 0x70, 0x01, 0xC0, 0x03, 0x18, 0x00, 0x60, 0x00, 0xC6, 0x00, 0x18,
  0x00, 0x61, 0x80, 0x06, 0x00, 0x18, 0x40, 0x01, 0x80, 0x06, 0x30, 0x00,
  0x60, 0x01, 0x8C, 0x00, 0x10, 0x00, 0x63, 0x00, 0x0C, 0x00, 0x18, 0xC0,
  0x03, 0x00, 0x0C, 0x30, 0x00, 0xC0, 0x03, 0x18, 0x00, 0x30, 0x00, 0xC6,
  0x00, 0x08, 0x00, 0x31, 0x80, 0x06, 0x00, 0x0C, 0x60, 0x01, 0x80, 0x02,
  0x18, 0x00, 0x60, 0x01, 0x84, 0x00, 0x18, 0x00, 0x63, 0x00, 0x06, 0x00,
  0x18, 0xC0, 0x01, 0x00, 0x06, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x04, 0x1F,
  0x01, 0x8F, 0xF8, 0x33, 0x03, 0x06, 0xC0, 0x30, 0xF0, 0x06, 0x1C, 0x00,
  0xC3, 0x80, 0x18, 0xE0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01,
  0x8C, 0x00, 0x31, 0x00, 0x06, 0x60, 0x00, 0x8C, 0x00, 0x31, 0x80, 0x06,
  0x30, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x46, 0x00, 0x18,
  0xC0, 0x03, 0x18, 0x00, 0x62, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x20,
  0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1C, 0x06, 0x06, 0x00, 0x61, 0xC0, 0x0C,
  0x30, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D,
  0x80, 0x01, 0xA0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x16,
  0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x06, 0x60, 0x00, 0xCC,
  0x00, 0x30, 0xC0, 0x06, 0x18, 0x01, 0x81, 0xC0, 0xE0, 0x1F, 0xF8, 0x01,
  0xFC, 0x00, 0x01, 0x0F, 0xC0, 0x0C, 0xFF, 0xC0, 0x37, 0x03, 0x80, 0xF0,
  0x06, 0x03, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x20, 0x00, 0xC1, 0x80, 0x03,
  0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x04,
  0x00, 0x0C, 0x30, 0x00, 0x20, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00,
  0x18, 0x20, 0x00, 0x61, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60,
  0x70, 0x01, 0x81, 0xE0, 0x0C, 0x04, 0xC0, 0xE0, 0x31, 0xFF, 0x00, 0xC3,
  0xF8, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF8, 0x30, 0x3F, 0xE3, 0x07, 0x03,
  0x20, 0xC0, 0x1E, 0x18, 0x00, 0xE1, 0x80, 0x06, 0x30, 0x00, 0x63, 0x00,
  0x04, 0x60, 0x00, 0x46, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x40,
  0x00, 0xCC, 0x00, 0x08, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C,
  0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x10, 0xC0, 0x03, 0x04, 0x00, 0x70,
  0x60, 0x0F, 0x07, 0x01, 0xB0, 0x3F, 0xF3, 0x00, 0xFC, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x04,
  0x3E, 0x19, 0xF8, 0x37, 0x00, 0x68, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x70, 0x38, 0x30, 0x07, 0x18, 0x00, 0xC6,
  0x00, 0x31, 0x80, 0x0C, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30,
  0x00, 0xC6, 0x00, 0x61, 0xC0, 0x70, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x07, 0xFF, 0xFF, 0xC1,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x20, 0x0C, 0x00, 0x80, 0x18, 0x03, 0xF0, 0x3E, 0x00, 0x10, 0x00, 0x66,
  0x00, 0x08, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x88,
  0x00, 0x33, 0x00, 0x04, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x20,
  0x00, 0xCC, 0x00, 0x11, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0,
  0x03, 0x10, 0x00, 0x62, 0x00, 0x18, 0x40, 0x03, 0x0C, 0x00, 0xE1, 0x80,
  0x1C, 0x30, 0x07, 0x83, 0x03, 0xA0, 0x7F, 0xCC, 0x03, 0xF0, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0x2C, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x18, 0x00,
  0xC6, 0x00, 0x61, 0x80, 0x18, 0x60, 0x0C, 0x08, 0x03, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x06, 0x00, 0x41, 0x80, 0x18,
  0x40, 0x06, 0x30, 0x01, 0x88, 0x00, 0x66, 0x00, 0x19, 0x00, 0x02, 0xC0,
  0x00, 0xB0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x3C, 0x00, 0xE0, 0x06, 0xC0, 0x0E, 0x00, 0x6C, 0x00, 0xE0, 0x0C,
  0xC0, 0x1E, 0x00, 0xCC, 0x01, 0x60, 0x0C, 0xC0, 0x36, 0x01, 0x8C, 0x03,
  0x20, 0x18, 0x40, 0x62, 0x03, 0x04, 0x06, 0x30, 0x30, 0x40, 0xC3, 0x03,
  0x06, 0x0C, 0x30, 0x60, 0x61, 0x83, 0x06, 0x06, 0x18, 0x30, 0xC0, 0x61,
  0x03, 0x0C, 0x06, 0x30, 0x31, 0x80, 0x63, 0x03, 0x18, 0x06, 0x60, 0x11,
  0x80, 0x66, 0x01, 0x30, 0x06, 0xC0, 0x13, 0x00, 0x6C, 0x01, 0x60, 0x06,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x30, 0x01,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x18, 0x18, 0x00, 0xE0, 0x30,
  0x03, 0x00, 0xC0, 0x18, 0x01, 0x80, 0xC0, 0x06, 0x07, 0x00, 0x18, 0x18,
  0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00, 0x01, 0x98, 0x00, 0x06, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x36,
  0x00, 0x01, 0x8C, 0x00, 0x0E, 0x30, 0x00, 0x30, 0x60, 0x01, 0x81, 0x80,
  0x0C, 0x03, 0x00, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x60, 0x70,
  0x01, 0x83, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x0C,
  0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x01, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0xC0,
  0x00, 0x41, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x30, 0x00,
  0x06, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0x02, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x1C, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60,
  0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0x00, 0x80, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x80, 0x0C, 0xC1, 0x80, 0x1B, 0x01, 0x80, 0x26, 0x01,
  0x80, 0xD8, 0x01, 0x83, 0x30, 0x01, 0xFC, 0x00, 0x01, 0xF0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 36, 10, 1, -36 },
  { 37, 9, 10, 13, 5, -38 },
  { 49, 25, 36, 24, 1, -36 },
  { 162, 20, 46, 24, 2, -41 },
  { 277, 23, 36, 31, 5, -36 },
  { 381, 23, 37, 26, 1, -36 },
  { 488, 4, 10, 8, 5, -38 },
  { 493, 14, 51, 14, 2, -40 },
  { 583, 14, 52, 14, -3, -40 },
  { 674, 19, 20, 20, 3, -36 },
  { 722, 20, 26, 24, 2, -30 },
  { 787, 6, 11, 9, -2, -4 },
  { 796, 9, 2, 13, 2, -17 },
  { 799, 4, 3, 11, 1, -3 },
  { 801, 21, 39, 17, -2, -36 },
  { 904, 20, 36, 24, 2, -36 },
  { 994, 11, 36, 24, 7, -36 },
  { 1044, 21, 36, 24, 1, -36 },
  { 1139, 21, 36, 24, 1, -36 },
  { 1234, 21, 36, 24, 1, -36 },
  { 1329, 21, 36, 24, 3, -36 },
  { 1424, 19, 36, 24, 2, -36 },
  { 1510, 20, 36, 24, 4, -36 },
  { 1600, 22, 36, 24, 1, -36 },
  { 1699, 18, 36, 24, 4, -36 },
  { 1780, 7, 26, 9, 1, -26 },
  { 1803, 10, 33, 9, -2, -26 },
  { 1845, 19, 20, 22, 2, -26 },
  { 1893, 18, 12, 24, 3, -22 },
  { 1920, 19, 20, 22, 1, -26 },
  { 1968, 15, 36, 19, 4, -36 },
  { 2036, 34, 46, 39, 2, -35 },
  { 2232, 23, 36, 26, -1, -36 },
  { 2336, 22, 36, 26, 2, -36 },
  { 2435, 23, 36, 27, 3, -36 },
  { 2539, 24, 36, 28, 2, -36 },
  { 2647, 24, 36, 24, 2, -36 },
  { 2755, 24, 36, 24, 2, -36 },
  { 2863, 24, 36, 29, 3, -36 },
  { 2971, 27, 36, 30, 2, -36 },
  { 3093, 8, 36, 12, 2, -36 },
  { 3129, 22, 36, 23, 1, -36 },
  { 3228, 26, 36, 27, 2, -36 },
  { 3345, 17, 36, 22, 2, -36 },
  { 3422, 34, 36, 36, 2, -36 },
  { 3575, 27, 36, 30, 2, -36 },
  { 3697, 24, 36, 28, 3, -36 },
  { 3805, 24, 36, 26, 2, -36 },
  { 3913, 24, 42, 28, 3, -36 },
  { 4039, 24, 36, 27, 2, -36 },
  { 4147, 24, 36, 25, 1, -36 },
  { 4255, 23, 36, 25, 5, -36 },
  { 4359, 25, 36, 28, 3, -36 },
  { 4472, 24, 36, 26, 4, -36 },
  { 4580, 35, 36, 38, 5, -36 },
  { 4738, 28, 36, 26, -1, -36 },
  { 4864, 23, 36, 25, 5, -36 },
  { 4968, 26, 36, 25, 0, -36 },
  { 5085, 14, 49, 10, 0, -41 },
  { 5171, 7, 39, 17, 5, -36 },
  { 5206, 14, 49, 10, -3, -41 },
  { 5292, 13, 18, 18, 3, -36 },
  { 5322, 17, 2, 18, -2, 0 },
  { 5327, 5, 7, 13, 7, -38 },
  { 5332, 19, 26, 23, 1, -26 },
  { 5394, 20, 38, 24, 1, -38 },
  { 5489, 18, 26, 22, 2, -26 },
  { 5548, 22, 38, 24, 2, -38 },
  { 5653, 19, 26, 22, 1, -26 },
  { 5715, 15, 39, 14, 3, -39 },
  { 5789, 22, 36, 24, 0, -26 },
  { 5888, 19, 38, 23, 1, -38 },
  { 5979, 9, 35, 10, 1, -35 },
  { 6019, 16, 45, 10, -6, -35 },
  { 6109, 20, 38, 21, 1, -38 },
  { 6204, 9, 38, 10, 1, -38 },
  { 6247, 34, 26, 37, 1, -26 },
  { 6358, 19, 26, 23, 1, -26 },
  { 6420, 19, 26, 24, 2, -26 },
  { 6482, 22, 36, 24, -1, -26 },
  { 6581, 20, 36, 24, 2, -26 },
  { 6671, 15, 26, 15, 1, -26 },
  { 6720, 18, 26, 22, 1, -26 },
  { 6779, 11, 33, 14, 3, -33 },
  { 6825, 19, 26, 23, 3, -26 },
  { 6887, 18, 26, 21, 3, -26 },
  { 6946, 28, 26, 32, 4, -26 },
  { 7037, 22, 26, 21, -1, -26 },
  { 7109, 23, 36, 20, -2, -26 },
  { 7213, 20, 26, 21, 0, -26 },
  { 7278, 15, 49, 14, 2, -39 },
  { 7370, 8, 43, 10, 1, -36 },
  { 7413, 16, 49, 14, -3, -39 },
  { 7511, 23, 8, 29, 3, -19 },
};

const GFXfont RobotoCondensed_ExtraLightItalic50pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic50pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic50pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC50PT7B_H_
