#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/RobotoCondensed_ExtraLightItalic
// Headers: 67

#include "RobotoCondensed_ExtraLightItalic6pt7b.h"
#include "RobotoCondensed_ExtraLightItalic7pt7b.h"
#include "RobotoCondensed_ExtraLightItalic8pt7b.h"
#include "RobotoCondensed_ExtraLightItalic9pt7b.h"
#include "RobotoCondensed_ExtraLightItalic10pt7b.h"
#include "RobotoCondensed_ExtraLightItalic11pt7b.h"
#include "RobotoCondensed_ExtraLightItalic12pt7b.h"
#include "RobotoCondensed_ExtraLightItalic13pt7b.h"
#include "RobotoCondensed_ExtraLightItalic14pt7b.h"
#include "RobotoCondensed_ExtraLightItalic15pt7b.h"
#include "RobotoCondensed_ExtraLightItalic16pt7b.h"
#include "RobotoCondensed_ExtraLightItalic17pt7b.h"
#include "RobotoCondensed_ExtraLightItalic18pt7b.h"
#include "RobotoCondensed_ExtraLightItalic19pt7b.h"
#include "RobotoCondensed_ExtraLightItalic20pt7b.h"
#include "RobotoCondensed_ExtraLightItalic21pt7b.h"
#include "RobotoCondensed_ExtraLightItalic22pt7b.h"
#include "RobotoCondensed_ExtraLightItalic23pt7b.h"
#include "RobotoCondensed_ExtraLightItalic24pt7b.h"
#include "RobotoCondensed_ExtraLightItalic25pt7b.h"
#include "RobotoCondensed_ExtraLightItalic26pt7b.h"
#include "RobotoCondensed_ExtraLightItalic27pt7b.h"
#include "RobotoCondensed_ExtraLightItalic28pt7b.h"
#include "RobotoCondensed_ExtraLightItalic29pt7b.h"
#include "RobotoCondensed_ExtraLightItalic30pt7b.h"
#include "RobotoCondensed_ExtraLightItalic31pt7b.h"
#include "RobotoCondensed_ExtraLightItalic32pt7b.h"
#include "RobotoCondensed_ExtraLightItalic33pt7b.h"
#include "RobotoCondensed_ExtraLightItalic34pt7b.h"
#include "RobotoCondensed_ExtraLightItalic35pt7b.h"
#include "RobotoCondensed_ExtraLightItalic36pt7b.h"
#include "RobotoCondensed_ExtraLightItalic37pt7b.h"
#include "RobotoCondensed_ExtraLightItalic38pt7b.h"
#include "RobotoCondensed_ExtraLightItalic39pt7b.h"
#include "RobotoCondensed_ExtraLightItalic40pt7b.h"
#include "RobotoCondensed_ExtraLightItalic41pt7b.h"
#include "RobotoCondensed_ExtraLightItalic42pt7b.h"
#include "RobotoCondensed_ExtraLightItalic43pt7b.h"
#include "RobotoCondensed_ExtraLightItalic44pt7b.h"
#include "RobotoCondensed_ExtraLightItalic45pt7b.h"
#include "RobotoCondensed_ExtraLightItalic46pt7b.h"
#include "RobotoCondensed_ExtraLightItalic47pt7b.h"
#include "RobotoCondensed_ExtraLightItalic48pt7b.h"
#include "RobotoCondensed_ExtraLightItalic49pt7b.h"
#include "RobotoCondensed_ExtraLightItalic50pt7b.h"
#include "RobotoCondensed_ExtraLightItalic51pt7b.h"
#include "RobotoCondensed_ExtraLightItalic52pt7b.h"
#include "RobotoCondensed_ExtraLightItalic53pt7b.h"
#include "RobotoCondensed_ExtraLightItalic54pt7b.h"
#include "RobotoCondensed_ExtraLightItalic55pt7b.h"
#include "RobotoCondensed_ExtraLightItalic56pt7b.h"
#include "RobotoCondensed_ExtraLightItalic57pt7b.h"
#include "RobotoCondensed_ExtraLightItalic58pt7b.h"
#include "RobotoCondensed_ExtraLightItalic59pt7b.h"
#include "RobotoCondensed_ExtraLightItalic60pt7b.h"
#include "RobotoCondensed_ExtraLightItalic61pt7b.h"
#include "RobotoCondensed_ExtraLightItalic62pt7b.h"
#include "RobotoCondensed_ExtraLightItalic63pt7b.h"
#include "RobotoCondensed_ExtraLightItalic64pt7b.h"
#include "RobotoCondensed_ExtraLightItalic65pt7b.h"
#include "RobotoCondensed_ExtraLightItalic66pt7b.h"
#include "RobotoCondensed_ExtraLightItalic67pt7b.h"
#include "RobotoCondensed_ExtraLightItalic68pt7b.h"
#include "RobotoCondensed_ExtraLightItalic69pt7b.h"
#include "RobotoCondensed_ExtraLightItalic70pt7b.h"
#include "RobotoCondensed_ExtraLightItalic71pt7b.h"
#include "RobotoCondensed_ExtraLightItalic72pt7b.h"
