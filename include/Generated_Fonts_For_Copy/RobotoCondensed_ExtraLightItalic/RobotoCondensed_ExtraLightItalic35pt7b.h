#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC35PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x20, 0x82, 0x18, 0x61, 0x04, 0x10, 0x43, 0x08, 0x20, 0x82,
  0x08, 0x61, 0x00, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x4D, 0x34, 0xB2, 0x8A,
  0x29, 0x80, 0x00, 0x41, 0x00, 0x20, 0x80, 0x30, 0x80, 0x10, 0x40, 0x08,
  0x20, 0x0C, 0x20, 0x04, 0x10, 0x3F, 0xFF, 0x03, 0x08, 0x01, 0x04, 0x00,
  0x82, 0x00, 0xC3, 0x00, 0x41, 0x00, 0x20, 0x80, 0x30, 0xC0, 0x10, 0x40,
  0x08, 0x20, 0x7F, 0xFE, 0x04, 0x10, 0x02, 0x08, 0x01, 0x0C, 0x01, 0x04,
  0x00, 0x82, 0x00, 0x43, 0x00, 0x41, 0x00, 0x00, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x0F, 0x80, 0x71, 0x80, 0x81, 0x82, 0x01, 0x0C, 0x03, 0x10,
  0x06, 0x20, 0x0C, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x98,
  0x01, 0x30, 0x06, 0x20, 0x08, 0x40, 0x30, 0xC0, 0xC0, 0xC3, 0x00, 0xFC,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x00, 0x1E, 0x00, 0x19, 0x80, 0x18,
  0x40, 0x08, 0x20, 0x44, 0x10, 0x66, 0x08, 0x23, 0x04, 0x21, 0x02, 0x30,
  0xC1, 0x10, 0x21, 0x10, 0x11, 0x90, 0x07, 0x98, 0x00, 0x08, 0x00, 0x08,
  0xF0, 0x0C, 0xCC, 0x04, 0xC2, 0x04, 0x41, 0x04, 0x20, 0x86, 0x10, 0x42,
  0x18, 0x22, 0x08, 0x13, 0x04, 0x08, 0x01, 0x08, 0x00, 0x8C, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x03, 0x30, 0x06, 0x18, 0x04, 0x08, 0x0C, 0x08, 0x0C,
  0x18, 0x08, 0x10, 0x0C, 0x30, 0x0C, 0x60, 0x04, 0xC0, 0x07, 0x00, 0x06,
  0x00, 0x0F, 0x00, 0x19, 0x00, 0x31, 0x82, 0x60, 0x82, 0x40, 0x42, 0xC0,
  0x66, 0xC0, 0x24, 0x80, 0x3C, 0xC0, 0x18, 0xC0, 0x18, 0x60, 0x28, 0x30,
  0xCC, 0x1F, 0x04, 0x2D, 0xA4, 0x90, 0x00, 0x80, 0xC0, 0xC0, 0x40, 0x40,
  0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80,
  0xC0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x18, 0x04, 0x03,
  0x00, 0x80, 0x60, 0x30, 0x08, 0x04, 0x02, 0x00, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x71, 0x1C, 0xEB, 0x80, 0xE0, 0x07, 0x00, 0x48,
  0x06, 0x60, 0x61, 0x06, 0x0C, 0x20, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x7F, 0xFE,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x33, 0x22, 0x64, 0x80, 0xFE, 0xF0, 0x00, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x00, 0x03, 0xE0, 0x18,
  0xC0, 0x81, 0x84, 0x02, 0x30, 0x08, 0x80, 0x22, 0x00, 0x98, 0x02, 0x40,
  0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0xC0, 0x1B, 0x00, 0x68, 0x01, 0x20,
  0x04, 0x80, 0x12, 0x00, 0xC8, 0x03, 0x20, 0x08, 0x80, 0x63, 0x01, 0x04,
  0x0C, 0x18, 0xE0, 0x3E, 0x00, 0x02, 0x3D, 0xCE, 0x30, 0x60, 0x81, 0x02,
  0x04, 0x18, 0x30, 0x40, 0x81, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x06,
  0x08, 0x10, 0x20, 0x01, 0xF0, 0x18, 0x60, 0xC0, 0xC6, 0x01, 0x10, 0x04,
  0xC0, 0x12, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xFF, 0xF0, 0x01,
  0xF0, 0x0E, 0x30, 0x30, 0x30, 0x40, 0x21, 0x00, 0x42, 0x00, 0x8C, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x03, 0x00, 0x7C, 0x00,
  0x0E, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x12, 0x00, 0x24, 0x00,
  0xCC, 0x01, 0x08, 0x06, 0x18, 0x18, 0x18, 0x60, 0x1F, 0x00, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x0A, 0x00, 0x48, 0x03, 0x20, 0x09, 0x80, 0x46,
  0x03, 0x10, 0x18, 0x40, 0x41, 0x02, 0x04, 0x18, 0x30, 0x40, 0xC2, 0x02,
  0x18, 0x08, 0xC0, 0x23, 0xFF, 0xF0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x07, 0xFE, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x6F,
  0x80, 0xF1, 0x81, 0x81, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x22, 0x00, 0x44, 0x00, 0x8C, 0x03, 0x08, 0x04, 0x18,
  0x10, 0x18, 0xE0, 0x1F, 0x00, 0x00, 0x70, 0x0E, 0x01, 0x80, 0x18, 0x00,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x02, 0x3E, 0x13, 0x18, 0xE0,
  0x6E, 0x01, 0x60, 0x0B, 0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x05,
  0x00, 0x68, 0x02, 0x60, 0x31, 0x03, 0x06, 0x30, 0x1F, 0x00, 0x7F, 0xFC,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x0E, 0x30, 0x30, 0x30,
  0x40, 0x21, 0x80, 0x62, 0x00, 0xC4, 0x01, 0x88, 0x02, 0x10, 0x04, 0x20,
  0x18, 0x60, 0x60, 0x63, 0x80, 0x7C, 0x03, 0x06, 0x0C, 0x04, 0x30, 0x0C,
  0x40, 0x09, 0x80, 0x12, 0x00, 0x24, 0x00, 0x48, 0x01, 0x18, 0x06, 0x10,
  0x18, 0x18, 0x60, 0x1F, 0x80, 0x07, 0x81, 0x8E, 0x30, 0x26, 0x03, 0x40,
  0x14, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x3C, 0x07, 0xC0, 0xE6, 0x3A, 0x3E, 0x60, 0x04, 0x00, 0x40, 0x08, 0x01,
  0x80, 0x30, 0x06, 0x01, 0xC0, 0xF0, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x61, 0x80, 0x0E, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x30,
  0x40, 0x83, 0x0C, 0x10, 0x00, 0x00, 0x08, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x80, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x20, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x00, 0x40, 0x00, 0x0F, 0x07, 0x30, 0x81, 0x20, 0x2C, 0x05,
  0x80, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x38, 0x38, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x06, 0x03, 0x00, 0x02, 0x06, 0x00, 0x03, 0x04, 0x00,
  0x01, 0x08, 0x0F, 0x01, 0x18, 0x18, 0xC1, 0x10, 0x20, 0x41, 0x30, 0x40,
  0xC1, 0x20, 0x40, 0x81, 0x20, 0x80, 0x81, 0x60, 0x80, 0x81, 0x41, 0x81,
  0x81, 0x41, 0x01, 0x01, 0x41, 0x01, 0x02, 0xC1, 0x01, 0x02, 0xC3, 0x03,
  0x02, 0x83, 0x02, 0x04, 0x83, 0x06, 0x04, 0x81, 0x0A, 0x08, 0x81, 0x99,
  0x10, 0xC0, 0xE1, 0xE0, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x06,
  0x80, 0x02, 0x40, 0x03, 0x20, 0x01, 0x10, 0x01, 0x88, 0x00, 0x84, 0x00,
  0xC3, 0x00, 0x41, 0x80, 0x60, 0x40, 0x20, 0x20, 0x30, 0x10, 0x10, 0x08,
  0x08, 0x04, 0x08, 0x03, 0x07, 0xFF, 0x84, 0x00, 0x42, 0x00, 0x23, 0x00,
  0x11, 0x00, 0x09, 0x80, 0x04, 0x80, 0x02, 0xC0, 0x01, 0x80, 0x0F, 0xF8,
  0x0C, 0x0C, 0x08, 0x02, 0x08, 0x03, 0x08, 0x01, 0x08, 0x01, 0x18, 0x01,
  0x18, 0x03, 0x10, 0x02, 0x10, 0x06, 0x10, 0x0C, 0x10, 0x38, 0x3F, 0xF0,
  0x30, 0x18, 0x20, 0x0C, 0x20, 0x04, 0x20, 0x06, 0x20, 0x06, 0x60, 0x06,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x18, 0xC0, 0x70, 0xFF, 0xC0,
  0x01, 0xF8, 0x01, 0x87, 0x03, 0x00, 0x81, 0x00, 0x61, 0x00, 0x11, 0x80,
  0x08, 0x80, 0x04, 0x40, 0x02, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x03, 0x20, 0x01, 0x18, 0x00, 0x8C, 0x00, 0xC2, 0x00, 0xC1, 0x80,
  0xC0, 0x71, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xF8, 0x06, 0x07, 0x02, 0x00,
  0x81, 0x00, 0x20, 0x80, 0x18, 0x40, 0x0C, 0x60, 0x02, 0x30, 0x01, 0x10,
  0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00, 0x33, 0x00, 0x19, 0x80, 0x08,
  0x80, 0x04, 0x40, 0x02, 0x20, 0x03, 0x10, 0x01, 0x98, 0x00, 0x88, 0x00,
  0xC4, 0x00, 0x42, 0x00, 0x41, 0x00, 0xC1, 0x81, 0xC0, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x86, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0xFF, 0xC1, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x86, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0xFF, 0xC1, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x01, 0xC7, 0x01, 0x80, 0xC1, 0x00, 0x21, 0x80, 0x18, 0x80,
  0x04, 0xC0, 0x02, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x01, 0xFD, 0x80, 0x04, 0xC0, 0x02,
  0x60, 0x01, 0x30, 0x00, 0x88, 0x00, 0xC4, 0x00, 0x63, 0x00, 0x20, 0x80,
  0x30, 0x30, 0xF0, 0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x21, 0x80, 0x04, 0x20,
  0x00, 0x84, 0x00, 0x30, 0x80, 0x06, 0x10, 0x00, 0x86, 0x00, 0x10, 0xC0,
  0x02, 0x10, 0x00, 0x42, 0x00, 0x18, 0x40, 0x03, 0x08, 0x00, 0x43, 0xFF,
  0xF8, 0x60, 0x01, 0x08, 0x00, 0x21, 0x00, 0x0C, 0x20, 0x01, 0x84, 0x00,
  0x21, 0x80, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x06, 0x10, 0x00,
  0xC6, 0x00, 0x10, 0xC0, 0x02, 0x00, 0x08, 0x42, 0x31, 0x88, 0x42, 0x11,
  0x88, 0x42, 0x11, 0x8C, 0x42, 0x10, 0x8C, 0x62, 0x10, 0x80, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x22, 0x00, 0xC4, 0x01, 0x08,
  0x02, 0x10, 0x0C, 0x30, 0x30, 0x30, 0xC0, 0x3E, 0x00, 0x0C, 0x00, 0xC1,
  0x80, 0x30, 0x20, 0x0C, 0x04, 0x03, 0x00, 0x80, 0x40, 0x10, 0x10, 0x06,
  0x04, 0x00, 0xC1, 0x00, 0x10, 0x40, 0x02, 0x18, 0x00, 0x46, 0x00, 0x09,
  0x80, 0x03, 0x78, 0x00, 0x71, 0x00, 0x0C, 0x30, 0x01, 0x02, 0x00, 0x20,
  0x60, 0x04, 0x04, 0x01, 0x80, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x80, 0x80,
  0x10, 0x10, 0x03, 0x06, 0x00, 0x20, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xFF, 0xF0, 0x0C,
  0x00, 0x03, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x0A, 0x00, 0x0E, 0x0A,
  0x00, 0x0A, 0x0A, 0x00, 0x1A, 0x1A, 0x00, 0x12, 0x1B, 0x00, 0x36, 0x13,
  0x00, 0x24, 0x11, 0x00, 0x64, 0x11, 0x00, 0x44, 0x11, 0x00, 0x84, 0x31,
  0x00, 0x8C, 0x31, 0x81, 0x0C, 0x20, 0x81, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x84, 0x08, 0x60, 0x8C, 0x18, 0x60, 0xC8, 0x18, 0x40,
  0x58, 0x10, 0x40, 0x50, 0x10, 0x40, 0x70, 0x10, 0xC0, 0x60, 0x10, 0xC0,
  0x60, 0x30, 0x0C, 0x00, 0x20, 0xC0, 0x02, 0x0E, 0x00, 0x20, 0xA0, 0x02,
  0x0B, 0x00, 0x60, 0x90, 0x06, 0x19, 0x00, 0x41, 0x98, 0x04, 0x10, 0x80,
  0x41, 0x08, 0x04, 0x10, 0x40, 0xC1, 0x04, 0x0C, 0x30, 0x60, 0x83, 0x02,
  0x08, 0x20, 0x20, 0x82, 0x03, 0x08, 0x20, 0x11, 0x86, 0x01, 0x18, 0x60,
  0x09, 0x06, 0x00, 0x90, 0x40, 0x0D, 0x04, 0x00, 0x70, 0x40, 0x07, 0x0C,
  0x00, 0x60, 0xC0, 0x02, 0x00, 0x01, 0xF8, 0x03, 0x87, 0x03, 0x00, 0x81,
  0x00, 0x21, 0x00, 0x11, 0x80, 0x0C, 0x80, 0x06, 0x40, 0x03, 0x60, 0x01,
  0xA0, 0x00, 0xD0, 0x00, 0x48, 0x00, 0x24, 0x00, 0x16, 0x00, 0x0B, 0x00,
  0x0D, 0x00, 0x06, 0x80, 0x02, 0x40, 0x01, 0x20, 0x01, 0x90, 0x00, 0x8C,
  0x00, 0xC2, 0x00, 0x41, 0x80, 0xC0, 0x71, 0xC0, 0x0F, 0x80, 0x00, 0x0F,
  0xFC, 0x06, 0x03, 0x02, 0x00, 0xC1, 0x00, 0x20, 0x80, 0x18, 0x40, 0x0C,
  0x60, 0x06, 0x30, 0x03, 0x10, 0x01, 0x88, 0x00, 0x84, 0x00, 0xC2, 0x00,
  0x43, 0x00, 0x61, 0x80, 0xE0, 0xFF, 0xC0, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x03, 0x87, 0x03, 0x00, 0x81,
  0x00, 0x61, 0x00, 0x11, 0x80, 0x0C, 0x80, 0x06, 0x40, 0x03, 0x60, 0x01,
  0xA0, 0x00, 0xD0, 0x00, 0x48, 0x00, 0x24, 0x00, 0x16, 0x00, 0x0B, 0x00,
  0x0D, 0x00, 0x06, 0x80, 0x02, 0x40, 0x01, 0x20, 0x01, 0x90, 0x00, 0x8C,
  0x00, 0xC2, 0x00, 0xC1, 0x80, 0xC0, 0x71, 0xC0, 0x0F, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x0F, 0xF8, 0x06, 0x03, 0x02,
  0x00, 0xC1, 0x00, 0x20, 0x80, 0x18, 0x40, 0x0C, 0x60, 0x06, 0x20, 0x03,
  0x10, 0x01, 0x08, 0x01, 0x84, 0x00, 0x86, 0x00, 0xC3, 0x01, 0x81, 0xFF,
  0x80, 0x80, 0x80, 0x40, 0x60, 0x20, 0x30, 0x30, 0x08, 0x18, 0x06, 0x08,
  0x03, 0x04, 0x00, 0x82, 0x00, 0x41, 0x00, 0x31, 0x80, 0x08, 0xC0, 0x04,
  0x00, 0x00, 0xF8, 0x01, 0xC7, 0x03, 0x00, 0x81, 0x00, 0x61, 0x80, 0x10,
  0x80, 0x08, 0x40, 0x04, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x20, 0x01, 0x90, 0x00, 0x88, 0x00, 0xC6, 0x00, 0x41,
  0x80, 0x60, 0x71, 0xE0, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x88,
  0x00, 0x44, 0x00, 0x22, 0x00, 0x13, 0x00, 0x19, 0x80, 0x0C, 0x80, 0x04,
  0x40, 0x02, 0x20, 0x01, 0x10, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x44, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x02, 0x20,
  0x01, 0x10, 0x00, 0x8C, 0x00, 0x82, 0x00, 0xC1, 0x80, 0xC0, 0x71, 0xC0,
  0x1F, 0x80, 0x00, 0xC0, 0x01, 0x60, 0x01, 0xB0, 0x00, 0xC8, 0x00, 0x44,
  0x00, 0x62, 0x00, 0x21, 0x00, 0x30, 0xC0, 0x10, 0x60, 0x18, 0x30, 0x08,
  0x08, 0x0C, 0x04, 0x04, 0x02, 0x02, 0x01, 0x02, 0x00, 0xC1, 0x00, 0x61,
  0x80, 0x10, 0x80, 0x08, 0xC0, 0x04, 0x40, 0x02, 0x60, 0x01, 0x20, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x08, 0x01,
  0xA0, 0x0C, 0x00, 0x90, 0x06, 0x00, 0xC8, 0x03, 0x80, 0x44, 0x02, 0xC0,
  0x22, 0x01, 0x20, 0x31, 0x01, 0x90, 0x10, 0x80, 0x88, 0x08, 0x40, 0x44,
  0x0C, 0x20, 0x42, 0x04, 0x10, 0x21, 0x06, 0x08, 0x30, 0x82, 0x06, 0x10,
  0x41, 0x03, 0x08, 0x21, 0x81, 0x88, 0x10, 0x80, 0xC4, 0x0C, 0x40, 0x66,
  0x06, 0x60, 0x32, 0x01, 0x20, 0x09, 0x00, 0x90, 0x05, 0x00, 0x50, 0x02,
  0x80, 0x28, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x00, 0x04, 0x00, 0x30, 0x60, 0x06, 0x02, 0x00, 0x40,
  0x30, 0x0C, 0x03, 0x01, 0x80, 0x10, 0x30, 0x01, 0x82, 0x00, 0x08, 0x60,
  0x00, 0x8C, 0x00, 0x04, 0x80, 0x00, 0x58, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x90, 0x00, 0x19, 0x00, 0x01, 0x18, 0x00, 0x20,
  0x80, 0x06, 0x0C, 0x00, 0xC0, 0x40, 0x08, 0x04, 0x01, 0x80, 0x60, 0x30,
  0x02, 0x02, 0x00, 0x30, 0x40, 0x01, 0x00, 0xC0, 0x01, 0x20, 0x01, 0x98,
  0x01, 0x8C, 0x00, 0x82, 0x00, 0xC1, 0x00, 0xC0, 0xC0, 0x40, 0x20, 0x60,
  0x10, 0x20, 0x0C, 0x20, 0x02, 0x30, 0x01, 0x10, 0x00, 0x90, 0x00, 0x78,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xC1,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0xF8, 0x00, 0x84, 0x21, 0x08, 0x61, 0x08, 0x42, 0x10, 0x86,
  0x10, 0x84, 0x21, 0x08, 0x61, 0x08, 0x42, 0x10, 0x86, 0x07, 0x80, 0x40,
  0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18,
  0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0xF0, 0x00, 0x02,
  0x03, 0x01, 0x41, 0xA0, 0x90, 0xC8, 0x44, 0x43, 0x21, 0xA0, 0x50, 0x30,
  0x10, 0xFF, 0xF8, 0xCC, 0x62, 0x20, 0x07, 0xE0, 0x61, 0x86, 0x06, 0x60,
  0x32, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x0F, 0xF1, 0xC0, 0x98, 0x05,
  0x80, 0x68, 0x02, 0x40, 0x12, 0x01, 0x90, 0x14, 0xE3, 0x21, 0xF1, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x11, 0xE0, 0x58, 0xE3, 0x80, 0x8C, 0x02, 0x30, 0x0C, 0x80,
  0x32, 0x00, 0xC8, 0x03, 0x60, 0x09, 0x80, 0x24, 0x00, 0x90, 0x02, 0x40,
  0x19, 0x00, 0x4C, 0x03, 0x38, 0x18, 0x98, 0xC2, 0x3E, 0x00, 0x07, 0xE0,
  0x61, 0x86, 0x06, 0x60, 0x12, 0x00, 0xB0, 0x05, 0x00, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x01, 0x60, 0x1B, 0x00, 0x88, 0x08,
  0x31, 0xC0, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x07, 0xC4, 0x0C, 0x64,
  0x18, 0x14, 0x30, 0x0C, 0x20, 0x08, 0x60, 0x08, 0x60, 0x08, 0x40, 0x08,
  0x40, 0x18, 0x40, 0x18, 0x40, 0x10, 0xC0, 0x10, 0xC0, 0x10, 0x40, 0x10,
  0x40, 0x30, 0x60, 0x70, 0x31, 0xA0, 0x1F, 0x20, 0x03, 0xE0, 0x61, 0x86,
  0x06, 0x60, 0x12, 0x00, 0xB0, 0x05, 0x00, 0x28, 0x01, 0xFF, 0xFE, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x04, 0x31, 0xC0,
  0xF8, 0x00, 0x01, 0xE0, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00,
  0xC0, 0x7F, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0,
  0x10, 0x00, 0x03, 0xE2, 0x0C, 0x64, 0x30, 0x28, 0xC0, 0x31, 0x00, 0x66,
  0x00, 0x8C, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x19, 0x80, 0x23, 0x00,
  0x46, 0x00, 0x8C, 0x01, 0x08, 0x06, 0x10, 0x1C, 0x18, 0xD0, 0x1F, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x30, 0x18, 0x38, 0xE0, 0x1F,
  0x00, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x11, 0xE0, 0xB1, 0x85, 0x06, 0x70, 0x13, 0x00, 0x98, 0x04,
  0x80, 0x24, 0x01, 0x60, 0x1B, 0x00, 0xD0, 0x04, 0x80, 0x24, 0x01, 0x20,
  0x0B, 0x00, 0xD8, 0x06, 0x80, 0x24, 0x01, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x00, 0x04, 0x10, 0x41, 0x0C, 0x30, 0x82, 0x08, 0x21, 0x84, 0x10, 0x41,
  0x0C, 0x30, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x0C, 0x07, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x08, 0x40, 0x41, 0x02, 0x0C, 0x10, 0x21, 0x80, 0x8C, 0x02,
  0x60, 0x0B, 0x00, 0x7C, 0x01, 0xD8, 0x06, 0x20, 0x10, 0xC0, 0x41, 0x01,
  0x06, 0x0C, 0x08, 0x30, 0x30, 0x80, 0x42, 0x01, 0x80, 0x0C, 0x30, 0x82,
  0x08, 0x21, 0x86, 0x10, 0x41, 0x04, 0x30, 0xC2, 0x08, 0x20, 0x86, 0x10,
  0x41, 0x04, 0x30, 0xC2, 0x00, 0x11, 0xE0, 0x78, 0x2C, 0x63, 0x18, 0xF0,
  0x6C, 0x19, 0xC0, 0x70, 0x13, 0x00, 0xC0, 0x26, 0x01, 0x00, 0x48, 0x02,
  0x00, 0x90, 0x04, 0x01, 0x60, 0x18, 0x06, 0xC0, 0x30, 0x0D, 0x00, 0x40,
  0x12, 0x00, 0x80, 0x24, 0x01, 0x00, 0x58, 0x02, 0x00, 0xB0, 0x0C, 0x03,
  0x40, 0x10, 0x04, 0x80, 0x20, 0x09, 0x00, 0x40, 0x10, 0x11, 0xE0, 0x91,
  0x85, 0x06, 0x70, 0x13, 0x00, 0x98, 0x04, 0x80, 0x24, 0x01, 0x20, 0x1B,
  0x00, 0xD0, 0x04, 0x80, 0x24, 0x01, 0x20, 0x0B, 0x00, 0xD8, 0x06, 0x80,
  0x24, 0x01, 0x00, 0x03, 0xE0, 0x38, 0xC1, 0x81, 0x8C, 0x02, 0x20, 0x0D,
  0x80, 0x34, 0x00, 0xD0, 0x03, 0x40, 0x0D, 0x00, 0x2C, 0x00, 0xB0, 0x02,
  0xC0, 0x19, 0x00, 0x44, 0x03, 0x18, 0x18, 0x31, 0xC0, 0x7E, 0x00, 0x08,
  0xF0, 0x16, 0x38, 0x30, 0x10, 0xC0, 0x21, 0x80, 0x62, 0x00, 0xC4, 0x01,
  0x88, 0x03, 0x30, 0x04, 0x60, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0xC4,
  0x01, 0x18, 0x06, 0x38, 0x18, 0x5C, 0x60, 0x8F, 0x81, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x07, 0xC4,
  0x31, 0x91, 0x81, 0x4C, 0x03, 0x20, 0x09, 0x80, 0x26, 0x00, 0x90, 0x02,
  0x40, 0x09, 0x00, 0x64, 0x01, 0x30, 0x04, 0xC0, 0x13, 0x00, 0x44, 0x03,
  0x10, 0x1C, 0x31, 0xA0, 0x7C, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x13, 0xC5, 0x81, 0xC0, 0xE0, 0x30,
  0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C,
  0x03, 0x00, 0x80, 0x20, 0x00, 0x07, 0xC0, 0xE3, 0x0C, 0x04, 0x40, 0x22,
  0x01, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x40, 0x12, 0x01, 0x98, 0x08, 0x73, 0x81, 0xF8, 0x00, 0x08,
  0x08, 0x18, 0x10, 0x10, 0xFE, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x20,
  0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x40, 0x78, 0x20, 0x09,
  0x00, 0x48, 0x02, 0xC0, 0x34, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0xC0,
  0x36, 0x01, 0xA0, 0x09, 0x00, 0x48, 0x02, 0x40, 0x32, 0x03, 0x98, 0x18,
  0x63, 0x41, 0xE2, 0x00, 0xC0, 0x1E, 0x00, 0x90, 0x0C, 0x80, 0x44, 0x06,
  0x20, 0x21, 0x03, 0x0C, 0x10, 0x21, 0x81, 0x08, 0x08, 0x40, 0x44, 0x02,
  0x20, 0x1A, 0x00, 0x50, 0x03, 0x00, 0x18, 0x00, 0x80, 0x00, 0x80, 0x40,
  0x30, 0x18, 0x0E, 0x03, 0x01, 0x40, 0xE0, 0x68, 0x14, 0x09, 0x06, 0xC1,
  0x20, 0x98, 0x66, 0x11, 0x08, 0xC4, 0x23, 0x18, 0x84, 0x43, 0x20, 0x88,
  0x24, 0x12, 0x05, 0x82, 0x40, 0xA0, 0x58, 0x1C, 0x0A, 0x03, 0x01, 0x40,
  0x60, 0x30, 0x08, 0x02, 0x00, 0x08, 0x02, 0x18, 0x08, 0x10, 0x30, 0x30,
  0xC0, 0x21, 0x00, 0x44, 0x00, 0xD8, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x0F, 0x00, 0x32, 0x00, 0x44, 0x01, 0x0C, 0x06, 0x08, 0x18, 0x18, 0x20,
  0x10, 0x80, 0x30, 0x18, 0x03, 0x08, 0x02, 0x08, 0x06, 0x08, 0x04, 0x08,
  0x0C, 0x08, 0x08, 0x0C, 0x18, 0x0C, 0x10, 0x04, 0x30, 0x04, 0x20, 0x04,
  0x60, 0x04, 0x40, 0x04, 0xC0, 0x06, 0x80, 0x07, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x30, 0x01, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0x20, 0x18, 0x06, 0x00, 0x80, 0x20, 0x04, 0x01, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x80, 0x70,
  0x18, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x00, 0x80,
  0x08, 0x20, 0x82, 0x08, 0x61, 0x84, 0x10, 0x41, 0x0C, 0x30, 0x82, 0x08,
  0x20, 0x86, 0x18, 0x41, 0x04, 0x10, 0xC3, 0x0C, 0x20, 0x82, 0x00, 0x04,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x1C,
  0x06, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x06, 0x00, 0x80, 0x10, 0x04, 0x01, 0x80, 0x60, 0x10, 0x00, 0x1E, 0x01,
  0x33, 0x01, 0x61, 0x83, 0x40, 0x82, 0xC0, 0x66, 0x80, 0x38,
};

const GFXglyph RobotoCondensed_ExtraLightItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 25, 7, 1, -25 },
  { 20, 6, 7, 9, 4, -26 },
  { 26, 17, 25, 17, 1, -25 },
  { 80, 15, 31, 16, 1, -28 },
  { 139, 17, 25, 22, 3, -25 },
  { 193, 16, 25, 18, 1, -25 },
  { 243, 3, 7, 6, 3, -26 },
  { 246, 9, 36, 10, 2, -28 },
  { 287, 10, 36, 10, -2, -28 },
  { 332, 13, 14, 14, 2, -25 },
  { 355, 15, 17, 17, 1, -20 },
  { 387, 4, 7, 6, -1, -3 },
  { 391, 7, 1, 9, 1, -12 },
  { 392, 2, 2, 8, 1, -2 },
  { 393, 14, 27, 12, -1, -25 },
  { 441, 14, 25, 16, 2, -25 },
  { 485, 7, 25, 16, 5, -25 },
  { 507, 14, 25, 16, 1, -25 },
  { 551, 15, 25, 16, 1, -25 },
  { 598, 14, 25, 16, 1, -25 },
  { 642, 15, 25, 16, 2, -25 },
  { 689, 13, 25, 16, 2, -25 },
  { 730, 14, 25, 16, 3, -25 },
  { 774, 15, 25, 16, 1, -25 },
  { 821, 12, 25, 16, 3, -25 },
  { 859, 6, 18, 6, 0, -18 },
  { 873, 7, 22, 6, -1, -18 },
  { 893, 14, 14, 15, 1, -18 },
  { 918, 13, 7, 17, 2, -15 },
  { 930, 13, 14, 15, 1, -18 },
  { 953, 11, 25, 13, 3, -25 },
  { 988, 24, 32, 27, 1, -24 },
  { 1084, 17, 25, 18, -1, -25 },
  { 1138, 16, 25, 18, 1, -25 },
  { 1188, 17, 25, 19, 2, -25 },
  { 1242, 17, 25, 19, 1, -25 },
  { 1296, 17, 25, 17, 1, -25 },
  { 1350, 17, 25, 17, 1, -25 },
  { 1404, 17, 25, 20, 2, -25 },
  { 1458, 19, 25, 21, 1, -25 },
  { 1518, 5, 25, 8, 2, -25 },
  { 1534, 15, 25, 16, 1, -25 },
  { 1581, 19, 25, 19, 1, -25 },
  { 1641, 12, 25, 16, 1, -25 },
  { 1679, 24, 25, 25, 1, -25 },
  { 1754, 20, 25, 21, 1, -25 },
  { 1817, 17, 25, 20, 2, -25 },
  { 1871, 17, 25, 18, 1, -25 },
  { 1925, 17, 29, 20, 2, -25 },
  { 1987, 17, 25, 19, 1, -25 },
  { 2041, 17, 25, 18, 1, -25 },
  { 2095, 16, 25, 18, 3, -25 },
  { 2145, 17, 25, 20, 2, -25 },
  { 2199, 17, 25, 18, 3, -25 },
  { 2253, 25, 25, 26, 3, -25 },
  { 2332, 20, 25, 18, -1, -25 },
  { 2395, 17, 25, 18, 3, -25 },
  { 2449, 18, 25, 18, 0, -25 },
  { 2506, 10, 33, 7, 0, -28 },
  { 2548, 5, 27, 12, 4, -25 },
  { 2565, 9, 33, 7, -2, -28 },
  { 2603, 9, 12, 13, 2, -25 },
  { 2617, 13, 1, 13, -2, 0 },
  { 2619, 4, 5, 9, 5, -27 },
  { 2622, 13, 18, 16, 1, -18 },
  { 2652, 14, 26, 16, 1, -26 },
  { 2698, 13, 18, 15, 1, -18 },
  { 2728, 16, 26, 16, 1, -26 },
  { 2780, 13, 18, 15, 1, -18 },
  { 2810, 11, 26, 10, 2, -26 },
  { 2846, 15, 25, 16, 0, -18 },
  { 2893, 13, 26, 16, 1, -26 },
  { 2936, 6, 25, 7, 1, -25 },
  { 2955, 11, 32, 7, -4, -25 },
  { 2999, 14, 26, 14, 1, -26 },
  { 3045, 6, 26, 7, 1, -26 },
  { 3065, 23, 18, 26, 1, -18 },
  { 3117, 13, 18, 16, 1, -18 },
  { 3147, 14, 18, 17, 1, -18 },
  { 3179, 15, 25, 16, 0, -18 },
  { 3226, 14, 25, 16, 1, -18 },
  { 3270, 10, 18, 10, 1, -18 },
  { 3293, 13, 18, 15, 1, -18 },
  { 3323, 8, 23, 10, 2, -23 },
  { 3346, 13, 18, 16, 2, -18 },
  { 3376, 13, 18, 14, 2, -18 },
  { 3406, 19, 18, 22, 3, -18 },
  { 3449, 15, 18, 14, -1, -18 },
  { 3483, 16, 25, 14, -1, -18 },
  { 3533, 14, 18, 14, 0, -18 },
  { 3565, 11, 34, 10, 1, -27 },
  { 3612, 6, 30, 7, 1, -25 },
  { 3635, 11, 34, 10, -2, -27 },
  { 3682, 16, 6, 20, 2, -13 },
};

const GFXfont RobotoCondensed_ExtraLightItalic35pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic35pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic35pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC35PT7B_H_
