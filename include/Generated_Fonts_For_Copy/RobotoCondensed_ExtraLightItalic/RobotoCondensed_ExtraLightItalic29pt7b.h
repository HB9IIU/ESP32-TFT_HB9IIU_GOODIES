#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC29PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x12, 0x22, 0x22, 0x24, 0x44, 0x40, 0x00, 0x08, 0x80,
  0x4A, 0x52, 0x99, 0x48, 0x01, 0x08, 0x04, 0x20, 0x11, 0x00, 0x84, 0x02,
  0x10, 0x08, 0x43, 0xFF, 0xC1, 0x08, 0x04, 0x20, 0x21, 0x00, 0x84, 0x02,
  0x10, 0x10, 0x80, 0x42, 0x0F, 0xFF, 0x08, 0x40, 0x21, 0x00, 0x84, 0x02,
  0x20, 0x10, 0x80, 0x42, 0x00, 0x00, 0x80, 0x08, 0x00, 0x80, 0x3C, 0x0C,
  0x61, 0x83, 0x10, 0x13, 0x01, 0x20, 0x12, 0x00, 0x30, 0x01, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x80, 0x68, 0x04, 0x80,
  0x44, 0x0C, 0x61, 0x83, 0xE0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x38, 0x02,
  0x20, 0x31, 0x05, 0x04, 0x28, 0x42, 0x42, 0x22, 0x11, 0x10, 0x90, 0x89,
  0x03, 0x88, 0x00, 0x80, 0x08, 0xE0, 0xC8, 0x84, 0x84, 0x44, 0x24, 0x21,
  0x22, 0x0A, 0x10, 0x40, 0x84, 0x02, 0x20, 0x0E, 0x00, 0x03, 0x80, 0x22,
  0x02, 0x18, 0x10, 0x41, 0x04, 0x08, 0x20, 0x62, 0x01, 0x20, 0x0A, 0x00,
  0x20, 0x07, 0x00, 0x64, 0x06, 0x20, 0xA0, 0x8A, 0x04, 0x50, 0x12, 0x80,
  0xE4, 0x02, 0x30, 0x38, 0xC2, 0x43, 0xE1, 0x00, 0x56, 0xA0, 0x01, 0x03,
  0x02, 0x04, 0x08, 0x08, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x20, 0x20, 0x10, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02,
  0x02, 0x04, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x20, 0x40, 0x80, 0x06, 0x00,
  0x80, 0x10, 0x02, 0x1E, 0x4C, 0x3E, 0x03, 0x00, 0xA0, 0x22, 0x08, 0x63,
  0x04, 0x00, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x0F, 0xFF, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08,
  0x00, 0x24, 0xB5, 0x00, 0xFC, 0xA0, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x00, 0x03, 0xC0, 0xC6, 0x18, 0x21, 0x01, 0x30,
  0x12, 0x01, 0x20, 0x16, 0x01, 0x40, 0x14, 0x02, 0x40, 0x24, 0x02, 0x40,
  0x24, 0x02, 0xC0, 0x6C, 0x04, 0x40, 0x44, 0x08, 0x40, 0x86, 0x30, 0x3E,
  0x00, 0x04, 0xFE, 0x41, 0x08, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41,
  0x04, 0x20, 0x82, 0x08, 0x20, 0x07, 0xC0, 0x86, 0x10, 0x23, 0x02, 0x20,
  0x32, 0x03, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x00, 0xFF,
  0xC0, 0x07, 0xC0, 0xC6, 0x10, 0x21, 0x01, 0x20, 0x12, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x0C, 0x0F, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x28,
  0x06, 0x80, 0x48, 0x04, 0xC0, 0x86, 0x18, 0x3E, 0x00, 0x00, 0x20, 0x06,
  0x00, 0xA0, 0x0A, 0x01, 0x60, 0x24, 0x06, 0x40, 0x44, 0x08, 0x41, 0x04,
  0x30, 0xC2, 0x08, 0x40, 0x8C, 0x08, 0xFF, 0xF0, 0x08, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x1F, 0xF1, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x2F, 0x07, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x48, 0x04, 0x80, 0xC8, 0x08, 0xC1, 0x84, 0x30, 0x3E,
  0x00, 0x00, 0xE0, 0x60, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x3C,
  0x38, 0xCC, 0x09, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x70, 0x0E, 0x03, 0x40,
  0x48, 0x09, 0x02, 0x10, 0x81, 0xE0, 0x7F, 0xF0, 0x03, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x00, 0x07, 0xC0, 0xC6, 0x18, 0x31, 0x01, 0x20, 0x12, 0x01, 0x20,
  0x12, 0x02, 0x30, 0x21, 0x8C, 0x0F, 0x03, 0x08, 0x60, 0x44, 0x06, 0x80,
  0x28, 0x02, 0x80, 0x48, 0x04, 0xC0, 0x86, 0x18, 0x3E, 0x00, 0x0F, 0x03,
  0x18, 0x81, 0x30, 0x24, 0x06, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x50, 0x0A,
  0x03, 0x20, 0x66, 0x34, 0x79, 0x80, 0x20, 0x04, 0x01, 0x00, 0x60, 0x18,
  0x06, 0x0F, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x23,
  0x00, 0x08, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x82,
  0x08, 0x61, 0x08, 0x00, 0x00, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x02, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x20, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x02, 0x00, 0x00, 0x3E, 0x62, 0xC1,
  0x81, 0x81, 0x01, 0x01, 0x02, 0x06, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x7F, 0x00, 0x1C, 0x18, 0x03,
  0x00, 0x40, 0x40, 0x02, 0x08, 0x00, 0x21, 0x80, 0x01, 0x10, 0x38, 0x12,
  0x0C, 0x61, 0x20, 0x84, 0x14, 0x10, 0x41, 0x41, 0x04, 0x14, 0x20, 0x41,
  0x82, 0x08, 0x18, 0x20, 0x82, 0x84, 0x08, 0x28, 0x40, 0x82, 0x84, 0x18,
  0x48, 0x42, 0x84, 0x86, 0x68, 0x88, 0x38, 0xF0, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x30, 0x00, 0xFC, 0x00, 0x00,
  0x20, 0x01, 0x80, 0x05, 0x00, 0x24, 0x00, 0x90, 0x06, 0x40, 0x11, 0x00,
  0x44, 0x02, 0x10, 0x08, 0x40, 0x40, 0x81, 0x02, 0x08, 0x08, 0x20, 0x21,
  0xFF, 0x84, 0x02, 0x20, 0x08, 0x80, 0x34, 0x00, 0x50, 0x01, 0xC0, 0x04,
  0x1F, 0xE0, 0x81, 0x84, 0x06, 0x20, 0x11, 0x00, 0x88, 0x04, 0xC0, 0x24,
  0x02, 0x20, 0x31, 0x03, 0x0F, 0xF0, 0x40, 0xC6, 0x03, 0x20, 0x09, 0x00,
  0x48, 0x02, 0x40, 0x12, 0x01, 0x30, 0x19, 0x01, 0x8F, 0xF0, 0x00, 0x03,
  0xE0, 0x61, 0x84, 0x06, 0x40, 0x12, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x50,
  0x04, 0x80, 0x24, 0x03, 0x10, 0x10, 0xC3, 0x03, 0xF0, 0x00, 0x1F, 0xE0,
  0x40, 0xC1, 0x00, 0x84, 0x02, 0x10, 0x04, 0x40, 0x13, 0x00, 0x48, 0x01,
  0x20, 0x04, 0x80, 0x12, 0x00, 0xC8, 0x02, 0x60, 0x09, 0x00, 0x24, 0x00,
  0x90, 0x04, 0x40, 0x11, 0x00, 0x8C, 0x06, 0x20, 0x60, 0xFF, 0x00, 0x1F,
  0xFC, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x03, 0xFE, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFE, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x00, 0x03, 0xE0, 0x30, 0xC1, 0x80, 0x8C, 0x02, 0x20, 0x0C, 0x80, 0x14,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x7E, 0x80, 0x1A,
  0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x13, 0x00, 0x44, 0x02, 0x08, 0x30,
  0x1F, 0x00, 0x18, 0x01, 0x10, 0x01, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02,
  0x10, 0x02, 0x30, 0x02, 0x20, 0x02, 0x20, 0x04, 0x20, 0x04, 0x3F, 0xFC,
  0x20, 0x04, 0x60, 0x04, 0x40, 0x04, 0x40, 0x08, 0x40, 0x08, 0x40, 0x08,
  0x40, 0x08, 0xC0, 0x08, 0x80, 0x18, 0x80, 0x10, 0x08, 0x42, 0x21, 0x08,
  0x42, 0x31, 0x08, 0x42, 0x11, 0x88, 0x42, 0x10, 0x8C, 0x00, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x88, 0x0C,
  0x40, 0x42, 0x02, 0x10, 0x20, 0x43, 0x01, 0xE0, 0x00, 0x18, 0x06, 0x20,
  0x18, 0x40, 0x60, 0x81, 0x81, 0x02, 0x02, 0x08, 0x0C, 0x20, 0x10, 0x80,
  0x22, 0x00, 0x48, 0x00, 0xA8, 0x01, 0x90, 0x06, 0x10, 0x08, 0x20, 0x10,
  0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x83, 0x00, 0x84, 0x01, 0x08, 0x01,
  0x00, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C,
  0x02, 0x00, 0xFF, 0xC0, 0x18, 0x00, 0x31, 0x80, 0x06, 0x18, 0x00, 0x61,
  0x40, 0x0A, 0x14, 0x00, 0xA1, 0x40, 0x12, 0x34, 0x01, 0x62, 0x40, 0x24,
  0x24, 0x02, 0x42, 0x20, 0x44, 0x22, 0x04, 0x42, 0x20, 0x84, 0x62, 0x08,
  0xC4, 0x21, 0x08, 0x42, 0x10, 0x84, 0x12, 0x08, 0x41, 0x20, 0x84, 0x14,
  0x08, 0xC1, 0x41, 0x88, 0x18, 0x10, 0x80, 0x81, 0x00, 0x18, 0x01, 0x18,
  0x01, 0x14, 0x03, 0x14, 0x02, 0x14, 0x02, 0x12, 0x02, 0x32, 0x02, 0x22,
  0x02, 0x21, 0x06, 0x21, 0x04, 0x21, 0x84, 0x20, 0x84, 0x60, 0x84, 0x40,
  0x44, 0x40, 0x4C, 0x40, 0x48, 0x40, 0x28, 0x40, 0x28, 0xC0, 0x38, 0x80,
  0x18, 0x80, 0x18, 0x03, 0xE0, 0x30, 0xC1, 0x01, 0x88, 0x02, 0x20, 0x09,
  0x00, 0x24, 0x00, 0xD0, 0x02, 0xC0, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02,
  0x80, 0x0A, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x22, 0x00, 0x8C, 0x04,
  0x18, 0x60, 0x1F, 0x00, 0x1F, 0xE0, 0x40, 0x61, 0x00, 0x84, 0x03, 0x10,
  0x04, 0x40, 0x13, 0x00, 0xC8, 0x02, 0x20, 0x08, 0x80, 0x42, 0x06, 0x0F,
  0xF0, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x30, 0xC1, 0x01, 0x88, 0x02,
  0x20, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0xC0, 0x0A, 0x00, 0x28, 0x00,
  0xA0, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x22, 0x00,
  0x8C, 0x04, 0x18, 0x60, 0x3F, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x1F, 0xE0, 0x40, 0x61, 0x00, 0x84, 0x03, 0x10, 0x04, 0x40, 0x13,
  0x00, 0xC8, 0x02, 0x20, 0x08, 0x80, 0x42, 0x02, 0x0F, 0xF0, 0x60, 0x81,
  0x03, 0x04, 0x04, 0x10, 0x10, 0x40, 0x41, 0x00, 0x88, 0x02, 0x20, 0x08,
  0x80, 0x10, 0x03, 0xE0, 0x30, 0xC1, 0x80, 0x84, 0x02, 0x20, 0x08, 0x80,
  0x22, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x20, 0x04, 0x80, 0x32, 0x00, 0x8C, 0x06, 0x18,
  0x30, 0x1F, 0x00, 0xFF, 0xF8, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x00, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x03, 0x20, 0x09, 0x80,
  0x24, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x64, 0x01, 0x30, 0x04, 0x80,
  0x12, 0x00, 0x48, 0x01, 0x20, 0x08, 0x80, 0x22, 0x01, 0x8C, 0x04, 0x18,
  0x60, 0x3F, 0x00, 0x80, 0x0C, 0x00, 0xE0, 0x05, 0x00, 0x68, 0x02, 0x40,
  0x13, 0x01, 0x08, 0x08, 0x40, 0x82, 0x04, 0x10, 0x60, 0x82, 0x04, 0x30,
  0x11, 0x00, 0x88, 0x04, 0x80, 0x24, 0x01, 0x40, 0x0A, 0x00, 0x60, 0x01,
  0x00, 0x00, 0x80, 0x40, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02,
  0x80, 0xA0, 0x48, 0x12, 0x04, 0x81, 0x20, 0xC8, 0x22, 0x08, 0x82, 0x20,
  0x8C, 0x22, 0x10, 0xC4, 0x21, 0x04, 0x42, 0x10, 0x4C, 0x12, 0x04, 0x81,
  0x20, 0x48, 0x12, 0x05, 0x01, 0x40, 0x50, 0x14, 0x05, 0x01, 0x40, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x00, 0x10, 0x02, 0x08, 0x06, 0x08,
  0x04, 0x0C, 0x08, 0x04, 0x18, 0x04, 0x10, 0x02, 0x20, 0x02, 0x40, 0x03,
  0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x80, 0x02, 0x80, 0x04, 0x40, 0x08,
  0x40, 0x18, 0x40, 0x10, 0x20, 0x20, 0x20, 0x60, 0x30, 0x40, 0x10, 0x80,
  0x10, 0x80, 0x0C, 0x00, 0xB0, 0x0C, 0x80, 0x44, 0x04, 0x30, 0x60, 0x82,
  0x04, 0x20, 0x21, 0x00, 0x90, 0x05, 0x00, 0x28, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xF0, 0x88, 0x88, 0x44, 0x44,
  0x44, 0x42, 0x22, 0x22, 0x22, 0x11, 0x11, 0x10, 0x0F, 0x01, 0x01, 0x01,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0xF0,
  0x04, 0x18, 0x50, 0xA2, 0x44, 0x50, 0xA1, 0x83, 0x04, 0xFF, 0xC0, 0x89,
  0x10, 0x07, 0xC0, 0x86, 0x10, 0x23, 0x02, 0x20, 0x20, 0x02, 0x00, 0x20,
  0xFE, 0x30, 0x26, 0x02, 0x40, 0x44, 0x04, 0x40, 0x44, 0x0C, 0x63, 0x43,
  0xC4, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x09, 0xE1, 0x42,
  0x30, 0x24, 0x04, 0x80, 0xB0, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40,
  0x58, 0x0A, 0x01, 0x60, 0x4A, 0x19, 0x3C, 0x00, 0x0F, 0x82, 0x18, 0x81,
  0x30, 0x14, 0x02, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x28, 0x09, 0x81, 0x18, 0xC1, 0xF0, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x3C, 0x43, 0x16, 0x20, 0x61, 0x01, 0x10, 0x08,
  0x80, 0x44, 0x02, 0x60, 0x32, 0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x20,
  0x30, 0x81, 0x06, 0x38, 0x1E, 0x40, 0x0F, 0x83, 0x18, 0x81, 0x30, 0x34,
  0x02, 0x80, 0x60, 0x0F, 0xFE, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x81, 0x18, 0x61, 0xF0, 0x07, 0x04, 0x04, 0x02, 0x01, 0x01, 0x83, 0xF0,
  0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60,
  0x20, 0x10, 0x08, 0x04, 0x00, 0x07, 0x88, 0x62, 0x84, 0x0C, 0x20, 0x22,
  0x01, 0x10, 0x08, 0x80, 0x4C, 0x04, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80,
  0x44, 0x06, 0x10, 0x20, 0xC7, 0x03, 0xC8, 0x00, 0x40, 0x02, 0x00, 0x21,
  0x01, 0x04, 0x30, 0x1F, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x60, 0x09, 0xE1, 0x42, 0x30, 0x66, 0x04, 0x80, 0xB0, 0x14, 0x06, 0x80,
  0x90, 0x12, 0x02, 0x40, 0x58, 0x0A, 0x01, 0x40, 0x48, 0x09, 0x01, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x84, 0x21, 0x08, 0x46, 0x21, 0x08, 0x42, 0x31,
  0x08, 0x40, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x01, 0x83,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x19, 0x06,
  0x21, 0x84, 0x20, 0x88, 0x32, 0x04, 0x80, 0xB0, 0x1B, 0x02, 0x20, 0x44,
  0x18, 0x42, 0x08, 0x40, 0x88, 0x11, 0x01, 0x00, 0x08, 0x84, 0x21, 0x08,
  0xC4, 0x21, 0x08, 0x46, 0x21, 0x08, 0x42, 0x31, 0x08, 0x40, 0x27, 0x87,
  0xC5, 0x09, 0x88, 0xC1, 0xC0, 0x90, 0x18, 0x16, 0x02, 0x02, 0x80, 0x40,
  0x50, 0x18, 0x0A, 0x02, 0x01, 0x40, 0x40, 0x68, 0x08, 0x0B, 0x01, 0x01,
  0x40, 0x20, 0x28, 0x0C, 0x05, 0x01, 0x00, 0xA0, 0x20, 0x34, 0x04, 0x04,
  0x27, 0x85, 0x88, 0xC1, 0x98, 0x12, 0x02, 0xC0, 0x50, 0x0A, 0x02, 0x40,
  0x48, 0x09, 0x01, 0x60, 0x28, 0x05, 0x01, 0x20, 0x24, 0x04, 0x07, 0x83,
  0x08, 0xC0, 0x90, 0x14, 0x02, 0x80, 0x50, 0x0E, 0x01, 0x80, 0x30, 0x06,
  0x01, 0x40, 0x28, 0x04, 0x81, 0x18, 0x41, 0xF0, 0x13, 0xC1, 0x42, 0x18,
  0x11, 0x01, 0x10, 0x12, 0x01, 0x20, 0x12, 0x01, 0x20, 0x12, 0x01, 0x20,
  0x24, 0x02, 0x40, 0x26, 0x04, 0x50, 0x84, 0xF0, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x0F, 0x11, 0x8A, 0x20, 0x62, 0x02, 0x40,
  0x24, 0x02, 0x40, 0x2C, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80,
  0x44, 0x08, 0x63, 0x83, 0xC8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x27, 0x28, 0x30, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40,
  0x40, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x0F, 0x0C, 0x32, 0x05, 0x01, 0x40,
  0x08, 0x03, 0x00, 0x30, 0x02, 0x00, 0x40, 0x08, 0x02, 0x80, 0xA0, 0x4C,
  0x30, 0xF0, 0x10, 0x42, 0x3F, 0x20, 0x82, 0x18, 0x41, 0x04, 0x10, 0x43,
  0x08, 0x20, 0x82, 0x07, 0x00, 0x20, 0x32, 0x02, 0x20, 0x22, 0x02, 0x20,
  0x24, 0x02, 0x40, 0x64, 0x04, 0x40, 0x44, 0x04, 0x40, 0x4C, 0x04, 0x40,
  0xC4, 0x18, 0x63, 0x83, 0xC8, 0x80, 0x60, 0x38, 0x0A, 0x02, 0xC1, 0x10,
  0x44, 0x21, 0x08, 0x46, 0x11, 0x04, 0x40, 0xA0, 0x28, 0x0C, 0x03, 0x00,
  0x80, 0x80, 0x81, 0x40, 0xC0, 0xB0, 0x60, 0xC8, 0x50, 0x44, 0x28, 0x22,
  0x14, 0x21, 0x12, 0x10, 0x89, 0x18, 0x48, 0x48, 0x24, 0x24, 0x16, 0x14,
  0x0A, 0x0A, 0x05, 0x05, 0x03, 0x03, 0x01, 0x81, 0x80, 0x80, 0x80, 0x18,
  0x18, 0x40, 0x82, 0x08, 0x08, 0xC0, 0x44, 0x02, 0x40, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x28, 0x03, 0x60, 0x11, 0x01, 0x08, 0x18, 0x20, 0x81, 0x08,
  0x0C, 0x10, 0x08, 0x80, 0x44, 0x04, 0x20, 0x20, 0x82, 0x04, 0x10, 0x21,
  0x01, 0x08, 0x08, 0x80, 0x44, 0x02, 0x60, 0x0A, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0x70,
  0x00, 0x1F, 0xF0, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x0F,
  0xFC, 0x00, 0x81, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x04, 0x02, 0x01, 0x01, 0x03, 0x00, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x02, 0x00, 0x80, 0x11, 0x11,
  0x13, 0x22, 0x22, 0x22, 0x64, 0x44, 0x44, 0x48, 0x88, 0x88, 0x80, 0x04,
  0x03, 0x00, 0x80, 0x60, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x08, 0x02, 0x06, 0x06, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x08, 0x0C, 0x0C, 0x08, 0x00, 0x38, 0x0A, 0x20, 0x60,
  0x85, 0x02, 0x28, 0x0E, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLightItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 21, 6, 1, -21 },
  { 12, 5, 6, 8, 3, -22 },
  { 16, 14, 21, 14, 1, -21 },
  { 53, 12, 27, 14, 1, -24 },
  { 94, 13, 21, 18, 3, -21 },
  { 129, 13, 21, 15, 1, -21 },
  { 164, 2, 6, 5, 3, -22 },
  { 166, 8, 30, 8, 1, -23 },
  { 196, 8, 30, 8, -2, -23 },
  { 226, 11, 11, 12, 2, -21 },
  { 242, 12, 15, 14, 1, -17 },
  { 265, 3, 6, 5, -1, -2 },
  { 268, 6, 1, 7, 1, -10 },
  { 269, 2, 2, 6, 1, -2 },
  { 270, 12, 23, 10, -1, -21 },
  { 305, 12, 21, 14, 1, -21 },
  { 337, 6, 21, 14, 4, -21 },
  { 353, 12, 21, 14, 1, -21 },
  { 385, 12, 21, 14, 1, -21 },
  { 417, 12, 21, 14, 1, -21 },
  { 449, 12, 21, 14, 2, -21 },
  { 481, 11, 21, 14, 1, -21 },
  { 510, 12, 21, 14, 2, -21 },
  { 542, 12, 21, 14, 1, -21 },
  { 574, 11, 21, 14, 2, -21 },
  { 603, 5, 15, 5, 0, -15 },
  { 613, 6, 19, 5, -1, -15 },
  { 628, 11, 11, 13, 1, -15 },
  { 644, 10, 7, 14, 2, -13 },
  { 653, 11, 11, 13, 1, -15 },
  { 669, 8, 21, 11, 3, -21 },
  { 690, 20, 26, 22, 1, -20 },
  { 755, 14, 21, 15, -1, -21 },
  { 792, 13, 21, 15, 1, -21 },
  { 827, 13, 21, 16, 2, -21 },
  { 862, 14, 21, 16, 1, -21 },
  { 899, 14, 21, 14, 1, -21 },
  { 936, 14, 21, 14, 1, -21 },
  { 973, 14, 21, 17, 2, -21 },
  { 1010, 16, 21, 17, 1, -21 },
  { 1052, 5, 21, 7, 1, -21 },
  { 1066, 13, 21, 14, 0, -21 },
  { 1101, 15, 21, 16, 1, -21 },
  { 1141, 10, 21, 13, 1, -21 },
  { 1168, 20, 21, 21, 1, -21 },
  { 1221, 16, 21, 17, 1, -21 },
  { 1263, 14, 21, 17, 2, -21 },
  { 1300, 14, 21, 15, 1, -21 },
  { 1337, 14, 25, 17, 2, -21 },
  { 1381, 14, 21, 16, 1, -21 },
  { 1418, 14, 21, 15, 1, -21 },
  { 1455, 13, 21, 15, 3, -21 },
  { 1490, 14, 21, 16, 2, -21 },
  { 1527, 13, 21, 15, 3, -21 },
  { 1562, 20, 21, 22, 3, -21 },
  { 1615, 16, 21, 15, 0, -21 },
  { 1657, 13, 21, 15, 3, -21 },
  { 1692, 15, 21, 15, 0, -21 },
  { 1732, 8, 28, 6, 0, -24 },
  { 1760, 4, 23, 10, 3, -21 },
  { 1772, 8, 28, 6, -2, -24 },
  { 1800, 7, 10, 10, 2, -21 },
  { 1809, 10, 1, 11, -1, 0 },
  { 1811, 3, 4, 8, 4, -22 },
  { 1813, 12, 16, 13, 0, -16 },
  { 1837, 11, 22, 14, 1, -22 },
  { 1868, 11, 16, 13, 1, -16 },
  { 1890, 13, 22, 14, 1, -22 },
  { 1926, 11, 16, 13, 1, -16 },
  { 1948, 9, 22, 8, 2, -22 },
  { 1973, 13, 22, 14, 0, -16 },
  { 2009, 11, 22, 14, 1, -22 },
  { 2040, 5, 22, 6, 1, -22 },
  { 2054, 10, 28, 6, -4, -22 },
  { 2089, 11, 22, 12, 1, -22 },
  { 2120, 5, 22, 6, 1, -22 },
  { 2134, 19, 16, 22, 1, -16 },
  { 2172, 11, 16, 14, 1, -16 },
  { 2194, 11, 16, 14, 1, -16 },
  { 2216, 12, 22, 14, 0, -16 },
  { 2249, 12, 22, 14, 1, -16 },
  { 2282, 8, 16, 9, 1, -16 },
  { 2298, 10, 16, 12, 1, -16 },
  { 2318, 6, 19, 8, 2, -19 },
  { 2333, 12, 16, 14, 1, -16 },
  { 2357, 10, 16, 12, 2, -16 },
  { 2377, 17, 16, 19, 2, -16 },
  { 2411, 13, 16, 12, -1, -16 },
  { 2437, 13, 22, 12, -1, -16 },
  { 2473, 12, 16, 12, 0, -16 },
  { 2497, 9, 29, 8, 1, -23 },
  { 2530, 4, 25, 6, 1, -21 },
  { 2543, 9, 29, 8, -2, -23 },
  { 2576, 13, 5, 17, 2, -11 },
};

const GFXfont RobotoCondensed_ExtraLightItalic29pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic29pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic29pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC29PT7B_H_
