#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC54PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x01, 0x00, 0x31, 0xB0, 0xD8,
  0x6C, 0x36, 0x33, 0x19, 0x0D, 0x86, 0xC3, 0x61, 0x31, 0x80, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x00, 0x80, 0x00, 0x60,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x00, 0x80, 0x00, 0x60, 0x30, 0x03,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01,
  0x00, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x60,
  0x30, 0x03, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x00, 0x60, 0x30, 0x00,
  0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x03, 0xFC, 0x00, 0x3E, 0x7C, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0x60, 0x30,
  0x01, 0x81, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xC0, 0x00,
  0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0x63, 0x00, 0x01, 0x86, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x70, 0x03, 0x80,
  0xE0, 0x1C, 0x01, 0xE3, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x18, 0x00, 0x07, 0x06,
  0x00, 0x03, 0x01, 0x00, 0x03, 0x00, 0x80, 0x01, 0x80, 0x60, 0x18, 0x80,
  0x30, 0x18, 0xC0, 0x18, 0x0C, 0x60, 0x08, 0x0C, 0x30, 0x04, 0x0C, 0x18,
  0x06, 0x0C, 0x0C, 0x03, 0x06, 0x06, 0x01, 0x06, 0x03, 0x01, 0x86, 0x00,
  0xC1, 0x83, 0x00, 0x71, 0xC3, 0x00, 0x1F, 0xC3, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC1,
  0xF8, 0x00, 0xC3, 0x8E, 0x00, 0xC1, 0x83, 0x00, 0x61, 0x80, 0xC0, 0x60,
  0x80, 0x60, 0x60, 0xC0, 0x30, 0x30, 0x60, 0x18, 0x30, 0x30, 0x0C, 0x30,
  0x10, 0x06, 0x10, 0x08, 0x03, 0x18, 0x0C, 0x01, 0x18, 0x06, 0x01, 0x98,
  0x01, 0x00, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x7B, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x30,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60,
  0x03, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x03, 0x80,
  0x01, 0x86, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x30, 0x00, 0x0E, 0x30, 0x00,
  0x0C, 0x18, 0x02, 0x18, 0x1C, 0x06, 0x30, 0x0C, 0x06, 0x70, 0x0E, 0x06,
  0x60, 0x06, 0x0C, 0xE0, 0x03, 0x0C, 0xC0, 0x03, 0x0C, 0xC0, 0x01, 0x98,
  0xC0, 0x01, 0xD8, 0xC0, 0x00, 0xF0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x60,
  0xE0, 0x00, 0xF0, 0x60, 0x03, 0xB0, 0x70, 0x07, 0x18, 0x3F, 0x3C, 0x18,
  0x0F, 0xF8, 0x0C, 0x01, 0x80, 0x00, 0x33, 0x33, 0x36, 0x66, 0x64, 0xC0,
  0x00, 0x04, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x00, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x2C, 0x06,
  0x07, 0xFC, 0x31, 0xF8, 0xFB, 0x7E, 0x00, 0xFF, 0x80, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xD8, 0x00, 0x0C, 0x60, 0x00, 0xC3, 0x00, 0x0E, 0x0C,
  0x00, 0xE0, 0x70, 0x0E, 0x01, 0x80, 0x60, 0x0E, 0x02, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x18,
  0x70, 0xC1, 0x00, 0xFF, 0xFF, 0xF0, 0x6F, 0xF4, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x03, 0xFC, 0x00, 0x3C, 0xF0, 0x03, 0x00, 0xC0,
  0x30, 0x07, 0x03, 0x00, 0x18, 0x38, 0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00,
  0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98,
  0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x33, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00,
  0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x19,
  0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x06, 0x18, 0x00,
  0x30, 0xC0, 0x03, 0x86, 0x00, 0x18, 0x18, 0x01, 0xC0, 0xC0, 0x1C, 0x07,
  0x01, 0xC0, 0x1E, 0x3C, 0x00, 0x7F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x0F, 0x07, 0xF1, 0xF2, 0x78, 0x6E, 0x06, 0x80, 0x60, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x01, 0xE7, 0xC0, 0x07, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x70, 0x01,
  0x80, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0x1E, 0x00, 0x70, 0x1C, 0x03,
  0x00, 0x38, 0x1C, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00,
  0x0C, 0x70, 0x00, 0x31, 0x80, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x01, 0x8C, 0x00,
  0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x06, 0x00, 0x18,
  0x1C, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x7C, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x66, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xE1,
  0x80, 0x01, 0x83, 0x00, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x70, 0x30,
  0x00, 0xC0, 0x60, 0x03, 0x00, 0xC0, 0x0E, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x18, 0x07, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0xE0, 0x01, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x1F, 0x80, 0x05,
  0xFF, 0x80, 0x1F, 0x03, 0x80, 0x38, 0x03, 0x80, 0x60, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x30, 0x00, 0x60,
  0x60, 0x01, 0x80, 0xC0, 0x03, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x30, 0x01,
  0xF3, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x01, 0xFC, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0xFC, 0x0C, 0x7F, 0xC1, 0xB8, 0x1C, 0x6C,
  0x01, 0xCF, 0x00, 0x19, 0xC0, 0x03, 0xB8, 0x00, 0x36, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00,
  0x0C, 0xE0, 0x01, 0x8C, 0x00, 0x61, 0xC0, 0x1C, 0x1C, 0x07, 0x01, 0xE7,
  0xC0, 0x1F, 0xE0, 0x00, 0x20, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0xF8,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x0C, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x06,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x1C,
  0x07, 0x00, 0x18, 0x03, 0x80, 0x70, 0x01, 0xC0, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0x81, 0xC0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x70,
  0x18, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x70, 0x00, 0xE0,
  0x30, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x1F, 0x9F, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xF0, 0x03, 0xEF, 0x80, 0x70,
  0x1C, 0x0C, 0x00, 0xC1, 0xC0, 0x0E, 0x38, 0x00, 0x63, 0x00, 0x06, 0x30,
  0x00, 0x66, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0xEC, 0x00, 0x1E, 0x60, 0x01, 0x66, 0x00, 0x3C, 0x70, 0x06,
  0xC3, 0x81, 0xCC, 0x1F, 0xF8, 0xC0, 0x7E, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x07,
  0xF0, 0x00, 0x7C, 0x00, 0x00, 0x06, 0x0F, 0x0F, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0xE0, 0x00, 0x00, 0xC0,
  0x3C, 0x07, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x01, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xC0, 0x08, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x0F, 0x3C, 0x1C, 0x0E, 0x30, 0x06, 0x70, 0x06, 0x60, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x04, 0x06, 0x00, 0x3E, 0x00,
  0x30, 0x60, 0x07, 0xFC, 0x01, 0x87, 0x00, 0x70, 0x70, 0x0C, 0x30, 0x06,
  0x01, 0x80, 0x63, 0x80, 0x60, 0x0C, 0x03, 0x18, 0x03, 0x00, 0x60, 0x18,
  0xC0, 0x30, 0x02, 0x00, 0xCC, 0x01, 0x00, 0x30, 0x06, 0x60, 0x18, 0x01,
  0x80, 0x32, 0x00, 0xC0, 0x0C, 0x01, 0xB0, 0x0C, 0x00, 0x40, 0x0D, 0x80,
  0x60, 0x06, 0x00, 0x4C, 0x03, 0x00, 0x30, 0x06, 0x40, 0x30, 0x01, 0x80,
  0x36, 0x01, 0x80, 0x08, 0x01, 0xB0, 0x0C, 0x00, 0xC0, 0x09, 0x80, 0x60,
  0x06, 0x00, 0xCC, 0x02, 0x00, 0x30, 0x06, 0x60, 0x30, 0x03, 0x00, 0x23,
  0x01, 0x80, 0x18, 0x03, 0x18, 0x0C, 0x01, 0xC0, 0x18, 0xC0, 0x60, 0x0E,
  0x01, 0x86, 0x01, 0x80, 0x90, 0x1C, 0x30, 0x0C, 0x0C, 0xC0, 0xC1, 0x80,
  0x79, 0xC7, 0x1C, 0x0C, 0x01, 0xF8, 0x1F, 0x80, 0x60, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x04,
  0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x03,
  0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x01, 0x80,
  0x03, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0C, 0x00, 0x06, 0x06,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x30, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x03, 0x00, 0x3C, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x03,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x0C, 0x00, 0xF0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x18, 0x00, 0xF0, 0x18, 0x00, 0x38, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60,
  0x00, 0x70, 0x60, 0x00, 0xE0, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xC7, 0xC0,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x70, 0x00,
  0x18, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x03, 0xE7, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00,
  0x38, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x18, 0x18,
  0x00, 0x06, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C,
  0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x18, 0x00,
  0x03, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x1E, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xE7, 0xE0, 0x03, 0xC0,
  0x1C, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x1C, 0x18,
  0x00, 0x03, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x01, 0xFF, 0xC6,
  0x00, 0x7F, 0xF1, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x71, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x0C,
  0x00, 0x03, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x1C, 0x00, 0xF0,
  0x03, 0xF3, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x03, 0x00, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60,
  0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0,
  0xC0, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0x80, 0x60, 0x03, 0x80,
  0x70, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x03, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x38, 0x03, 0x00, 0x07, 0x00, 0x30, 0x00, 0xE0,
  0x06, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x70, 0x00, 0x60,
  0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0C,
  0x70, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x19, 0xF0, 0x00, 0x01, 0xB9, 0x80,
  0x00, 0x1F, 0x18, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x30, 0x07, 0x00, 0x03, 0x00, 0x30, 0x00, 0x30, 0x03,
  0x80, 0x03, 0x00, 0x18, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0xE0, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x70, 0x06, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x01, 0xB0, 0x2C, 0x00, 0x00, 0x1A, 0x06, 0xC0, 0x00,
  0x03, 0x60, 0x66, 0x00, 0x00, 0x36, 0x06, 0x60, 0x00, 0x06, 0x60, 0x66,
  0x00, 0x00, 0x66, 0x06, 0x60, 0x00, 0x0C, 0x60, 0x46, 0x00, 0x00, 0xCC,
  0x0C, 0x60, 0x00, 0x18, 0xC0, 0xC3, 0x00, 0x01, 0x8C, 0x0C, 0x30, 0x00,
  0x30, 0xC0, 0xC3, 0x00, 0x07, 0x0C, 0x0C, 0x30, 0x00, 0x60, 0xC1, 0x83,
  0x00, 0x0C, 0x18, 0x18, 0x10, 0x00, 0xC1, 0x81, 0x81, 0x80, 0x18, 0x18,
  0x18, 0x18, 0x01, 0x81, 0x81, 0x81, 0x80, 0x30, 0x18, 0x18, 0x18, 0x03,
  0x03, 0x83, 0x01, 0x80, 0x60, 0x30, 0x30, 0x0C, 0x06, 0x03, 0x03, 0x00,
  0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x30,
  0x30, 0x0C, 0x18, 0x06, 0x06, 0x00, 0x43, 0x00, 0x60, 0x60, 0x06, 0x30,
  0x06, 0x06, 0x00, 0x66, 0x00, 0x60, 0x60, 0x06, 0xE0, 0x06, 0x06, 0x00,
  0x6C, 0x00, 0x60, 0x60, 0x07, 0xC0, 0x0C, 0x0C, 0x00, 0x38, 0x00, 0xC0,
  0xC0, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0x80, 0xF0, 0x00, 0x06,
  0x03, 0xC0, 0x00, 0x18, 0x0D, 0x80, 0x00, 0x60, 0x76, 0x00, 0x03, 0x81,
  0x98, 0x00, 0x0C, 0x06, 0x30, 0x00, 0x30, 0x18, 0xC0, 0x00, 0xC0, 0x61,
  0x80, 0x03, 0x01, 0x86, 0x00, 0x0C, 0x0C, 0x18, 0x00, 0x70, 0x30, 0x30,
  0x01, 0x80, 0xC0, 0xC0, 0x06, 0x03, 0x03, 0x00, 0x18, 0x0C, 0x06, 0x00,
  0x60, 0x70, 0x18, 0x01, 0x81, 0x80, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0x30,
  0x18, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x0E,
  0x00, 0x30, 0x70, 0x30, 0x00, 0xC1, 0x80, 0xC0, 0x03, 0x06, 0x03, 0x00,
  0x06, 0x18, 0x0C, 0x00, 0x18, 0x60, 0x30, 0x00, 0x61, 0x81, 0x80, 0x00,
  0xCE, 0x06, 0x00, 0x03, 0x30, 0x18, 0x00, 0x06, 0xC0, 0x60, 0x00, 0x1B,
  0x01, 0x80, 0x00, 0x6C, 0x06, 0x00, 0x00, 0xF0, 0x30, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x38,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03,
  0x30, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x07, 0x00,
  0x07, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x03, 0xF7, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x30, 0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00,
  0x06, 0x07, 0x00, 0x03, 0x81, 0x80, 0x01, 0xC0, 0x60, 0x01, 0xE0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x18, 0x18, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x38, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0E,
  0x07, 0x00, 0x07, 0x00, 0xC0, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x03, 0xF7,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x30,
  0x01, 0xE0, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x60,
  0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x81, 0x80, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x80, 0x60,
  0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xE7, 0xE0, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x03,
  0x80, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x06, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x06, 0x38, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x07, 0x03, 0x00,
  0x03, 0x80, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x03, 0xF3, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C,
  0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00,
  0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x00,
  0xC0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x63, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x0E, 0x00, 0x06, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03,
  0x00, 0xC0, 0x03, 0x80, 0x60, 0x01, 0x80, 0x30, 0x01, 0xC0, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0,
  0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x06,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x31, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x01, 0xC0,
  0x00, 0x6E, 0x00, 0x07, 0x00, 0x01, 0x98, 0x00, 0x14, 0x00, 0x0C, 0x60,
  0x00, 0xD0, 0x00, 0x31, 0x80, 0x03, 0x40, 0x00, 0xC6, 0x00, 0x19, 0x80,
  0x06, 0x18, 0x00, 0x66, 0x00, 0x18, 0x60, 0x01, 0x98, 0x00, 0xE1, 0x80,
  0x0C, 0x60, 0x03, 0x06, 0x00, 0x31, 0x80, 0x0C, 0x18, 0x01, 0x86, 0x00,
  0x60, 0x60, 0x06, 0x18, 0x01, 0x81, 0x80, 0x10, 0x60, 0x06, 0x06, 0x00,
  0xC1, 0x80, 0x30, 0x18, 0x03, 0x02, 0x00, 0xC0, 0x60, 0x18, 0x08, 0x07,
  0x01, 0x80, 0x60, 0x30, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x1C, 0x0C,
  0x03, 0x03, 0x00, 0x30, 0x30, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x30, 0x30,
  0x03, 0x06, 0x00, 0xC1, 0x80, 0x0C, 0x10, 0x03, 0x06, 0x00, 0x30, 0xC0,
  0x0C, 0x38, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0xC3, 0x00,
  0x0C, 0x60, 0x01, 0x18, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00,
  0x19, 0x80, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00,
  0x36, 0x00, 0x06, 0xC0, 0x00, 0xD0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0xE0, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x30, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0x98, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0xC7, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xC0,
  0x00, 0x60, 0x70, 0x00, 0x60, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x38, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x18, 0x00,
  0x18, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x66, 0x00, 0x00, 0x17, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x81,
  0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x40, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x10, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x0F, 0xE0, 0x3F,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0xB0, 0x06, 0xC0,
  0x31, 0x00, 0xC4, 0x06, 0x18, 0x18, 0x60, 0xC1, 0x83, 0x06, 0x18, 0x18,
  0x60, 0x23, 0x00, 0xCC, 0x03, 0x60, 0x0D, 0x80, 0x3C, 0x00, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFC, 0xE1, 0x83, 0x0E, 0x18, 0x30, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x7C, 0xF8, 0x07, 0x00, 0xC0, 0x60, 0x03, 0x06,
  0x00, 0x18, 0x30, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x03,
  0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0x00, 0x60, 0xE0, 0x03, 0x0C, 0x00, 0x18,
  0xC0, 0x01, 0x86, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00,
  0x38, 0xC0, 0x01, 0xC6, 0x00, 0x1E, 0x38, 0x01, 0xE0, 0xC0, 0x3B, 0x07,
  0xDF, 0x98, 0x0F, 0xF0, 0xC0, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x3F, 0xC0, 0x19, 0xE7, 0xC0, 0x6C,
  0x03, 0x01, 0xE0, 0x0E, 0x0F, 0x00, 0x18, 0x38, 0x00, 0x60, 0xC0, 0x00,
  0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x31, 0x80, 0x00, 0xC6,
  0x00, 0x03, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00,
  0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x31, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x70,
  0x00, 0xC1, 0xE0, 0x07, 0x06, 0xC0, 0x38, 0x31, 0xE7, 0xC0, 0xC3, 0xFC,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xF0, 0x03, 0xE7, 0xC0,
  0x70, 0x0C, 0x0E, 0x00, 0x61, 0xC0, 0x06, 0x18, 0x00, 0x73, 0x00, 0x03,
  0x30, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x0C, 0xC0,
  0x00, 0xCC, 0x00, 0x18, 0xC0, 0x01, 0x86, 0x00, 0x30, 0x60, 0x07, 0x07,
  0x00, 0xE0, 0x3E, 0x7C, 0x00, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0xFE,
  0x0C, 0x03, 0xE7, 0x98, 0x07, 0x00, 0xD8, 0x0E, 0x00, 0x58, 0x0C, 0x00,
  0x78, 0x18, 0x00, 0x38, 0x18, 0x00, 0x38, 0x30, 0x00, 0x30, 0x30, 0x00,
  0x30, 0x30, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00,
  0x30, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xC0, 0xC0, 0x00,
  0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0x60, 0x01,
  0x80, 0x60, 0x07, 0x80, 0x30, 0x0D, 0x80, 0x3E, 0x79, 0x80, 0x1F, 0xF1,
  0x80, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xF0, 0x03, 0xE7, 0xC0,
  0x70, 0x0C, 0x0E, 0x00, 0x61, 0xC0, 0x06, 0x18, 0x00, 0x63, 0x00, 0x03,
  0x30, 0x00, 0x37, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00,
  0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEC, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x01, 0x03,
  0x80, 0x70, 0x1F, 0x3E, 0x00, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x1E, 0x40, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x83, 0x00, 0xF9,
  0xE6, 0x01, 0xC0, 0x36, 0x03, 0x80, 0x16, 0x03, 0x00, 0x1E, 0x06, 0x00,
  0x0E, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00,
  0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00,
  0x18, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00,
  0x30, 0x30, 0x00, 0x30, 0x18, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x18, 0x01,
  0xE0, 0x0C, 0x03, 0x60, 0x0F, 0x9E, 0x60, 0x07, 0xFC, 0x60, 0x00, 0x40,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x40, 0x03, 0x80, 0x60, 0x07, 0x00, 0x38, 0x0E,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x61, 0xFC, 0x03, 0x3C, 0xF0, 0x1B, 0x80, 0xC0, 0xD0,
  0x06, 0x0D, 0x80, 0x18, 0x78, 0x00, 0xC3, 0x80, 0x06, 0x1C, 0x00, 0x30,
  0xC0, 0x01, 0x86, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00,
  0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x03, 0x18,
  0x00, 0x18, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03,
  0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80,
  0x03, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xC0, 0x03, 0x03, 0xC0, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x1C, 0x18, 0x00, 0xE0, 0x60,
  0x07, 0x01, 0x80, 0x38, 0x0C, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0xC0, 0x70,
  0x03, 0x03, 0x80, 0x0C, 0x1C, 0x00, 0x30, 0xE0, 0x01, 0x87, 0x00, 0x06,
  0x38, 0x00, 0x19, 0xC0, 0x00, 0x6F, 0x00, 0x01, 0xEE, 0x00, 0x07, 0x18,
  0x00, 0x38, 0x70, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x80, 0x0C, 0x06, 0x00,
  0x30, 0x1C, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xE0, 0x18, 0x01, 0x80, 0x60,
  0x07, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x38, 0x38, 0x00, 0x60, 0xC0, 0x01,
  0xC0, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x61, 0xFC, 0x03, 0xFC, 0x06, 0x79, 0xE0,
  0xF9, 0xE0, 0x6C, 0x07, 0x1C, 0x06, 0x0D, 0x80, 0x33, 0x80, 0x30, 0xD0,
  0x01, 0xB0, 0x03, 0x0E, 0x00, 0x1E, 0x00, 0x30, 0xE0, 0x01, 0xC0, 0x03,
  0x0C, 0x00, 0x1C, 0x00, 0x30, 0xC0, 0x01, 0x80, 0x03, 0x18, 0x00, 0x18,
  0x00, 0x31, 0x80, 0x01, 0x80, 0x03, 0x18, 0x00, 0x30, 0x00, 0x31, 0x80,
  0x03, 0x00, 0x03, 0x18, 0x00, 0x30, 0x00, 0x31, 0x80, 0x03, 0x00, 0x06,
  0x30, 0x00, 0x30, 0x00, 0x63, 0x00, 0x03, 0x00, 0x06, 0x30, 0x00, 0x60,
  0x00, 0x63, 0x00, 0x06, 0x00, 0x06, 0x30, 0x00, 0x60, 0x00, 0x67, 0x00,
  0x06, 0x00, 0x0C, 0x60, 0x00, 0x60, 0x00, 0xC6, 0x00, 0x06, 0x00, 0x0C,
  0x60, 0x00, 0xC0, 0x00, 0xC6, 0x00, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0xC0,
  0x00, 0xCE, 0x00, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xC0, 0x01, 0x8C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0xFE, 0x01, 0x9E, 0x78, 0x0D,
  0xC0, 0x60, 0x68, 0x03, 0x06, 0x80, 0x0C, 0x3C, 0x00, 0x61, 0xC0, 0x03,
  0x0E, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80,
  0x01, 0x8C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x31,
  0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00,
  0x30, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x06, 0x18,
  0x00, 0x30, 0xC0, 0x01, 0x8E, 0x00, 0x0C, 0x60, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0xF9, 0xF0, 0x0E, 0x01, 0xC0, 0x60, 0x07, 0x06,
  0x00, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x07, 0x30, 0x00, 0x19, 0x80, 0x00,
  0xCC, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D,
  0x80, 0x00, 0x6C, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00,
  0x18, 0x60, 0x01, 0xC3, 0x00, 0x0C, 0x1C, 0x00, 0xC0, 0x70, 0x1E, 0x01,
  0xF3, 0xC0, 0x07, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x8F, 0xF0, 0x01, 0x9E, 0x7C, 0x01, 0xB0, 0x0C, 0x01, 0xE0, 0x0E, 0x03,
  0xC0, 0x06, 0x03, 0x80, 0x06, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03,
  0x00, 0x03, 0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06,
  0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C,
  0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x1C,
  0x00, 0x30, 0x1E, 0x00, 0x70, 0x1B, 0x00, 0xE0, 0x31, 0xE7, 0xC0, 0x30,
  0xFF, 0x00, 0x30, 0x18, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x20, 0x3E, 0x79, 0x81, 0xC0, 0x36, 0x0E, 0x00,
  0x58, 0x30, 0x01, 0xE1, 0x80, 0x03, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x30,
  0xC0, 0x00, 0xC3, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80,
  0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x63, 0x00, 0x01,
  0x8C, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C,
  0x00, 0x0C, 0x30, 0x00, 0x30, 0x60, 0x01, 0xC1, 0x80, 0x06, 0x06, 0x00,
  0x38, 0x0C, 0x03, 0x60, 0x3E, 0x79, 0x80, 0x7F, 0xC6, 0x00, 0x10, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x3F, 0x06, 0x7F, 0x06, 0xC0,
  0x07, 0x80, 0x0D, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xF8, 0x03, 0xE7, 0xC0,
  0x70, 0x0E, 0x0E, 0x00, 0x60, 0xC0, 0x07, 0x0C, 0x00, 0x31, 0x80, 0x03,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xCC, 0x00, 0x18, 0xC0, 0x01, 0x8E, 0x00, 0x18, 0x60, 0x03, 0x07,
  0x00, 0xE0, 0x3E, 0x7C, 0x00, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xE0,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x7A, 0x03, 0xE0, 0x08, 0x00, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86,
  0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x01,
  0x86, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x1C, 0x00, 0x18,
  0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00,
  0x18, 0x60, 0x00, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x70, 0xC0, 0x07, 0x07,
  0x00, 0x78, 0x18, 0x06, 0xC0, 0xF9, 0xE6, 0x03, 0xFE, 0x30, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x36, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0C, 0x60,
  0x00, 0xC6, 0x00, 0x18, 0x60, 0x01, 0x82, 0x00, 0x30, 0x30, 0x03, 0x03,
  0x00, 0x70, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x18, 0x18, 0x01, 0x81, 0x80, 0x18, 0x30, 0x01, 0x83, 0x00, 0x18, 0x60,
  0x01, 0x86, 0x00, 0x08, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xD8,
  0x00, 0x0D, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xB0, 0x01, 0xE0, 0x06, 0x60, 0x0D, 0x80, 0x39, 0x80, 0x36, 0x00,
  0xC6, 0x00, 0xD8, 0x03, 0x18, 0x06, 0x60, 0x18, 0x60, 0x19, 0x80, 0x61,
  0x80, 0xC6, 0x03, 0x86, 0x03, 0x18, 0x0C, 0x18, 0x18, 0x60, 0x30, 0x60,
  0x61, 0x81, 0x81, 0x81, 0x86, 0x06, 0x06, 0x0C, 0x08, 0x38, 0x18, 0x30,
  0x30, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x18, 0x06, 0x30, 0x0C,
  0x60, 0x08, 0xC0, 0x33, 0x80, 0x33, 0x00, 0xCC, 0x00, 0xD8, 0x03, 0x30,
  0x03, 0x60, 0x0D, 0x80, 0x0F, 0x00, 0x36, 0x00, 0x3C, 0x00, 0x58, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x06, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x70,
  0x1C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x38, 0x00,
  0x60, 0x60, 0x00, 0x61, 0x80, 0x00, 0xC7, 0x00, 0x01, 0x9C, 0x00, 0x01,
  0xB0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x6C, 0x00, 0x01, 0xD8, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x38, 0x30, 0x00, 0xE0, 0x60, 0x01, 0x80, 0xE0, 0x06, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x80, 0x07, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x00,
  0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x70, 0x0C, 0x00,
  0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x1C, 0x00, 0x60,
  0x0C, 0x00, 0x30, 0x06, 0x00, 0x18, 0x06, 0x00, 0x04, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x04, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x10, 0x00, 0x01, 0x80, 0xC0,
  0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x08, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0xCE,
  0x1C, 0x00, 0x66, 0x07, 0x00, 0x26, 0x01, 0xC0, 0x33, 0x00, 0x70, 0x3B,
  0x00, 0x1C, 0x39, 0x80, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLightItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 9, 39, 10, 1, -38 },
  { 45, 9, 11, 14, 6, -41 },
  { 58, 27, 38, 26, 1, -38 },
  { 187, 22, 50, 25, 2, -44 },
  { 325, 25, 40, 34, 5, -39 },
  { 450, 24, 40, 28, 2, -39 },
  { 570, 4, 11, 9, 5, -41 },
  { 576, 15, 55, 15, 3, -43 },
  { 680, 15, 55, 15, -3, -43 },
  { 784, 21, 21, 22, 3, -38 },
  { 840, 22, 28, 26, 2, -32 },
  { 917, 7, 11, 10, -2, -4 },
  { 927, 10, 2, 14, 2, -18 },
  { 930, 4, 4, 12, 1, -3 },
  { 932, 22, 41, 18, -2, -38 },
  { 1045, 21, 40, 25, 3, -39 },
  { 1150, 12, 38, 25, 7, -38 },
  { 1207, 23, 39, 25, 1, -39 },
  { 1320, 22, 40, 25, 2, -39 },
  { 1430, 23, 38, 25, 1, -38 },
  { 1540, 23, 39, 25, 3, -38 },
  { 1653, 19, 39, 25, 3, -38 },
  { 1746, 22, 38, 25, 4, -38 },
  { 1851, 24, 40, 25, 1, -39 },
  { 1971, 20, 39, 25, 4, -39 },
  { 2069, 8, 29, 10, 1, -28 },
  { 2098, 11, 35, 10, -2, -28 },
  { 2147, 20, 21, 24, 2, -28 },
  { 2200, 20, 13, 26, 3, -24 },
  { 2233, 21, 21, 24, 1, -28 },
  { 2289, 16, 40, 21, 5, -39 },
  { 2369, 37, 49, 42, 2, -37 },
  { 2596, 26, 38, 28, -2, -38 },
  { 2720, 24, 38, 28, 2, -38 },
  { 2834, 26, 40, 30, 3, -39 },
  { 2964, 26, 38, 30, 2, -38 },
  { 3088, 26, 38, 26, 2, -38 },
  { 3212, 26, 38, 26, 2, -38 },
  { 3336, 26, 40, 31, 3, -39 },
  { 3466, 29, 38, 32, 2, -38 },
  { 3604, 8, 38, 13, 3, -38 },
  { 3642, 24, 39, 25, 1, -38 },
  { 3759, 28, 38, 29, 2, -38 },
  { 3892, 18, 38, 24, 2, -38 },
  { 3978, 36, 38, 39, 2, -38 },
  { 4149, 30, 38, 32, 2, -38 },
  { 4292, 26, 40, 31, 3, -39 },
  { 4422, 26, 38, 28, 2, -38 },
  { 4546, 26, 46, 31, 3, -39 },
  { 4696, 26, 38, 29, 2, -38 },
  { 4820, 26, 40, 27, 1, -39 },
  { 4950, 25, 38, 27, 5, -38 },
  { 5069, 27, 39, 30, 3, -38 },
  { 5201, 25, 38, 28, 5, -38 },
  { 5320, 38, 38, 41, 5, -38 },
  { 5501, 30, 38, 28, -1, -38 },
  { 5644, 25, 38, 27, 5, -38 },
  { 5763, 28, 38, 27, 0, -38 },
  { 5896, 15, 52, 11, 0, -44 },
  { 5994, 7, 41, 18, 6, -38 },
  { 6030, 14, 52, 11, -3, -44 },
  { 6121, 14, 19, 19, 3, -38 },
  { 6155, 19, 2, 20, -3, 0 },
  { 6160, 6, 7, 14, 7, -40 },
  { 6166, 21, 31, 25, 1, -30 },
  { 6248, 22, 42, 25, 1, -41 },
  { 6364, 20, 31, 24, 2, -30 },
  { 6442, 24, 42, 25, 2, -41 },
  { 6568, 20, 31, 24, 2, -30 },
  { 6646, 17, 42, 15, 3, -42 },
  { 6736, 24, 41, 25, 0, -30 },
  { 6859, 21, 41, 25, 1, -41 },
  { 6967, 9, 39, 11, 2, -39 },
  { 7011, 18, 50, 11, -7, -39 },
  { 7124, 22, 41, 22, 1, -41 },
  { 7237, 9, 41, 11, 2, -41 },
  { 7284, 36, 30, 40, 1, -30 },
  { 7419, 21, 30, 25, 1, -30 },
  { 7498, 21, 31, 26, 2, -30 },
  { 7580, 24, 41, 25, -1, -30 },
  { 7703, 22, 41, 25, 2, -30 },
  { 7816, 16, 30, 16, 1, -30 },
  { 7876, 20, 31, 23, 1, -30 },
  { 7954, 12, 37, 15, 3, -36 },
  { 8010, 21, 30, 25, 3, -29 },
  { 8089, 20, 29, 22, 3, -29 },
  { 8162, 30, 29, 34, 4, -29 },
  { 8271, 23, 29, 22, -1, -29 },
  { 8355, 25, 40, 22, -2, -29 },
  { 8480, 22, 29, 22, 0, -29 },
  { 8560, 17, 53, 15, 2, -42 },
  { 8673, 9, 45, 11, 1, -38 },
  { 8724, 17, 53, 15, -3, -42 },
  { 8837, 25, 9, 31, 3, -20 },
};

const GFXfont RobotoCondensed_ExtraLightItalic54pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic54pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic54pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC54PT7B_H_
