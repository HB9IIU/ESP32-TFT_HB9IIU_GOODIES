#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC61PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x3C, 0x07, 0x00, 0x00, 0x30, 0xDC, 0x37, 0x0D,
  0x87, 0x61, 0x98, 0x66, 0x1B, 0x86, 0xC1, 0xB0, 0xCC, 0x33, 0x0C, 0xC3,
  0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x07, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x07, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0xC0, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x18, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3C, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x38,
  0x00, 0x60, 0x18, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x0E,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x31, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x18,
  0x00, 0x06, 0x0C, 0x00, 0x07, 0x07, 0x00, 0x03, 0x81, 0x80, 0x03, 0x80,
  0xE0, 0x03, 0x80, 0x38, 0x07, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x30, 0x18, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x86,
  0x00, 0xC0, 0x18, 0xC0, 0x0C, 0x01, 0x8C, 0x00, 0xC0, 0x30, 0xC0, 0x0C,
  0x06, 0x0C, 0x00, 0xC0, 0xE0, 0xC0, 0x18, 0x0C, 0x0C, 0x01, 0x81, 0x80,
  0xC0, 0x18, 0x38, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0x30, 0x60, 0x06, 0x06,
  0x0C, 0x00, 0x7F, 0xC0, 0xC0, 0x03, 0xF8, 0x18, 0x00, 0x04, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x81, 0xF8, 0x00, 0x30, 0x7B, 0xC0, 0x06, 0x0E,
  0x06, 0x00, 0x60, 0xC0, 0x60, 0x0C, 0x18, 0x03, 0x01, 0x81, 0x80, 0x30,
  0x38, 0x18, 0x03, 0x03, 0x03, 0x00, 0x30, 0x60, 0x30, 0x03, 0x0E, 0x03,
  0x00, 0x30, 0xC0, 0x30, 0x03, 0x18, 0x03, 0x00, 0x63, 0x00, 0x30, 0x06,
  0x30, 0x03, 0x00, 0x62, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x18, 0x38, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1C, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x03,
  0x00, 0x06, 0x00, 0x60, 0x01, 0xC0, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x0E, 0x00, 0x18, 0x03, 0x80, 0x03, 0x00, 0x60,
  0x00, 0x70, 0x1C, 0x00, 0x06, 0x07, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x1C,
  0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x0C,
  0x00, 0x01, 0xC1, 0xC0, 0x0C, 0x70, 0x1C, 0x03, 0x8C, 0x01, 0x80, 0x63,
  0x80, 0x38, 0x0C, 0xE0, 0x03, 0x01, 0x98, 0x00, 0x70, 0x63, 0x00, 0x06,
  0x0C, 0xE0, 0x00, 0xE3, 0x9C, 0x00, 0x0E, 0x63, 0x00, 0x00, 0xDC, 0x60,
  0x00, 0x1F, 0x0C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x0F,
  0x03, 0x80, 0x03, 0xF0, 0x70, 0x00, 0xE6, 0x07, 0x80, 0x38, 0xE0, 0x7E,
  0x7C, 0x0E, 0x07, 0xFF, 0x00, 0xC0, 0x0F, 0x00, 0x00, 0x31, 0x8C, 0x63,
  0x39, 0x8C, 0x63, 0x39, 0x8C, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x01, 0xE0, 0x38, 0x0F,
  0xF0, 0x60, 0xFC, 0xFC, 0xCF, 0xC0, 0x7F, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xEC, 0x00, 0x03, 0x8C, 0x00, 0x0E,
  0x18, 0x00, 0x38, 0x18, 0x00, 0x60, 0x38, 0x01, 0xC0, 0x30, 0x07, 0x00,
  0x70, 0x1C, 0x00, 0x60, 0x10, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x1C, 0x38, 0x70, 0xC1,
  0x87, 0x0C, 0x38, 0x61, 0xC7, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0x77, 0x9C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x0C, 0x01, 0x80, 0x0E, 0x03, 0x00,
  0x06, 0x07, 0x00, 0x06, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x38, 0x00, 0x03, 0x38, 0x00, 0x03, 0x30, 0x00, 0x07, 0x30, 0x00,
  0x07, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x60, 0x00,
  0xC0, 0x70, 0x01, 0xC0, 0x30, 0x03, 0x80, 0x38, 0x0F, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x01, 0xE0, 0x1F,
  0x83, 0xF6, 0x3E, 0x1B, 0xE0, 0xEE, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xE0, 0x3C,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x18, 0x00, 0x18, 0x0E, 0x00,
  0x06, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18,
  0x00, 0x06, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x1E, 0x03, 0xC0, 0x0E,
  0x00, 0x60, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x83, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x61, 0x80, 0x00, 0x30,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xC0,
  0xE0, 0x00, 0xC0, 0x38, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x18, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00,
  0x18, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x01, 0xC0, 0x03, 0x80, 0x70,
  0x00, 0xC0, 0x18, 0x00, 0x70, 0x06, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x03, 0x00, 0x60,
  0x00, 0xC0, 0x38, 0x00, 0x30, 0x1C, 0x00, 0x0C, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x7F, 0x00, 0x06, 0xFF, 0xE0, 0x06,
  0xF0, 0xF8, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x60, 0x00,
  0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x03, 0x00,
  0x07, 0x01, 0xC0, 0x07, 0x00, 0x60, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x0F, 0xE0, 0x18, 0xFF, 0xE0, 0xC7, 0x87, 0xC3, 0x30,
  0x07, 0x0D, 0x80, 0x0E, 0x3C, 0x00, 0x19, 0xE0, 0x00, 0x77, 0x00, 0x01,
  0xDC, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6E, 0x00, 0x03, 0x98, 0x00, 0x0C,
  0x60, 0x00, 0x71, 0xC0, 0x01, 0x83, 0x00, 0x0C, 0x0E, 0x00, 0x70, 0x1C,
  0x07, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0C, 0x00, 0x06, 0x03, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60,
  0x70, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x18, 0x00,
  0x0C, 0x03, 0x00, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x0E, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0x03, 0x80, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x01, 0x80, 0x70,
  0x00, 0x38, 0x0C, 0x00, 0x03, 0x03, 0x80, 0x00, 0x60, 0x60, 0x00, 0x0E,
  0x1C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x38, 0x60, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x38, 0x1C, 0x00, 0x06, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00,
  0x70, 0x03, 0xC0, 0x3C, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x1E, 0x03, 0x80, 0x70, 0x03, 0x80, 0xC0, 0x03, 0x03, 0x80, 0x07, 0x0E,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0x39, 0x80,
  0x00, 0x77, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xB0, 0x00,
  0x07, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00,
  0x66, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x98, 0x00, 0x0F, 0x38, 0x00, 0x3C,
  0x30, 0x00, 0xF8, 0x70, 0x03, 0xB0, 0x70, 0x0E, 0xE0, 0xF0, 0x79, 0x80,
  0xFF, 0xE3, 0x00, 0x7E, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x83,
  0xC1, 0xE0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x83, 0xC0, 0x80, 0x00, 0xE0,
  0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x07, 0x81, 0xC1, 0xC0, 0x1C, 0x70,
  0x01, 0x8C, 0x00, 0x33, 0x80, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x1B, 0x80,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0xE0, 0x00, 0xF8, 0x00, 0x30,
  0x30, 0x00, 0xFF, 0x80, 0x0C, 0x1C, 0x00, 0x70, 0x70, 0x03, 0x06, 0x00,
  0x30, 0x0E, 0x00, 0xC3, 0x80, 0x18, 0x01, 0x80, 0x30, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x70, 0x07, 0x00, 0x30, 0x03, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC6, 0x00, 0xE0, 0x03, 0x00, 0x33, 0x80, 0x30, 0x01, 0x80, 0x0C, 0xC0,
  0x1C, 0x00, 0x60, 0x03, 0x30, 0x06, 0x00, 0x18, 0x00, 0xCC, 0x01, 0x80,
  0x06, 0x00, 0x66, 0x00, 0xE0, 0x03, 0x80, 0x19, 0x80, 0x30, 0x00, 0xC0,
  0x06, 0x60, 0x0C, 0x00, 0x30, 0x01, 0x98, 0x03, 0x00, 0x0C, 0x00, 0x66,
  0x01, 0xC0, 0x07, 0x00, 0x33, 0x00, 0x60, 0x01, 0x80, 0x0C, 0xC0, 0x18,
  0x00, 0x60, 0x03, 0x30, 0x06, 0x00, 0x38, 0x01, 0x8C, 0x01, 0x80, 0x0E,
  0x00, 0x63, 0x00, 0x60, 0x07, 0x80, 0x30, 0xC0, 0x18, 0x01, 0xC0, 0x0C,
  0x30, 0x06, 0x00, 0xD8, 0x06, 0x0C, 0x01, 0x80, 0x66, 0x03, 0x83, 0x00,
  0x70, 0x31, 0x81, 0xC0, 0xC0, 0x0F, 0x38, 0x71, 0xE0, 0x38, 0x01, 0xFC,
  0x0F, 0xF0, 0x06, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x60, 0x03,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x06, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xC0, 0x0F, 0x80, 0x18, 0x00, 0x3C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x60, 0x38, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x1C,
  0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x38, 0x0E, 0x00, 0x0F, 0x00, 0xE0,
  0x07, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x1E,
  0x00, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x18,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x18, 0x38, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x03, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x07, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x80,
  0x60, 0x01, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0x80,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0,
  0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x33, 0x80, 0x00, 0x03,
  0x38, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x1E, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0xF8,
  0x00, 0x60, 0x00, 0xF0, 0x01, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x06, 0x01, 0x80, 0x00, 0x78, 0x06,
  0x00, 0x03, 0xC0, 0x18, 0x00, 0x3E, 0x00, 0x60, 0x07, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x0E, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x03,
  0xFF, 0xE3, 0x00, 0x1F, 0xFF, 0x18, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x1E, 0x00,
  0x70, 0x07, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x70, 0x0C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC0, 0x70, 0x00,
  0x18, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x30, 0x01,
  0xC0, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x38, 0x01, 0x80, 0x00,
  0x70, 0x01, 0x80, 0x00, 0xE0, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x3C, 0x00,
  0x00, 0x0C, 0x7C, 0x00, 0x00, 0x0C, 0xEE, 0x00, 0x00, 0x0D, 0xCE, 0x00,
  0x00, 0x0F, 0x87, 0x00, 0x00, 0x1F, 0x07, 0x00, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x60, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x1E,
  0x00, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x06, 0xC0, 0x00,
  0x00, 0x6C, 0x06, 0x60, 0x00, 0x00, 0x76, 0x03, 0x30, 0x00, 0x00, 0x33,
  0x01, 0x98, 0x00, 0x00, 0x39, 0x80, 0xCE, 0x00, 0x00, 0x19, 0xC0, 0x67,
  0x00, 0x00, 0x1C, 0xC0, 0x71, 0x80, 0x00, 0x0C, 0x60, 0x30, 0xC0, 0x00,
  0x0C, 0x30, 0x18, 0x60, 0x00, 0x06, 0x18, 0x0C, 0x30, 0x00, 0x06, 0x1C,
  0x06, 0x1C, 0x00, 0x03, 0x0E, 0x03, 0x06, 0x00, 0x03, 0x06, 0x03, 0x83,
  0x00, 0x01, 0x83, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x01,
  0xC0, 0xC0, 0x60, 0x60, 0x00, 0xC0, 0xE0, 0x30, 0x38, 0x00, 0xE0, 0x70,
  0x18, 0x0C, 0x00, 0x60, 0x30, 0x1C, 0x06, 0x00, 0x70, 0x18, 0x0C, 0x03,
  0x00, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x38, 0x06, 0x03, 0x00, 0xC0, 0x18,
  0x07, 0x01, 0x80, 0x30, 0x1C, 0x03, 0x01, 0xC0, 0x18, 0x0C, 0x01, 0x80,
  0xE0, 0x0C, 0x0E, 0x00, 0xC0, 0x60, 0x06, 0x06, 0x00, 0x60, 0x30, 0x03,
  0x06, 0x00, 0x70, 0x18, 0x01, 0xC3, 0x00, 0x38, 0x0C, 0x00, 0x63, 0x00,
  0x18, 0x0E, 0x00, 0x31, 0x80, 0x0C, 0x07, 0x00, 0x19, 0x80, 0x06, 0x03,
  0x00, 0x0D, 0xC0, 0x03, 0x01, 0x80, 0x06, 0xC0, 0x03, 0x80, 0xC0, 0x01,
  0xE0, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x18, 0x07, 0x80, 0x00, 0x06,
  0x01, 0xF0, 0x00, 0x01, 0x80, 0x6C, 0x00, 0x00, 0xE0, 0x3B, 0x00, 0x00,
  0x38, 0x0E, 0x60, 0x00, 0x0C, 0x03, 0x98, 0x00, 0x03, 0x00, 0xC7, 0x00,
  0x00, 0xC0, 0x30, 0xC0, 0x00, 0x30, 0x0C, 0x30, 0x00, 0x1C, 0x07, 0x0E,
  0x00, 0x07, 0x01, 0xC1, 0x80, 0x01, 0x80, 0x70, 0x60, 0x00, 0x60, 0x18,
  0x0C, 0x00, 0x18, 0x06, 0x03, 0x00, 0x06, 0x01, 0x80, 0xE0, 0x03, 0x80,
  0xE0, 0x18, 0x00, 0xE0, 0x38, 0x06, 0x00, 0x30, 0x0C, 0x01, 0xC0, 0x0C,
  0x03, 0x00, 0x30, 0x03, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0x70, 0x1C, 0x00, 0x60, 0x1C, 0x07, 0x00, 0x1C, 0x06, 0x01, 0x80, 0x03,
  0x01, 0x80, 0x60, 0x00, 0xC0, 0x60, 0x18, 0x00, 0x18, 0x38, 0x0E, 0x00,
  0x06, 0x0E, 0x03, 0x80, 0x01, 0xC3, 0x00, 0xE0, 0x00, 0x30, 0xC0, 0x30,
  0x00, 0x0C, 0x30, 0x0C, 0x00, 0x03, 0x8C, 0x03, 0x00, 0x00, 0x67, 0x01,
  0xC0, 0x00, 0x19, 0xC0, 0x70, 0x00, 0x03, 0x60, 0x18, 0x00, 0x00, 0xD8,
  0x06, 0x00, 0x00, 0x3E, 0x01, 0x80, 0x00, 0x07, 0x80, 0x60, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x07, 0x18, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x70, 0x01, 0xF0, 0x03, 0x00,
  0x01, 0xC0, 0x18, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x00,
  0xC0, 0x70, 0x00, 0x07, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x03, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x38, 0x06, 0x00, 0x03, 0xC0, 0x30, 0x00, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x71, 0x80, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x06, 0x38,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x10, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x60, 0x01,
  0xF0, 0x03, 0x00, 0x03, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x03, 0x80, 0x00, 0x38, 0x18,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0x30, 0x00,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0xE0, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x1C, 0x01, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x01,
  0xC0, 0x1C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x70, 0x06, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x1C, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60,
  0x1C, 0x00, 0x07, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x03, 0x80,
  0x01, 0x80, 0x18, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x78, 0x00, 0x06, 0xE0, 0x00,
  0x36, 0x00, 0x03, 0xB8, 0x00, 0x0D, 0x80, 0x00, 0xCE, 0x00, 0x07, 0x60,
  0x00, 0x73, 0x80, 0x01, 0x98, 0x00, 0x18, 0x60, 0x00, 0x66, 0x00, 0x06,
  0x18, 0x00, 0x31, 0x80, 0x03, 0x86, 0x00, 0x0C, 0x60, 0x00, 0xC1, 0x80,
  0x07, 0x18, 0x00, 0x30, 0x60, 0x01, 0x86, 0x00, 0x1C, 0x18, 0x00, 0x61,
  0x80, 0x06, 0x06, 0x00, 0x30, 0x30, 0x03, 0x81, 0x80, 0x0C, 0x0C, 0x00,
  0xC0, 0x60, 0x07, 0x03, 0x00, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x1C, 0x06,
  0x00, 0x60, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x70, 0x0C,
  0x03, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x07, 0x01, 0x80, 0x30,
  0x0C, 0x01, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0x70, 0x30, 0x03, 0x01, 0x80,
  0x0C, 0x0C, 0x00, 0xC0, 0xE0, 0x03, 0x07, 0x00, 0x18, 0x30, 0x00, 0xC1,
  0x80, 0x06, 0x0C, 0x00, 0x30, 0xE0, 0x01, 0x87, 0x00, 0x0C, 0x30, 0x00,
  0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x06, 0x30,
  0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0xE0, 0x00, 0x67, 0x00, 0x03,
  0x30, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x36, 0x00,
  0x01, 0xB8, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x60, 0x38, 0x00, 0x0E, 0x01, 0x80, 0x01,
  0xC0, 0x18, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x00,
  0xC0, 0x06, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x60, 0x1C, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x70, 0x38, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0xE0, 0x70, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0,
  0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0,
  0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x0C, 0x06,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x80, 0x06, 0xC0, 0x07, 0x60, 0x03, 0x30, 0x03, 0x98, 0x01,
  0x8C, 0x01, 0xC3, 0x00, 0xC1, 0x80, 0xE0, 0xC0, 0x60, 0x60, 0x70, 0x30,
  0x30, 0x18, 0x38, 0x06, 0x18, 0x03, 0x1C, 0x01, 0x8C, 0x00, 0xCE, 0x00,
  0x66, 0x00, 0x37, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xC1, 0xC1, 0x83, 0x83, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0xE0, 0x0F, 0x01, 0xE0, 0x38, 0x00, 0xC0, 0xE0, 0x01, 0xC1,
  0x80, 0x01, 0x87, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0x80, 0x38, 0x78, 0x00,
  0x61, 0xE0, 0x00, 0xC3, 0x80, 0x01, 0x8E, 0x00, 0x03, 0x18, 0x00, 0x06,
  0x70, 0x00, 0x1C, 0xE0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x01, 0xC7,
  0x00, 0x07, 0x8E, 0x00, 0x1B, 0x0C, 0x00, 0x6E, 0x1E, 0x03, 0x9C, 0x1F,
  0xFE, 0x38, 0x1F, 0xF0, 0x70, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x3F, 0xE0, 0x06, 0x7F, 0xF8, 0x07, 0x70,
  0x0E, 0x03, 0xF0, 0x03, 0x01, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x70,
  0x00, 0x30, 0x30, 0x00, 0x18, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0C,
  0x00, 0x03, 0x86, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x61,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x86, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x38, 0x78, 0x00, 0x38, 0x34, 0x00, 0x18, 0x1B, 0x00, 0x1C, 0x0C, 0xE0,
  0x3C, 0x06, 0x3F, 0xFC, 0x07, 0x07, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1E, 0x03, 0xC0, 0x70,
  0x01, 0x81, 0xC0, 0x03, 0x83, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x18, 0x00,
  0x0E, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0x39, 0x80, 0x00, 0x77, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0x63, 0x80, 0x01, 0x83, 0x00, 0x03, 0x07, 0x00, 0x0C, 0x06, 0x00,
  0x38, 0x0F, 0x01, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x1F, 0xF0, 0xE0, 0x0F, 0xFF, 0x18, 0x03, 0xC0, 0x73, 0x00, 0xE0,
  0x03, 0x60, 0x18, 0x00, 0x2C, 0x07, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x70,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x06, 0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x06, 0x07,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x70,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x70, 0x0E, 0x00, 0x1E, 0x00, 0xC0,
  0x06, 0xC0, 0x1E, 0x03, 0xB8, 0x01, 0xFF, 0xE6, 0x00, 0x1F, 0xF0, 0xC0,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x1E, 0x03, 0xC0, 0x70, 0x01, 0x81, 0xC0, 0x03, 0x83, 0x00, 0x03,
  0x0E, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0x77, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x9F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x04, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xF0, 0x07,
  0xCC, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x1C, 0x01,
  0xFF, 0xE3, 0x00, 0x78, 0x0E, 0x60, 0x1C, 0x00, 0x6C, 0x03, 0x00, 0x0D,
  0x80, 0xE0, 0x00, 0xF0, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x30, 0x38, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x38,
  0x18, 0x00, 0x06, 0x07, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x60, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x30, 0x38, 0x00, 0x0E, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C,
  0x00, 0x0E, 0x01, 0xC0, 0x03, 0xC0, 0x18, 0x00, 0xF8, 0x03, 0xC0, 0x77,
  0x00, 0x3F, 0xFC, 0xC0, 0x03, 0xFE, 0x18, 0x00, 0x04, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x02, 0x00, 0x07, 0x00, 0x60, 0x00, 0xC0, 0x0E, 0x00,
  0x78, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x07, 0xF8, 0x03, 0x1F, 0xFC,
  0x03, 0x38, 0x0E, 0x07, 0x60, 0x06, 0x06, 0xC0, 0x06, 0x06, 0x80, 0x07,
  0x07, 0x80, 0x03, 0x07, 0x00, 0x03, 0x0F, 0x00, 0x03, 0x0E, 0x00, 0x03,
  0x0E, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x1C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0E,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x70, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x01, 0x80, 0x70, 0x3C, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x1E, 0x03,
  0x00, 0x1E, 0x03, 0x80, 0x1E, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x1C, 0x00,
  0x60, 0x1C, 0x00, 0x30, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x0C, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x1C, 0x00, 0x01, 0x9C, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0xC0, 0x00, 0x3C, 0x70,
  0x00, 0x1C, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x01,
  0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x70, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x0C,
  0x00, 0x1C, 0x06, 0x00, 0x07, 0x03, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x70,
  0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x87, 0xFC, 0x01, 0xFE, 0x01, 0xC7, 0xFF, 0x03, 0xFF, 0x80, 0xE7,
  0x03, 0xC3, 0x80, 0xE0, 0x66, 0x00, 0xE3, 0x00, 0x30, 0x36, 0x00, 0x33,
  0x00, 0x1C, 0x1E, 0x00, 0x1F, 0x00, 0x06, 0x0E, 0x00, 0x0F, 0x80, 0x03,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0x87, 0x00, 0x03, 0xC0, 0x00, 0xC3, 0x80,
  0x01, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xE0, 0x00, 0x30, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x38, 0x00, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x86, 0x00, 0x03, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x80,
  0x00, 0xE3, 0x80, 0x00, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x8C, 0x00, 0x03, 0x00, 0x01, 0x86, 0x00, 0x03, 0x80, 0x00, 0xC3,
  0x00, 0x01, 0x80, 0x00, 0x61, 0x80, 0x00, 0xC0, 0x00, 0x31, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x07, 0xF8, 0x03, 0x1F, 0xFC, 0x03, 0x38, 0x0E, 0x07, 0x60, 0x0E,
  0x06, 0xC0, 0x06, 0x06, 0x80, 0x07, 0x07, 0x80, 0x03, 0x07, 0x00, 0x03,
  0x07, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x07,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x06,
  0x18, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x38, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x1C,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x70, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x38, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x1C, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x1C, 0x00, 0x06, 0x18, 0x00, 0x07, 0x38, 0x00, 0x07, 0x30, 0x00, 0x03,
  0x30, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60, 0x00, 0x30, 0x70, 0x00, 0x70,
  0x30, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x0F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x7F,
  0xC0, 0x03, 0x3F, 0xFC, 0x00, 0x6E, 0x01, 0xC0, 0x1F, 0x00, 0x18, 0x03,
  0xC0, 0x03, 0x80, 0x70, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x01, 0x80, 0x00,
  0xC0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x30,
  0x00, 0x0E, 0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x06,
  0x07, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x70, 0x00,
  0x1C, 0x0E, 0x00, 0x07, 0x01, 0xE0, 0x00, 0xC0, 0x36, 0x00, 0x38, 0x06,
  0x70, 0x1E, 0x00, 0xC7, 0xFF, 0x80, 0x38, 0x7F, 0xC0, 0x07, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0xC0, 0x7F, 0xF8, 0xC0,
  0x78, 0x0E, 0x60, 0x70, 0x01, 0xB0, 0x30, 0x00, 0x58, 0x38, 0x00, 0x3C,
  0x38, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0E, 0x00, 0x01,
  0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x61, 0xC0, 0x00,
  0x30, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00,
  0x07, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x61, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x0F, 0x01, 0x80, 0x0F, 0x80,
  0xE0, 0x1D, 0x80, 0x3F, 0xFC, 0xC0, 0x0F, 0xF8, 0x60, 0x00, 0x40, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0xC3, 0xF0, 0x33, 0xFC, 0x0D, 0xC0, 0x07, 0x60, 0x01, 0xB0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1E,
  0x01, 0xC0, 0x70, 0x01, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x63, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x06, 0x00,
  0x0E, 0x0E, 0x00, 0x38, 0x0E, 0x01, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x01, 0xFF, 0xEF, 0xFF, 0x81,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x1C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0E,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0C,
  0x30, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x70, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30,
  0xC0, 0x00, 0x70, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xE0,
  0xE0, 0x01, 0xE0, 0x60, 0x03, 0x60, 0x70, 0x07, 0xE0, 0x78, 0x0E, 0xC0,
  0x3F, 0xFC, 0xC0, 0x1F, 0xF0, 0xC0, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x6C, 0x00, 0x03, 0xB8, 0x00, 0x0C, 0xE0, 0x00, 0x71, 0x80,
  0x01, 0x86, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0xC0, 0x06,
  0x07, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x1C, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x80, 0x38, 0x0C, 0x00, 0x60, 0x70, 0x01, 0x81,
  0x80, 0x06, 0x0E, 0x00, 0x18, 0x30, 0x00, 0x61, 0xC0, 0x01, 0x86, 0x00,
  0x07, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xD8, 0x00, 0x03,
  0x60, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x6C, 0x00, 0x1C,
  0x00, 0x3B, 0x00, 0x0F, 0x00, 0x0C, 0xC0, 0x03, 0xC0, 0x03, 0x30, 0x01,
  0xF0, 0x01, 0xCC, 0x00, 0x6C, 0x00, 0x63, 0x80, 0x1B, 0x00, 0x38, 0xE0,
  0x0C, 0xE0, 0x0C, 0x38, 0x03, 0x38, 0x03, 0x06, 0x01, 0x86, 0x01, 0xC1,
  0x80, 0x61, 0x80, 0x60, 0x60, 0x38, 0x60, 0x38, 0x18, 0x0C, 0x18, 0x0C,
  0x06, 0x07, 0x06, 0x03, 0x01, 0x81, 0x81, 0x81, 0x80, 0x60, 0x60, 0x60,
  0x60, 0x18, 0x30, 0x18, 0x38, 0x06, 0x0C, 0x06, 0x0C, 0x01, 0x86, 0x01,
  0xC7, 0x00, 0x61, 0x80, 0x31, 0x80, 0x18, 0xE0, 0x0C, 0x60, 0x06, 0x30,
  0x03, 0x38, 0x01, 0xDC, 0x00, 0xCC, 0x00, 0x76, 0x00, 0x37, 0x00, 0x0D,
  0x80, 0x0D, 0x80, 0x03, 0xC0, 0x03, 0x60, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x03, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0xE0,
  0x18, 0x00, 0x30, 0x06, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x07,
  0x00, 0x0E, 0x01, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x0C,
  0x18, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x03, 0x00, 0x07,
  0x00, 0xC0, 0x01, 0x80, 0x38, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x01, 0xC0,
  0x18, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x70, 0x38, 0x00, 0x06, 0x03, 0x80, 0x00, 0xE0,
  0x18, 0x00, 0x0C, 0x01, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x18, 0x01, 0x80,
  0x01, 0x80, 0x18, 0x00, 0x30, 0x01, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x30,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x04, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0x3C, 0x78, 0x00, 0x63, 0x01, 0xC0, 0x06, 0x60,
  0x0E, 0x00, 0x66, 0x00, 0x70, 0x0C, 0xC0, 0x03, 0x81, 0xCC, 0x00, 0x1C,
  0x38, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 10, 44, 12, 1, -43 },
  { 56, 10, 13, 16, 7, -46 },
  { 73, 31, 43, 29, 1, -43 },
  { 240, 25, 57, 29, 2, -50 },
  { 419, 28, 45, 38, 6, -44 },
  { 577, 27, 45, 32, 2, -44 },
  { 729, 5, 13, 10, 6, -46 },
  { 738, 17, 62, 17, 3, -48 },
  { 870, 16, 62, 17, -3, -48 },
  { 994, 23, 24, 25, 4, -43 },
  { 1063, 24, 32, 29, 3, -36 },
  { 1159, 7, 13, 11, -2, -5 },
  { 1171, 12, 2, 16, 2, -21 },
  { 1174, 5, 4, 13, 1, -3 },
  { 1177, 25, 47, 21, -2, -43 },
  { 1324, 24, 45, 29, 3, -44 },
  { 1459, 14, 43, 29, 8, -43 },
  { 1535, 26, 44, 29, 1, -44 },
  { 1678, 25, 45, 29, 2, -44 },
  { 1819, 26, 43, 29, 1, -43 },
  { 1959, 25, 44, 29, 4, -43 },
  { 2097, 22, 44, 29, 3, -43 },
  { 2218, 24, 43, 29, 5, -43 },
  { 2347, 27, 45, 29, 1, -44 },
  { 2499, 23, 44, 29, 4, -44 },
  { 2626, 9, 32, 11, 1, -31 },
  { 2662, 12, 39, 11, -2, -31 },
  { 2721, 22, 25, 27, 3, -32 },
  { 2790, 23, 14, 29, 3, -27 },
  { 2831, 23, 25, 27, 2, -32 },
  { 2903, 19, 45, 23, 5, -44 },
  { 3010, 42, 56, 47, 2, -42 },
  { 3304, 29, 43, 32, -2, -43 },
  { 3460, 28, 43, 32, 2, -43 },
  { 3611, 28, 45, 34, 4, -44 },
  { 3769, 30, 43, 34, 2, -43 },
  { 3931, 30, 43, 30, 2, -43 },
  { 4093, 30, 43, 29, 2, -43 },
  { 4255, 29, 45, 35, 4, -44 },
  { 4419, 34, 43, 36, 2, -43 },
  { 4602, 10, 43, 14, 3, -43 },
  { 4656, 27, 44, 29, 1, -43 },
  { 4805, 32, 43, 33, 2, -43 },
  { 4977, 21, 43, 27, 2, -43 },
  { 5090, 41, 43, 44, 2, -43 },
  { 5311, 34, 43, 37, 2, -43 },
  { 5494, 30, 45, 35, 3, -44 },
  { 5663, 29, 43, 32, 2, -43 },
  { 5819, 30, 52, 35, 3, -44 },
  { 6014, 29, 43, 33, 2, -43 },
  { 6170, 30, 45, 31, 1, -44 },
  { 6339, 28, 43, 31, 6, -43 },
  { 6490, 31, 44, 34, 3, -43 },
  { 6661, 29, 43, 32, 5, -43 },
  { 6817, 42, 43, 46, 6, -43 },
  { 7043, 34, 43, 31, -1, -43 },
  { 7226, 28, 43, 31, 6, -43 },
  { 7377, 32, 43, 31, 0, -43 },
  { 7549, 17, 59, 13, 0, -50 },
  { 7675, 9, 47, 20, 6, -43 },
  { 7728, 17, 59, 13, -4, -50 },
  { 7854, 17, 22, 22, 3, -43 },
  { 7901, 22, 2, 22, -3, 0 },
  { 7907, 7, 8, 16, 8, -46 },
  { 7914, 23, 34, 28, 1, -33 },
  { 8012, 25, 47, 29, 1, -46 },
  { 8159, 23, 34, 27, 2, -33 },
  { 8257, 27, 47, 29, 2, -46 },
  { 8416, 23, 34, 27, 2, -33 },
  { 8514, 18, 47, 17, 4, -47 },
  { 8620, 27, 45, 29, 0, -33 },
  { 8772, 24, 46, 29, 1, -46 },
  { 8910, 10, 44, 12, 2, -44 },
  { 8965, 20, 56, 12, -8, -44 },
  { 9105, 25, 46, 25, 1, -46 },
  { 9249, 10, 46, 12, 2, -46 },
  { 9307, 41, 33, 46, 1, -33 },
  { 9477, 24, 33, 29, 1, -33 },
  { 9576, 24, 34, 29, 2, -33 },
  { 9678, 27, 45, 29, -1, -33 },
  { 9830, 25, 45, 29, 2, -33 },
  { 9971, 18, 33, 18, 1, -33 },
  { 10046, 23, 34, 26, 1, -33 },
  { 10144, 14, 42, 17, 3, -41 },
  { 10218, 24, 33, 29, 3, -32 },
  { 10317, 22, 32, 25, 4, -32 },
  { 10405, 34, 32, 39, 5, -32 },
  { 10541, 26, 32, 25, -1, -32 },
  { 10645, 28, 44, 25, -2, -32 },
  { 10799, 25, 32, 25, 0, -32 },
  { 10899, 19, 61, 17, 2, -48 },
  { 11044, 10, 51, 12, 1, -43 },
  { 11108, 19, 61, 17, -4, -48 },
  { 11253, 28, 10, 36, 4, -23 },
};

const GFXfont RobotoCondensed_ExtraLightItalic61pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic61pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic61pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC61PT7B_H_
