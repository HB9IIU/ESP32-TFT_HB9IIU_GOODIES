#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC48PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C,
  0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xC0, 0x21,
  0x21, 0x63, 0x63, 0x63, 0x63, 0x42, 0x42, 0xC6, 0xC6, 0x00, 0x04, 0x04,
  0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x10, 0x18, 0x00, 0x30, 0x10, 0x00, 0x30, 0x30,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60,
  0x00, 0x40, 0x40, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x80, 0x80,
  0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0x01, 0x00, 0x03, 0x03, 0x00,
  0x03, 0x03, 0x00, 0x02, 0x02, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x04, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x08, 0x08, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x10, 0x10, 0x00, 0x30, 0x30, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x38, 0x1C, 0x07,
  0x00, 0xC0, 0x60, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x02, 0x08, 0x00, 0x21,
  0x80, 0x02, 0x18, 0x00, 0x21, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0,
  0x01, 0x8C, 0x00, 0x30, 0x60, 0x07, 0x06, 0x00, 0xE0, 0x38, 0x1C, 0x01,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x61, 0x80, 0x01,
  0x81, 0x00, 0x02, 0x03, 0x00, 0x0C, 0x06, 0x03, 0x18, 0x0C, 0x0C, 0x20,
  0x18, 0x10, 0x40, 0x20, 0x60, 0x80, 0x41, 0x81, 0x01, 0x86, 0x02, 0x03,
  0x08, 0x04, 0x0C, 0x30, 0x0C, 0x18, 0xC0, 0x0F, 0xE1, 0x00, 0x0F, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x83, 0xC0, 0x03, 0x1F,
  0xC0, 0x0C, 0x30, 0xC0, 0x10, 0xC0, 0x80, 0x61, 0x01, 0x81, 0x86, 0x03,
  0x06, 0x0C, 0x06, 0x08, 0x10, 0x0C, 0x30, 0x20, 0x10, 0xC0, 0x40, 0x21,
  0x00, 0x80, 0xC6, 0x01, 0x01, 0x80, 0x02, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0x0E,
  0x1C, 0x00, 0x70, 0x30, 0x01, 0x80, 0xC0, 0x04, 0x01, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x30, 0x00,
  0x41, 0x80, 0x01, 0x8C, 0x00, 0x06, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x03,
  0x18, 0x18, 0x08, 0xC0, 0x30, 0x63, 0x00, 0xC1, 0x98, 0x01, 0x84, 0x60,
  0x06, 0x31, 0x80, 0x0C, 0xC4, 0x00, 0x36, 0x10, 0x00, 0x70, 0x60, 0x01,
  0xC1, 0x80, 0x07, 0x03, 0x00, 0x36, 0x0E, 0x03, 0x98, 0x1F, 0xF8, 0x30,
  0x1F, 0x80, 0xC0, 0x6D, 0xB6, 0xB6, 0xD0, 0x00, 0x08, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x0C, 0x0C, 0x0F, 0xC3, 0x0F, 0x3E, 0xDF, 0x01, 0xFE, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x07, 0x60, 0x01, 0x98, 0x00, 0xC3, 0x00, 0x60, 0xE0, 0x30,
  0x18, 0x18, 0x03, 0x02, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x30, 0xC6,
  0x18, 0x63, 0x0C, 0x61, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF0,
  0x06, 0x07, 0x01, 0x80, 0x60, 0x60, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18,
  0x40, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x40, 0x01, 0x98, 0x00, 0x33,
  0x00, 0x06, 0x60, 0x00, 0xC8, 0x00, 0x19, 0x00, 0x03, 0x60, 0x00, 0x4C,
  0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x64, 0x00, 0x0C, 0x80, 0x01, 0xB0,
  0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x23, 0x00, 0x0C, 0x20,
  0x01, 0x86, 0x00, 0x60, 0xC0, 0x1C, 0x1C, 0x03, 0x01, 0x81, 0xC0, 0x1F,
  0xF0, 0x01, 0xF8, 0x00, 0x00, 0x60, 0x3C, 0x3F, 0x9E, 0x27, 0x0D, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01, 0xC0, 0xC0, 0x30,
  0x06, 0x06, 0x00, 0x60, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x18,
  0x00, 0x31, 0x80, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01, 0xC0, 0xE0,
  0x30, 0x06, 0x06, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x08, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x40, 0x00, 0xC4, 0x00, 0x0C, 0x40, 0x00, 0xC6,
  0x00, 0x08, 0x60, 0x01, 0x86, 0x00, 0x30, 0x30, 0x07, 0x01, 0x80, 0xE0,
  0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0x60, 0x00, 0x64, 0x00, 0x06, 0x40, 0x00,
  0xCC, 0x00, 0x18, 0xC0, 0x01, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x08, 0x00,
  0xC1, 0x80, 0x0C, 0x18, 0x01, 0x81, 0x80, 0x30, 0x18, 0x03, 0x01, 0x80,
  0x60, 0x10, 0x0C, 0x03, 0x01, 0x80, 0x30, 0x18, 0x03, 0x03, 0x00, 0x30,
  0x60, 0x03, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x19, 0xF8, 0x01, 0x7F, 0xC0, 0x1C, 0x06, 0x03, 0x80, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x30, 0xC0,
  0x03, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x06, 0x00, 0x60, 0x60, 0x0C, 0x03,
  0x03, 0x80, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF0,
  0x07, 0x80, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0xFC,
  0x0C, 0xFF, 0x83, 0x60, 0x30, 0xB0, 0x06, 0x78, 0x01, 0x9C, 0x00, 0x26,
  0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD0, 0x00, 0x34, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xB0, 0x00, 0x64, 0x00, 0x19, 0x80, 0x0C, 0x60, 0x03,
  0x18, 0x01, 0x83, 0x00, 0xE0, 0xE0, 0x70, 0x1F, 0xF8, 0x01, 0xF8, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xFE, 0x00, 0x70, 0x38, 0x07, 0x00, 0xE0, 0x30, 0x03, 0x03, 0x00,
  0x08, 0x18, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x83,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x06, 0x03, 0x00, 0x60, 0x0C, 0x0E,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x38, 0x38, 0x03, 0x00, 0x60, 0x30,
  0x01, 0x83, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x01, 0x0C, 0x00, 0x08,
  0x40, 0x00, 0x46, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x86, 0x00,
  0x18, 0x30, 0x01, 0xC1, 0xC0, 0x1C, 0x07, 0x01, 0xC0, 0x1F, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x70, 0x30, 0x30, 0x06,
  0x18, 0x01, 0x86, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x60, 0x00, 0xD8,
  0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x34, 0x00,
  0x0D, 0x00, 0x06, 0x60, 0x01, 0x98, 0x00, 0xE6, 0x00, 0x78, 0xC0, 0x36,
  0x38, 0x19, 0x07, 0xFC, 0xC0, 0x7C, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x00, 0x0C, 0x1C, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x70, 0xC0, 0x01, 0x80, 0xF0, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x20,
  0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x20, 0x7F, 0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0x08, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x70, 0x61, 0x80, 0x66, 0x00, 0xCC,
  0x00, 0x90, 0x01, 0x60, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x08, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x81,
  0x80, 0x1E, 0x00, 0x41, 0x80, 0x3F, 0xC0, 0x20, 0x80, 0x30, 0x30, 0x18,
  0xC0, 0x30, 0x18, 0x0C, 0x40, 0x30, 0x08, 0x06, 0x60, 0x30, 0x04, 0x03,
  0x30, 0x18, 0x06, 0x01, 0xB0, 0x18, 0x03, 0x00, 0x98, 0x0C, 0x01, 0x00,
  0x4C, 0x04, 0x00, 0x80, 0x24, 0x06, 0x00, 0xC0, 0x36, 0x03, 0x00, 0x60,
  0x1B, 0x01, 0x00, 0x20, 0x0D, 0x80, 0x80, 0x10, 0x04, 0xC0, 0xC0, 0x18,
  0x06, 0x40, 0x60, 0x0C, 0x03, 0x20, 0x30, 0x0E, 0x01, 0x10, 0x18, 0x06,
  0x01, 0x88, 0x0C, 0x07, 0x00, 0x84, 0x06, 0x06, 0xC0, 0xC2, 0x01, 0x86,
  0x60, 0xC1, 0x00, 0xFE, 0x1F, 0xC0, 0xC0, 0x3E, 0x07, 0x80, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x34, 0x00, 0x00,
  0xCC, 0x00, 0x01, 0x98, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x30,
  0x40, 0x00, 0x60, 0x80, 0x01, 0x81, 0x00, 0x03, 0x03, 0x00, 0x0C, 0x06,
  0x00, 0x18, 0x0C, 0x00, 0x20, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x08, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x40, 0x03, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x10, 0x60,
  0x00, 0x20, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x98, 0x00,
  0x03, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x08, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x01, 0x80, 0x1C, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x82,
  0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0xC3, 0x00, 0x06, 0x10, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x60,
  0x07, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x80, 0x1E, 0x0C, 0x00, 0x30,
  0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x10, 0x80, 0x00, 0xC4, 0x00,
  0x06, 0x60, 0x00, 0x23, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC4,
  0x00, 0x0C, 0x60, 0x00, 0xE3, 0x00, 0x0E, 0x18, 0x00, 0xE0, 0xFF, 0xFE,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1C, 0x07,
  0x00, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC6,
  0x00, 0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x33, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x30, 0x60, 0x00, 0xC1,
  0x80, 0x06, 0x07, 0x00, 0x30, 0x0E, 0x03, 0xC0, 0x1F, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x18, 0x01, 0xC0, 0x30,
  0x01, 0xC0, 0x60, 0x01, 0x80, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00,
  0x02, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x40, 0x00,
  0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x20, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63,
  0x00, 0x00, 0x86, 0x00, 0x03, 0x08, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x60,
  0x00, 0x10, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x04, 0x00,
  0x0C, 0x18, 0x00, 0x30, 0x30, 0x00, 0xE0, 0x60, 0x07, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xE0, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xC0,
  0x01, 0x83, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x3F, 0xE3, 0x00, 0xFF, 0xC4, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00,
  0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0E, 0x00, 0x0E, 0x0C, 0x00,
  0x38, 0x0E, 0x03, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x02, 0x06,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x30, 0x20, 0x00,
  0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x04, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x18, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x03, 0x02, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x60, 0x40, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x08, 0x30, 0x00, 0xC1, 0x80, 0x06,
  0x0C, 0x00, 0x60, 0x20, 0x03, 0x01, 0x80, 0x30, 0x06, 0x07, 0x00, 0x3F,
  0xF0, 0x00, 0x7E, 0x00, 0x00, 0x06, 0x00, 0x03, 0x03, 0x00, 0x03, 0x81,
  0x80, 0x03, 0x80, 0xC0, 0x03, 0x80, 0x60, 0x03, 0x80, 0x20, 0x03, 0x80,
  0x30, 0x03, 0x80, 0x18, 0x03, 0x80, 0x0C, 0x03, 0x80, 0x06, 0x03, 0x80,
  0x03, 0x03, 0x80, 0x01, 0x03, 0x80, 0x01, 0x83, 0x80, 0x00, 0xC3, 0x80,
  0x00, 0x63, 0x80, 0x00, 0x33, 0x80, 0x00, 0x1B, 0xE0, 0x00, 0x0B, 0xB0,
  0x00, 0x0F, 0x8C, 0x00, 0x07, 0x86, 0x00, 0x03, 0x81, 0x80, 0x01, 0x80,
  0xC0, 0x00, 0x80, 0x30, 0x00, 0x40, 0x18, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x70, 0x04, 0x00, 0x18, 0x06,
  0x00, 0x0E, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0x60,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x0F, 0x05, 0x80, 0x00, 0x1A, 0x05, 0x80, 0x00, 0x1E,
  0x0D, 0x80, 0x00, 0x36, 0x0C, 0x80, 0x00, 0x36, 0x0C, 0x80, 0x00, 0x66,
  0x0C, 0xC0, 0x00, 0x66, 0x0C, 0xC0, 0x00, 0xC4, 0x08, 0xC0, 0x00, 0xCC,
  0x18, 0xC0, 0x01, 0x8C, 0x18, 0x40, 0x01, 0x0C, 0x18, 0x40, 0x03, 0x0C,
  0x18, 0x60, 0x02, 0x08, 0x18, 0x60, 0x06, 0x08, 0x10, 0x60, 0x04, 0x18,
  0x30, 0x20, 0x0C, 0x18, 0x30, 0x20, 0x18, 0x18, 0x30, 0x30, 0x18, 0x18,
  0x30, 0x30, 0x30, 0x10, 0x20, 0x30, 0x30, 0x30, 0x20, 0x30, 0x60, 0x30,
  0x60, 0x10, 0x60, 0x30, 0x60, 0x10, 0xC0, 0x30, 0x60, 0x18, 0xC0, 0x30,
  0x60, 0x19, 0x80, 0x20, 0x40, 0x19, 0x80, 0x60, 0xC0, 0x0B, 0x00, 0x60,
  0xC0, 0x0B, 0x00, 0x60, 0xC0, 0x0E, 0x00, 0x60, 0xC0, 0x0E, 0x00, 0x60,
  0xC0, 0x0C, 0x00, 0x40, 0x07, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0x70,
  0x00, 0x0C, 0x1E, 0x00, 0x03, 0x07, 0x80, 0x00, 0x81, 0xA0, 0x00, 0x60,
  0xCC, 0x00, 0x18, 0x33, 0x00, 0x06, 0x0C, 0x60, 0x01, 0x83, 0x18, 0x00,
  0x60, 0xC2, 0x00, 0x30, 0x20, 0xC0, 0x0C, 0x18, 0x30, 0x03, 0x06, 0x06,
  0x00, 0xC1, 0x81, 0x80, 0x30, 0x60, 0x60, 0x08, 0x18, 0x0C, 0x06, 0x04,
  0x03, 0x01, 0x83, 0x00, 0x40, 0x60, 0xC0, 0x18, 0x18, 0x30, 0x06, 0x06,
  0x0C, 0x00, 0xC1, 0x03, 0x00, 0x30, 0xC1, 0x80, 0x04, 0x30, 0x60, 0x01,
  0x8C, 0x18, 0x00, 0x63, 0x06, 0x00, 0x08, 0xC1, 0x80, 0x03, 0x20, 0x60,
  0x00, 0xD8, 0x30, 0x00, 0x1E, 0x0C, 0x00, 0x07, 0x83, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x38, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xC0, 0x07, 0x01, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x00, 0xC1, 0x80, 0x01,
  0x87, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x10, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0xC0, 0x00, 0x19, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x98,
  0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00,
  0x06, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x01,
  0x86, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0x1F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x18, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0x60, 0x00, 0xC0,
  0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x18,
  0x00, 0x08, 0x30, 0x00, 0x30, 0x40, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00,
  0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x70, 0x20, 0x03,
  0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0x01, 0xC0, 0x18, 0x00, 0xC0, 0x60,
  0x01, 0x81, 0x80, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x10, 0x00,
  0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0x40, 0x00, 0x0D,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0x26, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98,
  0x00, 0x03, 0x30, 0x00, 0x06, 0x40, 0x00, 0x08, 0x80, 0x00, 0x31, 0x80,
  0x00, 0x63, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x0C, 0x00,
  0x30, 0x1C, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0x1F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x18, 0x01, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x80, 0x01, 0x83,
  0x00, 0x03, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x18, 0x20,
  0x00, 0x30, 0x40, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x60, 0x60, 0x03, 0x80, 0xFF, 0xFE,
  0x01, 0xFF, 0xF0, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x02, 0x01, 0x80, 0x06, 0x03,
  0x00, 0x0C, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60,
  0x00, 0x30, 0xC0, 0x00, 0x61, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xE0, 0x07, 0x80, 0xE0, 0x1C, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0xC0,
  0x01, 0x81, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00,
  0x00, 0xC2, 0x00, 0x01, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x0C, 0x00,
  0x70, 0x0E, 0x03, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x0C, 0x00,
  0x06, 0x08, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x18, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x30, 0x00, 0x08, 0x30, 0x00,
  0x18, 0x20, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x10, 0x60, 0x00, 0x30, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x70, 0x03,
  0x80, 0x38, 0x0F, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x19, 0x00, 0x00, 0x33, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x8C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60,
  0x40, 0x00, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x18, 0x06,
  0x00, 0x30, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x06, 0x00, 0x30,
  0x0C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x80, 0x03, 0x03,
  0x00, 0x02, 0x06, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0,
  0x00, 0x31, 0x80, 0x00, 0x66, 0x00, 0x00, 0x4C, 0x00, 0x00, 0xB0, 0x00,
  0x01, 0x60, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0xB0, 0x00, 0xE0, 0x00,
  0xD8, 0x00, 0x78, 0x00, 0x6C, 0x00, 0x2C, 0x00, 0x66, 0x00, 0x36, 0x00,
  0x33, 0x00, 0x1B, 0x00, 0x19, 0x80, 0x19, 0x80, 0x18, 0xC0, 0x0C, 0xC0,
  0x0C, 0x60, 0x04, 0x60, 0x04, 0x30, 0x06, 0x10, 0x06, 0x18, 0x03, 0x08,
  0x03, 0x0C, 0x03, 0x04, 0x03, 0x02, 0x01, 0x82, 0x01, 0x81, 0x00, 0x81,
  0x00, 0xC0, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x30, 0x60,
  0x30, 0x20, 0x18, 0x30, 0x18, 0x30, 0x0C, 0x10, 0x0C, 0x18, 0x06, 0x18,
  0x06, 0x08, 0x03, 0x0C, 0x03, 0x0C, 0x01, 0x8C, 0x00, 0x86, 0x00, 0xC6,
  0x00, 0x46, 0x00, 0x62, 0x00, 0x23, 0x00, 0x33, 0x00, 0x11, 0x00, 0x19,
  0x80, 0x0D, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0x40, 0x01,
  0x40, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x01, 0xC0, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x60, 0x18, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x13, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x06, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x0C,
  0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x38,
  0x00, 0x60, 0x06, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x18,
  0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x61, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x18,
  0x0C, 0x00, 0x60, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x0C, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0x60, 0x00, 0xC1, 0x80, 0x01, 0x86, 0x00, 0x03,
  0x0C, 0x00, 0x02, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0xC1, 0x83, 0x06, 0x04, 0x08, 0x18, 0x30, 0x60, 0xC1, 0x81,
  0x02, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x40, 0x81, 0x83, 0x06, 0x0C, 0x18,
  0x10, 0x20, 0x60, 0xC1, 0x83, 0x06, 0x04, 0x08, 0x18, 0x30, 0x60, 0x01,
  0xF8, 0x0F, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x34, 0x03, 0x40, 0x66, 0x06,
  0x60, 0xC6, 0x0C, 0x61, 0x82, 0x18, 0x23, 0x03, 0x30, 0x36, 0x03, 0x60,
  0x3C, 0x01, 0xC0, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x61, 0x83, 0x06,
  0x18, 0x30, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x70, 0x38, 0x30, 0x06, 0x0C,
  0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0x00, 0x63, 0x00, 0x19,
  0x80, 0x06, 0x60, 0x01, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0,
  0x07, 0x30, 0x03, 0xCC, 0x01, 0xA1, 0x81, 0xC8, 0x7F, 0xE6, 0x07, 0xE1,
  0x80, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0xFC, 0x06, 0x7F, 0xC0, 0xD8, 0x1C, 0x1E, 0x01, 0x83, 0x80,
  0x18, 0x60, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00,
  0x31, 0x80, 0x06, 0x20, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00,
  0x46, 0x00, 0x08, 0xC0, 0x03, 0x10, 0x00, 0x66, 0x00, 0x08, 0xC0, 0x03,
  0x18, 0x00, 0x63, 0x80, 0x18, 0x50, 0x07, 0x09, 0x81, 0xC3, 0x1F, 0xF0,
  0x61, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1C, 0x06, 0x07, 0x00,
  0x60, 0xC0, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x11, 0x80, 0x02, 0x30, 0x00,
  0x44, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x06,
  0x30, 0x00, 0x86, 0x00, 0x30, 0xC0, 0x04, 0x0C, 0x01, 0x81, 0xC0, 0xE0,
  0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x7E, 0x18, 0x0F, 0xF8,
  0xC0, 0xE0, 0x66, 0x06, 0x00, 0xA0, 0x60, 0x07, 0x06, 0x00, 0x18, 0x30,
  0x00, 0xC1, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x06, 0x00, 0x18,
  0x20, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00,
  0x08, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83,
  0x00, 0x08, 0x18, 0x00, 0xC0, 0x60, 0x0E, 0x03, 0x81, 0xB0, 0x0F, 0xF9,
  0x80, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x70, 0x38, 0x38,
  0x07, 0x0C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x04, 0xC0, 0x01, 0x30, 0x00,
  0x48, 0x00, 0x16, 0x00, 0x0D, 0xFF, 0xFF, 0x7F, 0xFF, 0xD8, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x20, 0xE0, 0x38, 0x1F, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x07, 0xFE, 0x3F, 0xF8,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x7E, 0x18, 0x0F, 0xF8, 0xC0,
  0xE0, 0x66, 0x0E, 0x00, 0xA0, 0x60, 0x07, 0x06, 0x00, 0x18, 0x30, 0x00,
  0xC1, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x06, 0x00, 0x18, 0x20,
  0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x08,
  0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00,
  0x0C, 0x18, 0x00, 0xC0, 0x60, 0x0E, 0x03, 0x81, 0xB0, 0x0F, 0xF9, 0x80,
  0x3F, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x08, 0x00, 0xC0, 0xE0, 0x0C, 0x03, 0x80, 0xC0, 0x0F,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0xFC, 0x06, 0x3F, 0xC0, 0xDC, 0x1C,
  0x1A, 0x01, 0x83, 0x80, 0x10, 0x70, 0x02, 0x1C, 0x00, 0x63, 0x80, 0x0C,
  0x60, 0x01, 0x0C, 0x00, 0x21, 0x80, 0x0C, 0x20, 0x01, 0x8C, 0x00, 0x31,
  0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x10, 0xC0, 0x06, 0x10, 0x00, 0xC6,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x43, 0x00, 0x08, 0x60, 0x03, 0x08,
  0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x80, 0x03, 0x03, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x08,
  0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60,
  0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x38, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x60, 0xC0,
  0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x00, 0x80, 0xC0, 0x18,
  0x18, 0x01, 0x83, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x01,
  0x38, 0x00, 0x37, 0x80, 0x03, 0xCC, 0x00, 0x38, 0xC0, 0x03, 0x06, 0x00,
  0x30, 0x60, 0x02, 0x03, 0x00, 0x60, 0x30, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x00, 0xC0, 0x60, 0x0C, 0x04, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00,
  0x70, 0x01, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x06,
  0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x10, 0x30, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x60, 0x40,
  0xC0, 0x0C, 0x3F, 0x00, 0xF8, 0x0C, 0xFF, 0x83, 0xFE, 0x0D, 0x81, 0xC6,
  0x06, 0x0F, 0x00, 0xCC, 0x03, 0x0A, 0x00, 0xD8, 0x03, 0x1C, 0x00, 0x70,
  0x03, 0x1C, 0x00, 0x60, 0x03, 0x18, 0x00, 0x60, 0x03, 0x18, 0x00, 0x40,
  0x03, 0x18, 0x00, 0xC0, 0x03, 0x10, 0x00, 0xC0, 0x03, 0x30, 0x00, 0xC0,
  0x03, 0x30, 0x00, 0xC0, 0x03, 0x30, 0x00, 0xC0, 0x02, 0x30, 0x00, 0x80,
  0x06, 0x30, 0x01, 0x80, 0x06, 0x20, 0x01, 0x80, 0x06, 0x60, 0x01, 0x80,
  0x06, 0x60, 0x01, 0x80, 0x06, 0x60, 0x01, 0x80, 0x04, 0x60, 0x01, 0x00,
  0x0C, 0x60, 0x03, 0x00, 0x0C, 0x40, 0x03, 0x00, 0x0C, 0xC0, 0x03, 0x00,
  0x0C, 0xC0, 0x03, 0x00, 0x08, 0xC0, 0x03, 0x00, 0x08, 0x0C, 0x3F, 0x01,
  0x8F, 0xF0, 0x33, 0x07, 0x06, 0x80, 0x60, 0xE0, 0x04, 0x1C, 0x00, 0x87,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x43, 0x00, 0x08, 0x60, 0x03, 0x08,
  0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x04, 0x30,
  0x01, 0x84, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x10, 0xC0,
  0x02, 0x18, 0x00, 0xC2, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x60, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0x60, 0x38, 0x30, 0x06, 0x18, 0x00, 0xCE, 0x00,
  0x33, 0x00, 0x0C, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x34, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x02, 0xC0,
  0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0C, 0xC0, 0x03, 0x18, 0x01,
  0x86, 0x00, 0xC0, 0xC0, 0x60, 0x1F, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0x0F,
  0xC0, 0x19, 0xFF, 0x00, 0xD8, 0x1C, 0x07, 0x80, 0x60, 0x38, 0x01, 0x81,
  0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00,
  0xC1, 0x00, 0x06, 0x08, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30,
  0x00, 0x41, 0x80, 0x02, 0x08, 0x00, 0x30, 0x40, 0x01, 0x86, 0x00, 0x08,
  0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x60, 0x50, 0x07, 0x06, 0xE0,
  0x70, 0x33, 0xFF, 0x01, 0x87, 0xE0, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x60,
  0xFF, 0x8C, 0x38, 0x19, 0x86, 0x00, 0xA1, 0x80, 0x1C, 0x60, 0x01, 0x8C,
  0x00, 0x31, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x11, 0x80, 0x06, 0x20,
  0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x08, 0xC0,
  0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80,
  0x0C, 0x18, 0x03, 0x83, 0x81, 0xF0, 0x3F, 0xE6, 0x01, 0xF0, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x0C,
  0x3C, 0x33, 0xF0, 0xD8, 0x03, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x60, 0x30, 0x30, 0x06, 0x18, 0x01, 0x86, 0x00, 0x21, 0x80,
  0x08, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x06, 0x30, 0x01, 0x86, 0x00,
  0xC1, 0xC0, 0x70, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x06, 0x01, 0x00, 0x40,
  0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x07, 0xC0, 0xF0,
  0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x0C, 0x00, 0x21, 0x00, 0x0C,
  0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0x86, 0x00, 0x30,
  0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x43,
  0x00, 0x18, 0x40, 0x03, 0x08, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x03, 0x04,
  0x00, 0x60, 0xC0, 0x1C, 0x18, 0x07, 0x83, 0x81, 0xB0, 0x3F, 0xE6, 0x03,
  0xF0, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xC8, 0x00, 0x64, 0x00,
  0x63, 0x00, 0x31, 0x80, 0x10, 0xC0, 0x18, 0x60, 0x08, 0x30, 0x0C, 0x08,
  0x06, 0x04, 0x06, 0x03, 0x03, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x60, 0x80,
  0x10, 0xC0, 0x08, 0x40, 0x06, 0x60, 0x03, 0x20, 0x01, 0xB0, 0x00, 0xD8,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0xD8, 0x01, 0x80, 0x1B, 0x00, 0x70, 0x03, 0x60, 0x0E, 0x00, 0xCC,
  0x03, 0x40, 0x19, 0x80, 0x68, 0x06, 0x30, 0x09, 0x80, 0xC6, 0x03, 0x30,
  0x18, 0xC0, 0x66, 0x06, 0x18, 0x18, 0xC0, 0xC3, 0x03, 0x18, 0x10, 0x20,
  0xC3, 0x06, 0x04, 0x18, 0x60, 0xC0, 0x82, 0x0C, 0x30, 0x10, 0xC0, 0x86,
  0x03, 0x18, 0x10, 0x80, 0x66, 0x02, 0x30, 0x0C, 0xC0, 0x46, 0x01, 0xB0,
  0x0D, 0x80, 0x36, 0x01, 0xB0, 0x06, 0x80, 0x34, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x38, 0x30, 0x01, 0x80, 0xC0, 0x18, 0x06, 0x01,
  0x80, 0x30, 0x0C, 0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x18, 0xE0, 0x00,
  0xC6, 0x00, 0x06, 0x60, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x40, 0x00, 0x1B, 0x00, 0x01, 0x98, 0x00, 0x18,
  0x60, 0x00, 0xC3, 0x00, 0x0C, 0x0C, 0x00, 0xC0, 0x60, 0x0E, 0x03, 0x00,
  0x60, 0x0C, 0x06, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x60, 0x10, 0x00, 0xC0, 0x30,
  0x01, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x60, 0x02, 0x01, 0x80, 0x04, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x00, 0x86, 0x00,
  0x01, 0x18, 0x00, 0x03, 0x30, 0x00, 0x06, 0x40, 0x00, 0x0D, 0x80, 0x00,
  0x1A, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x00, 0x04, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x40, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x06, 0x06, 0x04,
  0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x10, 0x30, 0x30, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x60,
  0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0x00, 0x33, 0x0E, 0x00, 0xD8, 0x1C, 0x02, 0x40, 0x38,
  0x1B, 0x00, 0x70, 0xCC, 0x00, 0xFE, 0x00, 0x01, 0xF0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 34, 9, 1, -34 },
  { 35, 8, 10, 13, 5, -36 },
  { 45, 24, 34, 23, 1, -34 },
  { 147, 20, 43, 23, 2, -39 },
  { 255, 23, 34, 30, 4, -34 },
  { 353, 22, 34, 25, 1, -34 },
  { 447, 3, 10, 8, 5, -36 },
  { 451, 14, 49, 13, 2, -38 },
  { 537, 14, 49, 13, -3, -38 },
  { 623, 18, 19, 20, 3, -34 },
  { 666, 20, 25, 23, 2, -28 },
  { 729, 6, 10, 9, -2, -4 },
  { 737, 9, 2, 12, 2, -17 },
  { 740, 3, 3, 10, 1, -3 },
  { 742, 20, 37, 16, -2, -34 },
  { 835, 19, 34, 23, 2, -34 },
  { 916, 11, 34, 23, 6, -34 },
  { 963, 20, 34, 23, 1, -34 },
  { 1048, 20, 34, 23, 1, -34 },
  { 1133, 20, 34, 23, 1, -34 },
  { 1218, 20, 34, 23, 3, -34 },
  { 1303, 18, 34, 23, 2, -34 },
  { 1380, 19, 34, 23, 4, -34 },
  { 1461, 21, 34, 23, 1, -34 },
  { 1551, 18, 34, 23, 3, -34 },
  { 1628, 7, 25, 9, 1, -25 },
  { 1650, 10, 31, 8, -2, -25 },
  { 1689, 18, 19, 21, 2, -25 },
  { 1732, 18, 12, 23, 3, -22 },
  { 1759, 18, 19, 21, 1, -25 },
  { 1802, 15, 34, 18, 4, -34 },
  { 1866, 33, 44, 37, 2, -33 },
  { 2048, 23, 34, 25, -1, -34 },
  { 2146, 21, 34, 25, 2, -34 },
  { 2236, 22, 34, 26, 3, -34 },
  { 2330, 23, 34, 27, 2, -34 },
  { 2428, 23, 34, 23, 2, -34 },
  { 2526, 23, 34, 23, 2, -34 },
  { 2624, 23, 34, 28, 3, -34 },
  { 2722, 26, 34, 29, 2, -34 },
  { 2833, 8, 34, 11, 2, -34 },
  { 2867, 21, 34, 23, 1, -34 },
  { 2957, 25, 34, 26, 2, -34 },
  { 3064, 16, 34, 21, 2, -34 },
  { 3132, 32, 34, 35, 2, -34 },
  { 3268, 26, 34, 29, 2, -34 },
  { 3379, 23, 34, 27, 3, -34 },
  { 3477, 23, 34, 25, 2, -34 },
  { 3575, 23, 40, 27, 3, -34 },
  { 3690, 23, 34, 26, 2, -34 },
  { 3788, 23, 34, 24, 1, -34 },
  { 3886, 21, 34, 24, 5, -34 },
  { 3976, 24, 34, 27, 3, -34 },
  { 4078, 23, 34, 25, 4, -34 },
  { 4176, 33, 34, 36, 5, -34 },
  { 4317, 27, 34, 25, -1, -34 },
  { 4432, 23, 34, 24, 4, -34 },
  { 4530, 25, 34, 24, 0, -34 },
  { 4637, 14, 46, 10, 0, -39 },
  { 4718, 7, 37, 16, 5, -34 },
  { 4751, 13, 46, 10, -3, -39 },
  { 4826, 12, 17, 17, 3, -34 },
  { 4852, 17, 2, 18, -2, 0 },
  { 4857, 6, 6, 13, 6, -36 },
  { 4862, 18, 26, 22, 1, -26 },
  { 4921, 19, 36, 23, 1, -36 },
  { 5007, 19, 26, 21, 1, -26 },
  { 5069, 21, 36, 23, 2, -36 },
  { 5164, 18, 26, 21, 1, -26 },
  { 5223, 14, 36, 14, 3, -36 },
  { 5286, 21, 36, 23, 0, -26 },
  { 5381, 19, 36, 22, 1, -36 },
  { 5467, 8, 35, 9, 1, -35 },
  { 5502, 15, 45, 10, -6, -35 },
  { 5587, 20, 36, 20, 1, -36 },
  { 5677, 8, 36, 9, 1, -36 },
  { 5713, 32, 26, 36, 1, -26 },
  { 5817, 19, 26, 22, 1, -26 },
  { 5879, 18, 26, 23, 2, -26 },
  { 5938, 21, 36, 23, -1, -26 },
  { 6033, 19, 36, 23, 2, -26 },
  { 6119, 14, 26, 14, 1, -26 },
  { 6165, 18, 26, 21, 1, -26 },
  { 6224, 10, 32, 13, 3, -32 },
  { 6264, 19, 26, 22, 2, -26 },
  { 6326, 17, 26, 20, 3, -26 },
  { 6382, 27, 26, 31, 4, -26 },
  { 6470, 21, 26, 20, -1, -26 },
  { 6539, 23, 36, 20, -2, -26 },
  { 6643, 19, 26, 20, 0, -26 },
  { 6705, 15, 47, 14, 2, -37 },
  { 6794, 8, 40, 10, 1, -34 },
  { 6834, 15, 47, 14, -3, -37 },
  { 6923, 22, 8, 28, 3, -18 },
};

const GFXfont RobotoCondensed_ExtraLightItalic48pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic48pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic48pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC48PT7B_H_
