#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC56PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x81, 0xC0, 0x40, 0x00,
  0x30, 0xCC, 0x73, 0x19, 0x86, 0x61, 0x98, 0x66, 0x19, 0x84, 0x63, 0x30,
  0xCC, 0x33, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x18,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x60, 0x30, 0x00, 0x04, 0x03, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x01, 0x80, 0xC0, 0x00, 0x10, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x0C, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x18, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x40,
  0x30, 0x00, 0x0C, 0x02, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x08, 0x06, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x07, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0xE0,
  0x38, 0x03, 0x80, 0x38, 0x0E, 0x00, 0x30, 0x18, 0x00, 0x70, 0x60, 0x00,
  0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06,
  0x30, 0x00, 0x1C, 0x30, 0x00, 0x30, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0x80,
  0xC0, 0x07, 0x01, 0xC0, 0x3C, 0x01, 0xFB, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00,
  0x06, 0x01, 0x80, 0x31, 0x80, 0x20, 0x18, 0x60, 0x18, 0x06, 0x10, 0x06,
  0x03, 0x0C, 0x01, 0x81, 0x83, 0x00, 0x60, 0x60, 0xC0, 0x18, 0x30, 0x30,
  0x0C, 0x18, 0x0C, 0x03, 0x06, 0x01, 0x81, 0x83, 0x00, 0x60, 0x61, 0x80,
  0x0E, 0x70, 0x60, 0x01, 0xF8, 0x30, 0x00, 0x10, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC1, 0xFC, 0x00,
  0x30, 0xE3, 0x80, 0x18, 0x30, 0x60, 0x0C, 0x18, 0x0C, 0x03, 0x0C, 0x03,
  0x01, 0x83, 0x00, 0xC0, 0xC0, 0xC0, 0x30, 0x30, 0x20, 0x0C, 0x18, 0x18,
  0x03, 0x0C, 0x06, 0x00, 0xC3, 0x01, 0x80, 0x31, 0x80, 0x60, 0x08, 0xC0,
  0x18, 0x06, 0x30, 0x06, 0x01, 0x80, 0x00, 0x80, 0xC0, 0x00, 0x30, 0x70,
  0x00, 0x0F, 0x38, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0x30, 0x01, 0xC0, 0x30, 0x01, 0x80, 0x30, 0x01, 0x80, 0x30, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x03, 0x00,
  0xE0, 0x01, 0x81, 0xC0, 0x01, 0x83, 0x80, 0x01, 0x87, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0x30, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x03, 0x1C, 0x0C,
  0x03, 0x38, 0x0E, 0x03, 0x30, 0x06, 0x03, 0x60, 0x07, 0x06, 0x60, 0x03,
  0x06, 0xE0, 0x03, 0x86, 0xC0, 0x01, 0x8C, 0xC0, 0x00, 0xCC, 0xC0, 0x00,
  0xD8, 0xC0, 0x00, 0x78, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x60, 0x00,
  0xF8, 0x70, 0x01, 0x98, 0x38, 0x07, 0x1C, 0x1F, 0x3E, 0x0C, 0x0F, 0xF8,
  0x06, 0x00, 0x80, 0x00, 0x36, 0x66, 0x66, 0x6C, 0xCC, 0xCC, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x04, 0x00, 0x00, 0x40, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x10, 0x0C, 0x02, 0xF8, 0x30, 0x7C, 0xF8, 0xCF, 0xC0,
  0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x19,
  0x80, 0x00, 0xE7, 0x00, 0x07, 0x0C, 0x00, 0x38, 0x18, 0x01, 0xC0, 0x60,
  0x06, 0x00, 0xC0, 0x30, 0x03, 0x80, 0xC0, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x18, 0x30,
  0x60, 0xC3, 0x86, 0x1C, 0x30, 0xE3, 0x82, 0x00, 0xFF, 0xFF, 0xFC, 0x7F,
  0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xBE, 0x00, 0x70, 0x1C, 0x03, 0x80, 0x30, 0x0C, 0x00, 0x60, 0x60, 0x01,
  0x83, 0x80, 0x06, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x31, 0x80, 0x00, 0xC6,
  0x00, 0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00,
  0x07, 0x30, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06,
  0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0,
  0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x1C, 0xC0, 0x00,
  0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3,
  0x00, 0x07, 0x0C, 0x00, 0x18, 0x38, 0x00, 0xE0, 0x60, 0x03, 0x01, 0xC0,
  0x18, 0x03, 0x00, 0xC0, 0x0F, 0x9E, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x18, 0x03, 0xC0, 0xFC, 0x1F, 0x67, 0xC3, 0x38, 0x19, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x0C, 0x03, 0x80, 0x0E,
  0x03, 0x00, 0x06, 0x07, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x01, 0xF7, 0xC0, 0x0F, 0x01, 0xC0, 0x38, 0x01, 0x80,
  0x60, 0x01, 0x81, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x18,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xE3, 0x00,
  0x01, 0x87, 0x00, 0x07, 0x06, 0x00, 0x0C, 0x0E, 0x00, 0x30, 0x0E, 0x01,
  0xC0, 0x0F, 0xDF, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x06,
  0xC0, 0x00, 0x1D, 0x80, 0x00, 0x33, 0x00, 0x00, 0xCE, 0x00, 0x03, 0x98,
  0x00, 0x06, 0x30, 0x00, 0x18, 0x60, 0x00, 0x60, 0xC0, 0x01, 0xC1, 0x80,
  0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x60, 0x30, 0x01,
  0x80, 0x60, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x0C, 0x03, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x18, 0x00, 0x60, 0x60, 0x01,
  0x81, 0xC0, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x7E, 0x00, 0x0D, 0xFF, 0x80, 0x0F, 0x83, 0xC0, 0x1E,
  0x00, 0xE0, 0x18, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x70, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x60,
  0x00, 0xC0, 0x70, 0x01, 0x80, 0x30, 0x03, 0x80, 0x18, 0x07, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x7E, 0x03, 0x1F, 0xF8,
  0x33, 0x83, 0xC3, 0x60, 0x0E, 0x6C, 0x00, 0x67, 0x80, 0x06, 0x70, 0x00,
  0x76, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xCE, 0x00, 0x0C, 0x60, 0x01, 0xC6,
  0x00, 0x38, 0x30, 0x03, 0x03, 0x80, 0xE0, 0x1F, 0x7C, 0x00, 0xFF, 0x80,
  0x00, 0x80, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x06, 0x01,
  0x80, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x07, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x07, 0x06,
  0x00, 0x06, 0x06, 0x00, 0x06, 0x07, 0x00, 0x0C, 0x03, 0x00, 0x1C, 0x01,
  0x80, 0x38, 0x01, 0xE0, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xC1, 0xE0, 0x06, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x38,
  0x00, 0x18, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x70, 0x00, 0x60, 0x38, 0x00, 0xE0, 0x1C,
  0x03, 0xC0, 0x0F, 0x9F, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x0E, 0x03, 0x80, 0xE0, 0x0E,
  0x06, 0x00, 0x38, 0x60, 0x00, 0xC7, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80,
  0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x76, 0x00, 0x03, 0xB0, 0x00, 0x1B,
  0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00,
  0x0D, 0x80, 0x00, 0xEE, 0x00, 0x07, 0x30, 0x00, 0x71, 0x80, 0x07, 0x8E,
  0x00, 0x6C, 0x38, 0x07, 0x60, 0xE0, 0xF6, 0x03, 0xFE, 0x30, 0x0F, 0xC1,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x0F, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x30, 0x0E, 0x03, 0x80, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x40, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xEF, 0x83, 0x80, 0xC3, 0x80,
  0x71, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0xC0, 0x03, 0xE0, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0x60, 0x70, 0x00, 0xF8, 0x00, 0xC0,
  0xC0, 0x07, 0xFC, 0x01, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0x06, 0x00, 0x60,
  0x18, 0x02, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x30, 0x06, 0x00, 0x60, 0x08,
  0x60, 0x0C, 0x00, 0x80, 0x11, 0x80, 0x30, 0x03, 0x00, 0x23, 0x00, 0x60,
  0x06, 0x00, 0xC6, 0x01, 0x80, 0x0C, 0x01, 0x98, 0x03, 0x00, 0x18, 0x03,
  0x30, 0x06, 0x00, 0x60, 0x06, 0x60, 0x18, 0x00, 0xC0, 0x0C, 0xC0, 0x30,
  0x01, 0x80, 0x11, 0x00, 0x60, 0x03, 0x00, 0x66, 0x01, 0x80, 0x0C, 0x00,
  0xCC, 0x03, 0x00, 0x18, 0x01, 0x98, 0x06, 0x00, 0x30, 0x02, 0x30, 0x0C,
  0x00, 0xE0, 0x0C, 0x60, 0x18, 0x01, 0x80, 0x18, 0xC0, 0x30, 0x07, 0x00,
  0x61, 0x80, 0x60, 0x0E, 0x00, 0xC3, 0x00, 0xC0, 0x3C, 0x03, 0x06, 0x01,
  0x80, 0xD8, 0x06, 0x0C, 0x03, 0x83, 0x18, 0x18, 0x18, 0x03, 0xDC, 0x39,
  0xE0, 0x30, 0x03, 0xF0, 0x3F, 0x80, 0x30, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x02,
  0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x0C, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x01,
  0x80, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x06,
  0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x30, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x30, 0x70, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0xE0, 0x07, 0x80, 0x60, 0x00, 0xE0, 0x30, 0x00, 0x30,
  0x18, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x06, 0x00, 0x01,
  0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x70, 0x60, 0x00,
  0x30, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x18, 0x00, 0x1C, 0x0C, 0x00,
  0x1C, 0x06, 0x00, 0x3C, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0x80,
  0x07, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x30, 0x00, 0x1C, 0x18,
  0x00, 0x06, 0x1C, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x18,
  0x60, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x0E, 0x06, 0x00, 0x1E, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFD, 0xF8, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x70, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x38,
  0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x0E, 0x00, 0x78, 0x01, 0x80, 0x03,
  0x80, 0x30, 0x00, 0x38, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x18,
  0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x0C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x38,
  0x06, 0x00, 0x1E, 0x01, 0x80, 0x0F, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x03,
  0x80, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x7F, 0xF3, 0x80,
  0x1F, 0xFC, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x86, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x01,
  0xC0, 0x1F, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80,
  0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0x81, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x60, 0x18, 0x00, 0x70, 0x0C, 0x00,
  0x30, 0x07, 0x00, 0x30, 0x01, 0xC0, 0x70, 0x00, 0x7D, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x38, 0x0C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x38,
  0x01, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x06,
  0x00, 0x38, 0x00, 0x30, 0x03, 0x80, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x60, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0x39, 0xF0, 0x00, 0x01, 0x9D, 0x80, 0x00, 0x0D, 0x86,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x18, 0x07, 0x00,
  0x01, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x60, 0x03, 0x00, 0x03,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x70, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x36,
  0x00, 0x00, 0x0D, 0x80, 0xD8, 0x00, 0x00, 0x66, 0x06, 0x60, 0x00, 0x01,
  0xB0, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x66, 0x00, 0x00, 0x33, 0x01, 0x8C,
  0x00, 0x01, 0x8C, 0x06, 0x30, 0x00, 0x0E, 0x30, 0x18, 0xC0, 0x00, 0x31,
  0xC0, 0xC3, 0x00, 0x01, 0xC6, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x0C, 0x10,
  0x00, 0x38, 0x60, 0x30, 0x60, 0x00, 0xC1, 0x80, 0xC1, 0x80, 0x07, 0x06,
  0x07, 0x06, 0x00, 0x18, 0x38, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x60, 0x60,
  0x03, 0x03, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x60, 0x30,
  0x18, 0x0C, 0x03, 0x00, 0xC0, 0xE0, 0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x06, 0x0C, 0x01, 0x80,
  0xC0, 0x18, 0x30, 0x06, 0x03, 0x00, 0x61, 0x80, 0x18, 0x1C, 0x01, 0x86,
  0x00, 0xC0, 0x60, 0x06, 0x30, 0x03, 0x01, 0x80, 0x08, 0xC0, 0x0C, 0x06,
  0x00, 0x36, 0x00, 0x30, 0x18, 0x00, 0xF8, 0x00, 0xC0, 0x60, 0x03, 0xC0,
  0x07, 0x03, 0x80, 0x0F, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0x30, 0x1E, 0x00, 0x00, 0x60, 0x36, 0x00, 0x00, 0xC0,
  0x6C, 0x00, 0x01, 0x80, 0xD8, 0x00, 0x03, 0x01, 0x98, 0x00, 0x0E, 0x07,
  0x30, 0x00, 0x18, 0x0C, 0x60, 0x00, 0x30, 0x18, 0x60, 0x00, 0x60, 0x30,
  0xC0, 0x00, 0xC0, 0x60, 0xC0, 0x01, 0x81, 0xC1, 0x80, 0x07, 0x03, 0x83,
  0x00, 0x0C, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x0E,
  0x00, 0x60, 0x30, 0x0C, 0x00, 0xC0, 0xE0, 0x18, 0x03, 0x81, 0xC0, 0x18,
  0x06, 0x03, 0x00, 0x30, 0x0C, 0x06, 0x00, 0x60, 0x18, 0x0C, 0x00, 0x60,
  0x30, 0x18, 0x00, 0xC0, 0xE0, 0x70, 0x01, 0xC1, 0x80, 0xC0, 0x01, 0x83,
  0x01, 0x80, 0x03, 0x06, 0x03, 0x00, 0x03, 0x0C, 0x06, 0x00, 0x06, 0x18,
  0x0C, 0x00, 0x0C, 0x70, 0x38, 0x00, 0x0C, 0xC0, 0x60, 0x00, 0x19, 0x80,
  0xC0, 0x00, 0x3B, 0x01, 0x80, 0x00, 0x36, 0x03, 0x00, 0x00, 0x6C, 0x06,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x39, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x06, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x30, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x0E, 0x00, 0x3C, 0x01,
  0x80, 0x01, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x30, 0x18, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x60, 0x30, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x01, 0x80, 0x07, 0xC0,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06,
  0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x80, 0x70, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x04,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0C, 0x00, 0x3C, 0x01, 0x80, 0x01, 0xC0,
  0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x38, 0x00,
  0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x60, 0x30,
  0x00, 0x18, 0x0C, 0x00, 0x0E, 0x01, 0x80, 0x07, 0x80, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x80, 0x18, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00,
  0x60, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x0E,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x3C, 0x03, 0xC0, 0x0E, 0x00, 0x18, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00,
  0x30, 0x18, 0x00, 0x06, 0x07, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0C, 0x18,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x06, 0x03, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x83, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x07,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x1E, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0E, 0x60, 0x00,
  0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60,
  0x00, 0x0E, 0x18, 0x00, 0x03, 0x07, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x38, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0x30, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0xE0, 0x01, 0x80, 0x30, 0x00,
  0x60, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0x30, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0xC0, 0x00, 0x70, 0x00, 0x0D, 0x80, 0x00, 0xE0, 0x00, 0x33, 0x00, 0x01,
  0xC0, 0x00, 0x66, 0x00, 0x06, 0x80, 0x01, 0xCC, 0x00, 0x0D, 0x00, 0x03,
  0x18, 0x00, 0x32, 0x00, 0x06, 0x30, 0x00, 0x66, 0x00, 0x1C, 0x60, 0x00,
  0x8C, 0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0x61, 0x80, 0x06, 0x30, 0x01,
  0x83, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00,
  0x41, 0x80, 0x18, 0x18, 0x01, 0x83, 0x00, 0x30, 0x38, 0x03, 0x06, 0x00,
  0xE0, 0x70, 0x0C, 0x04, 0x01, 0x80, 0x60, 0x18, 0x08, 0x03, 0x00, 0xC0,
  0x30, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x18,
  0x18, 0x03, 0x07, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x0C,
  0x18, 0x00, 0xC3, 0x00, 0x18, 0x70, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0x46, 0x00, 0x0C, 0x60, 0x00,
  0xCC, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00,
  0x26, 0x00, 0x06, 0xC0, 0x00, 0x58, 0x00, 0x0D, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x01, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x60, 0x00, 0x38, 0x01, 0x80, 0x00, 0x30, 0x07,
  0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x07, 0x00, 0x01, 0xC0,
  0x06, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x18, 0x00, 0xE0, 0x00, 0x38, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x60, 0x1C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x0C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x18,
  0x00, 0x38, 0x06, 0x00, 0x0C, 0x01, 0xC0, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x0C, 0x00, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x06, 0x07, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x70, 0x00, 0x01, 0x98, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x03, 0x03, 0x03, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x06, 0x80, 0x0D, 0x00, 0x33,
  0x00, 0x66, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x30, 0x18, 0x20, 0x60, 0x60,
  0xC0, 0xC3, 0x01, 0x86, 0x03, 0x18, 0x06, 0x30, 0x04, 0xC0, 0x0D, 0x80,
  0x1E, 0x00, 0x30, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0xE0, 0xC0, 0xC1,
  0xC1, 0x81, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7E, 0xF8, 0x07,
  0x00, 0xE0, 0x70, 0x03, 0x87, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03,
  0x18, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0x00, 0x30,
  0xE0, 0x01, 0x8E, 0x00, 0x18, 0xE0, 0x00, 0xC6, 0x00, 0x06, 0x70, 0x00,
  0x33, 0x00, 0x01, 0x98, 0x00, 0x1C, 0xC0, 0x00, 0xC6, 0x00, 0x0E, 0x30,
  0x00, 0xF0, 0xC0, 0x0D, 0x87, 0x01, 0xCC, 0x1F, 0xFC, 0x60, 0x7F, 0x83,
  0x00, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x61, 0xFE, 0x00, 0xCF, 0xBE, 0x01, 0xB8, 0x0E, 0x03, 0xC0,
  0x0E, 0x07, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x38, 0x00, 0x30, 0x60, 0x00,
  0x60, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x8E, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61,
  0x80, 0x00, 0xC7, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x70, 0xC0, 0x00, 0xC3, 0x80, 0x01, 0x87, 0x00,
  0x06, 0x0F, 0x00, 0x1C, 0x1A, 0x00, 0x30, 0x37, 0x01, 0xC0, 0x67, 0xDF,
  0x01, 0x83, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0xFD, 0xF0, 0x0E, 0x01, 0xC0, 0xE0, 0x07, 0x06, 0x00, 0x18, 0x60,
  0x00, 0xC3, 0x00, 0x06, 0x30, 0x00, 0x19, 0x80, 0x00, 0xDC, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x01, 0x98, 0x00, 0x18, 0xC0, 0x00,
  0xC6, 0x00, 0x0E, 0x18, 0x00, 0x60, 0xE0, 0x06, 0x03, 0x80, 0xE0, 0x0F,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x01, 0x00, 0xC0, 0x0F, 0xF0, 0xE0,
  0x1F, 0xBC, 0x60, 0x1E, 0x03, 0x30, 0x0C, 0x00, 0xD8, 0x0C, 0x00, 0x2C,
  0x0E, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x07, 0x00, 0x03, 0x03, 0x00, 0x01,
  0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00,
  0x03, 0x07, 0x00, 0x03, 0x83, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x1C, 0x06,
  0x00, 0x0C, 0x03, 0x00, 0x0E, 0x01, 0xC0, 0x0F, 0x00, 0x70, 0x1D, 0x80,
  0x1F, 0x7C, 0xC0, 0x07, 0xF8, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x7D, 0xF0, 0x0F, 0x01, 0xC0, 0x60, 0x07, 0x06,
  0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x30, 0x00, 0x39, 0x80, 0x00,
  0xD8, 0x00, 0x06, 0xC0, 0x00, 0x76, 0x00, 0x03, 0x3F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xD8, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x03, 0x03,
  0x80, 0x78, 0x0F, 0xDF, 0x00, 0x3F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x1F, 0x60, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xC3,
  0x00, 0xF9, 0xE3, 0x01, 0xC0, 0x33, 0x01, 0x80, 0x1B, 0x03, 0x00, 0x0B,
  0x07, 0x00, 0x0F, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x38, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x38, 0x00, 0x30, 0x18, 0x00, 0x30,
  0x18, 0x00, 0x70, 0x1C, 0x00, 0xF0, 0x0E, 0x03, 0xB0, 0x07, 0xFF, 0x30,
  0x03, 0xFC, 0x60, 0x00, 0x40, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x40, 0x01, 0xC0, 0x60, 0x01, 0x80,
  0x70, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x40, 0x06, 0x1F, 0xE0,
  0x18, 0xF7, 0xC0, 0x66, 0x03, 0x81, 0xB0, 0x06, 0x07, 0x80, 0x1C, 0x1C,
  0x00, 0x30, 0xF0, 0x00, 0xC3, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61,
  0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0xE0, 0x00, 0xC3, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03,
  0x1C, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18,
  0x00, 0x18, 0x60, 0x00, 0x63, 0x00, 0x03, 0x00, 0x01, 0x01, 0xC0, 0xE0,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xE0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x38,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x0F,
  0xE0, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x0C, 0x03,
  0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60,
  0x30, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x30,
  0x00, 0x18, 0xC0, 0x00, 0x33, 0x80, 0x00, 0x6D, 0x80, 0x00, 0xF3, 0x00,
  0x01, 0xC3, 0x00, 0x07, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00,
  0x30, 0x1C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x38, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x70, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0x60,
  0x01, 0xC1, 0x80, 0x01, 0x80, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x01, 0x00, 0x01, 0x00, 0x18, 0x7F,
  0x80, 0x7F, 0x80, 0x63, 0xDF, 0x07, 0xDF, 0x01, 0x98, 0x0E, 0x38, 0x0E,
  0x06, 0xC0, 0x19, 0xC0, 0x18, 0x3E, 0x00, 0x66, 0x00, 0x60, 0xF0, 0x00,
  0xF0, 0x01, 0xC3, 0x80, 0x03, 0x80, 0x03, 0x0E, 0x00, 0x0E, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC0, 0x00, 0xC7, 0x00, 0x06,
  0x00, 0x07, 0x18, 0x00, 0x18, 0x00, 0x18, 0x60, 0x00, 0x60, 0x00, 0x61,
  0x80, 0x01, 0x80, 0x01, 0x86, 0x00, 0x06, 0x00, 0x06, 0x18, 0x00, 0x18,
  0x00, 0x18, 0xE0, 0x00, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x00, 0x03, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC0,
  0x00, 0xC3, 0x00, 0x03, 0x00, 0x03, 0x1C, 0x00, 0x18, 0x00, 0x1C, 0x60,
  0x00, 0x60, 0x00, 0x61, 0x80, 0x01, 0x80, 0x01, 0x86, 0x00, 0x06, 0x00,
  0x06, 0x18, 0x00, 0x18, 0x00, 0x18, 0x60, 0x00, 0x60, 0x00, 0x63, 0x00,
  0x03, 0x00, 0x03, 0x8C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x18, 0x7F, 0x80, 0x63, 0xDF, 0x01, 0x98, 0x0E, 0x06, 0xC0, 0x18, 0x1E,
  0x00, 0x70, 0xF0, 0x00, 0xC3, 0xC0, 0x03, 0x0E, 0x00, 0x0C, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x18, 0x60, 0x00, 0x61,
  0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x63, 0x80,
  0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03,
  0x0C, 0x00, 0x0C, 0x70, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18,
  0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0x7E, 0x00, 0xE0, 0x1C, 0x07, 0x00,
  0x30, 0x38, 0x00, 0xE0, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18,
  0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80,
  0x00, 0x76, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x1B, 0x80, 0x00,
  0x6C, 0x00, 0x01, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0x30, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x03, 0x06, 0x00,
  0x1C, 0x0C, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x7E, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC3, 0xFC, 0x00, 0x67, 0xDF,
  0x00, 0x37, 0x01, 0xC0, 0x1E, 0x00, 0x70, 0x0E, 0x00, 0x18, 0x0E, 0x00,
  0x0C, 0x07, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0xC0, 0xC0,
  0x00, 0xE0, 0x60, 0x00, 0x70, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x38, 0x18, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x0C,
  0x07, 0x00, 0x0E, 0x03, 0xC0, 0x06, 0x01, 0xB8, 0x0E, 0x01, 0xCF, 0xBE,
  0x00, 0xC1, 0xFE, 0x00, 0x60, 0x10, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFC, 0x30, 0x3F, 0x78, 0xC1,
  0xE0, 0x33, 0x06, 0x00, 0x6C, 0x30, 0x00, 0xF1, 0xC0, 0x01, 0x86, 0x00,
  0x06, 0x38, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06,
  0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60,
  0x00, 0x31, 0x80, 0x00, 0xCE, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xE0, 0x00, 0xC1,
  0x80, 0x03, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0xF0, 0x38, 0x0E, 0xC0, 0x7D,
  0xF7, 0x00, 0xFF, 0x18, 0x00, 0x40, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x0F, 0xC1, 0x9F, 0xC0, 0xDC, 0x00, 0x6C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7D,
  0xF8, 0x07, 0x01, 0xC0, 0x60, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1,
  0x80, 0x07, 0x18, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00,
  0x06, 0x18, 0x00, 0x60, 0xC0, 0x07, 0x03, 0x80, 0x70, 0x1F, 0xBF, 0x00,
  0x3F, 0xE0, 0x00, 0x10, 0x00, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00,
  0x31, 0x80, 0x01, 0x98, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30,
  0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0xC6, 0x00, 0x06,
  0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x66, 0x00,
  0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x63,
  0x00, 0x07, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x86, 0x00, 0x3C, 0x18, 0x03,
  0x60, 0xE0, 0x3B, 0x03, 0xFF, 0x38, 0x0F, 0xF1, 0x80, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x3B, 0x00, 0x01, 0x98, 0x00, 0x1C, 0xC0, 0x00, 0xC6, 0x00,
  0x0E, 0x30, 0x00, 0x61, 0xC0, 0x03, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81,
  0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x07,
  0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06,
  0x0C, 0x00, 0x30, 0x60, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x33, 0x00,
  0x01, 0x98, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x60,
  0x03, 0x80, 0x06, 0x60, 0x03, 0x80, 0x0E, 0x60, 0x03, 0x80, 0x0C, 0x60,
  0x07, 0x80, 0x0C, 0x60, 0x07, 0x80, 0x1C, 0x60, 0x0C, 0xC0, 0x18, 0x60,
  0x0C, 0xC0, 0x38, 0x60, 0x18, 0xC0, 0x30, 0x60, 0x18, 0xC0, 0x30, 0x60,
  0x18, 0xC0, 0x60, 0x60, 0x30, 0xC0, 0x60, 0x60, 0x30, 0xC0, 0xE0, 0x60,
  0x60, 0xC0, 0xC0, 0x60, 0x60, 0xC0, 0xC0, 0x60, 0xC0, 0xC1, 0x80, 0x70,
  0xC0, 0xC1, 0x80, 0x30, 0xC0, 0x43, 0x80, 0x31, 0x80, 0x63, 0x00, 0x31,
  0x80, 0x63, 0x00, 0x33, 0x00, 0x66, 0x00, 0x33, 0x00, 0x66, 0x00, 0x36,
  0x00, 0x6E, 0x00, 0x36, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x6C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x38, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x07, 0x00, 0x07, 0x03, 0x00,
  0x06, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x1C, 0x01, 0x80, 0x38, 0x01, 0xC0,
  0x30, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0xC0, 0x00, 0x61,
  0x80, 0x00, 0x33, 0x80, 0x00, 0x33, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x66,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0xC7, 0x00, 0x01, 0x83, 0x00, 0x03, 0x83,
  0x00, 0x07, 0x01, 0x80, 0x06, 0x01, 0x80, 0x0E, 0x01, 0xC0, 0x1C, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x70, 0x00, 0x60, 0xE0, 0x00,
  0x70, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xE0, 0x01, 0x80, 0x18, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01,
  0x80, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x1C, 0x00, 0x0C,
  0x06, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x70, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x63, 0x00, 0x00, 0x19, 0xC0,
  0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x31, 0xC3, 0x80, 0x0C, 0xC0, 0x70, 0x02, 0x70, 0x0E,
  0x01, 0x98, 0x01, 0xC0, 0xE6, 0x00, 0x38, 0x73, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLightItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 9, 41, 11, 1, -40 },
  { 48, 10, 12, 15, 6, -42 },
  { 63, 28, 40, 27, 1, -40 },
  { 203, 23, 52, 26, 2, -46 },
  { 353, 26, 42, 35, 5, -41 },
  { 490, 24, 42, 29, 2, -41 },
  { 616, 4, 12, 9, 6, -42 },
  { 622, 15, 57, 15, 3, -44 },
  { 729, 15, 57, 16, -3, -44 },
  { 836, 22, 22, 23, 3, -40 },
  { 897, 23, 29, 27, 2, -33 },
  { 981, 7, 12, 10, -2, -5 },
  { 992, 11, 2, 14, 2, -19 },
  { 995, 4, 4, 12, 1, -3 },
  { 997, 23, 43, 19, -2, -40 },
  { 1121, 22, 42, 26, 3, -41 },
  { 1237, 13, 40, 26, 7, -40 },
  { 1302, 24, 41, 26, 1, -41 },
  { 1425, 23, 42, 26, 2, -41 },
  { 1546, 23, 40, 26, 1, -40 },
  { 1661, 24, 41, 26, 3, -40 },
  { 1784, 20, 41, 26, 3, -40 },
  { 1887, 22, 40, 26, 5, -40 },
  { 1997, 24, 42, 26, 1, -41 },
  { 2123, 21, 41, 26, 4, -41 },
  { 2231, 8, 30, 10, 1, -29 },
  { 2261, 11, 36, 10, -2, -29 },
  { 2311, 21, 22, 25, 2, -29 },
  { 2369, 21, 13, 27, 3, -25 },
  { 2404, 21, 22, 25, 2, -29 },
  { 2462, 17, 42, 21, 5, -41 },
  { 2552, 39, 51, 43, 2, -39 },
  { 2801, 27, 40, 29, -2, -40 },
  { 2936, 25, 40, 29, 2, -40 },
  { 3061, 27, 42, 31, 3, -41 },
  { 3203, 27, 40, 31, 2, -40 },
  { 3338, 27, 40, 27, 2, -40 },
  { 3473, 27, 40, 27, 2, -40 },
  { 3608, 26, 42, 33, 4, -41 },
  { 3745, 31, 40, 33, 2, -40 },
  { 3900, 9, 40, 13, 3, -40 },
  { 3945, 25, 41, 26, 1, -40 },
  { 4074, 29, 40, 30, 2, -40 },
  { 4219, 19, 40, 25, 2, -40 },
  { 4314, 38, 40, 41, 2, -40 },
  { 4504, 31, 40, 34, 2, -40 },
  { 4659, 27, 42, 32, 3, -41 },
  { 4801, 27, 40, 29, 2, -40 },
  { 4936, 27, 48, 32, 3, -41 },
  { 5098, 27, 40, 31, 2, -40 },
  { 5233, 27, 42, 28, 1, -41 },
  { 5375, 26, 40, 28, 5, -40 },
  { 5505, 28, 41, 31, 3, -40 },
  { 5649, 26, 40, 29, 5, -40 },
  { 5779, 39, 40, 42, 5, -40 },
  { 5974, 31, 40, 29, -1, -40 },
  { 6129, 26, 40, 28, 5, -40 },
  { 6259, 29, 40, 29, 0, -40 },
  { 6404, 16, 55, 12, 0, -46 },
  { 6514, 8, 43, 19, 6, -40 },
  { 6557, 15, 55, 12, -3, -46 },
  { 6661, 15, 20, 20, 3, -40 },
  { 6699, 20, 2, 20, -3, 0 },
  { 6704, 7, 7, 15, 7, -42 },
  { 6711, 21, 32, 25, 1, -31 },
  { 6795, 23, 43, 26, 1, -42 },
  { 6919, 21, 32, 25, 2, -31 },
  { 7003, 25, 43, 26, 2, -42 },
  { 7138, 21, 32, 25, 2, -31 },
  { 7222, 17, 43, 16, 3, -43 },
  { 7314, 24, 42, 26, 0, -31 },
  { 7440, 22, 42, 26, 1, -42 },
  { 7556, 9, 41, 11, 2, -41 },
  { 7603, 18, 52, 11, -7, -41 },
  { 7720, 23, 42, 23, 1, -42 },
  { 7841, 9, 42, 11, 2, -42 },
  { 7889, 38, 31, 42, 1, -31 },
  { 8037, 22, 31, 26, 1, -31 },
  { 8123, 22, 32, 26, 2, -31 },
  { 8211, 25, 42, 26, -1, -31 },
  { 8343, 22, 42, 26, 2, -31 },
  { 8459, 17, 31, 16, 1, -31 },
  { 8525, 21, 32, 24, 1, -31 },
  { 8609, 12, 38, 16, 3, -37 },
  { 8666, 21, 31, 26, 3, -30 },
  { 8748, 21, 30, 23, 3, -30 },
  { 8827, 32, 30, 36, 4, -30 },
  { 8947, 24, 30, 23, -1, -30 },
  { 9037, 26, 41, 23, -2, -30 },
  { 9171, 23, 30, 23, 0, -30 },
  { 9258, 17, 56, 16, 2, -44 },
  { 9377, 9, 47, 11, 1, -40 },
  { 9430, 17, 56, 16, -3, -44 },
  { 9549, 26, 9, 33, 3, -21 },
};

const GFXfont RobotoCondensed_ExtraLightItalic56pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic56pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic56pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC56PT7B_H_
