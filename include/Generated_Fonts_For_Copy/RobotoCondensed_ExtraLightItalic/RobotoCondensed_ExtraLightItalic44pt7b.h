#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC44PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x06, 0x0C, 0x10, 0x20, 0x41,
  0x83, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x1C, 0x30, 0x00, 0x62, 0xC5, 0x1A, 0x34, 0x78, 0xB1, 0x46,
  0x8C, 0x00, 0x08, 0x10, 0x00, 0x60, 0x40, 0x01, 0x03, 0x00, 0x04, 0x0C,
  0x00, 0x30, 0x20, 0x00, 0x81, 0x80, 0x02, 0x06, 0x00, 0x18, 0x10, 0x00,
  0x60, 0xC0, 0x7F, 0xFF, 0xF0, 0x0C, 0x08, 0x00, 0x30, 0x60, 0x00, 0x81,
  0x80, 0x06, 0x04, 0x00, 0x18, 0x30, 0x00, 0x40, 0xC0, 0x03, 0x02, 0x00,
  0x0C, 0x18, 0x00, 0x20, 0x60, 0x01, 0x81, 0x00, 0x06, 0x0C, 0x03, 0xFF,
  0xFF, 0x00, 0xC0, 0x80, 0x03, 0x06, 0x00, 0x08, 0x18, 0x00, 0x60, 0x40,
  0x01, 0x83, 0x00, 0x04, 0x0C, 0x00, 0x30, 0x20, 0x00, 0xC1, 0x80, 0x02,
  0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x70, 0x30, 0x18, 0x06, 0x0C, 0x00, 0x82,
  0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x06, 0x30, 0x01, 0x8C, 0x00,
  0xC1, 0x80, 0x30, 0x70, 0x38, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0xEC, 0x00,
  0x0C, 0x30, 0x00, 0xC0, 0x80, 0x06, 0x04, 0x06, 0x20, 0x20, 0x23, 0x01,
  0x03, 0x18, 0x08, 0x30, 0xC0, 0x41, 0x06, 0x06, 0x10, 0x30, 0x31, 0x81,
  0x81, 0x18, 0x04, 0x18, 0x80, 0x3B, 0x8C, 0x00, 0xF8, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x43, 0xC0, 0x06, 0x3B, 0x00, 0x63, 0x0C, 0x02, 0x30, 0x20,
  0x31, 0x81, 0x03, 0x08, 0x08, 0x30, 0x40, 0x41, 0x06, 0x02, 0x18, 0x30,
  0x11, 0x81, 0x81, 0x88, 0x0C, 0x0C, 0x00, 0x60, 0x40, 0x01, 0x06, 0x00,
  0x0E, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x01, 0x83,
  0x00, 0x10, 0x18, 0x03, 0x01, 0x80, 0x20, 0x18, 0x02, 0x01, 0x00, 0x60,
  0x30, 0x02, 0x03, 0x00, 0x20, 0x60, 0x03, 0x0C, 0x00, 0x31, 0x80, 0x01,
  0x70, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x0E, 0x60, 0x01,
  0xC6, 0x03, 0x18, 0x30, 0x33, 0x03, 0x02, 0x60, 0x18, 0x66, 0x00, 0x86,
  0x40, 0x0C, 0xC4, 0x00, 0x6C, 0xC0, 0x07, 0x84, 0x00, 0x30, 0x60, 0x03,
  0x06, 0x00, 0x78, 0x30, 0x1C, 0x81, 0xFF, 0x0C, 0x0F, 0xC0, 0x40, 0x32,
  0x26, 0x66, 0x44, 0xC0, 0x00, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x80, 0x81, 0xE1, 0x87, 0x7D, 0xBC,
  0x0F, 0xF0, 0x03, 0x80, 0x06, 0x80, 0x04, 0xC0, 0x0C, 0x40, 0x18, 0x60,
  0x30, 0x30, 0x60, 0x30, 0x40, 0x10, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x18, 0x8C, 0x63, 0x31, 0x98, 0x80, 0x7F, 0xBF, 0xC0, 0x5F, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x30, 0x30, 0x18,
  0x06, 0x0C, 0x01, 0x82, 0x00, 0x21, 0x80, 0x08, 0x60, 0x02, 0x10, 0x00,
  0x8C, 0x00, 0x23, 0x00, 0x08, 0x80, 0x02, 0x20, 0x01, 0x98, 0x00, 0x66,
  0x00, 0x19, 0x80, 0x06, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x33, 0x00,
  0x0C, 0xC0, 0x03, 0x30, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x04,
  0x30, 0x03, 0x04, 0x00, 0x81, 0x80, 0x60, 0x30, 0x30, 0x0F, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x81, 0xE1, 0xE9, 0xC6, 0xC1, 0x80, 0x60, 0x10, 0x04,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x01, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x30, 0x18,
  0x18, 0x02, 0x0C, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0E, 0x06, 0x03, 0x00,
  0x60, 0x60, 0x0C, 0x18, 0x00, 0x83, 0x00, 0x10, 0x40, 0x02, 0x18, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x30, 0x00, 0x46, 0x00, 0x08,
  0xC0, 0x03, 0x08, 0x00, 0x61, 0x80, 0x18, 0x30, 0x07, 0x03, 0x01, 0xC0,
  0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x05, 0x80, 0x03, 0x60, 0x01, 0x98, 0x00, 0xC4, 0x00,
  0x31, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x02, 0x0C, 0x01, 0x83, 0x00, 0xC0,
  0x80, 0x60, 0x20, 0x18, 0x18, 0x0C, 0x06, 0x06, 0x01, 0x81, 0x00, 0x40,
  0xC0, 0x10, 0x60, 0x04, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x4F, 0xC0, 0x3F, 0xF8, 0x0E, 0x03, 0x03, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x88, 0x00, 0x62, 0x00, 0x18, 0x80, 0x04, 0x30,
  0x03, 0x0C, 0x00, 0x81, 0x80, 0x60, 0x60, 0x30, 0x0F, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x31,
  0xF8, 0x27, 0xFC, 0x2C, 0x06, 0x78, 0x06, 0x70, 0x03, 0x60, 0x03, 0x60,
  0x03, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x02, 0xC0, 0x06, 0x40, 0x06, 0x60, 0x0C, 0x60, 0x18, 0x30, 0x38, 0x1F,
  0xF0, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xF0, 0x0E, 0x07, 0x01, 0x80, 0x60, 0x60, 0x06, 0x18, 0x00, 0xC3,
  0x00, 0x18, 0x40, 0x03, 0x08, 0x00, 0x61, 0x00, 0x08, 0x20, 0x03, 0x06,
  0x00, 0x60, 0xC0, 0x18, 0x0C, 0x0E, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x0E,
  0x0E, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x18, 0x80,
  0x03, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x18, 0x00, 0x61, 0x00,
  0x18, 0x30, 0x03, 0x03, 0x01, 0xC0, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x01,
  0xF0, 0x07, 0xFC, 0x0C, 0x0E, 0x18, 0x06, 0x10, 0x03, 0x30, 0x03, 0x20,
  0x03, 0x60, 0x01, 0x60, 0x01, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x06, 0x60, 0x0E, 0x60, 0x1E, 0x30,
  0x36, 0x1F, 0xE6, 0x0F, 0x84, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x7F, 0x00, 0x78,
  0x00, 0x0C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC3, 0x8C, 0x00, 0x01, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18,
  0x18, 0x08, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x08, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x3F, 0xFF, 0x80, 0x10, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0x0E, 0x0C, 0x60,
  0x36, 0x01, 0xA0, 0x0F, 0x00, 0x78, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x78, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x00, 0x60, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x02, 0x02, 0x00, 0x00, 0x04, 0x0C, 0x01, 0xF0, 0x08,
  0x10, 0x0F, 0x70, 0x18, 0x60, 0x30, 0x30, 0x31, 0x80, 0xC0, 0x60, 0x63,
  0x01, 0x00, 0x80, 0xC4, 0x06, 0x01, 0x01, 0x98, 0x08, 0x06, 0x03, 0x30,
  0x30, 0x0C, 0x06, 0x40, 0x40, 0x10, 0x09, 0x81, 0x80, 0x20, 0x13, 0x03,
  0x00, 0xC0, 0x26, 0x04, 0x01, 0x80, 0xC8, 0x08, 0x02, 0x01, 0x10, 0x30,
  0x0C, 0x02, 0x20, 0x60, 0x18, 0x0C, 0x40, 0xC0, 0x70, 0x10, 0x81, 0x80,
  0xE0, 0x61, 0x03, 0x02, 0xC0, 0x82, 0x02, 0x0D, 0x83, 0x04, 0x07, 0xF1,
  0x9C, 0x08, 0x07, 0x81, 0xE0, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x48, 0x00, 0x06, 0x40,
  0x00, 0x22, 0x00, 0x03, 0x10, 0x00, 0x10, 0xC0, 0x01, 0x86, 0x00, 0x08,
  0x30, 0x00, 0xC1, 0x80, 0x04, 0x04, 0x00, 0x60, 0x20, 0x02, 0x01, 0x00,
  0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x03, 0x00, 0x80, 0x18, 0x0C, 0x00,
  0x40, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x30, 0x00, 0xC3, 0x00, 0x06, 0x18,
  0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x26, 0x00, 0x01,
  0x60, 0x00, 0x0B, 0x00, 0x00, 0x60, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x10,
  0x07, 0x06, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0x42, 0x00, 0x08, 0x40,
  0x01, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x61, 0x00,
  0x18, 0x20, 0x06, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x30, 0x07, 0x06, 0x00,
  0x30, 0x80, 0x06, 0x10, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00,
  0x33, 0x00, 0x04, 0x40, 0x01, 0x98, 0x00, 0x33, 0x00, 0x0C, 0x60, 0x03,
  0x8C, 0x00, 0xE1, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xF8, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x0C, 0x00, 0x21, 0x80, 0x03, 0x18,
  0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x32, 0x00, 0x03, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x0C, 0x80, 0x00, 0xC8, 0x00, 0x08, 0xC0, 0x01, 0x8C, 0x00,
  0x10, 0xC0, 0x03, 0x06, 0x00, 0x60, 0x30, 0x0C, 0x01, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0x00, 0x30, 0x18, 0x00,
  0xC0, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x20, 0x00, 0x41, 0x00, 0x03, 0x18,
  0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x00, 0x01,
  0x88, 0x00, 0x08, 0xC0, 0x00, 0x46, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80,
  0x01, 0x88, 0x00, 0x0C, 0x40, 0x00, 0x46, 0x00, 0x06, 0x30, 0x00, 0x31,
  0x80, 0x01, 0x0C, 0x00, 0x18, 0x40, 0x00, 0xC6, 0x00, 0x0C, 0x30, 0x00,
  0xC1, 0x80, 0x0C, 0x0C, 0x01, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xFE, 0x00, 0xE0, 0x38, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x04, 0x00, 0x08,
  0x60, 0x00, 0x62, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x3F, 0xE6, 0x01, 0xFF, 0x30, 0x00, 0x19, 0x80, 0x00,
  0xCC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x07, 0x03, 0x80, 0x70,
  0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x04, 0x00, 0x03, 0x04, 0x00, 0x02,
  0x04, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x08, 0x00, 0x06, 0x08, 0x00, 0x04, 0x18, 0x00, 0x04, 0x18, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x10, 0x00, 0x08,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x20, 0x00, 0x10, 0x20, 0x00, 0x10, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x40, 0x00, 0x20, 0xC0, 0x00, 0x20,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x80, 0x00, 0x40,
  0x80, 0x00, 0x40, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x06, 0x0C, 0x18,
  0x20, 0x41, 0x83, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x83, 0x04, 0x08, 0x30,
  0x60, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x30,
  0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x01, 0x83, 0x00, 0x30, 0x30,
  0x0C, 0x06, 0x03, 0x00, 0x7F, 0xC0, 0x03, 0xE0, 0x00, 0x04, 0x00, 0x0C,
  0x08, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x60, 0x03, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x30, 0x02, 0x00, 0xC0, 0x04, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x30,
  0x30, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x0E, 0x00, 0x02, 0x38,
  0x00, 0x0C, 0xE0, 0x00, 0x1B, 0x60, 0x00, 0x3C, 0x40, 0x00, 0x70, 0xC0,
  0x00, 0xC0, 0xC0, 0x01, 0x01, 0x80, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x00,
  0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x40, 0x06, 0x01, 0x80, 0x0C, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x30, 0x20,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x05, 0x86, 0x80, 0x00, 0x68, 0x24, 0x00, 0x02, 0x41,
  0x20, 0x00, 0x36, 0x19, 0x80, 0x01, 0x30, 0xCC, 0x00, 0x19, 0x86, 0x60,
  0x00, 0x8C, 0x31, 0x00, 0x0C, 0x41, 0x08, 0x00, 0xC2, 0x08, 0x40, 0x06,
  0x30, 0xC3, 0x00, 0x61, 0x86, 0x18, 0x03, 0x0C, 0x30, 0xC0, 0x30, 0x41,
  0x82, 0x01, 0x82, 0x08, 0x10, 0x18, 0x30, 0x40, 0xC0, 0x81, 0x86, 0x06,
  0x0C, 0x0C, 0x30, 0x30, 0x40, 0x61, 0x80, 0x86, 0x02, 0x0C, 0x04, 0x20,
  0x10, 0x40, 0x23, 0x01, 0x86, 0x01, 0x90, 0x0C, 0x30, 0x0D, 0x80, 0x61,
  0x80, 0x68, 0x03, 0x0C, 0x01, 0xC0, 0x10, 0x40, 0x0C, 0x00, 0x82, 0x00,
  0x60, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0F, 0x00, 0x02,
  0x0F, 0x00, 0x02, 0x0D, 0x00, 0x06, 0x0D, 0x80, 0x06, 0x0D, 0x80, 0x06,
  0x08, 0x80, 0x06, 0x18, 0xC0, 0x04, 0x18, 0x40, 0x0C, 0x18, 0x60, 0x0C,
  0x18, 0x60, 0x0C, 0x10, 0x20, 0x0C, 0x10, 0x30, 0x08, 0x30, 0x10, 0x08,
  0x30, 0x18, 0x18, 0x30, 0x18, 0x18, 0x30, 0x08, 0x18, 0x20, 0x0C, 0x18,
  0x20, 0x0C, 0x10, 0x60, 0x04, 0x10, 0x60, 0x06, 0x30, 0x60, 0x02, 0x30,
  0x60, 0x03, 0x30, 0x40, 0x03, 0x30, 0xC0, 0x01, 0x20, 0xC0, 0x01, 0xE0,
  0xC0, 0x01, 0xE0, 0xC0, 0x00, 0xE0, 0x80, 0x00, 0xE0, 0x80, 0x00, 0x60,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x18, 0x06, 0x00, 0xC0, 0x0C, 0x06,
  0x00, 0x18, 0x30, 0x00, 0x60, 0x80, 0x00, 0x86, 0x00, 0x02, 0x18, 0x00,
  0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x8C, 0x00, 0x02, 0x20, 0x00, 0x08,
  0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80,
  0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00,
  0xCC, 0x00, 0x06, 0x10, 0x00, 0x18, 0x40, 0x00, 0x41, 0x80, 0x03, 0x06,
  0x00, 0x18, 0x0C, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0x00, 0x38, 0x18, 0x00,
  0xC0, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x20, 0x00, 0x41, 0x00, 0x02, 0x18,
  0x00, 0x10, 0xC0, 0x00, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x00, 0x06,
  0x08, 0x00, 0x30, 0xC0, 0x03, 0x06, 0x00, 0x70, 0x3F, 0xFF, 0x01, 0xFF,
  0xE0, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x18, 0x06, 0x00, 0xC0, 0x0C, 0x06,
  0x00, 0x18, 0x30, 0x00, 0x60, 0x80, 0x00, 0x86, 0x00, 0x02, 0x10, 0x00,
  0x08, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x8C, 0x00, 0x02, 0x20, 0x00, 0x08,
  0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80,
  0x00, 0x44, 0x00, 0x03, 0x10, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00,
  0x8C, 0x00, 0x06, 0x10, 0x00, 0x18, 0x40, 0x00, 0xC1, 0x80, 0x03, 0x06,
  0x00, 0x18, 0x0C, 0x00, 0xC0, 0x38, 0x06, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x60, 0x07, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x40,
  0x00, 0x81, 0x00, 0x02, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x60, 0xC0, 0x01,
  0x83, 0x00, 0x06, 0x08, 0x00, 0x30, 0x20, 0x00, 0xC1, 0x80, 0x06, 0x06,
  0x00, 0x70, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0x00, 0x40, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x30, 0x08, 0x00, 0xC0,
  0x20, 0x01, 0x01, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x20, 0x60,
  0x00, 0xC1, 0x00, 0x03, 0x04, 0x00, 0x04, 0x00, 0x00, 0x3F, 0x00, 0x07,
  0xFE, 0x00, 0xE0, 0x18, 0x0E, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x0C,
  0x30, 0x00, 0x61, 0x00, 0x03, 0x08, 0x00, 0x18, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x08, 0xC0,
  0x00, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x60, 0xC0, 0x07, 0x03, 0x80, 0x70,
  0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x04, 0x30, 0x00, 0x10, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x08,
  0x00, 0x0C, 0x20, 0x00, 0x21, 0x80, 0x00, 0x86, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x60, 0x00, 0x61, 0x00, 0x01, 0x84, 0x00, 0x04, 0x30, 0x00, 0x10,
  0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x30, 0x80,
  0x00, 0x86, 0x00, 0x02, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01,
  0x84, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0xC1, 0x80, 0x02, 0x06,
  0x00, 0x18, 0x0C, 0x00, 0xC0, 0x38, 0x0E, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0x00, 0x00, 0xC0, 0x00, 0x16, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00,
  0xC4, 0x00, 0x06, 0x20, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x60,
  0x01, 0x83, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x40, 0x04, 0x02, 0x00, 0x60,
  0x18, 0x02, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x00, 0x30, 0x18, 0x00, 0x80,
  0xC0, 0x04, 0x0C, 0x00, 0x20, 0x60, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00,
  0x61, 0x00, 0x03, 0x18, 0x00, 0x08, 0x80, 0x00, 0x4C, 0x00, 0x02, 0x40,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x01, 0x00, 0x07, 0x80, 0x07, 0x00, 0x1B, 0x00, 0x0E, 0x00, 0x32,
  0x00, 0x3C, 0x00, 0x64, 0x00, 0x58, 0x01, 0x88, 0x00, 0xB0, 0x03, 0x10,
  0x03, 0x20, 0x04, 0x20, 0x04, 0x40, 0x18, 0x60, 0x18, 0x80, 0x30, 0xC0,
  0x21, 0x00, 0x41, 0x80, 0x42, 0x01, 0x83, 0x01, 0x84, 0x03, 0x06, 0x02,
  0x08, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x10, 0x30, 0x20, 0x30, 0x60,
  0x60, 0xC0, 0x60, 0xC0, 0xC1, 0x80, 0xC1, 0x01, 0x82, 0x01, 0x86, 0x01,
  0x0C, 0x01, 0x08, 0x02, 0x18, 0x02, 0x30, 0x04, 0x60, 0x04, 0x60, 0x08,
  0xC0, 0x08, 0x80, 0x11, 0x00, 0x13, 0x00, 0x26, 0x00, 0x24, 0x00, 0x6C,
  0x00, 0x48, 0x00, 0xD0, 0x00, 0xB0, 0x01, 0xE0, 0x01, 0x40, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0x80, 0x40, 0x01, 0x80, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x00,
  0x80, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x01, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x0C, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x06,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x03, 0x00, 0x01, 0x81, 0x80,
  0x00, 0xC0, 0xC0, 0x00, 0x32, 0x00, 0x01, 0x98, 0x00, 0x18, 0xC0, 0x01,
  0x82, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x18,
  0x06, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x10, 0x30, 0x00, 0xC3, 0x00,
  0x06, 0x18, 0x00, 0x11, 0x80, 0x00, 0xC8, 0x00, 0x06, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x07, 0xC0, 0xFC, 0x00, 0x82,
  0x08, 0x30, 0xC3, 0x0C, 0x10, 0x41, 0x06, 0x18, 0x61, 0x82, 0x08, 0x20,
  0xC3, 0x0C, 0x30, 0x41, 0x04, 0x18, 0x61, 0x86, 0x08, 0x20, 0x83, 0x0C,
  0x30, 0x01, 0xF0, 0x1F, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x14,
  0x03, 0x40, 0x24, 0x06, 0x60, 0x46, 0x0C, 0x20, 0x82, 0x18, 0x21, 0x02,
  0x30, 0x32, 0x03, 0x60, 0x34, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0xC3, 0x18,
  0x63, 0x0C, 0x00, 0xF8, 0x01, 0xFF, 0x03, 0x80, 0xC1, 0x80, 0x61, 0x80,
  0x10, 0x80, 0x08, 0xC0, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0xFF, 0xC1, 0xF0, 0x43, 0x80, 0x23, 0x00, 0x31, 0x00, 0x19, 0x80, 0x0C,
  0xC0, 0x06, 0x40, 0x06, 0x20, 0x03, 0x18, 0x03, 0x8C, 0x06, 0xC3, 0xFE,
  0x60, 0xFC, 0x30, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC7, 0xC0, 0x27, 0xFC, 0x0B, 0x03, 0x87, 0x00, 0x61, 0xC0,
  0x18, 0x60, 0x02, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0xC0, 0x02,
  0x30, 0x00, 0x8C, 0x00, 0x62, 0x00, 0x18, 0x80, 0x06, 0x60, 0x01, 0x18,
  0x00, 0x46, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x06, 0x1C, 0x03, 0x0D, 0x81,
  0xC3, 0x3F, 0xE0, 0xC3, 0xE0, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x03, 0x80,
  0xC1, 0x80, 0x61, 0x80, 0x11, 0x80, 0x0C, 0xC0, 0x06, 0x40, 0x03, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x04, 0xC0, 0x06, 0x20, 0x03, 0x18, 0x03, 0x0C, 0x01,
  0x83, 0x03, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x0F, 0xC2, 0x03, 0xFC, 0xC0,
  0xC0, 0xD8, 0x30, 0x07, 0x0C, 0x00, 0xC1, 0x00, 0x08, 0x60, 0x03, 0x0C,
  0x00, 0x61, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x21, 0x80, 0x04, 0x30,
  0x01, 0x86, 0x00, 0x30, 0x80, 0x06, 0x10, 0x00, 0xC2, 0x00, 0x10, 0x60,
  0x02, 0x0C, 0x00, 0xC1, 0x80, 0x38, 0x18, 0x0F, 0x01, 0xFE, 0x60, 0x1F,
  0x08, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0x80, 0xC1, 0x80, 0x61, 0x80,
  0x11, 0x80, 0x0C, 0xC0, 0x06, 0x40, 0x03, 0x60, 0x01, 0xBF, 0xFF, 0xDF,
  0xFF, 0xC8, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x83, 0x01, 0xC0, 0xFF,
  0x80, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xC0, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x3F, 0xF1, 0xFF, 0x81, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x00, 0x00, 0xFC, 0x20,
  0x3F, 0xCC, 0x1C, 0x0D, 0x83, 0x00, 0xF0, 0xC0, 0x0C, 0x10, 0x01, 0x86,
  0x00, 0x30, 0xC0, 0x06, 0x10, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x02, 0x18,
  0x00, 0x43, 0x00, 0x18, 0x60, 0x03, 0x08, 0x00, 0x61, 0x00, 0x0C, 0x20,
  0x01, 0x06, 0x00, 0x20, 0xC0, 0x0C, 0x18, 0x03, 0x81, 0x80, 0xF0, 0x1F,
  0xE6, 0x01, 0xF0, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x0C, 0x01, 0x80, 0xC0, 0x70, 0x0F, 0xFC, 0x00, 0x7E,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x1F,
  0x01, 0x1F, 0xE0, 0x90, 0x30, 0xD0, 0x0C, 0x70, 0x06, 0x38, 0x03, 0x18,
  0x01, 0x8C, 0x00, 0xC4, 0x00, 0x66, 0x00, 0x33, 0x00, 0x11, 0x80, 0x08,
  0x80, 0x0C, 0x40, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0x8C, 0x00,
  0x44, 0x00, 0x62, 0x00, 0x33, 0x00, 0x19, 0x80, 0x08, 0xC0, 0x04, 0x00,
  0x02, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x08,
  0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x30, 0x20,
  0x20, 0x60, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0x00, 0x04, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x3E, 0x00, 0xF8,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x18, 0x20, 0x0C, 0x08, 0x06, 0x06, 0x03, 0x01, 0x81, 0x80, 0x60,
  0xC0, 0x18, 0x60, 0x04, 0x30, 0x01, 0x18, 0x00, 0xCC, 0x00, 0x37, 0x00,
  0x0F, 0x60, 0x03, 0x98, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0x18, 0x18, 0x06,
  0x06, 0x01, 0x80, 0xC0, 0x40, 0x30, 0x10, 0x06, 0x0C, 0x01, 0x83, 0x00,
  0x30, 0xC0, 0x0C, 0x00, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04,
  0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10,
  0x30, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x60, 0x40, 0x40,
  0xC0, 0x08, 0x7C, 0x03, 0xE0, 0x4F, 0xF8, 0x7F, 0x86, 0xC0, 0xC6, 0x06,
  0x34, 0x03, 0x60, 0x31, 0xC0, 0x1E, 0x00, 0x8E, 0x00, 0xE0, 0x04, 0x60,
  0x06, 0x00, 0x23, 0x00, 0x30, 0x01, 0x30, 0x01, 0x80, 0x09, 0x80, 0x08,
  0x00, 0xCC, 0x00, 0x40, 0x06, 0x60, 0x06, 0x00, 0x32, 0x00, 0x30, 0x01,
  0x90, 0x01, 0x80, 0x09, 0x80, 0x0C, 0x00, 0x4C, 0x00, 0x40, 0x06, 0x60,
  0x02, 0x00, 0x32, 0x00, 0x30, 0x01, 0x90, 0x01, 0x80, 0x09, 0x80, 0x0C,
  0x00, 0x4C, 0x00, 0x60, 0x02, 0x60, 0x02, 0x00, 0x33, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x7C, 0x04, 0x7F, 0x82, 0x40, 0xC3, 0x40, 0x31, 0xC0, 0x18,
  0xE0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x10, 0x01, 0x98, 0x00, 0xCC, 0x00,
  0x46, 0x00, 0x23, 0x00, 0x31, 0x00, 0x18, 0x80, 0x0C, 0xC0, 0x06, 0x60,
  0x02, 0x30, 0x01, 0x10, 0x01, 0x88, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x23,
  0x00, 0x10, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0x01, 0x83, 0x00, 0x63, 0x00,
  0x31, 0x80, 0x09, 0x80, 0x06, 0xC0, 0x03, 0x40, 0x01, 0xE0, 0x00, 0xB0,
  0x00, 0x58, 0x00, 0x2C, 0x00, 0x34, 0x00, 0x1A, 0x00, 0x0D, 0x00, 0x04,
  0x80, 0x06, 0x60, 0x02, 0x30, 0x03, 0x08, 0x03, 0x06, 0x03, 0x81, 0xFF,
  0x00, 0x7F, 0x00, 0x02, 0x1F, 0x00, 0x27, 0xFC, 0x02, 0xC0, 0xC0, 0x70,
  0x06, 0x06, 0x00, 0x20, 0x60, 0x02, 0x06, 0x00, 0x20, 0x40, 0x02, 0x04,
  0x00, 0x20, 0xC0, 0x02, 0x0C, 0x00, 0x20, 0xC0, 0x06, 0x08, 0x00, 0x60,
  0x80, 0x06, 0x08, 0x00, 0x41, 0x80, 0x04, 0x18, 0x00, 0xC1, 0x80, 0x0C,
  0x18, 0x01, 0x81, 0x80, 0x30, 0x36, 0x07, 0x03, 0x3F, 0xE0, 0x30, 0xF8,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x03,
  0xF0, 0x83, 0xFC, 0xC3, 0x03, 0x63, 0x00, 0x73, 0x00, 0x31, 0x00, 0x09,
  0x80, 0x0C, 0xC0, 0x06, 0x40, 0x03, 0x60, 0x01, 0xB0, 0x00, 0x98, 0x00,
  0x4C, 0x00, 0x66, 0x00, 0x32, 0x00, 0x19, 0x00, 0x0C, 0x80, 0x04, 0x60,
  0x02, 0x30, 0x03, 0x18, 0x03, 0x86, 0x03, 0xC1, 0xFE, 0x40, 0x7E, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x78, 0x4F, 0xC2, 0xC0,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x01, 0xF8, 0x07,
  0xFC, 0x0C, 0x06, 0x18, 0x03, 0x10, 0x03, 0x10, 0x03, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x18, 0x60, 0x38, 0x3F, 0xE0, 0x0F, 0xC0, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x0C, 0x03, 0x07, 0xFF, 0xFF, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x00, 0xF0, 0x3C, 0x00, 0x18, 0x01, 0x88, 0x00,
  0xC4, 0x00, 0x66, 0x00, 0x33, 0x00, 0x11, 0x80, 0x08, 0x80, 0x0C, 0x40,
  0x06, 0x60, 0x03, 0x30, 0x01, 0x18, 0x00, 0x8C, 0x00, 0x44, 0x00, 0x62,
  0x00, 0x33, 0x00, 0x19, 0x80, 0x08, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x07,
  0x08, 0x07, 0x86, 0x06, 0xC1, 0xFE, 0x40, 0x7C, 0x20, 0x80, 0x02, 0xC0,
  0x06, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x0C, 0x40, 0x18, 0x40, 0x18, 0x60,
  0x30, 0x60, 0x30, 0x60, 0x20, 0x60, 0x60, 0x20, 0x40, 0x20, 0xC0, 0x20,
  0x80, 0x31, 0x80, 0x31, 0x00, 0x33, 0x00, 0x12, 0x00, 0x16, 0x00, 0x14,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x01, 0xA0, 0x0E,
  0x00, 0x90, 0x07, 0x00, 0xC8, 0x07, 0x80, 0x64, 0x03, 0xC0, 0x62, 0x01,
  0x60, 0x31, 0x81, 0xB0, 0x10, 0xC0, 0x88, 0x18, 0x60, 0xC4, 0x0C, 0x30,
  0x42, 0x0C, 0x18, 0x61, 0x06, 0x0C, 0x30, 0x82, 0x06, 0x30, 0x63, 0x03,
  0x18, 0x31, 0x01, 0x88, 0x19, 0x80, 0xCC, 0x0C, 0xC0, 0x24, 0x06, 0x40,
  0x16, 0x01, 0x60, 0x0A, 0x00, 0xA0, 0x05, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0xC0, 0x18,
  0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x30, 0x02, 0x0C, 0x00, 0x63, 0x00,
  0x0C, 0x60, 0x00, 0xD8, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x03, 0x60, 0x00, 0x44, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x01,
  0x81, 0x80, 0x30, 0x30, 0x0C, 0x02, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00,
  0xC0, 0x20, 0x06, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x30, 0x03,
  0x01, 0x80, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x02, 0x04, 0x00, 0x10, 0x60,
  0x00, 0x82, 0x00, 0x06, 0x30, 0x00, 0x31, 0x00, 0x01, 0x98, 0x00, 0x0C,
  0x80, 0x00, 0x2C, 0x00, 0x01, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x06, 0x0C,
  0x18, 0x20, 0x40, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x41, 0x83, 0x06, 0x0C,
  0x10, 0x20, 0xC1, 0x83, 0x06, 0x0C, 0x00, 0x01, 0x00, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x70, 0x07, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0x80, 0x04, 0x00, 0x00, 0x1F,
  0x00, 0x33, 0xF8, 0x03, 0x60, 0xC0, 0x2C, 0x06, 0x06, 0xC0, 0x30, 0xC8,
  0x01, 0xFC, 0x00, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLightItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 31, 8, 1, -31 },
  { 29, 7, 9, 12, 5, -33 },
  { 37, 22, 31, 21, 1, -31 },
  { 123, 18, 39, 21, 2, -35 },
  { 211, 21, 31, 28, 4, -31 },
  { 293, 20, 31, 23, 1, -31 },
  { 371, 4, 9, 7, 4, -33 },
  { 376, 12, 45, 12, 2, -35 },
  { 444, 12, 45, 12, -2, -35 },
  { 512, 16, 17, 18, 3, -31 },
  { 546, 18, 24, 21, 2, -27 },
  { 600, 5, 9, 8, -1, -4 },
  { 606, 9, 2, 11, 1, -15 },
  { 609, 3, 3, 10, 1, -3 },
  { 611, 18, 34, 15, -2, -31 },
  { 688, 18, 31, 21, 2, -31 },
  { 758, 10, 31, 21, 6, -31 },
  { 797, 18, 31, 21, 1, -31 },
  { 867, 19, 31, 21, 1, -31 },
  { 941, 18, 31, 21, 1, -31 },
  { 1011, 18, 31, 21, 3, -31 },
  { 1081, 16, 31, 21, 2, -31 },
  { 1143, 17, 31, 21, 4, -31 },
  { 1209, 19, 31, 21, 1, -31 },
  { 1283, 16, 31, 21, 3, -31 },
  { 1345, 6, 23, 8, 1, -23 },
  { 1363, 9, 28, 8, -2, -23 },
  { 1395, 16, 18, 19, 2, -23 },
  { 1431, 17, 11, 21, 2, -20 },
  { 1455, 17, 18, 19, 1, -23 },
  { 1494, 13, 31, 17, 4, -31 },
  { 1545, 31, 40, 34, 1, -30 },
  { 1700, 21, 31, 23, -1, -31 },
  { 1782, 19, 31, 23, 2, -31 },
  { 1856, 20, 31, 24, 3, -31 },
  { 1934, 21, 31, 24, 2, -31 },
  { 2016, 21, 31, 21, 2, -31 },
  { 2098, 21, 31, 21, 2, -31 },
  { 2180, 21, 31, 26, 3, -31 },
  { 2262, 24, 31, 26, 2, -31 },
  { 2355, 7, 31, 10, 2, -31 },
  { 2383, 19, 31, 21, 1, -31 },
  { 2457, 23, 31, 24, 2, -31 },
  { 2547, 14, 31, 20, 2, -31 },
  { 2602, 29, 31, 32, 2, -31 },
  { 2715, 24, 31, 26, 2, -31 },
  { 2808, 22, 31, 25, 2, -31 },
  { 2894, 21, 31, 23, 2, -31 },
  { 2976, 22, 37, 25, 2, -31 },
  { 3078, 22, 31, 24, 1, -31 },
  { 3164, 21, 31, 22, 1, -31 },
  { 3246, 20, 31, 22, 4, -31 },
  { 3324, 22, 31, 25, 2, -31 },
  { 3410, 21, 31, 23, 4, -31 },
  { 3492, 31, 31, 33, 4, -31 },
  { 3613, 25, 31, 23, -1, -31 },
  { 3710, 21, 31, 22, 4, -31 },
  { 3792, 23, 31, 22, 0, -31 },
  { 3882, 12, 43, 9, 0, -36 },
  { 3947, 6, 34, 15, 5, -31 },
  { 3973, 12, 43, 9, -3, -36 },
  { 4038, 12, 16, 16, 2, -31 },
  { 4062, 15, 2, 16, -2, 0 },
  { 4066, 5, 6, 12, 6, -33 },
  { 4070, 17, 23, 20, 1, -23 },
  { 4119, 18, 33, 21, 1, -33 },
  { 4194, 17, 23, 19, 1, -23 },
  { 4243, 19, 33, 21, 2, -33 },
  { 4322, 17, 23, 19, 1, -23 },
  { 4371, 13, 33, 12, 3, -33 },
  { 4425, 19, 32, 21, 0, -23 },
  { 4501, 17, 33, 21, 1, -33 },
  { 4572, 8, 32, 9, 1, -32 },
  { 4604, 15, 41, 9, -6, -32 },
  { 4681, 18, 33, 18, 1, -33 },
  { 4756, 8, 33, 9, 1, -33 },
  { 4789, 29, 23, 33, 1, -23 },
  { 4873, 17, 23, 21, 1, -23 },
  { 4922, 17, 23, 21, 2, -23 },
  { 4971, 20, 32, 21, -1, -23 },
  { 5051, 17, 32, 21, 2, -23 },
  { 5119, 13, 23, 13, 1, -23 },
  { 5157, 16, 23, 19, 1, -23 },
  { 5203, 10, 29, 12, 2, -29 },
  { 5240, 17, 23, 21, 2, -23 },
  { 5289, 16, 23, 18, 3, -23 },
  { 5335, 25, 23, 28, 3, -23 },
  { 5407, 19, 23, 18, -1, -23 },
  { 5462, 21, 32, 18, -2, -23 },
  { 5546, 18, 23, 18, 0, -23 },
  { 5598, 14, 43, 13, 1, -34 },
  { 5674, 7, 37, 9, 1, -31 },
  { 5707, 14, 43, 13, -3, -34 },
  { 5783, 20, 7, 26, 3, -16 },
};

const GFXfont RobotoCondensed_ExtraLightItalic44pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic44pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic44pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC44PT7B_H_
