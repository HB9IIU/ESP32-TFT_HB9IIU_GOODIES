#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC66PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06,
  0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x38, 0x63, 0x86, 0x30, 0x63,
  0x06, 0x30, 0xE3, 0x0E, 0x70, 0xE7, 0x0C, 0x60, 0xC6, 0x0C, 0x61, 0xCE,
  0x18, 0xE1, 0x8C, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60, 0x38,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x07, 0x06, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x1C, 0x03, 0x80, 0x03,
  0xC0, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x04, 0x38, 0x03, 0x80, 0x18, 0x60,
  0x07, 0x00, 0x70, 0xC0, 0x0E, 0x01, 0xC1, 0x80, 0x18, 0x03, 0x07, 0x00,
  0x30, 0x0E, 0x0C, 0x00, 0x60, 0x38, 0x18, 0x00, 0xC0, 0x60, 0x30, 0x03,
  0x81, 0x80, 0x60, 0x06, 0x07, 0x00, 0xE0, 0x0C, 0x0C, 0x00, 0xC0, 0x38,
  0x30, 0x01, 0x80, 0xE0, 0xE0, 0x01, 0x83, 0x81, 0x80, 0x03, 0xFE, 0x06,
  0x00, 0x01, 0xF8, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x3F, 0x00, 0x00, 0xC0, 0xFF, 0x80, 0x03, 0x03, 0x83,
  0x00, 0x0E, 0x0E, 0x03, 0x00, 0x38, 0x38, 0x06, 0x00, 0x60, 0x60, 0x0C,
  0x01, 0x80, 0xC0, 0x1C, 0x07, 0x03, 0x00, 0x18, 0x0C, 0x06, 0x00, 0x30,
  0x30, 0x0C, 0x00, 0xE0, 0xE0, 0x18, 0x01, 0x81, 0x80, 0x70, 0x03, 0x06,
  0x00, 0xC0, 0x06, 0x1C, 0x01, 0x80, 0x0C, 0x30, 0x03, 0x00, 0x38, 0xC0,
  0x07, 0x00, 0x60, 0x80, 0x06, 0x01, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x18, 0x01, 0x80,
  0x01, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x00, 0x07,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x0E, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x60, 0x07, 0x00, 0x03, 0x00, 0x70, 0x00, 0x18, 0x07, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x03, 0x07, 0x80, 0x00, 0x18, 0x70, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x30, 0xE0, 0x38, 0x01, 0x8E,
  0x00, 0xC0, 0x1C, 0x60, 0x07, 0x00, 0xC7, 0x00, 0x1C, 0x06, 0x70, 0x00,
  0xE0, 0x73, 0x80, 0x03, 0x83, 0x98, 0x00, 0x1C, 0x18, 0xC0, 0x00, 0x71,
  0xCE, 0x00, 0x01, 0x8C, 0x70, 0x00, 0x0E, 0xE3, 0x80, 0x00, 0x36, 0x1C,
  0x00, 0x01, 0xF0, 0xE0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x03, 0xE0, 0xE0, 0x00, 0x77, 0x03, 0x80, 0x07, 0x1C, 0x0F, 0x00, 0xF0,
  0x60, 0x3F, 0xFF, 0x03, 0x80, 0xFF, 0xE0, 0x0C, 0x00, 0x78, 0x00, 0x00,
  0x33, 0x37, 0x77, 0x66, 0x6E, 0xCC, 0xCC, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x04, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x40, 0x0C,
  0x00, 0xF8, 0x06, 0x03, 0xFF, 0x07, 0x0F, 0xE7, 0xF3, 0x9F, 0x80, 0x7F,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x60, 0x00,
  0x70, 0x38, 0x00, 0x70, 0x0C, 0x00, 0x70, 0x07, 0x00, 0x70, 0x01, 0xC0,
  0x70, 0x00, 0xE0, 0x18, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x38,
  0x30, 0x70, 0xE0, 0x40, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xDE, 0xF7, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xE0, 0x3C,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x18, 0x0E, 0x00,
  0x06, 0x03, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x0C, 0x38,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C,
  0x70, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x06, 0x38, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0C, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00, 0x38,
  0x18, 0x00, 0x0C, 0x07, 0x00, 0x07, 0x00, 0xC0, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC1, 0xFF, 0x1F, 0x9F,
  0xF0, 0x6F, 0x01, 0xB0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xC0, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x03, 0x80, 0x00, 0x60, 0x38, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x70,
  0x00, 0x30, 0x1C, 0x00, 0x07, 0x03, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C,
  0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0E, 0x38, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0x3C, 0x03,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0D,
  0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x18, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38,
  0x38, 0x00, 0x03, 0x03, 0x80, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x18, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x70,
  0x07, 0x00, 0x06, 0x00, 0x60, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x1C,
  0x07, 0x00, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE1, 0xF8, 0x00,
  0x0C, 0xFF, 0xE0, 0x00, 0xDF, 0x3F, 0x00, 0x0F, 0x80, 0x78, 0x01, 0xE0,
  0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x1C, 0x0E, 0x00, 0x01, 0x80, 0x60, 0x00, 0x38, 0x07, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x0F, 0xC0,
  0x1C, 0x7F, 0xF0, 0x18, 0xF8, 0xF8, 0x19, 0xC0, 0x3C, 0x3B, 0x00, 0x1E,
  0x3E, 0x00, 0x0E, 0x3C, 0x00, 0x06, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07,
  0x70, 0x00, 0x03, 0x70, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E,
  0x60, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x18,
  0x30, 0x00, 0x38, 0x38, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0xE0, 0x1C, 0x00, 0x06, 0x03, 0x80, 0x00, 0x70, 0x30, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x1C, 0x03, 0x00, 0x01, 0x80, 0x38, 0x00, 0x38, 0x01, 0x80,
  0x07, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x80, 0x1C, 0x00, 0xE0,
  0x00, 0xE0, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x78, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xF0, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x06, 0x38, 0x00, 0x07, 0x30, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3E, 0x60, 0x00, 0x3C, 0x70, 0x00,
  0x6C, 0x38, 0x00, 0xCC, 0x3C, 0x03, 0xDC, 0x1F, 0x1F, 0x1C, 0x0F, 0xFE,
  0x18, 0x03, 0xF8, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x7C, 0x1E, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x06, 0x00,
  0x00, 0x20, 0x03, 0x80, 0x3E, 0x01, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0x80, 0xF0, 0x3C, 0x1C, 0x01, 0xC3, 0x80, 0x0E, 0x30, 0x00, 0xE7, 0x00,
  0x06, 0x60, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x0F, 0xC0, 0x01, 0x80, 0x60,
  0x00, 0xFF, 0x80, 0x06, 0x03, 0x80, 0x07, 0x87, 0x80, 0x18, 0x1C, 0x00,
  0x38, 0x07, 0x00, 0x30, 0x70, 0x01, 0xC0, 0x18, 0x00, 0xC1, 0x80, 0x0E,
  0x00, 0x60, 0x03, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x31, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xC6, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x18, 0x01, 0xC0, 0x03, 0x00, 0x18, 0xE0, 0x06, 0x00, 0x0C,
  0x00, 0x63, 0x00, 0x38, 0x00, 0x70, 0x01, 0x8C, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x30, 0x03, 0x00, 0x06, 0x00, 0x19, 0xC0, 0x1C, 0x00, 0x18, 0x00,
  0x66, 0x00, 0x60, 0x00, 0xE0, 0x03, 0x18, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x60, 0x06, 0x00, 0x0C, 0x00, 0x31, 0x80, 0x38, 0x00, 0x30, 0x00, 0xC6,
  0x00, 0xE0, 0x01, 0xC0, 0x06, 0x18, 0x03, 0x00, 0x06, 0x00, 0x18, 0xE0,
  0x0C, 0x00, 0x18, 0x00, 0x63, 0x80, 0x30, 0x00, 0xE0, 0x03, 0x0C, 0x00,
  0xC0, 0x03, 0x80, 0x0C, 0x30, 0x03, 0x00, 0x1E, 0x00, 0x60, 0xC0, 0x0C,
  0x00, 0xD8, 0x01, 0x83, 0x80, 0x30, 0x03, 0x60, 0x0C, 0x0E, 0x00, 0xE0,
  0x19, 0x80, 0x70, 0x38, 0x01, 0x81, 0xC7, 0x03, 0x80, 0x60, 0x07, 0xFE,
  0x0F, 0x3C, 0x01, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x06, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x03, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x60, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x18, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x0C, 0x00, 0xFE, 0x00, 0x30, 0x00, 0x3C, 0x00, 0xC0,
  0x00, 0x78, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30, 0x1C,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x06, 0x00,
  0x07, 0x80, 0x18, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x0E, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x18, 0x38, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xF0,
  0x18, 0x00, 0x0F, 0x80, 0x60, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x0F, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xC0,
  0x0F, 0xE0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x03, 0x80, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x60, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0E, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0xF0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0xFF, 0xF8, 0x70, 0x00, 0xFF, 0xF8, 0x60, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x0F, 0x80, 0x0F, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x38, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x18, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x38, 0x03,
  0x80, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0,
  0x3C, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x78, 0x03, 0x00,
  0x00, 0x1E, 0x00, 0x60, 0x00, 0x07, 0x80, 0x0C, 0x00, 0x01, 0xE0, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0x80, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0x0C, 0x3C, 0x00,
  0x00, 0x01, 0x8F, 0x80, 0x00, 0x00, 0x73, 0xB8, 0x00, 0x00, 0x0E, 0xE3,
  0x00, 0x00, 0x01, 0xB8, 0x70, 0x00, 0x00, 0x3E, 0x06, 0x00, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x38, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x06, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xD8, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x33,
  0x00, 0x00, 0x00, 0x6E, 0x01, 0x98, 0x00, 0x00, 0x07, 0x70, 0x0C, 0xC0,
  0x00, 0x00, 0x33, 0x00, 0x67, 0x00, 0x00, 0x03, 0x98, 0x07, 0x38, 0x00,
  0x00, 0x18, 0xC0, 0x38, 0xC0, 0x00, 0x01, 0xCE, 0x01, 0x86, 0x00, 0x00,
  0x0C, 0x70, 0x0C, 0x30, 0x00, 0x00, 0xE3, 0x00, 0x61, 0x80, 0x00, 0x0E,
  0x18, 0x03, 0x0E, 0x00, 0x00, 0x60, 0xC0, 0x38, 0x70, 0x00, 0x07, 0x06,
  0x01, 0xC1, 0x80, 0x00, 0x30, 0x70, 0x0C, 0x0C, 0x00, 0x03, 0x83, 0x80,
  0x60, 0x60, 0x00, 0x18, 0x18, 0x03, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x18,
  0x1C, 0x00, 0x0C, 0x06, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x0E, 0x03,
  0x00, 0x06, 0x03, 0x80, 0x60, 0x18, 0x00, 0x70, 0x1C, 0x03, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x01,
  0x80, 0x30, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0,
  0x1C, 0x03, 0x00, 0x30, 0x0E, 0x00, 0xE0, 0x18, 0x01, 0x80, 0x60, 0x06,
  0x00, 0xC0, 0x0E, 0x07, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x30, 0x01, 0x80,
  0x70, 0x01, 0x83, 0x80, 0x1C, 0x03, 0x80, 0x0C, 0x18, 0x00, 0xE0, 0x18,
  0x00, 0x61, 0xC0, 0x07, 0x00, 0xC0, 0x03, 0x1C, 0x00, 0x30, 0x06, 0x00,
  0x1C, 0xE0, 0x01, 0x80, 0x70, 0x00, 0x6E, 0x00, 0x0C, 0x03, 0x80, 0x03,
  0x60, 0x00, 0xE0, 0x1C, 0x00, 0x1F, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x30, 0x06, 0x00, 0x07, 0x80, 0x01, 0x80, 0x30, 0x00, 0x38, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x01, 0x80, 0x3C, 0x00, 0x00, 0x0C, 0x01, 0xE0,
  0x00, 0x00, 0x60, 0x0F, 0x80, 0x00, 0x07, 0x00, 0xEC, 0x00, 0x00, 0x38,
  0x07, 0x60, 0x00, 0x01, 0xC0, 0x3B, 0x80, 0x00, 0x0C, 0x01, 0xCC, 0x00,
  0x00, 0x60, 0x0C, 0x60, 0x00, 0x03, 0x00, 0x63, 0x80, 0x00, 0x38, 0x07,
  0x0C, 0x00, 0x01, 0xC0, 0x38, 0x70, 0x00, 0x0E, 0x01, 0xC1, 0x80, 0x00,
  0x60, 0x0E, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x70, 0x00, 0x18, 0x03, 0x01,
  0x80, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x70, 0x00, 0x70,
  0x0E, 0x01, 0x80, 0x03, 0x00, 0x60, 0x0E, 0x00, 0x18, 0x03, 0x00, 0x30,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x0E,
  0x00, 0x30, 0x03, 0x00, 0x70, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x0E, 0x00,
  0xC0, 0x18, 0x00, 0x30, 0x0E, 0x00, 0xC0, 0x01, 0xC0, 0x70, 0x0E, 0x00,
  0x06, 0x03, 0x80, 0x70, 0x00, 0x30, 0x18, 0x03, 0x80, 0x01, 0xC0, 0xC0,
  0x18, 0x00, 0x06, 0x06, 0x00, 0xC0, 0x00, 0x38, 0x70, 0x0E, 0x00, 0x01,
  0xC3, 0x80, 0x70, 0x00, 0x06, 0x1C, 0x03, 0x80, 0x00, 0x38, 0xC0, 0x1C,
  0x00, 0x00, 0xC6, 0x00, 0xC0, 0x00, 0x06, 0x30, 0x06, 0x00, 0x00, 0x3B,
  0x80, 0x70, 0x00, 0x00, 0xDC, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x07, 0x80,
  0x30, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x06, 0x1C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xC0,
  0x03, 0xF0, 0x00, 0xC0, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x38, 0x06, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x03, 0xC0, 0x0E, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x07, 0x18, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x1C, 0x60, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xC0, 0x03, 0xF0, 0x00, 0xC0, 0x00, 0x78, 0x00, 0xC0,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x1F, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x38, 0x00, 0x07, 0x00, 0x30, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x1C, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x03, 0x81, 0x80, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x18, 0x0E, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x60, 0x00, 0x03, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x1E, 0x00, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x07, 0x18, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0xC0, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x06, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xE0, 0x01, 0x80, 0x01, 0xC0,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x80, 0x00,
  0x60, 0x06, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1D,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x76, 0x00, 0x00, 0x78, 0x00, 0x01, 0x98,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x39, 0x80,
  0x00, 0x36, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x18, 0x00,
  0x06, 0x60, 0x00, 0x18, 0x70, 0x00, 0x19, 0x80, 0x00, 0xE1, 0xC0, 0x00,
  0xE6, 0x00, 0x03, 0x87, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x0C,
  0x70, 0x00, 0x70, 0x70, 0x00, 0x61, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0x83,
  0x00, 0x06, 0x07, 0x00, 0x0E, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0x70, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x00,
  0x1C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0xE0, 0x30, 0x03,
  0x80, 0x30, 0x03, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00,
  0x30, 0x0E, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x30, 0x01, 0x80, 0xE0, 0x03,
  0x80, 0xC0, 0x06, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x18, 0x0C, 0x00, 0x38,
  0x18, 0x00, 0x60, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0x81, 0x80, 0x03, 0x83,
  0x00, 0x06, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x38, 0x00, 0x38, 0x70,
  0x00, 0x60, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0x87, 0x00, 0x01, 0x8E, 0x00,
  0x07, 0x18, 0x00, 0x06, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x73, 0x80, 0x00, 0x67, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x03,
  0x30, 0x00, 0x06, 0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x60,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x30, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x06,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0x30, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x06, 0xC0, 0x03,
  0x60, 0x03, 0x30, 0x01, 0x8C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xC1, 0x80,
  0xE0, 0xC0, 0x60, 0x60, 0x70, 0x38, 0x30, 0x0C, 0x38, 0x06, 0x18, 0x03,
  0x1C, 0x01, 0x8C, 0x00, 0xEE, 0x00, 0x76, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0xE1, 0xC1, 0xC3, 0x83,
  0x83, 0x07, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x1E, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x0E, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x87, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0xFC, 0x01, 0xC1, 0xF0, 0x00, 0xC1, 0xE0, 0x00, 0x61, 0xE0, 0x00, 0x30,
  0xE0, 0x00, 0x18, 0xE0, 0x00, 0x1C, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x06,
  0x38, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x01,
  0xE3, 0x80, 0x01, 0xF0, 0xC0, 0x01, 0xF8, 0x70, 0x01, 0xDC, 0x1C, 0x03,
  0xCE, 0x0F, 0xFF, 0x87, 0x03, 0xFF, 0x83, 0x80, 0x3E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x1E, 0x00,
  0x1C, 0x3F, 0xF0, 0x07, 0x3F, 0xFE, 0x01, 0xDC, 0x03, 0xC0, 0x6E, 0x00,
  0x70, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x01, 0x83, 0xC0, 0x00, 0x60, 0xE0,
  0x00, 0x1C, 0x38, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x38, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x86, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xF0, 0x00,
  0x1C, 0x3E, 0x00, 0x0E, 0x0C, 0xC0, 0x07, 0x03, 0x3C, 0x03, 0x80, 0xC7,
  0xFF, 0xC0, 0x30, 0x7F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3C, 0x03, 0xC0, 0x38, 0x00,
  0xE0, 0x38, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x1C, 0x00,
  0x03, 0x8C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x06, 0x38, 0x00, 0x03, 0x1C, 0x00, 0x03,
  0x8E, 0x00, 0x01, 0x83, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xC0, 0xE0, 0x00,
  0xE0, 0x38, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0x01, 0xC0, 0x07, 0xFC,
  0x1C, 0x01, 0xFF, 0xF1, 0xC0, 0x3C, 0x03, 0x98, 0x07, 0x00, 0x19, 0x80,
  0xE0, 0x00, 0xD8, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x78, 0x18, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x30, 0x38, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x60, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0E,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x78, 0x06, 0x00, 0x0F, 0x80, 0x70, 0x01,
  0xF0, 0x03, 0x80, 0x7B, 0x00, 0x1F, 0xFE, 0x30, 0x00, 0xFF, 0xC3, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x3C, 0x03, 0xC0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x18,
  0x00, 0x1C, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x0C, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x98, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x20, 0x38, 0x00, 0x78, 0x0F,
  0x00, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFF, 0xC1, 0xC0, 0x0F, 0xFF, 0x8E, 0x00, 0xF0, 0x0E, 0x60, 0x0E,
  0x00, 0x33, 0x00, 0xE0, 0x00, 0xD8, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x1E, 0x03, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0x80, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x3C,
  0x01, 0x80, 0x03, 0xE0, 0x0E, 0x00, 0x3E, 0x00, 0x38, 0x07, 0xB0, 0x01,
  0xFF, 0xF1, 0x80, 0x03, 0xFF, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xE0, 0x07,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x07, 0xC0, 0x0E, 0x1F, 0xF8, 0x07, 0x1F, 0xFE, 0x03,
  0x9C, 0x07, 0x81, 0x98, 0x01, 0xC0, 0xD8, 0x00, 0x60, 0x68, 0x00, 0x38,
  0x7C, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x87, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00,
  0x30, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x18, 0x00,
  0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70,
  0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x8E,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x61, 0x80, 0x00, 0x30,
  0xC0, 0x00, 0x18, 0x60, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x23, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0x07, 0x00,
  0x07, 0x81, 0xC0, 0x03, 0xC0, 0x60, 0x01, 0xE0, 0x18, 0x00, 0xF0, 0x06,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x1E, 0x00, 0x38, 0x0F, 0x00,
  0x0C, 0x07, 0x80, 0x03, 0x03, 0xC0, 0x00, 0xC1, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x1C, 0x70, 0x00, 0x07, 0x38, 0x00, 0x01, 0x9E, 0x00, 0x00, 0x6F,
  0xC0, 0x00, 0x1F, 0x30, 0x00, 0x0F, 0x8E, 0x00, 0x03, 0xC1, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x80, 0x07, 0x00, 0x60,
  0x01, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x06, 0x00,
  0x38, 0x01, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x0E,
  0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x1C, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xE3, 0xFF,
  0xC0, 0xFF, 0xF8, 0x06, 0x38, 0x0E, 0x0F, 0x01, 0xC0, 0x33, 0x00, 0x38,
  0xE0, 0x07, 0x01, 0xB0, 0x00, 0xCE, 0x00, 0x38, 0x1F, 0x00, 0x07, 0x60,
  0x00, 0xC0, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x38, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x83,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x03, 0x87, 0xFE, 0x01, 0xC7, 0xFF, 0x80, 0xE7, 0x01, 0xE0, 0x67, 0x00,
  0x70, 0x36, 0x00, 0x18, 0x1B, 0x00, 0x0E, 0x1F, 0x00, 0x07, 0x0F, 0x00,
  0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xC0,
  0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x18,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x61, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x1C,
  0x30, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00,
  0x38, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x78, 0x03, 0x80, 0x78, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0x80, 0x00,
  0x0E, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x07, 0x30,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0x0F, 0xFC, 0x00, 0x39, 0xFF, 0xF0, 0x01, 0x9C, 0x03,
  0xC0, 0x0D, 0xC0, 0x0E, 0x00, 0x78, 0x00, 0x38, 0x03, 0x80, 0x00, 0xC0,
  0x3C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x70, 0x18, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x38, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x30,
  0x18, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x0E, 0x03, 0xE0, 0x00, 0xE0, 0x1D, 0x80, 0x0E, 0x00, 0xCE, 0x00,
  0xE0, 0x06, 0x3F, 0xFE, 0x00, 0x30, 0x7F, 0xE0, 0x03, 0x80, 0xF8, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0xF0, 0x70, 0x1F, 0xFF, 0x1C, 0x0F, 0x00, 0xE6, 0x07, 0x00, 0x1D,
  0x83, 0x80, 0x03, 0x60, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x18, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x70,
  0x00, 0x07, 0x1C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x06, 0x38, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x38, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07,
  0x81, 0x80, 0x03, 0xE0, 0x70, 0x01, 0xF0, 0x0E, 0x01, 0xEC, 0x03, 0xFF,
  0xE3, 0x00, 0x3F, 0xF1, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0xE1, 0xFC, 0x1C, 0xFF, 0x03, 0xB8, 0x00, 0x6E, 0x00,
  0x0D, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x3C, 0x03, 0xC0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x0C,
  0x0C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0xF0, 0x1E, 0x00, 0xF0,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07,
  0xF8, 0x0F, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0E,
  0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x1C, 0x38, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0,
  0x60, 0x00, 0x78, 0x18, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x06,
  0xC0, 0x38, 0x07, 0x30, 0x07, 0xFF, 0x8C, 0x00, 0xFF, 0xC7, 0x00, 0x0F,
  0x80, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x18, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x30, 0x70, 0x00, 0x70, 0x30, 0x00, 0x70, 0x30, 0x00, 0x60, 0x30,
  0x00, 0xE0, 0x30, 0x00, 0xC0, 0x38, 0x01, 0xC0, 0x38, 0x01, 0x80, 0x18,
  0x03, 0x80, 0x18, 0x03, 0x00, 0x18, 0x07, 0x00, 0x18, 0x06, 0x00, 0x18,
  0x0E, 0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x60, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x3C, 0x00,
  0x1D, 0xC0, 0x01, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0x00, 0x06, 0x30, 0x00,
  0xD8, 0x00, 0x71, 0x80, 0x06, 0xC0, 0x03, 0x0C, 0x00, 0x76, 0x00, 0x38,
  0x60, 0x03, 0x30, 0x01, 0xC3, 0x00, 0x39, 0xC0, 0x0C, 0x18, 0x01, 0x8E,
  0x00, 0xE0, 0xC0, 0x0C, 0x70, 0x06, 0x06, 0x00, 0xC3, 0x80, 0x70, 0x30,
  0x06, 0x0C, 0x03, 0x81, 0xC0, 0x70, 0x60, 0x18, 0x0E, 0x03, 0x03, 0x01,
  0xC0, 0x70, 0x38, 0x18, 0x0C, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x1C, 0x1C,
  0x06, 0x07, 0x00, 0xE0, 0xC0, 0x30, 0x30, 0x03, 0x06, 0x01, 0x83, 0x80,
  0x18, 0x70, 0x0E, 0x18, 0x00, 0xC3, 0x00, 0x71, 0xC0, 0x06, 0x38, 0x03,
  0x8C, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x01, 0x9C, 0x00, 0x67, 0x00, 0x0C,
  0xC0, 0x03, 0x30, 0x00, 0x66, 0x00, 0x1B, 0x80, 0x03, 0x60, 0x00, 0xD8,
  0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x00, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x00, 0x60, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x1C,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x39, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x1C, 0x06, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x18, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0C,
  0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0xE0,
  0x0C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x80, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x03, 0x07, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0x00, 0x20, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x31, 0xF7,
  0xC0, 0x00, 0xCE, 0x03, 0x80, 0x03, 0x30, 0x07, 0x00, 0x19, 0xC0, 0x0E,
  0x00, 0x66, 0x00, 0x3C, 0x03, 0xB8, 0x00, 0x78, 0x1C, 0xE0, 0x00, 0xF9,
  0xE3, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLightItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 11, 48, 13, 1, -47 },
  { 67, 12, 14, 17, 7, -50 },
  { 88, 33, 47, 32, 1, -47 },
  { 282, 28, 61, 31, 2, -54 },
  { 496, 31, 49, 41, 6, -48 },
  { 686, 29, 49, 34, 2, -48 },
  { 864, 4, 14, 11, 7, -50 },
  { 871, 18, 67, 18, 3, -52 },
  { 1022, 18, 67, 18, -4, -52 },
  { 1173, 25, 26, 27, 4, -47 },
  { 1255, 27, 34, 32, 3, -39 },
  { 1370, 8, 14, 12, -2, -5 },
  { 1384, 13, 2, 17, 2, -22 },
  { 1388, 5, 5, 14, 1, -4 },
  { 1392, 28, 51, 22, -3, -47 },
  { 1571, 26, 49, 31, 3, -48 },
  { 1731, 14, 47, 31, 9, -47 },
  { 1814, 28, 48, 31, 1, -48 },
  { 1982, 27, 49, 31, 2, -48 },
  { 2148, 28, 47, 31, 1, -47 },
  { 2313, 28, 48, 31, 4, -47 },
  { 2481, 24, 48, 31, 3, -47 },
  { 2625, 27, 47, 31, 5, -47 },
  { 2784, 28, 49, 31, 2, -48 },
  { 2956, 24, 48, 31, 5, -48 },
  { 3100, 10, 35, 12, 1, -34 },
  { 3144, 13, 43, 12, -2, -34 },
  { 3214, 24, 27, 29, 3, -35 },
  { 3295, 24, 15, 31, 4, -29 },
  { 3340, 25, 27, 29, 2, -35 },
  { 3425, 20, 49, 25, 6, -48 },
  { 3548, 46, 61, 51, 2, -46 },
  { 3899, 32, 47, 34, -2, -47 },
  { 4087, 30, 47, 34, 2, -47 },
  { 4264, 31, 49, 36, 4, -48 },
  { 4454, 32, 47, 37, 2, -47 },
  { 4642, 32, 47, 32, 2, -47 },
  { 4830, 32, 47, 32, 2, -47 },
  { 5018, 32, 49, 38, 4, -48 },
  { 5214, 36, 47, 39, 2, -47 },
  { 5426, 11, 47, 16, 3, -47 },
  { 5491, 29, 48, 31, 1, -47 },
  { 5665, 35, 47, 35, 2, -47 },
  { 5871, 23, 47, 29, 2, -47 },
  { 6007, 45, 47, 48, 2, -47 },
  { 6272, 37, 47, 40, 2, -47 },
  { 6490, 32, 49, 38, 4, -48 },
  { 6686, 32, 47, 34, 2, -47 },
  { 6874, 32, 56, 38, 3, -48 },
  { 7098, 32, 47, 36, 2, -47 },
  { 7286, 31, 49, 33, 2, -48 },
  { 7476, 30, 47, 34, 6, -47 },
  { 7653, 33, 48, 37, 4, -47 },
  { 7851, 31, 47, 34, 6, -47 },
  { 8034, 46, 47, 50, 6, -47 },
  { 8305, 37, 47, 34, -1, -47 },
  { 8523, 31, 47, 34, 6, -47 },
  { 8706, 34, 47, 34, 0, -47 },
  { 8906, 18, 64, 14, 1, -54 },
  { 9050, 9, 51, 22, 7, -47 },
  { 9108, 18, 64, 14, -4, -54 },
  { 9252, 17, 23, 24, 4, -47 },
  { 9301, 23, 2, 24, -3, 0 },
  { 9307, 7, 9, 17, 9, -50 },
  { 9315, 25, 37, 30, 1, -36 },
  { 9431, 26, 51, 31, 2, -50 },
  { 9597, 25, 37, 29, 2, -36 },
  { 9713, 28, 51, 31, 3, -50 },
  { 9892, 25, 37, 29, 2, -36 },
  { 10008, 20, 51, 19, 4, -51 },
  { 10136, 29, 49, 31, 0, -36 },
  { 10314, 25, 50, 31, 2, -50 },
  { 10471, 11, 48, 13, 2, -48 },
  { 10537, 21, 61, 13, -8, -48 },
  { 10698, 26, 50, 27, 2, -50 },
  { 10861, 11, 50, 13, 2, -50 },
  { 10930, 45, 36, 49, 1, -36 },
  { 11133, 25, 36, 31, 2, -36 },
  { 11246, 25, 37, 31, 3, -36 },
  { 11362, 29, 49, 31, -1, -36 },
  { 11540, 26, 49, 31, 3, -36 },
  { 11700, 19, 36, 19, 2, -36 },
  { 11786, 25, 37, 28, 1, -36 },
  { 11902, 14, 45, 19, 4, -44 },
  { 11981, 26, 36, 31, 3, -35 },
  { 12098, 24, 35, 27, 4, -35 },
  { 12203, 37, 35, 42, 5, -35 },
  { 12365, 28, 35, 27, -1, -35 },
  { 12488, 31, 48, 27, -3, -35 },
  { 12674, 27, 35, 27, 0, -35 },
  { 12793, 21, 66, 19, 2, -52 },
  { 12967, 11, 56, 13, 1, -47 },
  { 13044, 21, 65, 19, -4, -51 },
  { 13215, 30, 11, 38, 4, -25 },
};

const GFXfont RobotoCondensed_ExtraLightItalic66pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic66pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic66pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC66PT7B_H_
