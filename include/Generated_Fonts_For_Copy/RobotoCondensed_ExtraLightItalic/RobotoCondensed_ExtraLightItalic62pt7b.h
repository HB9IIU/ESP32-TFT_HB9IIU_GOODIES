#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC62PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x0E, 0x03, 0xC0,
  0x38, 0x00, 0x00, 0x30, 0xCC, 0x37, 0x0D, 0xC3, 0x61, 0xD8, 0x76, 0x19,
  0x86, 0xE1, 0xB0, 0x6C, 0x3B, 0x0C, 0xC3, 0x00, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x01, 0x80, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x38, 0x06, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x03, 0x80, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1E, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x18,
  0x0C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0x60, 0x00,
  0x1C, 0x18, 0x00, 0x07, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x86, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E,
  0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x70, 0x60, 0x00,
  0x18, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x03, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x38, 0x30, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x30, 0x03, 0x0C, 0x01, 0x80,
  0x18, 0xE0, 0x0C, 0x01, 0x86, 0x00, 0x60, 0x1C, 0x30, 0x03, 0x00, 0xC1,
  0x80, 0x18, 0x0C, 0x0C, 0x00, 0xC0, 0xE0, 0x60, 0x06, 0x06, 0x03, 0x00,
  0x60, 0x60, 0x18, 0x03, 0x06, 0x00, 0xC0, 0x38, 0x30, 0x07, 0x01, 0x83,
  0x00, 0x18, 0x18, 0x30, 0x00, 0x7F, 0xC3, 0x80, 0x01, 0xF8, 0x18, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0xFE, 0x00, 0x06, 0x0F, 0xF8, 0x00, 0x60,
  0xE0, 0xC0, 0x06, 0x0E, 0x03, 0x00, 0x30, 0x60, 0x18, 0x03, 0x06, 0x00,
  0xC0, 0x30, 0x30, 0x06, 0x03, 0x81, 0x80, 0x30, 0x18, 0x1C, 0x01, 0x81,
  0x80, 0xC0, 0x0C, 0x1C, 0x06, 0x00, 0x60, 0xC0, 0x30, 0x03, 0x0C, 0x01,
  0x80, 0x18, 0xE0, 0x0C, 0x01, 0x86, 0x00, 0x60, 0x0C, 0x20, 0x03, 0x00,
  0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0xC0, 0x1C, 0x00, 0x38, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x06, 0x07,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38,
  0x18, 0x01, 0x8E, 0x03, 0x80, 0x33, 0x80, 0x38, 0x06, 0x60, 0x03, 0x01,
  0xDC, 0x00, 0x70, 0x33, 0x00, 0x06, 0x06, 0x60, 0x00, 0xE1, 0xDC, 0x00,
  0x0C, 0x33, 0x80, 0x01, 0xCE, 0x60, 0x00, 0x1D, 0x8C, 0x00, 0x01, 0xF1,
  0xC0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0x03, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x36, 0x0F, 0x00, 0x1C, 0xE0, 0xF0, 0x07, 0x0C, 0x0F, 0xCF, 0xC1, 0xC0,
  0x7F, 0xE0, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x39, 0x8C, 0x63, 0x19, 0xCC,
  0x63, 0x19, 0xCC, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x18, 0x0F, 0xF0, 0x30,
  0xFC, 0xFC, 0xE7, 0xE0, 0x3F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xEE, 0x00, 0x03, 0x8C, 0x00, 0x0E, 0x1C, 0x00,
  0x18, 0x18, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x1C,
  0x00, 0x70, 0x10, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x1C, 0x38,
  0x70, 0xC1, 0x87, 0x0E, 0x38, 0x61, 0xC7, 0x04, 0x00, 0xFF, 0xFF, 0xFF,
  0x03, 0xBE, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xF0, 0x1C, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x06, 0x03, 0x80, 0x07, 0x03, 0x00, 0x07, 0x06, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x1C, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x38, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0xE0, 0x00,
  0x0C, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x60, 0x00, 0xC0, 0x70, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x3C, 0x07, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x1F, 0x81, 0xF6, 0x3F,
  0x19, 0xF0, 0x6E, 0x01, 0xA0, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x07, 0x03,
  0x80, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0C, 0x18, 0x00, 0x07,
  0x06, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xC0,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0xC0, 0x38, 0x00, 0x38, 0x0C,
  0x00, 0x06, 0x07, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x18,
  0x38, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x30,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x0C,
  0x38, 0x00, 0x07, 0x06, 0x00, 0x01, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00,
  0x70, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x3C, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x38, 0x00, 0x18,
  0x0E, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00,
  0xC0, 0x0C, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x18, 0x03, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x00,
  0xE0, 0x38, 0x00, 0x30, 0x1C, 0x00, 0x0C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x3F, 0x00,
  0x03, 0x7F, 0xF0, 0x01, 0xFC, 0x3E, 0x00, 0x7C, 0x03, 0xC0, 0x1C, 0x00,
  0x70, 0x02, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x83, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x18, 0x06, 0x00, 0x0E, 0x01,
  0xC0, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x01, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x0F, 0xC0, 0x18, 0xFF, 0xE0, 0x33, 0xC1, 0xE0,
  0xCE, 0x01, 0xE1, 0xB0, 0x01, 0xC3, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x9E,
  0x00, 0x03, 0x38, 0x00, 0x06, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x1D, 0x80,
  0x00, 0x3B, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x3B, 0x80, 0x00,
  0x67, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x18,
  0x18, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x3C, 0x0F, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x1E,
  0x03, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x30, 0x00, 0x30,
  0x0E, 0x00, 0x07, 0x01, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0C, 0x0C, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x70, 0x0E, 0x00, 0x0C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x01, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0xF0, 0x03, 0x80, 0x38, 0x00, 0x38, 0x06, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x70, 0x70, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x03,
  0x80, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x07,
  0x80, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x1E, 0x03, 0xC0,
  0x78, 0x03, 0x80, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x0E, 0x00, 0x07, 0x18,
  0x00, 0x0E, 0x70, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x37, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x76, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x98, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0x30, 0x00, 0x7C,
  0x70, 0x01, 0xB8, 0x70, 0x0E, 0x60, 0xF0, 0x78, 0xC0, 0xFF, 0xE3, 0x80,
  0x7F, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xC1, 0xE0, 0xF0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0xF0, 0x20,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x0E,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x3F, 0xC0, 0x1F, 0xFC, 0x07, 0x81, 0xC1, 0xC0, 0x1C, 0x30, 0x01, 0x8E,
  0x00, 0x39, 0x80, 0x07, 0x70, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x07,
  0xE0, 0x01, 0x80, 0xC0, 0x03, 0xFF, 0x00, 0x10, 0x38, 0x00, 0xF0, 0xF0,
  0x03, 0x06, 0x00, 0x38, 0x07, 0x00, 0x61, 0xC0, 0x0E, 0x00, 0xC0, 0x0C,
  0x30, 0x01, 0x80, 0x18, 0x01, 0x86, 0x00, 0x60, 0x03, 0x00, 0x31, 0xC0,
  0x1C, 0x00, 0xE0, 0x06, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC6, 0x00, 0xE0,
  0x03, 0x00, 0x19, 0x80, 0x18, 0x00, 0x60, 0x03, 0x30, 0x07, 0x00, 0x1C,
  0x00, 0xC6, 0x00, 0xC0, 0x03, 0x00, 0x19, 0xC0, 0x18, 0x00, 0x60, 0x03,
  0x30, 0x07, 0x00, 0x0C, 0x00, 0x66, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0xC0,
  0x18, 0x00, 0x60, 0x03, 0x18, 0x03, 0x00, 0x0C, 0x00, 0x63, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0xC0, 0x1C, 0x00, 0x30, 0x01, 0x98, 0x03, 0x00, 0x0C,
  0x00, 0x63, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x60, 0x0C, 0x00, 0x70, 0x03,
  0x0C, 0x01, 0x80, 0x0E, 0x00, 0x61, 0x80, 0x30, 0x03, 0xC0, 0x1C, 0x30,
  0x06, 0x00, 0xD8, 0x03, 0x06, 0x00, 0xE0, 0x33, 0x00, 0xC0, 0xC0, 0x0C,
  0x0E, 0x70, 0x30, 0x1C, 0x01, 0xE7, 0x87, 0x1E, 0x01, 0x80, 0x1F, 0xC0,
  0x7F, 0x00, 0x30, 0x01, 0xE0, 0x07, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x03, 0x00,
  0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0E, 0x18, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x38, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x18,
  0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x60, 0x03, 0x80, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00,
  0x38, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x1C, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x03, 0x03, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xC0,
  0x0F, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x07, 0x03, 0x80, 0x00, 0x30, 0x30,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0C, 0x06,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x38, 0x06, 0x00, 0x0F, 0x00, 0xE0, 0x03,
  0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x1E, 0x00,
  0xC0, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x38, 0x06, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x70, 0x0E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x81, 0x80, 0x00, 0x38, 0x0E, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x7C,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0xF8, 0x00,
  0x60, 0x00, 0x70, 0x01, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x0C, 0x1C, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x78, 0x01, 0x80, 0x1F,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x07, 0x00,
  0x01, 0xC0, 0x18, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06,
  0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x07, 0xFF, 0x86, 0x00, 0x1F, 0xFE, 0x18, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x30,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x7C, 0x00, 0xF0, 0x07, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70,
  0x18, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x38, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x1C, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38,
  0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01,
  0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0,
  0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x1C, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x18, 0x03, 0x80, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x30, 0x00, 0x07, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x06, 0x00, 0x07, 0x80, 0x03,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x07, 0x80, 0x01, 0x80, 0x07, 0x80, 0x00,
  0xC0, 0x03, 0x80, 0x00, 0x60, 0x03, 0x80, 0x00, 0x30, 0x03, 0x80, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x03, 0x03, 0x80, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x63, 0xF0, 0x00,
  0x00, 0x33, 0xB8, 0x00, 0x00, 0x1B, 0x8E, 0x00, 0x00, 0x0F, 0x87, 0x00,
  0x00, 0x0F, 0x81, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x00, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x6C, 0x00, 0x00, 0x03, 0x60,
  0x1B, 0x00, 0x00, 0x00, 0xD8, 0x06, 0xC0, 0x00, 0x00, 0x66, 0x03, 0xB0,
  0x00, 0x00, 0x3B, 0x80, 0xCE, 0x00, 0x00, 0x0C, 0xE0, 0x33, 0x80, 0x00,
  0x07, 0x30, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x03, 0x18, 0x00, 0x00, 0xE3,
  0x01, 0xC6, 0x00, 0x00, 0x30, 0xC0, 0x71, 0x80, 0x00, 0x1C, 0x70, 0x18,
  0x70, 0x00, 0x06, 0x18, 0x06, 0x0C, 0x00, 0x03, 0x86, 0x01, 0x83, 0x00,
  0x00, 0xC1, 0x80, 0x60, 0xC0, 0x00, 0x70, 0x60, 0x38, 0x30, 0x00, 0x18,
  0x38, 0x0E, 0x0C, 0x00, 0x0E, 0x0E, 0x03, 0x03, 0x80, 0x03, 0x03, 0x00,
  0xC0, 0x60, 0x01, 0xC0, 0xC0, 0x30, 0x18, 0x00, 0x60, 0x30, 0x0C, 0x06,
  0x00, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x06,
  0x01, 0xC0, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0xC0, 0x70, 0x06, 0x01, 0x80, 0x30, 0x18, 0x01, 0x80, 0xE0,
  0x0C, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x83, 0x00, 0x38, 0x0C, 0x00, 0x61,
  0xC0, 0x0C, 0x03, 0x00, 0x18, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x38, 0x00,
  0xC0, 0x70, 0x01, 0x8C, 0x00, 0x70, 0x1C, 0x00, 0x67, 0x00, 0x1C, 0x06,
  0x00, 0x0D, 0x80, 0x06, 0x01, 0x80, 0x03, 0xE0, 0x01, 0x80, 0x60, 0x00,
  0xF0, 0x00, 0x60, 0x18, 0x00, 0x3C, 0x00, 0x18, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x00, 0x30, 0x1E, 0x00, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x07,
  0x01, 0xB0, 0x00, 0x01, 0xC0, 0x6C, 0x00, 0x00, 0x60, 0x1B, 0x80, 0x00,
  0x18, 0x0E, 0x60, 0x00, 0x06, 0x03, 0x98, 0x00, 0x01, 0x80, 0xE7, 0x00,
  0x00, 0xE0, 0x30, 0xC0, 0x00, 0x38, 0x0C, 0x30, 0x00, 0x0C, 0x03, 0x06,
  0x00, 0x03, 0x01, 0xC1, 0x80, 0x00, 0xC0, 0x70, 0x70, 0x00, 0x70, 0x1C,
  0x0C, 0x00, 0x1C, 0x06, 0x03, 0x00, 0x07, 0x01, 0x80, 0xE0, 0x01, 0x80,
  0x60, 0x18, 0x00, 0x60, 0x38, 0x06, 0x00, 0x18, 0x0E, 0x00, 0xC0, 0x0E,
  0x03, 0x00, 0x30, 0x03, 0x80, 0xC0, 0x0E, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0x30, 0x0C, 0x00, 0x60, 0x0C, 0x07, 0x00, 0x1C, 0x03, 0x01, 0xC0, 0x03,
  0x01, 0xC0, 0x60, 0x00, 0xE0, 0x70, 0x18, 0x00, 0x18, 0x18, 0x06, 0x00,
  0x06, 0x06, 0x01, 0x80, 0x01, 0xC1, 0x80, 0xE0, 0x00, 0x30, 0x60, 0x38,
  0x00, 0x0C, 0x38, 0x0C, 0x00, 0x01, 0x8E, 0x03, 0x00, 0x00, 0x63, 0x00,
  0xC0, 0x00, 0x1C, 0xC0, 0x70, 0x00, 0x03, 0x30, 0x1C, 0x00, 0x00, 0xDC,
  0x07, 0x00, 0x00, 0x3F, 0x01, 0x80, 0x00, 0x07, 0xC0, 0x60, 0x00, 0x01,
  0xE0, 0x18, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x03, 0x80, 0x01,
  0xC0, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x38, 0x01, 0x80,
  0x00, 0x70, 0x06, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00,
  0x01, 0xE0, 0x30, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x78, 0x03, 0x00, 0x0F,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0x60,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x70, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x30, 0x0C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x1E, 0x00, 0xC0, 0x03,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x70, 0x01, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xE0, 0x03, 0x80, 0x01, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x70, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1E,
  0x01, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x38, 0x06, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0x38,
  0x00, 0x78, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x01, 0x87, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x60, 0x06, 0x00, 0x03, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x70, 0x01, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x30, 0x01, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x06, 0x03, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x01, 0x81, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x30,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x03, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xEE, 0x00, 0x01, 0xE0, 0x00, 0x19, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x38,
  0x00, 0x0D, 0x80, 0x00, 0xE3, 0x00, 0x03, 0xB0, 0x00, 0x18, 0x60, 0x00,
  0x66, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0xE1, 0x80, 0x03, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0x61, 0x80, 0x07, 0x06, 0x00, 0x1C, 0x30, 0x00,
  0xC0, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x07, 0x03,
  0x00, 0x18, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x00, 0x18, 0x0E, 0x00,
  0xE0, 0x60, 0x07, 0x01, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0x38, 0x03, 0x01,
  0x80, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0xC0, 0x1C, 0x07, 0x00, 0x60, 0x38, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00,
  0x30, 0x18, 0x01, 0x80, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x38, 0x00, 0xC0,
  0xC0, 0x06, 0x06, 0x00, 0x18, 0x38, 0x00, 0xC1, 0xC0, 0x03, 0x06, 0x00,
  0x18, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x61,
  0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x31, 0xC0, 0x01, 0xC6, 0x00,
  0x06, 0x30, 0x00, 0x39, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x30, 0x00, 0x19,
  0x80, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x0D, 0xC0, 0x00, 0x76, 0x00,
  0x01, 0xB0, 0x00, 0x0F, 0x80, 0x00, 0x36, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x30, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x30, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x06, 0x00,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x01, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x60, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x38, 0x00, 0x38, 0x01, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x06,
  0xC0, 0x03, 0x60, 0x03, 0x30, 0x01, 0x8C, 0x01, 0x86, 0x00, 0xC3, 0x00,
  0xC1, 0x80, 0x60, 0xC0, 0x60, 0x60, 0x30, 0x38, 0x30, 0x0C, 0x18, 0x06,
  0x18, 0x03, 0x0C, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x76, 0x00, 0x1B, 0x00,
  0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xE0, 0xC1, 0xC1, 0xC1,
  0x83, 0x83, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01,
  0xE0, 0x1C, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0E,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xC0, 0x0C, 0x0F, 0x00, 0x0C, 0x1C,
  0x00, 0x0C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x18, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0xC0, 0x00, 0x38, 0xC0,
  0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x01, 0xB0, 0x70, 0x03, 0xB0, 0x78,
  0x0E, 0x30, 0x3F, 0xFC, 0x30, 0x1F, 0xF0, 0x30, 0x01, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x3F, 0xE0, 0x06, 0x3F,
  0xF8, 0x03, 0x78, 0x0E, 0x03, 0xF0, 0x03, 0x81, 0xF0, 0x00, 0xC0, 0xF0,
  0x00, 0x70, 0x70, 0x00, 0x38, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x1C,
  0x00, 0x03, 0x0E, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0C,
  0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x38, 0x60, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x3C, 0x00, 0x0C, 0x1A, 0x00,
  0x0E, 0x0D, 0x80, 0x0E, 0x06, 0x70, 0x1E, 0x03, 0x1F, 0xFE, 0x03, 0x83,
  0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x1E, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0xC0, 0x01, 0x83, 0x80,
  0x03, 0x8E, 0x00, 0x07, 0x18, 0x00, 0x06, 0x70, 0x00, 0x0C, 0xC0, 0x00,
  0x19, 0x80, 0x00, 0x37, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x73, 0x80, 0x00, 0xC7, 0x00,
  0x03, 0x86, 0x00, 0x06, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x1E, 0x03,
  0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x3F, 0xE0,
  0xC0, 0x0F, 0xFE, 0x18, 0x07, 0x80, 0xE7, 0x00, 0xE0, 0x06, 0xE0, 0x38,
  0x00, 0x78, 0x0E, 0x00, 0x0F, 0x01, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C,
  0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0C, 0x0C, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0E, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x18, 0x18, 0x00, 0x07, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x18, 0x0C,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x80, 0x38,
  0x01, 0xB0, 0x07, 0x80, 0xE6, 0x00, 0x7F, 0xF8, 0xC0, 0x07, 0xFC, 0x38,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x0E, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x03,
  0x0E, 0x00, 0x07, 0x18, 0x00, 0x06, 0x70, 0x00, 0x0C, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x37, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xBF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x38, 0x0E, 0x01, 0xE0,
  0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x07, 0xF0, 0x07, 0xEC, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x0C, 0x01, 0xFF, 0xE1, 0x80, 0x78, 0x0E, 0x70, 0x0E,
  0x00, 0x6C, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x18, 0x00, 0x0E,
  0x07, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x06, 0x07, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0E, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0, 0x38,
  0x00, 0x78, 0x03, 0x80, 0x1B, 0x00, 0x78, 0x0E, 0x60, 0x07, 0xFF, 0x8C,
  0x00, 0x7F, 0xC3, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x08, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x40, 0x03, 0x07, 0xF8, 0x03, 0x1F, 0xFC,
  0x03, 0x38, 0x0E, 0x07, 0x70, 0x06, 0x07, 0x60, 0x07, 0x06, 0xC0, 0x03,
  0x07, 0x80, 0x03, 0x07, 0x00, 0x03, 0x07, 0x00, 0x03, 0x0E, 0x00, 0x03,
  0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x07,
  0x0C, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x0C,
  0x38, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x1C,
  0x30, 0x00, 0x18, 0x70, 0x00, 0x18, 0x70, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60, 0x00, 0x30, 0x01, 0xC0, 0x70,
  0x1C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x38, 0x0E, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x1C, 0x03,
  0x00, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x06, 0x00, 0xE0, 0x01, 0x80, 0x70, 0x00, 0x60, 0x38, 0x00, 0x38, 0x1C,
  0x00, 0x0E, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x31,
  0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x07, 0x7C, 0x00, 0x01, 0xFB, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x1C, 0x18, 0x00, 0x06, 0x07, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0xE0, 0x38, 0x00, 0x38, 0x06, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x00,
  0x30, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0x70, 0x07,
  0x00, 0x0C, 0x01, 0x80, 0x03, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x1C,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07,
  0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0,
  0x30, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0xC1, 0xFE, 0x00,
  0xFF, 0x80, 0x31, 0xFF, 0xC0, 0xFF, 0xF0, 0x1C, 0xE0, 0x38, 0x78, 0x1E,
  0x07, 0x60, 0x06, 0x38, 0x03, 0x81, 0xB0, 0x01, 0xDC, 0x00, 0x60, 0x68,
  0x00, 0x36, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xC3, 0x80, 0x00, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC3,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x86, 0x00, 0x01, 0x80,
  0x00, 0xE1, 0x80, 0x00, 0x60, 0x00, 0x38, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x87, 0x00, 0x01, 0xC0, 0x00,
  0x61, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x70, 0x00, 0x18, 0x00, 0x06, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x86, 0x00, 0x01, 0x80, 0x00, 0xE1, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x03, 0x07, 0xF8, 0x03, 0x1F, 0xFC, 0x03,
  0x38, 0x0E, 0x07, 0x70, 0x06, 0x07, 0x60, 0x07, 0x06, 0xC0, 0x03, 0x07,
  0x80, 0x03, 0x07, 0x00, 0x03, 0x07, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0E,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x0C,
  0x00, 0x07, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18,
  0x00, 0x06, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x30,
  0x00, 0x18, 0x70, 0x00, 0x18, 0x70, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x38, 0x60, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x0C, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x18,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x38, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x70, 0x00, 0x03, 0x70, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x1C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x70, 0x00, 0x70, 0x30,
  0x00, 0x60, 0x38, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x0F, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x7F, 0xC0,
  0x03, 0x1F, 0xFC, 0x00, 0x6F, 0x01, 0xC0, 0x1F, 0x80, 0x1C, 0x03, 0xE0,
  0x01, 0x80, 0x78, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x00, 0x60,
  0x30, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x07, 0x07,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x30, 0x00, 0x0C,
  0x06, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x60, 0x3C, 0x00, 0x1C, 0x06, 0xC0,
  0x07, 0x00, 0xCE, 0x03, 0xC0, 0x18, 0xFF, 0xF0, 0x03, 0x07, 0xF8, 0x00,
  0xE0, 0x10, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x83, 0x01, 0xFF, 0xC3, 0x07, 0x80, 0xE7, 0x07, 0x00, 0x36, 0x0E,
  0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x30,
  0x00, 0x0E, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xE0, 0xE0,
  0x01, 0xE0, 0x70, 0x03, 0x60, 0x78, 0x0E, 0x60, 0x3F, 0xFC, 0xE0, 0x1F,
  0xF0, 0xE0, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x61, 0xF8, 0x0C, 0x7F,
  0x01, 0x9C, 0x00, 0x76, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0E,
  0x01, 0xC0, 0x38, 0x01, 0xC0, 0xE0, 0x01, 0x81, 0x80, 0x03, 0x86, 0x00,
  0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x63, 0x80, 0x00, 0xC7, 0x00, 0x01, 0x86, 0x00,
  0x07, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x1E, 0x03, 0xE0, 0x1F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x7F, 0xFD, 0xFF,
  0xF0, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0E,
  0x38, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x70, 0x00, 0x18,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60, 0x00, 0x30,
  0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0x60, 0x01, 0xE0,
  0x70, 0x07, 0x60, 0x38, 0x0E, 0x60, 0x3F, 0xFC, 0xE0, 0x1F, 0xF0, 0xC0,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xB8,
  0x00, 0x0E, 0x60, 0x00, 0x31, 0x80, 0x01, 0xC6, 0x00, 0x06, 0x18, 0x00,
  0x38, 0x60, 0x00, 0xC1, 0xC0, 0x03, 0x07, 0x00, 0x18, 0x0C, 0x00, 0x60,
  0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x70, 0x0C, 0x01, 0x80, 0x38,
  0x0E, 0x00, 0x60, 0x30, 0x01, 0x81, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x38,
  0x00, 0x60, 0xC0, 0x01, 0xC3, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00,
  0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x70, 0x00, 0x0D, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xD8, 0x00, 0x18, 0x00, 0x3B, 0x00, 0x07, 0x00, 0x07, 0x60,
  0x00, 0xE0, 0x00, 0xCC, 0x00, 0x36, 0x00, 0x39, 0xC0, 0x06, 0xC0, 0x06,
  0x38, 0x01, 0xD8, 0x01, 0xC7, 0x00, 0x33, 0x00, 0x38, 0xE0, 0x0E, 0x60,
  0x06, 0x1C, 0x01, 0x8C, 0x01, 0xC1, 0x80, 0x31, 0x80, 0x30, 0x30, 0x0C,
  0x30, 0x0E, 0x06, 0x01, 0x86, 0x01, 0x80, 0xC0, 0x70, 0xC0, 0x30, 0x18,
  0x0C, 0x18, 0x0E, 0x03, 0x03, 0x83, 0x81, 0x80, 0x60, 0x60, 0x70, 0x70,
  0x0C, 0x0C, 0x06, 0x0C, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x18,
  0x70, 0x06, 0x18, 0x03, 0x0C, 0x00, 0xE3, 0x00, 0x63, 0x80, 0x1C, 0xE0,
  0x0C, 0x60, 0x03, 0x98, 0x01, 0x8C, 0x00, 0x73, 0x00, 0x33, 0x80, 0x06,
  0xC0, 0x06, 0x60, 0x00, 0xD8, 0x00, 0xDC, 0x00, 0x1E, 0x00, 0x0B, 0x00,
  0x03, 0xC0, 0x01, 0x60, 0x00, 0x78, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x1C, 0x60, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x07, 0x38, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0xE0, 0x1C, 0x00, 0x18, 0x01, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x03,
  0x00, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xC0, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x07, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x00,
  0x03, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x06, 0x00, 0x38, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x60, 0x07, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x19, 0xC0,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x70, 0x00, 0x00, 0x20, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x03, 0x3C, 0x78, 0x00,
  0x33, 0x01, 0xC0, 0x03, 0x70, 0x0E, 0x00, 0x66, 0x00, 0x70, 0x0E, 0xE0,
  0x03, 0x80, 0xCC, 0x00, 0x1E, 0x38, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xE0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 11, 45, 12, 1, -44 },
  { 63, 10, 13, 16, 7, -47 },
  { 80, 31, 44, 30, 1, -44 },
  { 251, 26, 58, 29, 2, -51 },
  { 440, 29, 46, 39, 6, -45 },
  { 607, 27, 46, 32, 2, -45 },
  { 763, 5, 13, 10, 6, -47 },
  { 772, 17, 63, 17, 3, -49 },
  { 906, 17, 63, 17, -3, -49 },
  { 1040, 23, 24, 25, 4, -44 },
  { 1109, 25, 32, 30, 3, -36 },
  { 1209, 7, 13, 11, -2, -5 },
  { 1221, 12, 2, 16, 2, -21 },
  { 1224, 5, 5, 14, 1, -4 },
  { 1228, 25, 48, 21, -2, -44 },
  { 1378, 24, 46, 29, 3, -45 },
  { 1516, 14, 44, 29, 8, -44 },
  { 1593, 26, 45, 29, 1, -45 },
  { 1740, 26, 46, 29, 2, -45 },
  { 1890, 26, 44, 29, 1, -44 },
  { 2033, 26, 45, 29, 4, -44 },
  { 2180, 23, 45, 29, 3, -44 },
  { 2310, 25, 44, 29, 5, -44 },
  { 2448, 27, 46, 29, 1, -45 },
  { 2604, 23, 45, 29, 4, -45 },
  { 2734, 9, 34, 11, 1, -33 },
  { 2773, 12, 41, 11, -2, -33 },
  { 2835, 23, 25, 27, 3, -33 },
  { 2907, 24, 14, 29, 3, -27 },
  { 2949, 23, 25, 27, 2, -33 },
  { 3021, 19, 46, 24, 5, -45 },
  { 3131, 43, 57, 48, 2, -43 },
  { 3438, 30, 44, 32, -2, -44 },
  { 3603, 28, 44, 32, 2, -44 },
  { 3757, 29, 46, 34, 4, -45 },
  { 3924, 30, 44, 34, 2, -44 },
  { 4089, 30, 44, 30, 2, -44 },
  { 4254, 30, 44, 30, 2, -44 },
  { 4419, 30, 46, 36, 4, -45 },
  { 4592, 34, 44, 37, 2, -44 },
  { 4779, 10, 44, 15, 3, -44 },
  { 4834, 27, 45, 29, 1, -44 },
  { 4986, 33, 44, 33, 2, -44 },
  { 5168, 21, 44, 28, 2, -44 },
  { 5284, 42, 44, 45, 2, -44 },
  { 5515, 34, 44, 37, 2, -44 },
  { 5702, 30, 46, 35, 3, -45 },
  { 5875, 30, 44, 32, 2, -44 },
  { 6040, 30, 53, 35, 3, -45 },
  { 6239, 30, 44, 34, 2, -44 },
  { 6404, 29, 46, 31, 2, -45 },
  { 6571, 28, 44, 31, 6, -44 },
  { 6725, 30, 45, 35, 4, -44 },
  { 6894, 30, 44, 32, 5, -44 },
  { 7059, 43, 44, 47, 6, -44 },
  { 7296, 35, 44, 32, -1, -44 },
  { 7489, 29, 44, 32, 6, -44 },
  { 7649, 32, 44, 32, 0, -44 },
  { 7825, 18, 59, 13, 0, -50 },
  { 7958, 9, 48, 21, 6, -44 },
  { 8012, 17, 59, 13, -4, -50 },
  { 8138, 17, 22, 22, 3, -44 },
  { 8185, 22, 2, 23, -3, 0 },
  { 8191, 7, 8, 16, 8, -46 },
  { 8198, 24, 35, 28, 1, -34 },
  { 8303, 25, 48, 29, 1, -47 },
  { 8453, 23, 35, 27, 2, -34 },
  { 8554, 27, 48, 29, 3, -47 },
  { 8716, 23, 35, 27, 2, -34 },
  { 8817, 18, 48, 18, 4, -48 },
  { 8925, 27, 47, 29, 0, -34 },
  { 9084, 24, 47, 29, 1, -47 },
  { 9225, 10, 45, 12, 2, -45 },
  { 9282, 20, 58, 12, -8, -45 },
  { 9427, 26, 47, 26, 1, -47 },
  { 9580, 10, 47, 12, 2, -47 },
  { 9639, 42, 34, 46, 1, -34 },
  { 9818, 24, 34, 29, 1, -34 },
  { 9920, 24, 35, 29, 2, -34 },
  { 10025, 27, 47, 29, -1, -34 },
  { 10184, 24, 47, 29, 3, -34 },
  { 10325, 19, 34, 18, 1, -34 },
  { 10406, 23, 35, 27, 1, -34 },
  { 10507, 14, 42, 17, 3, -41 },
  { 10581, 24, 34, 29, 3, -33 },
  { 10683, 22, 33, 26, 4, -33 },
  { 10774, 35, 33, 40, 5, -33 },
  { 10919, 27, 33, 26, -1, -33 },
  { 11031, 30, 46, 25, -3, -33 },
  { 11204, 25, 33, 26, 0, -33 },
  { 11308, 19, 61, 18, 2, -48 },
  { 11453, 11, 52, 13, 1, -44 },
  { 11525, 20, 61, 18, -4, -48 },
  { 11678, 28, 10, 36, 4, -23 },
};

const GFXfont RobotoCondensed_ExtraLightItalic62pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic62pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic62pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC62PT7B_H_
