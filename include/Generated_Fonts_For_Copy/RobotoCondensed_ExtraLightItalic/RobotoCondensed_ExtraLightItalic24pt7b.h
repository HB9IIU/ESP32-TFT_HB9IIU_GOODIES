#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC24PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x52, 0x49, 0x40, 0x04, 0x80, 0x99, 0xAA, 0xA0, 0x02,
  0x20, 0x44, 0x04, 0x40, 0x44, 0x08, 0x87, 0xFE, 0x08, 0x81, 0x10, 0x11,
  0x01, 0x10, 0x22, 0x0F, 0xFC, 0x22, 0x04, 0x40, 0x44, 0x04, 0x40, 0x44,
  0x00, 0x02, 0x00, 0x80, 0xF0, 0x42, 0x20, 0x48, 0x12, 0x04, 0x80, 0x20,
  0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x28, 0x0A, 0x04, 0x81, 0x10, 0x83,
  0xC0, 0x40, 0x10, 0x00, 0x38, 0x08, 0x81, 0x10, 0xC2, 0x28, 0x49, 0x0A,
  0x22, 0x43, 0x90, 0x04, 0x00, 0x98, 0x24, 0x89, 0x12, 0x22, 0x44, 0x50,
  0x88, 0x12, 0x01, 0xC0, 0x0F, 0x06, 0x41, 0x08, 0x42, 0x21, 0x04, 0x81,
  0x40, 0x60, 0x18, 0x09, 0x14, 0x46, 0x09, 0x82, 0xA0, 0x68, 0x13, 0x0A,
  0x7C, 0xC0, 0x55, 0x80, 0x02, 0x08, 0x20, 0x81, 0x04, 0x08, 0x10, 0x40,
  0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x10, 0x20, 0x81, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x42, 0x08, 0x21, 0x04, 0x10, 0x84, 0x20, 0x80, 0x04, 0x01, 0x00,
  0x43, 0x97, 0x1E, 0x03, 0x01, 0x40, 0x88, 0x42, 0x00, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x02, 0x0F, 0xFC, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x00, 0x25, 0xA8, 0xF0, 0xC0, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x20, 0x00, 0x0F, 0x04, 0x22, 0x08, 0x81, 0x40, 0x50,
  0x14, 0x05, 0x02, 0x40, 0xA0, 0x28, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x21,
  0x08, 0x3C, 0x00, 0x0B, 0xE2, 0x10, 0x84, 0x42, 0x10, 0x84, 0x22, 0x10,
  0x84, 0x20, 0x0F, 0x04, 0x22, 0x09, 0x02, 0x40, 0x80, 0x20, 0x08, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0xFF, 0x00,
  0x0F, 0x04, 0x22, 0x08, 0x81, 0x40, 0x40, 0x20, 0x08, 0x04, 0x1E, 0x00,
  0xC0, 0x10, 0x02, 0x80, 0xA0, 0x48, 0x11, 0x08, 0x3C, 0x00, 0x00, 0x40,
  0x30, 0x14, 0x05, 0x02, 0x81, 0x20, 0x88, 0x22, 0x10, 0x88, 0x24, 0x11,
  0xFF, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x1F, 0xC2, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x0F, 0x81, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x48, 0x08, 0x82, 0x10, 0x42, 0x10, 0x3C, 0x00, 0x03, 0x86, 0x04, 0x02,
  0x02, 0x02, 0x01, 0x78, 0xC2, 0x40, 0xA0, 0x60, 0x30, 0x18, 0x0C, 0x09,
  0x04, 0x84, 0x3C, 0x00, 0xFF, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x00, 0x0F, 0x04, 0x22, 0x04, 0x81, 0x20, 0x50, 0x12, 0x08, 0x84,
  0x1E, 0x18, 0x44, 0x12, 0x02, 0x80, 0xA0, 0x48, 0x13, 0x08, 0x3C, 0x00,
  0x1E, 0x10, 0x90, 0x50, 0x28, 0x0C, 0x06, 0x05, 0x02, 0x83, 0x62, 0x9E,
  0x40, 0x40, 0x20, 0x20, 0x10, 0x30, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x42, 0x21,
  0x10, 0x00, 0x81, 0x83, 0x06, 0x0C, 0x06, 0x00, 0x80, 0x30, 0x06, 0x01,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x40, 0x18, 0x02, 0x00,
  0xC0, 0x18, 0x18, 0x10, 0x30, 0x60, 0x40, 0x00, 0x3C, 0x85, 0x0C, 0x10,
  0x20, 0x41, 0x04, 0x10, 0x20, 0x81, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0xF8, 0x02, 0x04, 0x0C, 0x02, 0x18, 0x01, 0x10, 0x01, 0x20, 0xE1, 0x21,
  0x11, 0x42, 0x11, 0x44, 0x11, 0x84, 0x21, 0x84, 0x21, 0x88, 0x21, 0x88,
  0x21, 0x88, 0x42, 0x88, 0x42, 0x88, 0xC4, 0x87, 0x38, 0x80, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x1F, 0x80, 0x00, 0x80, 0x0C, 0x01, 0x40,
  0x14, 0x02, 0x40, 0x24, 0x04, 0x40, 0x42, 0x08, 0x20, 0x82, 0x10, 0x21,
  0xFE, 0x20, 0x22, 0x02, 0x40, 0x24, 0x01, 0x40, 0x10, 0x1F, 0x84, 0x08,
  0x81, 0x10, 0x12, 0x02, 0x40, 0x88, 0x12, 0x04, 0x7F, 0x08, 0x11, 0x01,
  0x20, 0x24, 0x05, 0x01, 0x20, 0x24, 0x08, 0xFE, 0x00, 0x07, 0xC0, 0x82,
  0x10, 0x22, 0x01, 0x20, 0x14, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x04, 0x80, 0x44, 0x04, 0x40, 0x86, 0x10, 0x1E, 0x00, 0x1F,
  0x82, 0x04, 0x20, 0x22, 0x02, 0x20, 0x22, 0x02, 0x20, 0x24, 0x02, 0x40,
  0x24, 0x02, 0x40, 0x24, 0x04, 0x40, 0x48, 0x04, 0x80, 0x88, 0x30, 0xFC,
  0x00, 0x1F, 0xE4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x7F, 0x88, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF,
  0x80, 0x1F, 0xE4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x7F, 0x88, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x00, 0x0F, 0x82, 0x08, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x10, 0xFA, 0x01, 0x40, 0x28, 0x05, 0x01, 0x20, 0x22, 0x0C, 0x3E,
  0x00, 0x10, 0x09, 0x00, 0x48, 0x02, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80,
  0x48, 0x02, 0x7F, 0xF2, 0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x40, 0x12,
  0x00, 0x90, 0x08, 0x80, 0x40, 0x11, 0x12, 0x22, 0x22, 0x24, 0x44, 0x44,
  0x48, 0x80, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x48, 0x09, 0x02, 0x10, 0x42, 0x10,
  0x3C, 0x00, 0x10, 0x12, 0x02, 0x20, 0x42, 0x08, 0x21, 0x02, 0x20, 0x24,
  0x04, 0x80, 0x58, 0x06, 0x40, 0x42, 0x04, 0x20, 0x41, 0x08, 0x10, 0x80,
  0x88, 0x08, 0x80, 0x40, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0xFF, 0x10, 0x01, 0x10,
  0x03, 0x30, 0x05, 0x28, 0x05, 0x28, 0x0A, 0x28, 0x0A, 0x28, 0x12, 0x48,
  0x12, 0x44, 0x22, 0x44, 0x24, 0x44, 0x44, 0x44, 0x44, 0x44, 0x84, 0x84,
  0x84, 0x83, 0x04, 0x83, 0x08, 0x82, 0x08, 0x10, 0x08, 0x80, 0x4A, 0x02,
  0x50, 0x12, 0x81, 0x12, 0x08, 0x90, 0x48, 0x42, 0x42, 0x12, 0x11, 0x10,
  0x48, 0x82, 0x44, 0x12, 0x40, 0x52, 0x02, 0x90, 0x08, 0x80, 0x40, 0x07,
  0xC0, 0x82, 0x10, 0x22, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40,
  0x24, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x40, 0x86, 0x18, 0x1E,
  0x00, 0x1F, 0x84, 0x08, 0x80, 0x90, 0x12, 0x02, 0x40, 0x48, 0x0A, 0x02,
  0x40, 0xCF, 0xE1, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x00, 0x07, 0xC0, 0x82, 0x10, 0x22, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14,
  0x01, 0x40, 0x24, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x40, 0x86,
  0x18, 0x3E, 0x00, 0x10, 0x00, 0x80, 0x08, 0x1F, 0x84, 0x08, 0x80, 0x90,
  0x12, 0x02, 0x40, 0x48, 0x0A, 0x02, 0x40, 0x8F, 0xE1, 0x04, 0x20, 0x84,
  0x11, 0x01, 0x20, 0x24, 0x04, 0x80, 0x40, 0x0F, 0x82, 0x08, 0x80, 0x90,
  0x14, 0x02, 0x40, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x02, 0x00, 0x28,
  0x05, 0x01, 0x20, 0x22, 0x08, 0x3E, 0x00, 0xFF, 0xE0, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x00, 0x20, 0x12, 0x01, 0x20, 0x12,
  0x01, 0x20, 0x12, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24,
  0x04, 0x80, 0x48, 0x04, 0x40, 0x86, 0x18, 0x3E, 0x00, 0x80, 0x30, 0x06,
  0x01, 0x20, 0x24, 0x08, 0x81, 0x10, 0x42, 0x08, 0x41, 0x08, 0x40, 0x88,
  0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x80, 0x10, 0x00, 0x80, 0x80, 0xC0,
  0x40, 0xA0, 0x60, 0x48, 0x28, 0x24, 0x24, 0x22, 0x12, 0x11, 0x09, 0x08,
  0x88, 0x88, 0x44, 0x44, 0x24, 0x24, 0x12, 0x12, 0x09, 0x09, 0x05, 0x05,
  0x02, 0x82, 0x81, 0x81, 0x40, 0xC0, 0x40, 0x40, 0x20, 0x00, 0x10, 0x08,
  0x80, 0x82, 0x08, 0x10, 0xC0, 0x84, 0x02, 0x40, 0x14, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x02, 0x40, 0x12, 0x01, 0x08, 0x10, 0x41, 0x82, 0x08, 0x08,
  0x80, 0x40, 0x80, 0x28, 0x09, 0x01, 0x20, 0x42, 0x10, 0x42, 0x08, 0x80,
  0xA0, 0x14, 0x03, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x00, 0x1F, 0xF0, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x00, 0xFF, 0xC0, 0x0E, 0x10, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x20, 0x70, 0x84, 0x44, 0x44, 0x44, 0x22, 0x22, 0x22, 0x11, 0x11,
  0x1C, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04,
  0x10, 0x42, 0x08, 0x20, 0x82, 0x38, 0x08, 0x18, 0x50, 0xA2, 0x44, 0x91,
  0x21, 0x82, 0xFF, 0xC8, 0x80, 0x0F, 0x04, 0x22, 0x08, 0x82, 0x00, 0x80,
  0x21, 0xF8, 0x82, 0x40, 0xA0, 0x48, 0x11, 0x0C, 0x3D, 0x00, 0x10, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x79, 0x46, 0xC1, 0x40, 0xA0, 0x50, 0x28, 0x18,
  0x0C, 0x06, 0x05, 0x02, 0xC2, 0x5E, 0x00, 0x1E, 0x10, 0x90, 0x28, 0x18,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0xA0, 0x98, 0x47, 0xC0, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x47, 0x92, 0x19, 0x02, 0x40, 0xA0, 0x28, 0x0A,
  0x04, 0x81, 0x20, 0x48, 0x12, 0x04, 0x47, 0x1E, 0x80, 0x1E, 0x10, 0x90,
  0x28, 0x18, 0x0F, 0xFE, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x43, 0xC0,
  0x07, 0x08, 0x10, 0x10, 0x10, 0x7C, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x0F, 0x44, 0x32, 0x04, 0x81, 0x40,
  0x50, 0x14, 0x09, 0x02, 0x40, 0x90, 0x24, 0x09, 0x8E, 0x3D, 0x00, 0x40,
  0x10, 0x04, 0xC2, 0x0F, 0x00, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x79,
  0x44, 0xC1, 0x40, 0xA0, 0x50, 0x28, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x81,
  0x41, 0x00, 0x03, 0x00, 0x02, 0x24, 0x44, 0x44, 0x48, 0x88, 0x88, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x30, 0xE0, 0x10, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x05, 0x04, 0x84, 0x44, 0x24, 0x14, 0x0E, 0x04,
  0x84, 0x42, 0x11, 0x08, 0x82, 0x41, 0x00, 0x12, 0x22, 0x22, 0x24, 0x44,
  0x44, 0x48, 0x88, 0x88, 0x17, 0x8E, 0x14, 0x48, 0x8C, 0x18, 0x24, 0x08,
  0x12, 0x04, 0x09, 0x02, 0x08, 0x82, 0x04, 0x81, 0x02, 0x40, 0x81, 0x20,
  0x40, 0x90, 0x20, 0x48, 0x10, 0x44, 0x10, 0x20, 0x2F, 0x28, 0x98, 0x28,
  0x14, 0x0A, 0x05, 0x05, 0x02, 0x81, 0x40, 0xA0, 0x50, 0x28, 0x20, 0x1E,
  0x10, 0x90, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xA0, 0x48,
  0x43, 0xC0, 0x17, 0x8A, 0x33, 0x04, 0x81, 0x20, 0x48, 0x12, 0x05, 0x01,
  0x40, 0x50, 0x24, 0x09, 0x84, 0x5E, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x00, 0x1E, 0x90, 0xD0, 0x28, 0x14, 0x0C, 0x06, 0x05, 0x02, 0x81, 0x40,
  0xA0, 0x58, 0xA7, 0xA0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x2C, 0xA1,
  0x82, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x08, 0x00, 0x0F, 0x08,
  0x48, 0x24, 0x02, 0x00, 0x80, 0x30, 0x06, 0x01, 0x00, 0x90, 0x48, 0x43,
  0xC0, 0x10, 0x42, 0x3E, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x1C, 0x20, 0xA0, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x05, 0x02, 0x81, 0x40,
  0xA0, 0xC8, 0xA7, 0xA0, 0x40, 0xA0, 0x50, 0x48, 0x24, 0x22, 0x11, 0x10,
  0x48, 0x28, 0x14, 0x0C, 0x06, 0x02, 0x00, 0x82, 0x0C, 0x10, 0x61, 0x85,
  0x0C, 0x28, 0xA1, 0x44, 0x92, 0x44, 0x92, 0x28, 0xA1, 0x45, 0x0A, 0x28,
  0x60, 0x83, 0x04, 0x10, 0x00, 0x20, 0xC8, 0x21, 0x10, 0x48, 0x0A, 0x03,
  0x00, 0x80, 0x30, 0x14, 0x08, 0x84, 0x21, 0x04, 0x81, 0x00, 0x10, 0x22,
  0x04, 0x41, 0x08, 0x21, 0x08, 0x21, 0x04, 0x40, 0x48, 0x0A, 0x01, 0x40,
  0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x20, 0x18, 0x00, 0x3F,
  0xC0, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x60, 0x10, 0x08, 0x04,
  0x01, 0x00, 0xFF, 0x00, 0x02, 0x08, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x83, 0x08, 0x08, 0x10, 0x10, 0x40, 0x81, 0x02, 0x04, 0x08, 0x08,
  0x08, 0x11, 0x11, 0x11, 0x12, 0x22, 0x22, 0x24, 0x44, 0x44, 0x48, 0x10,
  0x10, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x10, 0x10, 0xC1, 0x04,
  0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x10, 0x40, 0x38, 0x24, 0x42, 0x42,
  0x28, 0x1C,
};

const GFXglyph RobotoCondensed_ExtraLightItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 17, 5, 1, -17 },
  { 8, 4, 5, 6, 3, -18 },
  { 11, 12, 17, 12, 1, -17 },
  { 37, 10, 21, 11, 1, -19 },
  { 64, 11, 17, 15, 2, -17 },
  { 88, 10, 17, 13, 1, -17 },
  { 110, 2, 5, 4, 2, -18 },
  { 112, 7, 25, 7, 1, -19 },
  { 134, 6, 25, 7, -1, -19 },
  { 153, 10, 9, 10, 1, -17 },
  { 165, 10, 13, 12, 1, -15 },
  { 182, 3, 5, 4, -1, -2 },
  { 184, 5, 1, 6, 1, -8 },
  { 185, 1, 2, 5, 1, -2 },
  { 186, 10, 18, 8, -1, -17 },
  { 209, 10, 17, 11, 1, -17 },
  { 231, 5, 17, 11, 3, -17 },
  { 242, 10, 17, 11, 1, -17 },
  { 264, 10, 17, 11, 1, -17 },
  { 286, 10, 17, 11, 0, -17 },
  { 308, 11, 17, 11, 1, -17 },
  { 332, 9, 17, 11, 1, -17 },
  { 352, 10, 17, 11, 2, -17 },
  { 374, 10, 17, 11, 1, -17 },
  { 396, 9, 17, 11, 2, -17 },
  { 416, 4, 13, 4, 0, -13 },
  { 423, 5, 16, 4, -1, -13 },
  { 433, 9, 10, 11, 1, -13 },
  { 445, 9, 6, 11, 1, -11 },
  { 452, 9, 10, 11, 1, -13 },
  { 464, 7, 17, 9, 2, -17 },
  { 479, 16, 22, 19, 1, -17 },
  { 523, 12, 17, 12, -1, -17 },
  { 549, 11, 17, 12, 1, -17 },
  { 573, 12, 17, 13, 1, -17 },
  { 599, 12, 17, 13, 1, -17 },
  { 625, 11, 17, 12, 1, -17 },
  { 649, 11, 17, 12, 1, -17 },
  { 673, 11, 17, 14, 2, -17 },
  { 697, 13, 17, 14, 1, -17 },
  { 725, 4, 17, 6, 1, -17 },
  { 734, 11, 17, 11, 0, -17 },
  { 758, 12, 17, 13, 1, -17 },
  { 784, 8, 17, 11, 1, -17 },
  { 801, 16, 17, 17, 1, -17 },
  { 835, 13, 17, 14, 1, -17 },
  { 863, 12, 17, 14, 1, -17 },
  { 889, 11, 17, 12, 1, -17 },
  { 913, 12, 20, 14, 1, -17 },
  { 943, 11, 17, 13, 1, -17 },
  { 967, 11, 17, 12, 1, -17 },
  { 991, 11, 17, 12, 2, -17 },
  { 1015, 12, 17, 13, 1, -17 },
  { 1041, 11, 17, 12, 2, -17 },
  { 1065, 17, 17, 18, 2, -17 },
  { 1102, 13, 17, 12, 0, -17 },
  { 1130, 11, 17, 12, 2, -17 },
  { 1154, 13, 17, 12, 0, -17 },
  { 1182, 7, 24, 5, 0, -20 },
  { 1203, 4, 18, 8, 2, -17 },
  { 1212, 6, 24, 5, -1, -20 },
  { 1230, 7, 9, 9, 1, -17 },
  { 1238, 8, 1, 9, -1, 0 },
  { 1239, 3, 3, 6, 3, -18 },
  { 1241, 10, 13, 11, 0, -13 },
  { 1258, 9, 18, 11, 1, -18 },
  { 1279, 9, 13, 11, 1, -13 },
  { 1294, 10, 18, 11, 1, -18 },
  { 1317, 9, 13, 11, 1, -13 },
  { 1332, 8, 18, 7, 1, -18 },
  { 1350, 10, 18, 11, 0, -13 },
  { 1373, 9, 18, 11, 1, -18 },
  { 1394, 4, 18, 5, 1, -18 },
  { 1403, 8, 23, 5, -3, -18 },
  { 1426, 9, 18, 10, 1, -18 },
  { 1447, 4, 18, 5, 1, -18 },
  { 1456, 17, 13, 18, 0, -13 },
  { 1484, 9, 13, 11, 1, -13 },
  { 1499, 9, 13, 11, 1, -13 },
  { 1514, 10, 18, 11, 0, -13 },
  { 1537, 9, 18, 11, 1, -13 },
  { 1558, 7, 13, 7, 1, -13 },
  { 1570, 9, 13, 10, 0, -13 },
  { 1585, 6, 16, 7, 1, -16 },
  { 1597, 9, 13, 11, 1, -13 },
  { 1612, 9, 13, 10, 1, -13 },
  { 1627, 13, 13, 15, 2, -13 },
  { 1649, 10, 13, 10, 0, -13 },
  { 1666, 11, 18, 10, -1, -13 },
  { 1691, 10, 13, 10, 0, -13 },
  { 1708, 7, 24, 7, 1, -19 },
  { 1729, 4, 20, 5, 0, -17 },
  { 1739, 7, 24, 7, -1, -19 },
  { 1760, 12, 4, 14, 1, -9 },
};

const GFXfont RobotoCondensed_ExtraLightItalic24pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic24pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic24pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC24PT7B_H_
