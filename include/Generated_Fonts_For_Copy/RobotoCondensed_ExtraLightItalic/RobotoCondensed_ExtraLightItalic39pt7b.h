#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC39PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0xC3, 0x0C, 0x20, 0x82, 0x18, 0x61, 0x04, 0x10, 0x43,
  0x0C, 0x20, 0x82, 0x08, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x66, 0xCD,
  0x9A, 0x24, 0x48, 0xB3, 0x66, 0x00, 0x20, 0x40, 0x04, 0x18, 0x01, 0x82,
  0x00, 0x30, 0x40, 0x04, 0x18, 0x00, 0x82, 0x00, 0x30, 0x40, 0x04, 0x18,
  0x1F, 0xFF, 0xE0, 0x30, 0x40, 0x04, 0x18, 0x00, 0x83, 0x00, 0x30, 0x40,
  0x04, 0x08, 0x00, 0x83, 0x00, 0x30, 0x40, 0x04, 0x08, 0x00, 0x83, 0x00,
  0x30, 0x40, 0x7F, 0xFF, 0x80, 0x83, 0x00, 0x30, 0x40, 0x04, 0x08, 0x00,
  0x83, 0x00, 0x10, 0x40, 0x04, 0x08, 0x00, 0x83, 0x00, 0x10, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x0F, 0x80, 0x1E,
  0x70, 0x18, 0x08, 0x08, 0x06, 0x0C, 0x01, 0x04, 0x00, 0x82, 0x00, 0x43,
  0x00, 0x21, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x08, 0x40, 0x04, 0x20, 0x02, 0x10, 0x01, 0x08, 0x01, 0x86,
  0x01, 0x81, 0x81, 0xC0, 0x73, 0x80, 0x1F, 0x80, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x1E, 0x00, 0x0C, 0xC0, 0x06, 0x10, 0x01,
  0x06, 0x04, 0xC1, 0x81, 0x20, 0x60, 0x88, 0x18, 0x62, 0x04, 0x10, 0x81,
  0x08, 0x20, 0xC6, 0x08, 0x23, 0x01, 0x18, 0x80, 0x78, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x04, 0x3C, 0x03, 0x19, 0x81, 0x8C, 0x20, 0x46, 0x0C,
  0x31, 0x03, 0x18, 0x40, 0xC4, 0x10, 0x32, 0x04, 0x09, 0x81, 0x02, 0x40,
  0x41, 0x80, 0x10, 0x40, 0x06, 0x30, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xEE,
  0x00, 0xC1, 0x00, 0x40, 0xC0, 0x60, 0x60, 0x20, 0x30, 0x10, 0x10, 0x08,
  0x18, 0x04, 0x18, 0x03, 0x18, 0x01, 0x98, 0x00, 0x58, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x36, 0x00, 0x31, 0x81, 0x30, 0x40, 0x90, 0x30, 0xD8, 0x08,
  0x68, 0x06, 0x2C, 0x01, 0x36, 0x00, 0xD3, 0x00, 0x39, 0x80, 0x18, 0x40,
  0x0E, 0x30, 0x19, 0x0E, 0x38, 0xC1, 0xF0, 0x20, 0x69, 0x25, 0xA4, 0x00,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x04,
  0x00, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x0C, 0x30,
  0xDE, 0x4F, 0x07, 0xF0, 0x03, 0x00, 0x0F, 0x00, 0x33, 0x00, 0xC2, 0x01,
  0x06, 0x06, 0x04, 0x08, 0x08, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0xFF, 0xFE, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x13, 0x33, 0x26, 0xC8,
  0xFF, 0x5B, 0x00, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00, 0x01, 0xF0, 0x07, 0x30, 0x18,
  0x30, 0x60, 0x31, 0x80, 0x62, 0x00, 0x4C, 0x00, 0x98, 0x01, 0x20, 0x02,
  0xC0, 0x05, 0x80, 0x0B, 0x00, 0x34, 0x00, 0x68, 0x00, 0xD0, 0x01, 0x60,
  0x02, 0xC0, 0x05, 0x80, 0x1A, 0x00, 0x34, 0x00, 0x48, 0x00, 0x90, 0x03,
  0x30, 0x04, 0x60, 0x18, 0x40, 0x20, 0xC0, 0xC0, 0xC7, 0x00, 0xF8, 0x00,
  0x01, 0x83, 0xCF, 0x5C, 0x28, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x00,
  0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80,
  0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x02, 0x00, 0x00, 0xF8, 0x03, 0x9C,
  0x06, 0x06, 0x0C, 0x03, 0x08, 0x03, 0x18, 0x03, 0x10, 0x03, 0x30, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0xF8, 0x03, 0x9E, 0x06, 0x06, 0x0C, 0x03,
  0x08, 0x01, 0x18, 0x01, 0x18, 0x01, 0x10, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0xC0, 0x04, 0xC0, 0x04,
  0xC0, 0x0C, 0x40, 0x08, 0x60, 0x18, 0x20, 0x30, 0x3C, 0xE0, 0x0F, 0x80,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0A, 0x00, 0x16, 0x00, 0x36,
  0x00, 0x64, 0x00, 0x44, 0x00, 0xC4, 0x01, 0x8C, 0x01, 0x0C, 0x03, 0x0C,
  0x06, 0x08, 0x04, 0x08, 0x08, 0x08, 0x18, 0x18, 0x30, 0x18, 0x20, 0x18,
  0x60, 0x10, 0xC0, 0x10, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x07, 0xFF, 0x83, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0xF8, 0x03, 0xEE, 0x03, 0x81, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x8C, 0x00, 0xC6, 0x00, 0x61, 0x00, 0x20, 0x80, 0x30, 0x60,
  0x10, 0x10, 0x18, 0x0F, 0x38, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xE0,
  0x38, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x3E, 0x1B, 0x9C, 0x58, 0x19, 0xC0, 0x36, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0F, 0x00, 0x2C, 0x01,
  0xB0, 0x06, 0x40, 0x31, 0x81, 0x83, 0x9C, 0x03, 0xE0, 0x7F, 0xFF, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x01, 0xE7, 0x01, 0x80, 0xC1,
  0x80, 0x60, 0xC0, 0x10, 0x40, 0x0C, 0x60, 0x06, 0x30, 0x02, 0x18, 0x01,
  0x0C, 0x01, 0x82, 0x01, 0x81, 0x81, 0x80, 0x73, 0x80, 0x3F, 0x80, 0x30,
  0x60, 0x20, 0x18, 0x20, 0x04, 0x30, 0x03, 0x10, 0x01, 0x98, 0x00, 0xCC,
  0x00, 0x66, 0x00, 0x23, 0x00, 0x11, 0x80, 0x18, 0x40, 0x18, 0x30, 0x18,
  0x0F, 0x38, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x39, 0xC1, 0x81, 0x8C, 0x02,
  0x20, 0x0D, 0x80, 0x34, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x2C, 0x01, 0x90, 0x0A, 0x60, 0x78, 0xE7,
  0x61, 0xF1, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC1, 0x83, 0x06, 0x18, 0x30, 0xC1, 0x00, 0x00, 0x04, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x04, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x10, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x20, 0x00, 0x00, 0x07, 0xC1, 0xCE,
  0x30, 0x22, 0x03, 0x60, 0x34, 0x01, 0x40, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0xC0,
  0x0C, 0x00, 0x70, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x80,
  0x80, 0x00, 0x10, 0x30, 0x00, 0x03, 0x0C, 0x03, 0xC0, 0x21, 0x01, 0xCC,
  0x04, 0x60, 0x60, 0x40, 0x88, 0x08, 0x18, 0x13, 0x02, 0x03, 0x02, 0x60,
  0xC0, 0x40, 0x48, 0x10, 0x08, 0x0B, 0x02, 0x03, 0x01, 0x60, 0xC0, 0x60,
  0x68, 0x10, 0x08, 0x09, 0x02, 0x01, 0x01, 0x20, 0x40, 0x60, 0x24, 0x18,
  0x0C, 0x0D, 0x83, 0x01, 0x01, 0x30, 0x60, 0x60, 0x26, 0x0C, 0x1C, 0x08,
  0xC1, 0x82, 0x83, 0x18, 0x19, 0x98, 0xC1, 0x01, 0xE1, 0xE0, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x20, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xA0,
  0x00, 0x28, 0x00, 0x12, 0x00, 0x04, 0x80, 0x03, 0x30, 0x00, 0x8C, 0x00,
  0x63, 0x00, 0x10, 0x40, 0x0C, 0x10, 0x02, 0x04, 0x01, 0x81, 0x00, 0x40,
  0x40, 0x30, 0x18, 0x08, 0x06, 0x06, 0x00, 0x81, 0x00, 0x20, 0xC0, 0x08,
  0x3F, 0xFE, 0x18, 0x00, 0x84, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x20,
  0x00, 0x58, 0x00, 0x14, 0x00, 0x07, 0x00, 0x01, 0x07, 0xFC, 0x01, 0x03,
  0xC0, 0x40, 0x18, 0x10, 0x02, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C,
  0x20, 0x03, 0x08, 0x00, 0x82, 0x00, 0x61, 0x80, 0x10, 0x60, 0x0C, 0x10,
  0x1C, 0x07, 0xFF, 0x01, 0x00, 0xE0, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00,
  0x42, 0x00, 0x18, 0x80, 0x04, 0x20, 0x01, 0x18, 0x00, 0x46, 0x00, 0x31,
  0x80, 0x08, 0x40, 0x06, 0x10, 0x03, 0x04, 0x07, 0x83, 0xFF, 0x80, 0x00,
  0x7E, 0x00, 0x38, 0xE0, 0x1C, 0x06, 0x02, 0x00, 0x60, 0xC0, 0x04, 0x30,
  0x00, 0x84, 0x00, 0x11, 0x80, 0x03, 0x30, 0x00, 0x64, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0xCC, 0x00,
  0x11, 0x80, 0x06, 0x10, 0x00, 0x82, 0x00, 0x30, 0x60, 0x04, 0x06, 0x03,
  0x80, 0x71, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x81, 0xE0, 0x10,
  0x06, 0x02, 0x00, 0x60, 0xC0, 0x04, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x40,
  0x01, 0x08, 0x00, 0x21, 0x00, 0x04, 0x60, 0x00, 0x8C, 0x00, 0x31, 0x00,
  0x06, 0x20, 0x00, 0xC4, 0x00, 0x11, 0x80, 0x02, 0x30, 0x00, 0x46, 0x00,
  0x18, 0x80, 0x03, 0x10, 0x00, 0x42, 0x00, 0x08, 0xC0, 0x03, 0x18, 0x00,
  0xC3, 0x00, 0x10, 0x40, 0x06, 0x08, 0x03, 0x81, 0x03, 0xC0, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xFC, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x3F, 0xFC, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xF3, 0xC0, 0x60, 0x18, 0x30, 0x02,
  0x18, 0x00, 0xC4, 0x00, 0x33, 0x00, 0x04, 0x80, 0x01, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x01, 0xFE, 0x80, 0x01, 0xA0, 0x00, 0x48, 0x00, 0x12, 0x00, 0x04,
  0x80, 0x03, 0x20, 0x00, 0xC8, 0x00, 0x33, 0x00, 0x08, 0x40, 0x06, 0x18,
  0x07, 0x03, 0xCF, 0x80, 0x3F, 0x00, 0x06, 0x00, 0x0C, 0x10, 0x00, 0x20,
  0x40, 0x00, 0x81, 0x00, 0x02, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0,
  0x01, 0x82, 0x00, 0x04, 0x08, 0x00, 0x10, 0x20, 0x00, 0x41, 0x80, 0x03,
  0x06, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x7F, 0xFF, 0x81, 0x00, 0x02, 0x0C,
  0x00, 0x08, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x82, 0x00, 0x06, 0x08, 0x00,
  0x10, 0x20, 0x00, 0x41, 0x80, 0x01, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x40, 0x00, 0xC1, 0x00, 0x02, 0x04, 0x00, 0x08, 0x30, 0x00, 0x20, 0x04,
  0x30, 0xC3, 0x08, 0x20, 0x86, 0x18, 0x61, 0x04, 0x10, 0xC3, 0x08, 0x20,
  0x86, 0x18, 0x61, 0x04, 0x10, 0xC3, 0x0C, 0x20, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x88, 0x00, 0x84, 0x00, 0xC2, 0x00, 0x61, 0x80, 0x20, 0xC0,
  0x30, 0x30, 0x30, 0x1E, 0x70, 0x03, 0xE0, 0x00, 0x06, 0x00, 0x30, 0x20,
  0x03, 0x01, 0x00, 0x18, 0x08, 0x01, 0x80, 0xC0, 0x18, 0x06, 0x01, 0x80,
  0x30, 0x18, 0x01, 0x01, 0x80, 0x08, 0x18, 0x00, 0x41, 0x80, 0x06, 0x18,
  0x00, 0x31, 0x80, 0x01, 0x18, 0x00, 0x09, 0xC0, 0x00, 0x5B, 0x00, 0x07,
  0x88, 0x00, 0x38, 0x60, 0x01, 0x81, 0x00, 0x08, 0x0C, 0x00, 0x40, 0x20,
  0x02, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x80, 0x40,
  0x06, 0x02, 0x00, 0x18, 0x10, 0x00, 0xC1, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xA0, 0xF0, 0x00,
  0x34, 0x1A, 0x00, 0x05, 0x82, 0x40, 0x01, 0xB0, 0x48, 0x00, 0x26, 0x09,
  0x80, 0x0C, 0x81, 0x30, 0x01, 0x10, 0x62, 0x00, 0x62, 0x0C, 0x40, 0x08,
  0xC1, 0x08, 0x03, 0x18, 0x21, 0x00, 0x42, 0x04, 0x30, 0x18, 0x41, 0x86,
  0x02, 0x08, 0x30, 0x40, 0xC3, 0x06, 0x08, 0x10, 0x60, 0x81, 0x06, 0x0C,
  0x10, 0x20, 0x81, 0x02, 0x06, 0x30, 0x20, 0xC0, 0xC4, 0x04, 0x18, 0x09,
  0x81, 0x83, 0x01, 0x20, 0x30, 0x40, 0x2C, 0x06, 0x08, 0x05, 0x00, 0x81,
  0x00, 0xE0, 0x10, 0x60, 0x08, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0x70, 0x00, 0x81, 0xC0, 0x02, 0x0D, 0x00, 0x08, 0x36, 0x00, 0x60,
  0xC8, 0x01, 0x82, 0x20, 0x06, 0x08, 0xC0, 0x10, 0x21, 0x00, 0x41, 0x86,
  0x01, 0x06, 0x18, 0x0C, 0x18, 0x20, 0x30, 0x40, 0xC0, 0xC1, 0x01, 0x02,
  0x0C, 0x04, 0x08, 0x30, 0x18, 0x20, 0xC0, 0x21, 0x83, 0x00, 0xC6, 0x08,
  0x03, 0x18, 0x20, 0x04, 0x41, 0x80, 0x19, 0x06, 0x00, 0x24, 0x18, 0x00,
  0xB0, 0x40, 0x03, 0xC1, 0x00, 0x07, 0x04, 0x00, 0x18, 0x30, 0x00, 0x60,
  0x00, 0x7E, 0x00, 0x39, 0xE0, 0x1C, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x04,
  0x30, 0x00, 0xC4, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x64, 0x00, 0x0D,
  0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x12,
  0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x02, 0x60, 0x00, 0x4C,
  0x00, 0x19, 0x80, 0x02, 0x30, 0x00, 0xC2, 0x00, 0x10, 0x60, 0x06, 0x06,
  0x03, 0x80, 0x7B, 0xC0, 0x07, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x80, 0xF0,
  0x10, 0x03, 0x02, 0x00, 0x20, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18,
  0x40, 0x03, 0x08, 0x00, 0x61, 0x00, 0x08, 0x60, 0x03, 0x0C, 0x00, 0x61,
  0x00, 0x18, 0x20, 0x06, 0x04, 0x07, 0x81, 0xFF, 0xC0, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x39, 0xE0, 0x1C, 0x06, 0x06, 0x00, 0x60,
  0x80, 0x04, 0x30, 0x00, 0x84, 0x00, 0x19, 0x80, 0x03, 0x20, 0x00, 0x64,
  0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x04, 0x80, 0x00, 0x90,
  0x00, 0x12, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x13, 0x00, 0x02, 0x60,
  0x00, 0xCC, 0x00, 0x19, 0x80, 0x02, 0x30, 0x00, 0xC2, 0x00, 0x10, 0x60,
  0x06, 0x06, 0x03, 0x80, 0x7B, 0xC0, 0x07, 0xF8, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x07, 0xFE, 0x00,
  0x80, 0xF0, 0x10, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x06, 0x18, 0x00, 0xC2,
  0x00, 0x18, 0x40, 0x03, 0x08, 0x00, 0x63, 0x00, 0x08, 0x60, 0x03, 0x0C,
  0x00, 0x61, 0x00, 0x18, 0x20, 0x06, 0x04, 0x07, 0x81, 0xFF, 0xC0, 0x30,
  0x18, 0x06, 0x03, 0x00, 0x80, 0x20, 0x10, 0x06, 0x02, 0x00, 0xC0, 0xC0,
  0x08, 0x18, 0x01, 0x83, 0x00, 0x30, 0x40, 0x02, 0x08, 0x00, 0x61, 0x00,
  0x0C, 0x60, 0x00, 0x80, 0x00, 0x7E, 0x00, 0x38, 0xE0, 0x1C, 0x06, 0x06,
  0x00, 0x60, 0xC0, 0x0C, 0x30, 0x00, 0x86, 0x00, 0x10, 0xC0, 0x02, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x8C, 0x00, 0x11, 0x80, 0x02, 0x30, 0x00, 0xC6, 0x00,
  0x10, 0x60, 0x06, 0x0E, 0x01, 0x80, 0xF1, 0xE0, 0x07, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x30, 0x80, 0x02, 0x18, 0x00, 0x21, 0x80, 0x02, 0x18, 0x00, 0x61,
  0x00, 0x06, 0x10, 0x00, 0x61, 0x00, 0x04, 0x30, 0x00, 0x43, 0x00, 0x04,
  0x30, 0x00, 0xC2, 0x00, 0x0C, 0x20, 0x00, 0xC2, 0x00, 0x08, 0x60, 0x00,
  0x86, 0x00, 0x08, 0x60, 0x01, 0x84, 0x00, 0x18, 0x40, 0x01, 0x04, 0x00,
  0x10, 0xC0, 0x01, 0x0C, 0x00, 0x30, 0xC0, 0x02, 0x04, 0x00, 0x60, 0x60,
  0x0C, 0x03, 0x01, 0x80, 0x3C, 0x70, 0x00, 0xFC, 0x00, 0xC0, 0x00, 0x68,
  0x00, 0x09, 0x00, 0x03, 0x20, 0x00, 0x46, 0x00, 0x18, 0xC0, 0x02, 0x18,
  0x00, 0xC1, 0x00, 0x10, 0x20, 0x06, 0x04, 0x00, 0xC0, 0x80, 0x10, 0x18,
  0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x04, 0x04, 0x00, 0x81, 0x80, 0x10,
  0x20, 0x02, 0x0C, 0x00, 0x61, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x11,
  0x00, 0x02, 0x60, 0x00, 0x48, 0x00, 0x0B, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0A, 0x00,
  0x30, 0x03, 0x60, 0x0E, 0x00, 0x6C, 0x01, 0x40, 0x09, 0x80, 0x6C, 0x03,
  0x30, 0x09, 0x80, 0x46, 0x01, 0x30, 0x08, 0xC0, 0x62, 0x03, 0x18, 0x08,
  0x40, 0x43, 0x03, 0x08, 0x18, 0x20, 0x41, 0x03, 0x04, 0x08, 0x20, 0x40,
  0x83, 0x04, 0x18, 0x10, 0x40, 0x83, 0x02, 0x18, 0x10, 0x40, 0x43, 0x02,
  0x18, 0x08, 0x40, 0x62, 0x01, 0x18, 0x0C, 0x40, 0x22, 0x01, 0x98, 0x06,
  0xC0, 0x32, 0x00, 0xD8, 0x02, 0x40, 0x1A, 0x00, 0x58, 0x03, 0xC0, 0x0A,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x0C, 0x08, 0x00, 0x60, 0x30, 0x01, 0x00,
  0xC0, 0x0C, 0x01, 0x00, 0x60, 0x06, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x30,
  0x60, 0x00, 0xC3, 0x00, 0x01, 0x08, 0x00, 0x06, 0x60, 0x00, 0x0B, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x48, 0x00, 0x03, 0x30, 0x00, 0x18, 0x40, 0x00, 0xC1, 0x80, 0x02, 0x06,
  0x00, 0x18, 0x08, 0x00, 0xC0, 0x30, 0x02, 0x00, 0x40, 0x18, 0x01, 0x80,
  0xC0, 0x06, 0x06, 0x00, 0x08, 0x18, 0x00, 0x30, 0x80, 0x00, 0xF0, 0x00,
  0x6C, 0x00, 0x31, 0x00, 0x0C, 0x60, 0x06, 0x18, 0x01, 0x02, 0x00, 0xC0,
  0xC0, 0x60, 0x30, 0x10, 0x04, 0x0C, 0x01, 0x06, 0x00, 0x61, 0x00, 0x08,
  0xC0, 0x02, 0x60, 0x00, 0xD0, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xE0, 0x40,
  0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01,
  0xF0, 0x00, 0x83, 0x0C, 0x30, 0x41, 0x04, 0x10, 0x61, 0x86, 0x08, 0x20,
  0x82, 0x0C, 0x30, 0xC1, 0x04, 0x10, 0x41, 0x86, 0x08, 0x20, 0x82, 0x08,
  0x30, 0x07, 0xC0, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10,
  0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x3C,
  0x00, 0x01, 0x00, 0x70, 0x0E, 0x03, 0x40, 0x48, 0x19, 0x02, 0x20, 0xC6,
  0x10, 0xC6, 0x18, 0x81, 0x30, 0x24, 0x05, 0x80, 0x80, 0xFF, 0xFC, 0xC3,
  0x08, 0x61, 0x00, 0x03, 0xF0, 0x0E, 0x70, 0x30, 0x30, 0x80, 0x23, 0x00,
  0x44, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x0F, 0xF8, 0x78, 0x31,
  0x80, 0x46, 0x00, 0x98, 0x01, 0x20, 0x06, 0x40, 0x0C, 0x80, 0x39, 0x00,
  0x63, 0x03, 0x43, 0x9C, 0x83, 0xE1, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0xF8,
  0x37, 0x38, 0x70, 0x18, 0xC0, 0x31, 0x00, 0x22, 0x00, 0x4C, 0x00, 0x98,
  0x01, 0x30, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x36, 0x00, 0x6C, 0x00,
  0x90, 0x01, 0x20, 0x06, 0x40, 0x09, 0xC0, 0x33, 0xC0, 0xC6, 0xE7, 0x08,
  0x7C, 0x00, 0x03, 0xF0, 0x0E, 0x70, 0x30, 0x30, 0xC0, 0x23, 0x00, 0x64,
  0x00, 0xD8, 0x01, 0xB0, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x02, 0x60, 0x04, 0x40, 0x18, 0x80, 0x21,
  0x80, 0x81, 0xCE, 0x01, 0xF8, 0x00, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x07,
  0xC2, 0x07, 0x3B, 0x06, 0x05, 0x86, 0x01, 0xC2, 0x00, 0x43, 0x00, 0x21,
  0x00, 0x11, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x20, 0x02, 0x10, 0x01,
  0x08, 0x00, 0x84, 0x00, 0xC2, 0x00, 0x61, 0x00, 0x20, 0x80, 0x10, 0x60,
  0x18, 0x30, 0x14, 0x0E, 0x76, 0x03, 0xE3, 0x00, 0x03, 0xF0, 0x0E, 0x70,
  0x30, 0x30, 0xC0, 0x23, 0x00, 0x64, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x40,
  0x06, 0xFF, 0xFB, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0xC1, 0xE7, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x39, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x7F, 0x80, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x81, 0xCE,
  0xC1, 0x81, 0x61, 0x80, 0x60, 0x80, 0x30, 0xC0, 0x08, 0x40, 0x0C, 0x60,
  0x06, 0x30, 0x03, 0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0x42, 0x00, 0x61,
  0x00, 0x30, 0x80, 0x18, 0x40, 0x08, 0x20, 0x04, 0x18, 0x06, 0x0C, 0x07,
  0x03, 0x9D, 0x80, 0xF8, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x20, 0x18, 0x10, 0x18, 0x07, 0x38, 0x01, 0xF8, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x18, 0xF8, 0x37, 0x38, 0x78, 0x10, 0xA0, 0x31, 0x80, 0x63, 0x00,
  0xCC, 0x01, 0x98, 0x03, 0x30, 0x06, 0x40, 0x08, 0x80, 0x11, 0x00, 0x26,
  0x00, 0xCC, 0x01, 0x90, 0x03, 0x20, 0x04, 0x40, 0x08, 0x80, 0x13, 0x00,
  0x66, 0x00, 0xC8, 0x01, 0x80, 0x0E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x18, 0x30, 0x60, 0x81, 0x02, 0x0C, 0x18, 0x30, 0x40, 0x81, 0x06, 0x0C,
  0x18, 0x20, 0x40, 0x83, 0x06, 0x00, 0x00, 0x38, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x26, 0x01, 0xE0, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x06, 0x18,
  0x0C, 0x18, 0x18, 0x10, 0x30, 0x10, 0x60, 0x10, 0xC0, 0x31, 0x80, 0x33,
  0x00, 0x36, 0x00, 0x2E, 0x00, 0x3A, 0x00, 0x33, 0x00, 0x61, 0x00, 0x61,
  0x80, 0x40, 0x80, 0x40, 0xC0, 0x40, 0x40, 0x40, 0x60, 0xC0, 0x20, 0xC0,
  0x30, 0x80, 0x10, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x83, 0x04, 0x08, 0x10,
  0x60, 0xC1, 0x02, 0x04, 0x18, 0x30, 0x60, 0x81, 0x02, 0x0C, 0x18, 0x30,
  0x40, 0x81, 0x06, 0x0C, 0x00, 0x18, 0xF8, 0x1F, 0x06, 0xE7, 0x1C, 0xE1,
  0x60, 0x4C, 0x08, 0x50, 0x1E, 0x03, 0x18, 0x07, 0x00, 0xCC, 0x01, 0x80,
  0x33, 0x00, 0x60, 0x0C, 0xC0, 0x18, 0x03, 0x20, 0x06, 0x00, 0xC8, 0x01,
  0x00, 0x32, 0x00, 0x40, 0x09, 0x80, 0x10, 0x02, 0x60, 0x0C, 0x00, 0x98,
  0x03, 0x00, 0x64, 0x00, 0x80, 0x19, 0x00, 0x20, 0x04, 0x40, 0x08, 0x01,
  0x30, 0x02, 0x00, 0x4C, 0x01, 0x80, 0x13, 0x00, 0x60, 0x0C, 0x80, 0x10,
  0x03, 0x00, 0x18, 0xF8, 0x37, 0x38, 0x58, 0x10, 0xA0, 0x31, 0x80, 0x63,
  0x00, 0xCC, 0x01, 0x98, 0x03, 0x20, 0x06, 0x40, 0x08, 0x80, 0x11, 0x00,
  0x26, 0x00, 0xCC, 0x01, 0x90, 0x03, 0x20, 0x04, 0x40, 0x09, 0x80, 0x13,
  0x00, 0x66, 0x00, 0xC8, 0x01, 0x80, 0x01, 0xF0, 0x07, 0x1C, 0x0C, 0x04,
  0x18, 0x06, 0x10, 0x02, 0x30, 0x02, 0x20, 0x02, 0x60, 0x02, 0x60, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x06, 0x40, 0x06, 0x40, 0x04,
  0x40, 0x0C, 0x40, 0x08, 0x60, 0x18, 0x20, 0x30, 0x3C, 0xE0, 0x0F, 0x80,
  0x0C, 0x7C, 0x0D, 0xCE, 0x0A, 0x03, 0x0C, 0x03, 0x08, 0x01, 0x18, 0x01,
  0x18, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x30, 0x03,
  0x30, 0x03, 0x30, 0x02, 0x20, 0x02, 0x20, 0x06, 0x20, 0x04, 0x70, 0x0C,
  0x78, 0x18, 0x6E, 0x70, 0x43, 0xE0, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x07, 0xC2,
  0x1C, 0xEC, 0x60, 0x79, 0x80, 0x66, 0x00, 0x4C, 0x00, 0x90, 0x03, 0x60,
  0x06, 0xC0, 0x0D, 0x80, 0x12, 0x00, 0x24, 0x00, 0x48, 0x01, 0x90, 0x03,
  0x20, 0x06, 0x40, 0x08, 0x80, 0x11, 0x00, 0x63, 0x01, 0xC3, 0x9D, 0x83,
  0xE3, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x19, 0xE3, 0x70, 0x78, 0x0E, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x00, 0x03, 0xE0,
  0x3D, 0xE1, 0x80, 0x84, 0x03, 0x30, 0x04, 0x80, 0x13, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x20, 0x04, 0x80, 0x13, 0x00, 0xCC, 0x06, 0x1E, 0xF0, 0x1F, 0x00, 0x0C,
  0x06, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06,
  0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x64, 0x1C, 0x00, 0x30, 0x06, 0x60, 0x0C, 0x80, 0x19, 0x00,
  0x22, 0x00, 0x4C, 0x00, 0x98, 0x03, 0x30, 0x06, 0x40, 0x0C, 0x80, 0x11,
  0x00, 0x26, 0x00, 0x4C, 0x01, 0x98, 0x03, 0x20, 0x06, 0x60, 0x08, 0xC0,
  0x31, 0x80, 0xE1, 0x03, 0xC3, 0x9D, 0x83, 0xE3, 0x00, 0xC0, 0x04, 0x80,
  0x19, 0x00, 0x22, 0x00, 0xC6, 0x01, 0x0C, 0x02, 0x18, 0x0C, 0x10, 0x10,
  0x20, 0x60, 0x40, 0x80, 0x83, 0x01, 0x84, 0x03, 0x18, 0x06, 0x20, 0x04,
  0xC0, 0x09, 0x00, 0x12, 0x00, 0x2C, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x80,
  0x00, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x2C, 0x07, 0x01, 0xB0, 0x14, 0x04,
  0xC0, 0xD0, 0x33, 0x02, 0x40, 0xCC, 0x09, 0x02, 0x10, 0x64, 0x18, 0x41,
  0x10, 0x41, 0x0C, 0x41, 0x04, 0x21, 0x0C, 0x11, 0x86, 0x20, 0x44, 0x19,
  0x81, 0x30, 0x64, 0x04, 0x80, 0x90, 0x12, 0x02, 0xC0, 0x58, 0x0A, 0x01,
  0x40, 0x38, 0x05, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x0C,
  0x01, 0x86, 0x01, 0x81, 0x80, 0x80, 0xC0, 0xC0, 0x20, 0xC0, 0x18, 0xC0,
  0x04, 0x40, 0x02, 0x60, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x36, 0x00, 0x11, 0x00, 0x18, 0x80, 0x18, 0x60, 0x08, 0x10, 0x0C,
  0x0C, 0x0C, 0x02, 0x0C, 0x01, 0x84, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x80,
  0x18, 0x10, 0x03, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x02, 0x01, 0x80,
  0xC0, 0x10, 0x10, 0x02, 0x06, 0x00, 0x40, 0x80, 0x08, 0x30, 0x01, 0x84,
  0x00, 0x31, 0x80, 0x02, 0x20, 0x00, 0x4C, 0x00, 0x09, 0x00, 0x01, 0x60,
  0x00, 0x28, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x10, 0x07, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x70, 0x0E, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x01, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x04, 0x10, 0xC3, 0x0C,
  0x20, 0x82, 0x18, 0x61, 0x86, 0x10, 0x41, 0x0C, 0x30, 0xC2, 0x08, 0x21,
  0x86, 0x18, 0x61, 0x04, 0x10, 0xC3, 0x0C, 0x20, 0x80, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x70, 0x07, 0x00, 0xC0, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x10, 0x03, 0x00, 0xE0, 0x08, 0x00, 0x0E, 0x00, 0x4E, 0xE0, 0x12, 0x08,
  0x0D, 0x83, 0x02, 0x40, 0x61, 0x90, 0x0E, 0xCC, 0x01, 0xE0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 28, 7, 1, -28 },
  { 22, 7, 8, 10, 4, -29 },
  { 29, 19, 28, 19, 1, -28 },
  { 96, 17, 36, 18, 1, -32 },
  { 173, 18, 28, 24, 4, -28 },
  { 236, 17, 28, 20, 1, -28 },
  { 296, 3, 8, 6, 4, -29 },
  { 299, 11, 40, 11, 2, -31 },
  { 354, 11, 40, 11, -2, -31 },
  { 409, 15, 15, 16, 2, -28 },
  { 438, 16, 19, 19, 2, -22 },
  { 476, 4, 8, 7, -1, -3 },
  { 480, 8, 1, 10, 1, -13 },
  { 481, 3, 3, 9, 1, -3 },
  { 483, 17, 30, 13, -2, -28 },
  { 547, 15, 28, 18, 2, -28 },
  { 600, 9, 28, 18, 5, -28 },
  { 632, 16, 28, 18, 1, -28 },
  { 688, 16, 28, 18, 1, -28 },
  { 744, 16, 28, 18, 1, -28 },
  { 800, 17, 28, 18, 2, -28 },
  { 860, 14, 28, 18, 2, -28 },
  { 909, 16, 28, 18, 3, -28 },
  { 965, 17, 28, 18, 1, -28 },
  { 1025, 14, 28, 18, 3, -28 },
  { 1074, 6, 21, 7, 0, -21 },
  { 1090, 7, 26, 7, -1, -21 },
  { 1113, 14, 16, 17, 2, -21 },
  { 1141, 15, 8, 18, 2, -17 },
  { 1156, 15, 15, 17, 1, -20 },
  { 1185, 12, 28, 15, 3, -28 },
  { 1227, 27, 36, 30, 1, -27 },
  { 1349, 18, 28, 20, -1, -28 },
  { 1412, 18, 28, 20, 1, -28 },
  { 1475, 19, 28, 21, 2, -28 },
  { 1542, 19, 28, 22, 1, -28 },
  { 1609, 19, 28, 19, 1, -28 },
  { 1676, 19, 28, 19, 1, -28 },
  { 1743, 18, 28, 23, 3, -28 },
  { 1806, 22, 28, 23, 1, -28 },
  { 1883, 6, 28, 9, 2, -28 },
  { 1904, 17, 28, 18, 1, -28 },
  { 1964, 21, 28, 21, 1, -28 },
  { 2038, 13, 28, 17, 1, -28 },
  { 2084, 27, 28, 28, 1, -28 },
  { 2179, 22, 28, 23, 1, -28 },
  { 2256, 19, 28, 22, 2, -28 },
  { 2323, 19, 28, 20, 1, -28 },
  { 2390, 19, 33, 22, 2, -28 },
  { 2469, 19, 28, 21, 1, -28 },
  { 2536, 19, 28, 20, 1, -28 },
  { 2603, 17, 28, 20, 4, -28 },
  { 2663, 20, 28, 22, 2, -28 },
  { 2733, 19, 28, 20, 3, -28 },
  { 2800, 27, 28, 30, 4, -28 },
  { 2895, 22, 28, 20, -1, -28 },
  { 2972, 18, 28, 20, 4, -28 },
  { 3035, 20, 28, 20, 0, -28 },
  { 3105, 11, 38, 8, 0, -32 },
  { 3158, 6, 30, 13, 4, -28 },
  { 3181, 10, 38, 8, -2, -32 },
  { 3229, 11, 14, 14, 2, -28 },
  { 3249, 14, 1, 14, -2, 0 },
  { 3251, 5, 5, 10, 5, -29 },
  { 3255, 15, 21, 18, 1, -21 },
  { 3295, 15, 29, 18, 1, -29 },
  { 3350, 15, 21, 17, 1, -21 },
  { 3390, 17, 29, 18, 2, -29 },
  { 3452, 15, 21, 17, 1, -21 },
  { 3492, 12, 29, 11, 2, -29 },
  { 3536, 17, 29, 18, 0, -21 },
  { 3598, 15, 29, 18, 1, -29 },
  { 3653, 7, 28, 8, 1, -28 },
  { 3678, 13, 36, 8, -5, -28 },
  { 3737, 16, 29, 16, 1, -29 },
  { 3795, 7, 29, 8, 1, -29 },
  { 3821, 26, 21, 29, 1, -21 },
  { 3890, 15, 21, 18, 1, -21 },
  { 3930, 16, 21, 18, 1, -21 },
  { 3972, 16, 29, 18, 0, -21 },
  { 4030, 15, 29, 18, 2, -21 },
  { 4085, 11, 21, 11, 1, -21 },
  { 4114, 14, 21, 17, 1, -21 },
  { 4151, 9, 26, 11, 2, -26 },
  { 4181, 15, 21, 18, 2, -21 },
  { 4221, 15, 21, 16, 2, -21 },
  { 4261, 22, 21, 25, 3, -21 },
  { 4319, 17, 21, 16, -1, -21 },
  { 4364, 19, 29, 16, -2, -21 },
  { 4433, 16, 21, 16, 0, -21 },
  { 4475, 12, 38, 11, 1, -30 },
  { 4532, 6, 33, 8, 1, -28 },
  { 4557, 12, 38, 11, -2, -30 },
  { 4614, 18, 7, 23, 2, -15 },
};

const GFXfont RobotoCondensed_ExtraLightItalic39pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic39pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic39pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC39PT7B_H_
