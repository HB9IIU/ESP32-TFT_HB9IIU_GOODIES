#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC15PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x92, 0x02, 0x00, 0xFC, 0x0A, 0x0A, 0x12, 0x3F, 0x14,
  0x24, 0x24, 0xFE, 0x48, 0x48, 0x40, 0x00, 0xE4, 0x51, 0x81, 0x03, 0x02,
  0x0A, 0x28, 0xBC, 0x00, 0x71, 0x26, 0x54, 0xA6, 0x82, 0x05, 0x95, 0x4A,
  0x14, 0x30, 0x1C, 0x48, 0x91, 0x41, 0x06, 0x14, 0xA5, 0x85, 0x09, 0xE8,
  0x58, 0x12, 0x44, 0x88, 0x88, 0x88, 0x88, 0x88, 0x40, 0x21, 0x11, 0x11,
  0x11, 0x11, 0x12, 0x24, 0x80, 0x10, 0x8F, 0x88, 0x52, 0x40, 0x10, 0x42,
  0x08, 0xFC, 0x82, 0x08, 0x20, 0xE0, 0x60, 0x80, 0x02, 0x08, 0x10, 0x40,
  0x82, 0x04, 0x10, 0x20, 0x81, 0x04, 0x00, 0x39, 0x18, 0x61, 0x86, 0x18,
  0xA2, 0x8A, 0x46, 0x00, 0x74, 0x92, 0x52, 0x49, 0x00, 0x1C, 0x45, 0x08,
  0x10, 0x41, 0x02, 0x08, 0x20, 0x83, 0xF0, 0x1C, 0x45, 0x08, 0x10, 0x43,
  0x01, 0x02, 0x85, 0x09, 0xE0, 0x04, 0x18, 0x30, 0xA2, 0x44, 0x91, 0x7F,
  0x08, 0x10, 0x20, 0x3D, 0x04, 0x10, 0x70, 0x20, 0x82, 0x8A, 0x27, 0x00,
  0x19, 0x11, 0x0F, 0x46, 0x31, 0x8C, 0x5C, 0xFC, 0x10, 0x82, 0x10, 0x42,
  0x08, 0x41, 0x08, 0x00, 0x1C, 0x45, 0x0A, 0x12, 0x47, 0x11, 0x42, 0x85,
  0x09, 0xE0, 0x39, 0x18, 0x61, 0x86, 0x27, 0x82, 0x08, 0x4E, 0x00, 0x40,
  0x02, 0x20, 0x00, 0x02, 0x48, 0x09, 0xB1, 0x06, 0x08, 0xF8, 0x01, 0xF0,
  0x60, 0x40, 0xC2, 0x33, 0x00, 0x32, 0x62, 0x11, 0x10, 0x88, 0x00, 0x00,
  0x0F, 0x82, 0x08, 0x80, 0x93, 0x94, 0x92, 0x92, 0x64, 0x4C, 0x91, 0x92,
  0x53, 0xB1, 0x00, 0x20, 0x03, 0xC0, 0x08, 0x10, 0x50, 0xA2, 0x44, 0x91,
  0x3E, 0x43, 0x06, 0x08, 0x79, 0x14, 0x51, 0x87, 0xE8, 0x61, 0x86, 0x2F,
  0x00, 0x3C, 0x85, 0x0C, 0x08, 0x10, 0x20, 0x40, 0x85, 0x09, 0xE0, 0x78,
  0x89, 0x0A, 0x18, 0x30, 0x60, 0xC2, 0x85, 0x13, 0xC0, 0x7E, 0x81, 0x02,
  0x08, 0x1F, 0x20, 0x40, 0x81, 0x03, 0xE0, 0x7E, 0x81, 0x02, 0x08, 0x1F,
  0x20, 0x40, 0x81, 0x02, 0x00, 0x3C, 0x85, 0x0C, 0x08, 0x11, 0xE0, 0xC1,
  0x85, 0x09, 0xE0, 0x41, 0x41, 0x41, 0x42, 0x82, 0xFE, 0x82, 0x82, 0x82,
  0x84, 0x84, 0x55, 0x6A, 0xA8, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02,
  0x85, 0x11, 0xC0, 0x42, 0x89, 0x22, 0x8A, 0x1C, 0x24, 0x48, 0x89, 0x12,
  0x10, 0x42, 0x10, 0x88, 0x42, 0x10, 0x84, 0x3E, 0x40, 0x50, 0x26, 0x19,
  0x86, 0xA2, 0xA8, 0xAA, 0x4A, 0x52, 0x99, 0x26, 0x49, 0x10, 0x41, 0x41,
  0x61, 0x62, 0x92, 0x92, 0x8A, 0x8A, 0x8A, 0x84, 0x84, 0x3C, 0x85, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x85, 0x09, 0xE0, 0x7C, 0x85, 0x0A, 0x18, 0x5F,
  0x20, 0x40, 0x81, 0x02, 0x00, 0x3C, 0x85, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x85, 0x09, 0xE0, 0x40, 0x80, 0x3E, 0x21, 0x21, 0x21, 0x42, 0x7C, 0x44,
  0x44, 0x44, 0x44, 0x82, 0x1E, 0x22, 0x41, 0x40, 0x20, 0x18, 0x04, 0x02,
  0x82, 0x84, 0x78, 0xFE, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x80, 0x42, 0x85, 0x0C, 0x18, 0x30, 0x61, 0x42, 0x85, 0x09, 0xE0, 0x83,
  0x06, 0x12, 0x24, 0x49, 0x12, 0x28, 0x50, 0xC0, 0x80, 0x84, 0x30, 0x86,
  0x31, 0x46, 0x25, 0x28, 0xA5, 0x14, 0xA3, 0x18, 0x63, 0x08, 0x41, 0x08,
  0x00, 0x21, 0x22, 0x22, 0x14, 0x18, 0x10, 0x18, 0x28, 0x44, 0x44, 0x82,
  0x82, 0x85, 0x12, 0x42, 0x86, 0x08, 0x10, 0x20, 0x40, 0x80, 0x3F, 0x02,
  0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0xFC, 0x32, 0x22, 0x44,
  0x44, 0x44, 0x88, 0x8C, 0xAA, 0xAA, 0x95, 0x31, 0x11, 0x11, 0x22, 0x22,
  0x22, 0x4C, 0x26, 0x59, 0x90, 0xF8, 0x90, 0x39, 0x10, 0x5F, 0x86, 0x18,
  0x9E, 0x20, 0x82, 0x10, 0x7D, 0x14, 0x51, 0x46, 0x18, 0x7E, 0x39, 0x14,
  0x60, 0x82, 0x18, 0x9C, 0x04, 0x10, 0x41, 0x76, 0x28, 0xA2, 0x8A, 0x29,
  0x3A, 0x39, 0x14, 0x5F, 0x82, 0x08, 0x1E, 0x34, 0x44, 0xE4, 0x48, 0x88,
  0x88, 0x3A, 0x89, 0x12, 0x28, 0x50, 0xA2, 0x3C, 0x08, 0x11, 0xC0, 0x20,
  0x82, 0x10, 0x5D, 0x94, 0x51, 0x45, 0x18, 0x62, 0x20, 0x24, 0x92, 0x52,
  0x00, 0x08, 0x00, 0x21, 0x08, 0x42, 0x11, 0x08, 0x42, 0x60, 0x20, 0x82,
  0x10, 0x45, 0x25, 0x18, 0x51, 0x48, 0xA2, 0x24, 0x94, 0x92, 0x4A, 0x40,
  0x5D, 0xD9, 0x94, 0x45, 0x11, 0x44, 0x61, 0x18, 0x46, 0x21, 0x5D, 0x94,
  0x51, 0x45, 0x18, 0x62, 0x7C, 0x63, 0x18, 0xC6, 0x3E, 0x7D, 0x14, 0x51,
  0x46, 0x18, 0x7E, 0x82, 0x08, 0x00, 0x76, 0x28, 0xA2, 0x8A, 0x29, 0x3C,
  0x10, 0x41, 0x00, 0x5B, 0x10, 0x84, 0x22, 0x10, 0x39, 0x14, 0x08, 0x18,
  0x28, 0x9C, 0x4B, 0xA9, 0x24, 0x98, 0x86, 0x28, 0xA2, 0x8A, 0x29, 0x3C,
  0x8C, 0x65, 0x2A, 0x31, 0x08, 0x88, 0xCC, 0xA6, 0x55, 0x4A, 0xA6, 0x51,
  0x10, 0x08, 0x44, 0xA2, 0x84, 0x31, 0x44, 0xA2, 0x22, 0x44, 0x91, 0x22,
  0x83, 0x04, 0x08, 0x10, 0x43, 0x00, 0x7C, 0x20, 0x84, 0x21, 0x04, 0x3E,
  0x08, 0x84, 0x42, 0x10, 0x88, 0x42, 0x10, 0x84, 0x20, 0x80, 0x24, 0xA4,
  0x92, 0x4A, 0x48, 0x20, 0x84, 0x21, 0x08, 0x41, 0x11, 0x08, 0x42, 0x22,
  0x00, 0x63, 0x26, 0x30,
};

const GFXglyph RobotoCondensed_ExtraLightItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 11, 3, 0, -11 },
  { 6, 2, 3, 4, 2, -11 },
  { 7, 8, 11, 7, 0, -11 },
  { 18, 6, 13, 7, 1, -12 },
  { 28, 7, 11, 9, 1, -11 },
  { 38, 7, 11, 8, 0, -11 },
  { 48, 2, 3, 2, 1, -11 },
  { 49, 4, 15, 4, 1, -12 },
  { 57, 4, 15, 4, -1, -12 },
  { 65, 6, 6, 6, 1, -11 },
  { 70, 6, 9, 7, 1, -10 },
  { 77, 1, 3, 3, 0, -1 },
  { 78, 3, 1, 4, 0, -6 },
  { 79, 1, 1, 3, 0, -1 },
  { 80, 7, 12, 5, -1, -11 },
  { 91, 6, 11, 7, 1, -11 },
  { 100, 3, 11, 7, 2, -11 },
  { 105, 7, 11, 7, 0, -11 },
  { 115, 7, 11, 7, 0, -11 },
  { 125, 7, 11, 7, 0, -11 },
  { 135, 6, 11, 7, 1, -11 },
  { 144, 5, 11, 7, 1, -11 },
  { 151, 6, 11, 7, 1, -11 },
  { 160, 7, 11, 7, 0, -11 },
  { 170, 6, 11, 7, 1, -11 },
  { 179, 2, 8, 3, 0, -8 },
  { 181, 3, 10, 3, -1, -8 },
  { 185, 5, 6, 7, 1, -8 },
  { 189, 5, 4, 7, 1, -7 },
  { 192, 6, 6, 7, 0, -8 },
  { 197, 5, 11, 6, 1, -11 },
  { 204, 11, 13, 12, 0, -10 },
  { 222, 7, 11, 8, 0, -11 },
  { 232, 6, 11, 8, 1, -11 },
  { 241, 7, 11, 8, 1, -11 },
  { 251, 7, 11, 8, 1, -11 },
  { 261, 7, 11, 7, 1, -11 },
  { 271, 7, 11, 7, 1, -11 },
  { 281, 7, 11, 9, 1, -11 },
  { 291, 8, 11, 9, 1, -11 },
  { 302, 2, 11, 4, 1, -11 },
  { 305, 7, 11, 7, 0, -11 },
  { 315, 7, 11, 8, 1, -11 },
  { 325, 5, 11, 7, 1, -11 },
  { 332, 10, 11, 11, 1, -11 },
  { 346, 8, 11, 9, 1, -11 },
  { 357, 7, 11, 9, 1, -11 },
  { 367, 7, 11, 8, 1, -11 },
  { 377, 7, 13, 9, 1, -11 },
  { 389, 8, 11, 8, 0, -11 },
  { 400, 8, 11, 8, 0, -11 },
  { 411, 7, 11, 8, 1, -11 },
  { 421, 7, 11, 8, 1, -11 },
  { 431, 7, 11, 8, 1, -11 },
  { 441, 11, 11, 11, 1, -11 },
  { 457, 8, 11, 8, 0, -11 },
  { 468, 7, 11, 8, 1, -11 },
  { 478, 8, 11, 8, 0, -11 },
  { 489, 4, 14, 3, 0, -12 },
  { 496, 2, 12, 5, 2, -11 },
  { 499, 4, 14, 3, -1, -12 },
  { 506, 4, 5, 5, 1, -11 },
  { 509, 6, 1, 5, -1, 0 },
  { 510, 2, 2, 4, 2, -11 },
  { 511, 6, 8, 7, 0, -8 },
  { 517, 6, 12, 7, 0, -12 },
  { 526, 6, 8, 7, 0, -8 },
  { 532, 6, 12, 7, 1, -12 },
  { 541, 6, 8, 7, 0, -8 },
  { 547, 4, 12, 4, 1, -12 },
  { 553, 7, 11, 7, 0, -8 },
  { 563, 6, 12, 7, 0, -12 },
  { 572, 3, 11, 3, 0, -11 },
  { 577, 5, 14, 3, -2, -11 },
  { 586, 6, 12, 6, 0, -12 },
  { 595, 3, 12, 3, 0, -12 },
  { 600, 10, 8, 11, 0, -8 },
  { 610, 6, 8, 7, 0, -8 },
  { 616, 5, 8, 7, 1, -8 },
  { 621, 6, 11, 7, 0, -8 },
  { 630, 6, 11, 7, 1, -8 },
  { 639, 5, 8, 4, 0, -8 },
  { 644, 6, 8, 6, 0, -8 },
  { 650, 3, 10, 4, 1, -10 },
  { 654, 6, 8, 7, 1, -8 },
  { 660, 5, 8, 6, 1, -8 },
  { 665, 9, 8, 10, 1, -8 },
  { 674, 6, 8, 6, 0, -8 },
  { 680, 7, 11, 6, -1, -8 },
  { 690, 6, 8, 6, 0, -8 },
  { 696, 5, 15, 4, 0, -12 },
  { 706, 3, 13, 3, 0, -11 },
  { 711, 5, 15, 4, -1, -12 },
  { 721, 7, 3, 9, 1, -6 },
};

const GFXfont RobotoCondensed_ExtraLightItalic15pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic15pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC15PT7B_H_
