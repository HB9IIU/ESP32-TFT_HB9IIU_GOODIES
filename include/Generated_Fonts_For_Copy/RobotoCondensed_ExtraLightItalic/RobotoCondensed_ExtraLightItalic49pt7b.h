#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC49PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30,
  0x30, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xC0,
  0x31, 0x98, 0xC8, 0x4C, 0x66, 0x33, 0x19, 0x8C, 0x84, 0x42, 0x63, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x02, 0x03, 0x00, 0x03, 0x01, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x40, 0x00, 0x60, 0x60, 0x00, 0x20,
  0x30, 0x00, 0x30, 0x10, 0x00, 0x18, 0x18, 0x03, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xE0, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x01, 0x00, 0x01,
  0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x40, 0x40, 0x00, 0x60, 0x60, 0x00,
  0x30, 0x30, 0x00, 0x10, 0x10, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00,
  0x04, 0x06, 0x00, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x01, 0x01, 0x80,
  0x01, 0x80, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x60, 0x20,
  0x00, 0x30, 0x30, 0x00, 0x10, 0x18, 0x00, 0x18, 0x08, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x1C, 0x0C, 0x03, 0x00,
  0x60, 0x60, 0x06, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x80,
  0x03, 0x18, 0x00, 0x31, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x8C, 0x00, 0x08, 0xC0, 0x01,
  0x8C, 0x00, 0x18, 0xC0, 0x03, 0x06, 0x00, 0x30, 0x60, 0x06, 0x03, 0x81,
  0xC0, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x40, 0x60, 0x13, 0x01, 0x80, 0x4C, 0x06, 0x03, 0x20,
  0x18, 0x18, 0x80, 0x60, 0xC2, 0x01, 0x82, 0x08, 0x04, 0x18, 0x20, 0x30,
  0xC0, 0xC0, 0x82, 0x03, 0x06, 0x18, 0x07, 0xF0, 0xC0, 0x0F, 0x86, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x7C, 0x00,
  0xC3, 0xF8, 0x06, 0x18, 0x20, 0x30, 0xC0, 0xC0, 0xC3, 0x01, 0x06, 0x08,
  0x04, 0x30, 0x60, 0x10, 0x81, 0x80, 0x46, 0x06, 0x03, 0x30, 0x10, 0x0C,
  0x80, 0x40, 0x36, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x08, 0x30, 0x00,
  0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0x0E,
  0x0C, 0x00, 0x30, 0x30, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x10, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x18, 0x00,
  0x40, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x70, 0x00, 0x0F, 0x80, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x73, 0x00, 0x03, 0x8C, 0x00,
  0x0C, 0x18, 0x0C, 0x60, 0x60, 0x33, 0x00, 0xC0, 0xCC, 0x01, 0x82, 0x60,
  0x06, 0x19, 0x80, 0x0C, 0x66, 0x00, 0x33, 0x18, 0x00, 0x6C, 0x60, 0x01,
  0xE1, 0x80, 0x03, 0x06, 0x00, 0x1E, 0x1C, 0x00, 0xF8, 0x38, 0x06, 0x30,
  0x78, 0x70, 0xC0, 0xFF, 0x81, 0x80, 0x20, 0x00, 0x2D, 0xB6, 0x96, 0xD8,
  0x00, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x10,
  0x17, 0x82, 0x1F, 0x3E, 0xDF, 0x00, 0xFF, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x36, 0x00, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0xC0, 0xC0, 0x30, 0x18,
  0x0E, 0x01, 0x80, 0x80, 0x20, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x0C,
  0x30, 0xC6, 0x18, 0x63, 0x0C, 0x61, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x0F, 0xF8, 0x01, 0xC1, 0xC0, 0x30, 0x0E, 0x06, 0x00, 0x60,
  0x60, 0x06, 0x0C, 0x00, 0x20, 0xC0, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03,
  0x18, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x02, 0x30, 0x00,
  0x63, 0x00, 0x06, 0x20, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00,
  0x04, 0x60, 0x00, 0xC4, 0x00, 0x0C, 0x40, 0x00, 0xCC, 0x00, 0x0C, 0xC0,
  0x00, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x84, 0x00, 0x30, 0x60, 0x03, 0x06,
  0x00, 0x60, 0x60, 0x06, 0x03, 0x00, 0xC0, 0x38, 0x18, 0x01, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x40, 0xF0, 0xFD, 0xF3, 0xE0, 0xE0, 0x20, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02,
  0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x00,
  0x3F, 0x00, 0x0F, 0xFC, 0x01, 0xC0, 0xE0, 0x30, 0x06, 0x07, 0x00, 0x30,
  0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x31, 0x80, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xFE, 0x00, 0x70, 0x38, 0x07,
  0x00, 0xE0, 0x30, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0x41, 0x80, 0x03,
  0x0C, 0x00, 0x18, 0x60, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x62, 0x00, 0x02, 0x10,
  0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0xC0, 0x06,
  0x06, 0x00, 0x60, 0x1C, 0x0E, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0x60,
  0x00, 0x36, 0x00, 0x06, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x40, 0x01, 0x8C,
  0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x0C, 0x00, 0xC0,
  0x80, 0x18, 0x18, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0,
  0x10, 0x18, 0x03, 0x01, 0x80, 0x30, 0x30, 0x03, 0x06, 0x00, 0x30, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x7C, 0x00, 0x7F, 0xF8, 0x03, 0xC0, 0xE0, 0x18, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x86, 0x00, 0x0C, 0x30,
  0x00, 0x61, 0x80, 0x02, 0x0C, 0x00, 0x30, 0x20, 0x01, 0x81, 0x80, 0x18,
  0x0C, 0x01, 0x80, 0x38, 0x1C, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x07, 0xF0, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0xFC, 0x0C, 0x7F, 0xC3, 0x70, 0x38, 0xF0, 0x06, 0x38,
  0x01, 0xDC, 0x00, 0x37, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00,
  0x34, 0x00, 0x0D, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x34, 0x00, 0x19,
  0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0xC7, 0x00, 0x70, 0xC0, 0x18, 0x18,
  0x1C, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x03, 0xFE, 0x00, 0x38, 0x18, 0x03, 0x00, 0x60, 0x30, 0x03, 0x83,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0xC3, 0x00, 0x06, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x03, 0x00, 0x30, 0x18,
  0x03, 0x00, 0x70, 0x30, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xC1, 0xC0,
  0x18, 0x03, 0x01, 0x80, 0x0C, 0x18, 0x00, 0x61, 0x80, 0x01, 0x8C, 0x00,
  0x0C, 0x60, 0x00, 0x62, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x01, 0x8C,
  0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x06, 0x00, 0x60, 0x38, 0x0E,
  0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xE0,
  0x70, 0x70, 0x0C, 0x18, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06,
  0x60, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x01, 0xA0,
  0x00, 0x68, 0x00, 0x1A, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0xEC, 0x00,
  0x73, 0x00, 0x3C, 0x60, 0x1F, 0x1C, 0x0E, 0xC3, 0xFE, 0x20, 0x3F, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x80, 0x3F, 0x80, 0x0F, 0x80,
  0x00, 0x0E, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xE1, 0x80,
  0x01, 0xC0, 0x70, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x06, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x08, 0x3F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF3, 0xFF, 0xFC, 0x08, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x70, 0x71, 0xC0, 0x63,
  0x00, 0x6C, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0xC0, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x00, 0xC1, 0x80, 0x1F, 0x00, 0x61, 0x80, 0x3F, 0xC0, 0x10,
  0xC0, 0x38, 0x30, 0x08, 0xC0, 0x30, 0x08, 0x04, 0x60, 0x10, 0x0C, 0x02,
  0x60, 0x18, 0x06, 0x01, 0x30, 0x18, 0x03, 0x00, 0x90, 0x0C, 0x01, 0x00,
  0x58, 0x0C, 0x01, 0x80, 0x2C, 0x06, 0x00, 0xC0, 0x34, 0x03, 0x00, 0x60,
  0x1A, 0x03, 0x00, 0x20, 0x0F, 0x01, 0x80, 0x10, 0x05, 0x80, 0xC0, 0x18,
  0x02, 0xC0, 0x40, 0x0C, 0x03, 0x60, 0x20, 0x04, 0x01, 0xA0, 0x30, 0x06,
  0x00, 0x90, 0x18, 0x03, 0x00, 0xC8, 0x0C, 0x03, 0x80, 0x64, 0x06, 0x01,
  0xC0, 0x62, 0x03, 0x01, 0xE0, 0x31, 0x00, 0xC1, 0x90, 0x30, 0xC0, 0x71,
  0x8C, 0x70, 0x60, 0x1F, 0x83, 0xF0, 0x30, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x18, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x98,
  0x00, 0x03, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x18, 0x40, 0x00, 0x60, 0xC0,
  0x00, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x18, 0x0C, 0x00,
  0x30, 0x08, 0x00, 0xC0, 0x10, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0x80, 0x06, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0x61, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x02,
  0x60, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x60, 0x07, 0x01, 0x80, 0x0E, 0x06, 0x00, 0x18, 0x18,
  0x00, 0x20, 0x40, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x20, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x08, 0x00, 0x38, 0x60, 0x00, 0xC1,
  0x80, 0x06, 0x06, 0x00, 0x70, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0x00,
  0x1C, 0x0C, 0x00, 0x38, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x03,
  0x0C, 0x00, 0x0C, 0x20, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18,
  0x00, 0x08, 0x60, 0x00, 0x61, 0x80, 0x03, 0x8C, 0x00, 0x0C, 0x30, 0x00,
  0x60, 0xC0, 0x07, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0xE0, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x60, 0x00,
  0xC1, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x06,
  0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x31, 0x80, 0x00,
  0x63, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x18,
  0x18, 0x00, 0x70, 0x18, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x06, 0x00, 0x70,
  0x06, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x02,
  0x0C, 0x00, 0x02, 0x08, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x10, 0x00, 0x04,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x08, 0x20, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0xC0,
  0xC0, 0x03, 0x80, 0xC0, 0x0F, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x38, 0x03, 0x80, 0x0C, 0x07, 0x00,
  0x0E, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x00,
  0x02, 0x18, 0x00, 0x02, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x0F, 0xFC, 0x60, 0x0F, 0xFC, 0x60, 0x00,
  0x0C, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x30, 0x60, 0x00,
  0x30, 0x60, 0x00, 0x30, 0x30, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x1C, 0x03,
  0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C,
  0x0C, 0x00, 0x01, 0x81, 0x00, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x0C, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x10, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x18, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x40, 0x00, 0x08, 0x18,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x30, 0x20, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x10,
  0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x60, 0x00, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60,
  0x60, 0x60, 0x60, 0x40, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x86, 0x00,
  0x0C, 0x30, 0x00, 0x61, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x81,
  0x80, 0x18, 0x0C, 0x01, 0x80, 0x30, 0x18, 0x01, 0xFF, 0x80, 0x03, 0xF0,
  0x00, 0x02, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x18,
  0x00, 0x30, 0x06, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0x30, 0x30, 0x00, 0x08, 0x18, 0x00, 0x06, 0x0E, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x19, 0xE0, 0x00, 0x06, 0xF8, 0x00, 0x01,
  0x63, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x06, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x06, 0x00, 0x18, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x18,
  0x00, 0x70, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xA0, 0x78, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0xD8, 0x12, 0x00, 0x00, 0x6C, 0x19, 0x00,
  0x00, 0x66, 0x0C, 0xC0, 0x00, 0x32, 0x06, 0x60, 0x00, 0x33, 0x03, 0x30,
  0x00, 0x19, 0x81, 0x98, 0x00, 0x18, 0xC0, 0x84, 0x00, 0x0C, 0x60, 0xC3,
  0x00, 0x0C, 0x30, 0x61, 0x80, 0x06, 0x10, 0x30, 0xC0, 0x06, 0x18, 0x18,
  0x60, 0x03, 0x0C, 0x0C, 0x30, 0x03, 0x06, 0x04, 0x08, 0x01, 0x83, 0x06,
  0x06, 0x01, 0x81, 0x83, 0x03, 0x00, 0xC0, 0x81, 0x81, 0x80, 0xC0, 0xC0,
  0xC0, 0xC0, 0x60, 0x60, 0x60, 0x20, 0x60, 0x30, 0x20, 0x10, 0x20, 0x18,
  0x30, 0x0C, 0x30, 0x0C, 0x18, 0x06, 0x10, 0x0C, 0x0C, 0x03, 0x18, 0x06,
  0x06, 0x01, 0x88, 0x03, 0x03, 0x00, 0x4C, 0x01, 0x83, 0x00, 0x2C, 0x00,
  0xC1, 0x80, 0x1E, 0x00, 0x40, 0xC0, 0x0E, 0x00, 0x60, 0x60, 0x07, 0x00,
  0x30, 0x30, 0x01, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x0C, 0x1C, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x60, 0x78, 0x00, 0x0C, 0x0D,
  0x80, 0x01, 0x81, 0xB0, 0x00, 0x30, 0x62, 0x00, 0x04, 0x0C, 0x60, 0x01,
  0x81, 0x8C, 0x00, 0x30, 0x30, 0xC0, 0x06, 0x06, 0x18, 0x00, 0xC0, 0xC3,
  0x00, 0x18, 0x30, 0x30, 0x02, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x40, 0x18,
  0x18, 0x0C, 0x03, 0x03, 0x01, 0x80, 0x60, 0x40, 0x18, 0x0C, 0x18, 0x03,
  0x03, 0x03, 0x00, 0x60, 0x60, 0x60, 0x06, 0x0C, 0x0C, 0x00, 0xC1, 0x81,
  0x80, 0x08, 0x30, 0x20, 0x01, 0x86, 0x0C, 0x00, 0x31, 0x81, 0x80, 0x03,
  0x30, 0x30, 0x00, 0x66, 0x06, 0x00, 0x0C, 0xC0, 0xC0, 0x00, 0xD8, 0x30,
  0x00, 0x1B, 0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07,
  0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x60, 0x00, 0xC1, 0xC0, 0x01, 0x83, 0x00,
  0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00,
  0x19, 0x80, 0x00, 0x32, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01,
  0xB0, 0x00, 0x03, 0x60, 0x00, 0x04, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x02, 0x60,
  0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0xC6, 0x00,
  0x01, 0x8C, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x30, 0x18, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x18, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x60, 0x00,
  0xC0, 0xC0, 0x00, 0xC1, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0x80, 0x00, 0xC3,
  0x00, 0x01, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x30,
  0x01, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0x00, 0xE0,
  0x18, 0x00, 0xC0, 0x60, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x01, 0x8C,
  0x00, 0x03, 0x18, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80,
  0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0x60, 0x00, 0x04, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x23, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C,
  0x00, 0x06, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x18, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x18, 0x00, 0xE0, 0x30, 0x00,
  0xE0, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0x81, 0x00, 0x01, 0x86, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x21,
  0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x18,
  0x00, 0x70, 0x20, 0x01, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x10, 0x01, 0x80, 0x60, 0x03,
  0x00, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x0C,
  0x08, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61,
  0x80, 0x00, 0xC3, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0xE0, 0x38, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x30, 0x60, 0x00, 0x70,
  0x60, 0x00, 0x60, 0x30, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x0F, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x08, 0x00, 0x02, 0x18, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x10, 0x00,
  0x04, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x60, 0x00, 0x18, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x10, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x60, 0x01,
  0xC0, 0x70, 0x03, 0x80, 0x38, 0x0F, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x00, 0x00,
  0x66, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x18,
  0x20, 0x00, 0x30, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x08, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x04, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0xC0, 0x01, 0x01, 0x80, 0x02, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0x44, 0x00,
  0x00, 0x98, 0x00, 0x01, 0xA0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x6C, 0x00, 0x1C, 0x00, 0x1B, 0x00, 0x07, 0x00, 0x04, 0xC0,
  0x03, 0x40, 0x03, 0x30, 0x00, 0x90, 0x00, 0xCC, 0x00, 0x64, 0x00, 0x63,
  0x00, 0x19, 0x00, 0x18, 0xC0, 0x04, 0x40, 0x06, 0x30, 0x03, 0x18, 0x03,
  0x0C, 0x00, 0x86, 0x00, 0xC1, 0x00, 0x61, 0x80, 0x30, 0x40, 0x18, 0x60,
  0x18, 0x10, 0x04, 0x18, 0x06, 0x06, 0x03, 0x06, 0x01, 0x01, 0x80, 0x81,
  0x80, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x18, 0x18, 0x08, 0x18, 0x06, 0x04,
  0x02, 0x06, 0x01, 0x83, 0x00, 0x81, 0x80, 0x60, 0x80, 0x20, 0xC0, 0x18,
  0x60, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x08, 0x01, 0x84, 0x00, 0xC6, 0x00,
  0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x40, 0x06, 0x60, 0x03, 0x30,
  0x01, 0x98, 0x00, 0xCC, 0x00, 0x24, 0x00, 0x36, 0x00, 0x0B, 0x00, 0x05,
  0x80, 0x02, 0xC0, 0x01, 0x60, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xC0, 0x1C, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x60, 0x06, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0x30, 0x06,
  0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x18, 0x01,
  0x80, 0x01, 0x80, 0x30, 0x00, 0x18, 0x07, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x98, 0x00,
  0x0C, 0x60, 0x00, 0x71, 0x80, 0x01, 0x83, 0x00, 0x0C, 0x0C, 0x00, 0x70,
  0x30, 0x01, 0x80, 0x40, 0x0C, 0x01, 0x80, 0x70, 0x06, 0x01, 0x80, 0x18,
  0x0C, 0x00, 0x30, 0x30, 0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x06, 0x30,
  0x00, 0x19, 0x80, 0x00, 0x6C, 0x00, 0x00, 0xB0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xC1, 0x83, 0x02, 0x04,
  0x0C, 0x18, 0x30, 0x60, 0xC0, 0x81, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x20,
  0x40, 0xC1, 0x83, 0x06, 0x0C, 0x08, 0x10, 0x30, 0x60, 0xC1, 0x83, 0x02,
  0x04, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x7E, 0x03, 0xF0, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x02, 0x80, 0x36, 0x01, 0x30, 0x19, 0x80, 0x84,
  0x0C, 0x20, 0x41, 0x86, 0x0C, 0x60, 0x63, 0x03, 0x30, 0x09, 0x80, 0x58,
  0x03, 0xC0, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x61, 0xC3, 0x06, 0x18,
  0x30, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x1C, 0x06, 0x07, 0x00, 0x60, 0xC0,
  0x0C, 0x30, 0x00, 0x86, 0x00, 0x10, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0x38, 0x03, 0x0C, 0x00,
  0x63, 0x00, 0x0C, 0x60, 0x01, 0x98, 0x00, 0x33, 0x00, 0x04, 0x60, 0x01,
  0x8C, 0x00, 0x71, 0x80, 0x1E, 0x30, 0x06, 0xC3, 0x01, 0x98, 0x3F, 0xE3,
  0x03, 0xF0, 0x60, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x43, 0xF0, 0x0C, 0xFF, 0x80,
  0xDC, 0x0C, 0x0F, 0x00, 0x60, 0xE0, 0x06, 0x0C, 0x00, 0x21, 0x80, 0x03,
  0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31, 0x80, 0x02, 0x10, 0x00,
  0x63, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00,
  0x04, 0x20, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x18, 0x70,
  0x03, 0x87, 0x00, 0x30, 0x4C, 0x0E, 0x0C, 0x7F, 0xC0, 0xC3, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0x80, 0xE0, 0x30, 0x70, 0x06, 0x18, 0x01, 0x8C,
  0x00, 0x33, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x06, 0x30,
  0x01, 0x86, 0x00, 0xC1, 0xC0, 0x60, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x03, 0xF0, 0xC0, 0x3F, 0xE6, 0x07, 0x01, 0xB0,
  0x30, 0x05, 0x83, 0x00, 0x1C, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00,
  0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x00, 0x02, 0x18,
  0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x02,
  0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0,
  0x07, 0x03, 0x00, 0x70, 0x1C, 0x0F, 0x80, 0x7F, 0xCC, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x1C, 0x06, 0x03, 0x00, 0x60, 0xC0,
  0x0C, 0x30, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x64, 0x00,
  0x0D, 0x80, 0x01, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xC0, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC1, 0xC0, 0x70, 0x1F, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x07, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x07, 0xFE, 0x1F, 0xFC, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x7E, 0x08, 0x07, 0xFC, 0xC0, 0xE0, 0x36, 0x06,
  0x00, 0xB0, 0x60, 0x03, 0x86, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06,
  0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x20, 0x00, 0x41, 0x00,
  0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61,
  0x80, 0x02, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00,
  0xE0, 0x60, 0x0F, 0x03, 0x81, 0xD0, 0x0F, 0xF9, 0x80, 0x1F, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x08, 0x00, 0xC0, 0x60, 0x0E, 0x03, 0x80, 0xE0, 0x07, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x0F, 0x80, 0xC7, 0xF8, 0x19, 0x81, 0x83,
  0x60, 0x30, 0x78, 0x03, 0x0E, 0x00, 0x61, 0x80, 0x0C, 0x70, 0x01, 0x8C,
  0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC4, 0x00, 0x11, 0x80, 0x06, 0x30,
  0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x62, 0x00, 0x08, 0xC0,
  0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x00,
  0x04, 0x60, 0x01, 0x8C, 0x00, 0x30, 0x03, 0x01, 0xC0, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x06, 0x0C, 0x00,
  0xC0, 0xC0, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x08, 0x0C, 0x00, 0x81,
  0x80, 0x18, 0x30, 0x01, 0x86, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x13,
  0x80, 0x03, 0x78, 0x00, 0x3C, 0xC0, 0x03, 0x8C, 0x00, 0x30, 0x60, 0x03,
  0x06, 0x00, 0x20, 0x30, 0x06, 0x03, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x0C, 0x06, 0x00, 0xC0, 0x40, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x03,
  0x00, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x00, 0x0C, 0x3F, 0x00, 0xFC, 0x06,
  0x3F, 0xC1, 0xFF, 0x03, 0x70, 0x31, 0xC0, 0xC1, 0xA0, 0x19, 0x80, 0x60,
  0xE0, 0x06, 0x80, 0x18, 0xF0, 0x03, 0xC0, 0x0C, 0x70, 0x01, 0xC0, 0x06,
  0x38, 0x00, 0xC0, 0x03, 0x18, 0x00, 0x60, 0x01, 0x8C, 0x00, 0x30, 0x00,
  0xC4, 0x00, 0x10, 0x00, 0x66, 0x00, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x00,
  0x31, 0x80, 0x06, 0x00, 0x18, 0xC0, 0x03, 0x00, 0x0C, 0x60, 0x01, 0x80,
  0x06, 0x20, 0x00, 0x80, 0x03, 0x30, 0x00, 0xC0, 0x03, 0x18, 0x00, 0x60,
  0x01, 0x8C, 0x00, 0x30, 0x00, 0xC6, 0x00, 0x18, 0x00, 0x63, 0x00, 0x0C,
  0x00, 0x31, 0x00, 0x04, 0x00, 0x11, 0x80, 0x06, 0x00, 0x18, 0xC0, 0x03,
  0x00, 0x0C, 0x60, 0x01, 0x80, 0x06, 0x00, 0x04, 0x1F, 0x01, 0x8F, 0xF0,
  0x33, 0x03, 0x06, 0xC0, 0x60, 0xF0, 0x06, 0x1C, 0x00, 0xC3, 0x00, 0x18,
  0xE0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x88, 0x00, 0x23,
  0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC4,
  0x00, 0x11, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18,
  0x00, 0x62, 0x00, 0x08, 0xC0, 0x03, 0x18, 0x00, 0x60, 0x00, 0xFC, 0x00,
  0x7F, 0xE0, 0x1C, 0x0E, 0x06, 0x00, 0xE1, 0x80, 0x0C, 0x30, 0x01, 0x8C,
  0x00, 0x11, 0x80, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xA0,
  0x00, 0x3C, 0x00, 0x05, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0,
  0x00, 0xD8, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x30, 0xC0,
  0x0C, 0x18, 0x03, 0x81, 0x80, 0xE0, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0x01,
  0x0F, 0xC0, 0x0C, 0xFF, 0x80, 0x36, 0x03, 0x00, 0xF0, 0x06, 0x03, 0x80,
  0x18, 0x0C, 0x00, 0x20, 0x60, 0x00, 0x81, 0x80, 0x03, 0x06, 0x00, 0x0C,
  0x18, 0x00, 0x30, 0x60, 0x00, 0x81, 0x00, 0x02, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x10, 0x20, 0x00,
  0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x70, 0x03, 0x81,
  0xC0, 0x0C, 0x04, 0xC0, 0xE0, 0x31, 0xFF, 0x00, 0xC3, 0xF0, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xF8, 0x20, 0x7F, 0xCC, 0x38, 0x0D, 0x86, 0x00, 0xB1,
  0x80, 0x0E, 0x60, 0x01, 0x8C, 0x00, 0x11, 0x80, 0x06, 0x60, 0x00, 0xCC,
  0x00, 0x19, 0x80, 0x03, 0x20, 0x00, 0x4C, 0x00, 0x19, 0x80, 0x03, 0x30,
  0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x23, 0x00, 0x0C, 0x60,
  0x01, 0x8C, 0x00, 0x31, 0x80, 0x0E, 0x18, 0x03, 0xC3, 0x81, 0xD0, 0x3F,
  0xF6, 0x01, 0xF8, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x04, 0x3C, 0x33, 0xF0, 0xDC, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x70, 0x38, 0x30, 0x06, 0x18,
  0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x33, 0x00, 0x0C, 0xC0,
  0x03, 0x30, 0x01, 0x86, 0x00, 0xE1, 0xC0, 0x70, 0x3F, 0xF8, 0x03, 0xF8,
  0x00, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0xFF,
  0xC6, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00,
  0xC0, 0x30, 0x06, 0x01, 0xF0, 0x3C, 0x00, 0x18, 0x00, 0x63, 0x00, 0x0C,
  0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x20, 0x00, 0x8C, 0x00, 0x31,
  0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x02, 0x10, 0x00, 0xC6,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x08,
  0x00, 0x61, 0x00, 0x0C, 0x20, 0x01, 0x84, 0x00, 0x70, 0xC0, 0x1C, 0x18,
  0x06, 0x81, 0x81, 0xB0, 0x3F, 0xE6, 0x01, 0xF0, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x6C, 0x00, 0x19, 0x00, 0x0C, 0x60, 0x03, 0x18, 0x01, 0x86, 0x00,
  0x61, 0x80, 0x30, 0x60, 0x0C, 0x08, 0x02, 0x02, 0x01, 0x80, 0xC0, 0x40,
  0x30, 0x30, 0x0C, 0x08, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x10, 0xC0, 0x06,
  0x30, 0x01, 0x98, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0xA0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x78,
  0x01, 0x80, 0x0F, 0x00, 0x38, 0x03, 0x60, 0x0F, 0x00, 0x6C, 0x01, 0x60,
  0x19, 0x80, 0x6C, 0x03, 0x30, 0x0D, 0x80, 0x66, 0x03, 0x30, 0x18, 0xC0,
  0x66, 0x03, 0x18, 0x08, 0xC0, 0xC1, 0x03, 0x08, 0x18, 0x20, 0x41, 0x03,
  0x04, 0x18, 0x20, 0xC0, 0xC3, 0x04, 0x18, 0x18, 0xC0, 0xC6, 0x03, 0x18,
  0x18, 0xC0, 0x62, 0x03, 0x18, 0x0C, 0xC0, 0x66, 0x01, 0x90, 0x0C, 0xC0,
  0x36, 0x01, 0xB0, 0x06, 0xC0, 0x36, 0x00, 0xF0, 0x02, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x18, 0x30, 0x01, 0x80, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x10,
  0x0C, 0x00, 0xC0, 0xC0, 0x06, 0x0E, 0x00, 0x18, 0x60, 0x00, 0xC6, 0x00,
  0x02, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x1B, 0x00, 0x01, 0x8C, 0x00, 0x18, 0x60, 0x00,
  0xC3, 0x00, 0x0C, 0x0C, 0x00, 0xC0, 0x60, 0x0E, 0x01, 0x80, 0x60, 0x0C,
  0x06, 0x00, 0x70, 0x60, 0x01, 0x87, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x0C, 0x00, 0x18, 0x08, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x02,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x30, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x00, 0x86, 0x00, 0x01, 0x8C,
  0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60,
  0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x08, 0xC1, 0x80, 0x33,
  0x01, 0x80, 0x64, 0x01, 0x81, 0x98, 0x03, 0x83, 0x30, 0x03, 0xFC, 0x00,
  0x01, 0xE0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 35, 9, 1, -35 },
  { 36, 9, 10, 13, 5, -37 },
  { 48, 25, 35, 24, 1, -35 },
  { 158, 20, 44, 23, 2, -40 },
  { 268, 22, 35, 31, 5, -35 },
  { 365, 22, 36, 26, 1, -35 },
  { 464, 3, 10, 8, 5, -37 },
  { 468, 14, 50, 13, 2, -39 },
  { 556, 14, 50, 14, -3, -39 },
  { 644, 19, 19, 20, 3, -35 },
  { 690, 20, 26, 24, 2, -29 },
  { 755, 6, 10, 9, -2, -4 },
  { 763, 9, 2, 13, 2, -17 },
  { 766, 3, 3, 11, 1, -3 },
  { 768, 20, 38, 17, -2, -35 },
  { 863, 20, 35, 23, 2, -35 },
  { 951, 10, 35, 23, 7, -35 },
  { 995, 20, 35, 23, 1, -35 },
  { 1083, 21, 35, 23, 1, -35 },
  { 1175, 20, 35, 23, 1, -35 },
  { 1263, 21, 35, 23, 3, -35 },
  { 1355, 18, 35, 23, 2, -35 },
  { 1434, 20, 35, 23, 4, -35 },
  { 1522, 21, 35, 23, 1, -35 },
  { 1614, 18, 35, 23, 4, -35 },
  { 1693, 7, 26, 9, 1, -26 },
  { 1716, 10, 32, 9, -2, -26 },
  { 1756, 18, 20, 21, 2, -26 },
  { 1801, 18, 12, 23, 3, -22 },
  { 1828, 19, 20, 22, 1, -26 },
  { 1876, 15, 35, 19, 4, -35 },
  { 1942, 33, 45, 38, 2, -34 },
  { 2128, 23, 35, 25, -1, -35 },
  { 2229, 22, 35, 25, 2, -35 },
  { 2326, 23, 35, 27, 3, -35 },
  { 2427, 24, 35, 27, 2, -35 },
  { 2532, 23, 35, 24, 2, -35 },
  { 2633, 23, 35, 24, 2, -35 },
  { 2734, 24, 35, 28, 3, -35 },
  { 2839, 27, 35, 29, 2, -35 },
  { 2958, 8, 35, 12, 2, -35 },
  { 2993, 21, 35, 23, 1, -35 },
  { 3085, 26, 35, 26, 2, -35 },
  { 3199, 16, 35, 22, 2, -35 },
  { 3269, 33, 35, 36, 2, -35 },
  { 3414, 27, 35, 29, 2, -35 },
  { 3533, 23, 35, 28, 3, -35 },
  { 3634, 23, 35, 25, 2, -35 },
  { 3735, 23, 41, 28, 3, -35 },
  { 3853, 23, 35, 27, 2, -35 },
  { 3954, 24, 35, 25, 1, -35 },
  { 4059, 22, 35, 25, 5, -35 },
  { 4156, 24, 35, 27, 3, -35 },
  { 4261, 23, 35, 25, 4, -35 },
  { 4362, 34, 35, 37, 5, -35 },
  { 4511, 28, 35, 25, -1, -35 },
  { 4634, 22, 35, 25, 5, -35 },
  { 4731, 26, 35, 25, 0, -35 },
  { 4845, 14, 47, 10, 0, -40 },
  { 4928, 7, 38, 16, 5, -35 },
  { 4962, 13, 47, 10, -3, -40 },
  { 5039, 13, 17, 18, 3, -35 },
  { 5067, 17, 2, 18, -2, 0 },
  { 5072, 6, 6, 13, 6, -36 },
  { 5077, 19, 26, 22, 1, -26 },
  { 5139, 20, 37, 23, 1, -37 },
  { 5232, 18, 26, 21, 2, -26 },
  { 5291, 21, 37, 23, 2, -37 },
  { 5389, 19, 26, 22, 1, -26 },
  { 5451, 15, 38, 14, 3, -38 },
  { 5523, 21, 36, 23, 0, -26 },
  { 5618, 19, 37, 23, 1, -37 },
  { 5706, 9, 35, 10, 1, -35 },
  { 5746, 16, 45, 10, -6, -35 },
  { 5836, 20, 37, 20, 1, -37 },
  { 5929, 9, 37, 10, 1, -37 },
  { 5971, 33, 26, 37, 1, -26 },
  { 6079, 19, 26, 23, 1, -26 },
  { 6141, 19, 26, 23, 2, -26 },
  { 6203, 22, 36, 23, -1, -26 },
  { 6302, 19, 36, 23, 2, -26 },
  { 6388, 14, 26, 14, 1, -26 },
  { 6434, 18, 26, 21, 1, -26 },
  { 6493, 10, 33, 14, 3, -33 },
  { 6535, 19, 26, 23, 2, -26 },
  { 6597, 18, 26, 20, 3, -26 },
  { 6656, 27, 26, 31, 4, -26 },
  { 6744, 21, 26, 20, -1, -26 },
  { 6813, 23, 36, 20, -2, -26 },
  { 6917, 20, 26, 20, 0, -26 },
  { 6982, 15, 48, 14, 2, -38 },
  { 7072, 8, 41, 10, 1, -35 },
  { 7113, 15, 48, 14, -3, -38 },
  { 7203, 23, 8, 29, 3, -18 },
};

const GFXfont RobotoCondensed_ExtraLightItalic49pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic49pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic49pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC49PT7B_H_
