#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC17PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x92, 0x40, 0x40, 0xB6, 0xE0, 0x05, 0x04, 0x82, 0x47,
  0xF1, 0x20, 0x90, 0x50, 0x48, 0xFE, 0x14, 0x12, 0x09, 0x00, 0x08, 0x10,
  0xF2, 0x24, 0x28, 0x50, 0x10, 0x18, 0x0A, 0x14, 0x28, 0x8E, 0x08, 0x10,
  0x61, 0x26, 0x4C, 0xAA, 0x9A, 0x05, 0x95, 0x52, 0xA6, 0x48, 0x60, 0x0C,
  0x12, 0x22, 0x24, 0x18, 0x10, 0x28, 0x49, 0x45, 0x82, 0x46, 0x3A, 0xF0,
  0x08, 0x88, 0x44, 0x22, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x82, 0x00,
  0x20, 0x82, 0x10, 0x84, 0x21, 0x08, 0x84, 0x21, 0x10, 0x88, 0x80, 0x10,
  0x22, 0x53, 0xC3, 0x09, 0x22, 0x00, 0x10, 0x20, 0x40, 0x8F, 0xE4, 0x08,
  0x10, 0x20, 0x56, 0xE0, 0xC0, 0x02, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08,
  0x20, 0x41, 0x02, 0x08, 0x00, 0x3C, 0x89, 0x0C, 0x18, 0x30, 0xA1, 0x42,
  0x85, 0x12, 0x23, 0x80, 0x3D, 0x11, 0x22, 0x22, 0x22, 0x44, 0x1E, 0x44,
  0x8A, 0x10, 0x20, 0x81, 0x04, 0x10, 0x41, 0x07, 0xF0, 0x1E, 0x22, 0x21,
  0x01, 0x02, 0x1C, 0x04, 0x02, 0x82, 0x82, 0x44, 0x38, 0x02, 0x0C, 0x18,
  0x51, 0x24, 0x89, 0x22, 0x7E, 0x08, 0x10, 0x40, 0x3E, 0x41, 0x02, 0x07,
  0x80, 0x81, 0x02, 0x05, 0x0A, 0x23, 0x80, 0x1C, 0x84, 0x10, 0xBB, 0x18,
  0x61, 0x86, 0x18, 0x9C, 0x7E, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x20,
  0x41, 0x04, 0x00, 0x1E, 0x21, 0x21, 0x21, 0x22, 0x1C, 0x24, 0x42, 0x82,
  0x82, 0x44, 0x38, 0x39, 0x14, 0x61, 0x86, 0x18, 0x5F, 0x04, 0x21, 0x38,
  0x20, 0x00, 0x00, 0x80, 0x10, 0x00, 0x00, 0x00, 0x44, 0x48, 0x04, 0x66,
  0x20, 0x40, 0xC0, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x60, 0x20, 0x30, 0x10,
  0xC6, 0x30, 0x00, 0x39, 0x18, 0x41, 0x08, 0x41, 0x08, 0x40, 0x00, 0x10,
  0x0F, 0x82, 0x08, 0x80, 0xA0, 0x14, 0x73, 0x12, 0x64, 0x4C, 0x89, 0x92,
  0x34, 0x46, 0x89, 0x4E, 0xC8, 0x01, 0x00, 0x10, 0x01, 0xE0, 0x02, 0x03,
  0x01, 0x41, 0x20, 0x90, 0x88, 0x44, 0x3E, 0x21, 0x10, 0x90, 0x28, 0x10,
  0x3C, 0x85, 0x0A, 0x14, 0x2F, 0xA1, 0x41, 0x83, 0x06, 0x17, 0xC0, 0x1E,
  0x21, 0x41, 0x41, 0x80, 0x80, 0x80, 0x80, 0x82, 0x82, 0x84, 0x78, 0x3C,
  0x42, 0x41, 0x41, 0x41, 0x41, 0x81, 0x82, 0x82, 0x82, 0x84, 0xF8, 0x3F,
  0x40, 0x40, 0x40, 0x40, 0x7C, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFC, 0x3F,
  0x40, 0x40, 0x40, 0x40, 0x7C, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1E,
  0x21, 0x41, 0x40, 0x40, 0x80, 0x8F, 0x81, 0x82, 0x82, 0x82, 0x7C, 0x40,
  0xA0, 0x50, 0x28, 0x24, 0x13, 0xFA, 0x05, 0x02, 0x81, 0x41, 0x20, 0x90,
  0x40, 0x29, 0x24, 0x94, 0x92, 0x40, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x84, 0x84, 0x84, 0x78, 0x41, 0x21, 0x11, 0x09, 0x05, 0x03,
  0x01, 0x41, 0x10, 0x88, 0x42, 0x21, 0x10, 0x40, 0x42, 0x10, 0x84, 0x22,
  0x10, 0x84, 0x21, 0xF0, 0x20, 0x2C, 0x0D, 0x81, 0xB0, 0x55, 0x0C, 0xA2,
  0xA4, 0x54, 0x92, 0x92, 0x52, 0x8A, 0x22, 0x44, 0x40, 0x20, 0xB0, 0x58,
  0x2A, 0x15, 0x12, 0x4A, 0x25, 0x12, 0x85, 0x43, 0x20, 0x90, 0x40, 0x1E,
  0x21, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0x78, 0x3E,
  0x42, 0x41, 0x41, 0x41, 0x42, 0x7C, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1E,
  0x21, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0x78, 0x04,
  0x04, 0x3E, 0x42, 0x41, 0x41, 0x42, 0x42, 0x7C, 0x88, 0x84, 0x84, 0x84,
  0x82, 0x1E, 0x10, 0x88, 0x24, 0x02, 0x00, 0xC0, 0x18, 0x04, 0x81, 0x40,
  0x90, 0x87, 0x80, 0xFE, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81,
  0x02, 0x00, 0x41, 0x41, 0x41, 0x41, 0x41, 0x81, 0x82, 0x82, 0x82, 0x82,
  0x84, 0x78, 0x81, 0x20, 0x90, 0x48, 0x44, 0x22, 0x21, 0x10, 0x90, 0x28,
  0x18, 0x0C, 0x04, 0x00, 0x84, 0x30, 0x86, 0x30, 0xC6, 0x29, 0x45, 0x24,
  0xA8, 0xA5, 0x14, 0xA3, 0x18, 0x63, 0x0C, 0x41, 0x00, 0x20, 0x90, 0x84,
  0x42, 0x41, 0x40, 0x40, 0x20, 0x28, 0x24, 0x21, 0x10, 0x90, 0x40, 0x82,
  0x82, 0x84, 0x48, 0x48, 0x50, 0x60, 0x20, 0x20, 0x40, 0x40, 0x40, 0x3F,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x20, 0x10, 0x1F,
  0xC0, 0x19, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x84, 0x42, 0x10, 0xC0,
  0xAA, 0xA9, 0x55, 0x40, 0x38, 0x44, 0x21, 0x08, 0x42, 0x11, 0x08, 0x42,
  0x10, 0x88, 0xC0, 0x13, 0x55, 0x99, 0xFC, 0x90, 0x1C, 0x45, 0x08, 0x13,
  0xC8, 0xA1, 0x46, 0x74, 0x20, 0x40, 0x81, 0x03, 0xC4, 0x50, 0xA1, 0x42,
  0x85, 0x0A, 0x2B, 0x80, 0x39, 0x18, 0x60, 0x82, 0x08, 0xA2, 0xF0, 0x02,
  0x04, 0x08, 0x13, 0xA8, 0xA1, 0x42, 0x85, 0x0A, 0x24, 0x4F, 0x80, 0x1C,
  0x45, 0x0B, 0xF8, 0x10, 0x20, 0x22, 0x38, 0x19, 0x08, 0x8F, 0x21, 0x08,
  0x44, 0x21, 0x08, 0x00, 0x1E, 0x45, 0x0A, 0x14, 0x28, 0x61, 0x22, 0x7C,
  0x0A, 0x23, 0x80, 0x20, 0x40, 0x81, 0x03, 0xCC, 0x50, 0xA1, 0x42, 0x85,
  0x14, 0x28, 0x40, 0x20, 0x12, 0x92, 0x49, 0x40, 0x08, 0x00, 0x10, 0x88,
  0x42, 0x10, 0x88, 0x42, 0x13, 0x00, 0x20, 0x40, 0x81, 0x02, 0x28, 0x92,
  0x28, 0x70, 0xA1, 0x24, 0x48, 0x40, 0x24, 0x92, 0x52, 0x49, 0x28, 0x3C,
  0xE2, 0x31, 0x42, 0x14, 0x21, 0x42, 0x14, 0x22, 0x44, 0x28, 0x42, 0x84,
  0x20, 0x3C, 0xC5, 0x0A, 0x14, 0x28, 0x51, 0x42, 0x84, 0x39, 0x18, 0x61,
  0x86, 0x18, 0x62, 0x70, 0x3C, 0x45, 0x0A, 0x14, 0x28, 0x50, 0xA2, 0xB9,
  0x02, 0x04, 0x00, 0x3D, 0x18, 0x61, 0x86, 0x18, 0xA2, 0xF8, 0x20, 0x82,
  0x39, 0x10, 0x84, 0x21, 0x10, 0x80, 0x3C, 0x85, 0x01, 0x01, 0x80, 0x81,
  0x42, 0x78, 0x24, 0xF4, 0x44, 0x88, 0x88, 0xC0, 0x46, 0x18, 0x61, 0x86,
  0x18, 0xA2, 0xF8, 0x86, 0x18, 0xA2, 0x51, 0x46, 0x18, 0x40, 0x88, 0x62,
  0x28, 0xCA, 0x52, 0x95, 0x29, 0x46, 0x61, 0x18, 0x42, 0x00, 0x42, 0x48,
  0xA0, 0x81, 0x06, 0x12, 0x24, 0x84, 0x21, 0x21, 0x22, 0x22, 0x14, 0x14,
  0x18, 0x18, 0x10, 0x10, 0x20, 0xC0, 0x3E, 0x08, 0x20, 0x41, 0x04, 0x10,
  0x20, 0xFC, 0x08, 0x88, 0x42, 0x11, 0x08, 0x84, 0x10, 0x88, 0x42, 0x08,
  0x40, 0x24, 0x92, 0x92, 0x49, 0x29, 0x00, 0x20, 0x82, 0x11, 0x08, 0x42,
  0x08, 0x84, 0x42, 0x10, 0x88, 0x80, 0x61, 0x91, 0x8E,
};

const GFXglyph RobotoCondensed_ExtraLightItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 12, 3, 0, -12 },
  { 6, 3, 4, 4, 2, -13 },
  { 8, 9, 12, 8, 0, -12 },
  { 22, 7, 16, 8, 1, -14 },
  { 36, 7, 12, 11, 2, -12 },
  { 47, 8, 12, 9, 0, -12 },
  { 59, 1, 4, 3, 2, -13 },
  { 60, 5, 18, 5, 1, -14 },
  { 72, 5, 17, 5, -1, -13 },
  { 83, 7, 7, 7, 1, -12 },
  { 90, 7, 9, 8, 1, -10 },
  { 98, 2, 4, 3, -1, -1 },
  { 99, 3, 1, 4, 1, -6 },
  { 100, 2, 1, 4, 0, -1 },
  { 101, 7, 13, 6, -1, -12 },
  { 113, 7, 12, 8, 1, -12 },
  { 124, 4, 12, 8, 2, -12 },
  { 130, 7, 12, 8, 0, -12 },
  { 141, 8, 12, 8, 0, -12 },
  { 153, 7, 12, 8, 0, -12 },
  { 164, 7, 12, 8, 1, -12 },
  { 175, 6, 12, 8, 1, -12 },
  { 184, 7, 12, 8, 1, -12 },
  { 195, 8, 12, 8, 0, -12 },
  { 207, 6, 12, 8, 1, -12 },
  { 216, 3, 9, 3, 0, -9 },
  { 220, 4, 12, 3, -1, -9 },
  { 226, 6, 7, 7, 1, -9 },
  { 232, 6, 5, 8, 1, -8 },
  { 236, 7, 7, 8, 0, -9 },
  { 243, 6, 12, 7, 1, -12 },
  { 252, 11, 16, 13, 1, -12 },
  { 274, 9, 12, 9, -1, -12 },
  { 288, 7, 12, 9, 1, -12 },
  { 299, 8, 12, 9, 1, -12 },
  { 311, 8, 12, 9, 1, -12 },
  { 323, 8, 12, 8, 1, -12 },
  { 335, 8, 12, 8, 1, -12 },
  { 347, 8, 12, 10, 1, -12 },
  { 359, 9, 12, 10, 1, -12 },
  { 373, 3, 12, 4, 1, -12 },
  { 378, 8, 12, 8, 0, -12 },
  { 390, 9, 12, 9, 1, -12 },
  { 404, 5, 12, 8, 1, -12 },
  { 412, 11, 12, 12, 1, -12 },
  { 429, 9, 12, 10, 1, -12 },
  { 443, 8, 12, 10, 1, -12 },
  { 455, 8, 12, 9, 1, -12 },
  { 467, 8, 14, 10, 1, -12 },
  { 481, 8, 12, 9, 1, -12 },
  { 493, 9, 12, 9, 0, -12 },
  { 507, 7, 12, 9, 2, -12 },
  { 518, 8, 12, 10, 1, -12 },
  { 530, 9, 12, 9, 1, -12 },
  { 544, 11, 12, 13, 2, -12 },
  { 561, 9, 12, 9, 0, -12 },
  { 575, 8, 12, 9, 2, -12 },
  { 587, 9, 12, 9, 0, -12 },
  { 601, 5, 17, 4, 0, -14 },
  { 612, 2, 13, 6, 2, -12 },
  { 616, 5, 17, 4, -1, -14 },
  { 627, 4, 6, 6, 1, -12 },
  { 630, 6, 1, 6, -1, 0 },
  { 631, 2, 2, 5, 2, -13 },
  { 632, 7, 9, 8, 0, -9 },
  { 640, 7, 13, 8, 0, -13 },
  { 652, 6, 9, 7, 1, -9 },
  { 659, 7, 13, 8, 1, -13 },
  { 671, 7, 9, 7, 0, -9 },
  { 679, 5, 13, 5, 1, -13 },
  { 688, 7, 12, 8, 0, -9 },
  { 699, 7, 13, 8, 0, -13 },
  { 711, 3, 12, 3, 0, -12 },
  { 716, 5, 15, 3, -2, -12 },
  { 726, 7, 13, 7, 0, -13 },
  { 738, 3, 13, 3, 0, -13 },
  { 743, 12, 9, 13, 0, -9 },
  { 757, 7, 9, 8, 0, -9 },
  { 765, 6, 9, 8, 1, -9 },
  { 772, 7, 12, 8, 0, -9 },
  { 783, 6, 12, 8, 1, -9 },
  { 792, 5, 9, 5, 0, -9 },
  { 798, 7, 9, 7, 0, -9 },
  { 806, 4, 11, 5, 1, -11 },
  { 812, 6, 9, 8, 1, -9 },
  { 819, 6, 9, 7, 1, -9 },
  { 826, 10, 9, 11, 1, -9 },
  { 838, 7, 9, 7, 0, -9 },
  { 846, 8, 12, 7, -1, -9 },
  { 858, 7, 9, 7, 0, -9 },
  { 866, 5, 17, 5, 1, -13 },
  { 877, 3, 14, 3, 0, -12 },
  { 883, 5, 17, 5, -1, -13 },
  { 894, 8, 3, 10, 1, -7 },
};

const GFXfont RobotoCondensed_ExtraLightItalic17pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic17pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC17PT7B_H_
