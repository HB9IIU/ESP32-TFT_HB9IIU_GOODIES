#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC11PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x15, 0x02, 0xB0, 0x00, 0xA3, 0xCA, 0x51, 0xE5, 0x00, 0x11, 0x50,
  0x82, 0x08, 0x31, 0x70, 0x00, 0xE5, 0x6D, 0xC3, 0xB4, 0xA5, 0x32, 0x54,
  0x46, 0x4E, 0x4F, 0xC0, 0x0A, 0x49, 0x24, 0x92, 0x40, 0x24, 0x92, 0x49,
  0x25, 0x00, 0x0F, 0x4A, 0x01, 0x1C, 0x42, 0x00, 0x80, 0x40, 0x80, 0x11,
  0x22, 0x44, 0x88, 0x00, 0x79, 0x99, 0x99, 0xAE, 0x64, 0x94, 0x92, 0x3A,
  0x42, 0x21, 0x11, 0x1C, 0x3A, 0x42, 0x60, 0x06, 0x4E, 0x08, 0x8A, 0x65,
  0x78, 0x40, 0x68, 0x8E, 0x11, 0x1E, 0x68, 0x8E, 0x99, 0xAE, 0x71, 0x22,
  0x44, 0x88, 0x3A, 0x52, 0xE5, 0x46, 0x2E, 0x79, 0x99, 0xF1, 0x2C, 0x40,
  0x20, 0x40, 0x20, 0x1B, 0x20, 0xC1, 0x00, 0x64, 0x42, 0x12, 0xC0, 0x74,
  0x94, 0x04, 0x1E, 0x21, 0x5D, 0x55, 0xA5, 0xA5, 0xA9, 0xBE, 0x80, 0x78,
  0x11, 0x8C, 0x94, 0xB6, 0x21, 0x7A, 0x52, 0xE4, 0xA6, 0x36, 0x74, 0x63,
  0x08, 0x42, 0x5C, 0x19, 0x14, 0x51, 0x45, 0x18, 0xAC, 0x19, 0x04, 0x1C,
  0x41, 0x08, 0x28, 0x19, 0x04, 0x1C, 0x41, 0x08, 0x20, 0x7C, 0x61, 0x09,
  0x42, 0x3E, 0x01, 0x14, 0x5D, 0x45, 0x18, 0x60, 0x7E, 0x00, 0x42, 0x10,
  0x8A, 0x5C, 0x05, 0x25, 0x18, 0x61, 0x48, 0xA2, 0x04, 0x44, 0x44, 0x8A,
  0x01, 0x63, 0x62, 0x65, 0x66, 0x5A, 0x92, 0x92, 0x41, 0x96, 0x55, 0x55,
  0x58, 0xA2, 0x74, 0x63, 0x18, 0xC6, 0x5C, 0x79, 0x14, 0x51, 0x79, 0x08,
  0x20, 0x74, 0x63, 0x18, 0xC6, 0x5C, 0x10, 0x79, 0x14, 0x51, 0x7A, 0x08,
  0xA2, 0x39, 0x04, 0x08, 0x18, 0x28, 0x9C, 0x71, 0x08, 0x84, 0x21, 0x08,
  0x04, 0x63, 0x18, 0xCA, 0x5C, 0x0C, 0x65, 0x2A, 0x51, 0x08, 0x81, 0x92,
  0xAA, 0xAA, 0xAC, 0xCC, 0xC8, 0x08, 0x45, 0x23, 0x04, 0x21, 0x45, 0x22,
  0x8C, 0xA4, 0xC4, 0x21, 0x08, 0x3C, 0x21, 0x04, 0x21, 0x04, 0x3C, 0x09,
  0x24, 0xA4, 0x92, 0x00, 0xAA, 0x95, 0x40, 0x04, 0x92, 0x4A, 0x49, 0x00,
  0x4A, 0x80, 0x60, 0x10, 0x71, 0x17, 0x9F, 0x02, 0x10, 0xE4, 0xC6, 0x32,
  0xF0, 0x74, 0x88, 0x96, 0x00, 0x42, 0xF4, 0xC6, 0x52, 0x70, 0x75, 0xB8,
  0x87, 0x4A, 0x49, 0x24, 0x00, 0x7A, 0x63, 0x29, 0x38, 0x5C, 0x04, 0x47,
  0x59, 0x99, 0x90, 0x05, 0x6A, 0x00, 0x92, 0x92, 0x40, 0x02, 0x10, 0xA6,
  0x22, 0x94, 0x90, 0x15, 0x5A, 0x80, 0x77, 0x49, 0x89, 0x91, 0x92, 0x90,
  0x75, 0x59, 0x99, 0x72, 0x63, 0x19, 0x38, 0x72, 0x63, 0x19, 0x7A, 0x00,
  0x7A, 0x63, 0x29, 0x38, 0x40, 0x69, 0x49, 0x00, 0x74, 0x61, 0x9E, 0x2A,
  0xA0, 0x99, 0x9A, 0xAE, 0x0A, 0xAC, 0xC8, 0x06, 0x9D, 0xB6, 0x92, 0x40,
  0x02, 0x88, 0x46, 0x48, 0x02, 0x94, 0xC6, 0x21, 0x10, 0x31, 0x24, 0x4E,
  0x12, 0x24, 0x40, 0x44, 0x44, 0x40, 0x15, 0x6A, 0x80, 0x22, 0x22, 0x20,
  0x22, 0x24, 0x80, 0xC9, 0x80,
};

const GFXglyph RobotoCondensed_ExtraLightItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 8, 2, 0, -8 },
  { 3, 2, 2, 3, 1, -8 },
  { 4, 6, 8, 5, 0, -8 },
  { 10, 5, 10, 5, 0, -9 },
  { 17, 5, 8, 7, 1, -8 },
  { 22, 5, 8, 6, 0, -8 },
  { 27, 1, 2, 2, 1, -8 },
  { 28, 3, 12, 3, 1, -9 },
  { 33, 3, 12, 3, -1, -9 },
  { 38, 4, 4, 4, 1, -8 },
  { 40, 5, 6, 5, 0, -6 },
  { 44, 1, 2, 2, 0, -1 },
  { 45, 3, 1, 3, 0, -4 },
  { 46, 1, 1, 2, 0, -1 },
  { 47, 4, 9, 4, 0, -8 },
  { 52, 4, 8, 5, 1, -8 },
  { 56, 3, 8, 5, 1, -8 },
  { 59, 5, 8, 5, 0, -8 },
  { 64, 5, 8, 5, 0, -8 },
  { 69, 5, 8, 5, 0, -8 },
  { 74, 4, 8, 5, 1, -8 },
  { 78, 4, 8, 5, 1, -8 },
  { 82, 4, 8, 5, 1, -8 },
  { 86, 5, 8, 5, 0, -8 },
  { 91, 4, 8, 5, 1, -8 },
  { 95, 2, 6, 2, 0, -6 },
  { 97, 2, 7, 2, 0, -6 },
  { 99, 5, 5, 5, 0, -6 },
  { 103, 4, 2, 5, 1, -5 },
  { 104, 4, 5, 5, 0, -6 },
  { 107, 3, 8, 4, 1, -8 },
  { 110, 8, 10, 9, 0, -8 },
  { 120, 5, 8, 6, 0, -8 },
  { 125, 5, 8, 6, 0, -8 },
  { 130, 5, 8, 6, 1, -8 },
  { 135, 6, 8, 6, 0, -8 },
  { 141, 6, 8, 5, 0, -8 },
  { 147, 6, 8, 5, 0, -8 },
  { 153, 5, 8, 6, 1, -8 },
  { 158, 6, 8, 7, 0, -8 },
  { 164, 1, 8, 3, 1, -8 },
  { 165, 5, 8, 5, 0, -8 },
  { 170, 6, 8, 6, 0, -8 },
  { 176, 4, 8, 5, 0, -8 },
  { 180, 8, 8, 8, 0, -8 },
  { 188, 6, 8, 7, 0, -8 },
  { 194, 5, 8, 6, 1, -8 },
  { 199, 6, 8, 6, 0, -8 },
  { 205, 5, 9, 6, 1, -8 },
  { 211, 6, 8, 6, 0, -8 },
  { 217, 6, 8, 6, 0, -8 },
  { 223, 5, 8, 6, 1, -8 },
  { 228, 5, 8, 6, 1, -8 },
  { 233, 5, 8, 6, 1, -8 },
  { 238, 8, 8, 8, 1, -8 },
  { 246, 6, 8, 6, 0, -8 },
  { 252, 5, 8, 6, 1, -8 },
  { 257, 6, 8, 6, 0, -8 },
  { 263, 3, 11, 2, 0, -9 },
  { 268, 2, 9, 4, 1, -8 },
  { 271, 3, 11, 2, -1, -9 },
  { 276, 3, 4, 4, 1, -8 },
  { 278, 4, 1, 4, -1, 0 },
  { 279, 2, 2, 3, 1, -9 },
  { 280, 4, 6, 5, 0, -6 },
  { 283, 5, 9, 5, 0, -9 },
  { 289, 4, 6, 5, 0, -6 },
  { 292, 5, 9, 5, 0, -9 },
  { 298, 4, 6, 5, 0, -6 },
  { 301, 3, 9, 3, 1, -9 },
  { 305, 5, 8, 5, 0, -6 },
  { 310, 4, 9, 5, 0, -9 },
  { 315, 2, 8, 2, 0, -8 },
  { 317, 3, 10, 2, -1, -8 },
  { 321, 5, 9, 5, 0, -9 },
  { 327, 2, 9, 2, 0, -9 },
  { 330, 8, 6, 8, 0, -6 },
  { 336, 4, 6, 5, 0, -6 },
  { 339, 5, 6, 5, 0, -6 },
  { 343, 5, 8, 5, 0, -6 },
  { 348, 5, 8, 5, 0, -6 },
  { 353, 3, 6, 3, 0, -6 },
  { 356, 4, 6, 5, 0, -6 },
  { 359, 2, 7, 3, 1, -7 },
  { 361, 4, 6, 5, 1, -6 },
  { 364, 4, 6, 5, 1, -6 },
  { 367, 6, 6, 7, 1, -6 },
  { 372, 5, 6, 5, 0, -6 },
  { 376, 5, 8, 4, 0, -6 },
  { 381, 4, 6, 5, 0, -6 },
  { 384, 4, 11, 3, 0, -9 },
  { 390, 2, 9, 2, 0, -8 },
  { 393, 4, 11, 3, -1, -9 },
  { 399, 5, 2, 6, 1, -4 },
};

const GFXfont RobotoCondensed_ExtraLightItalic11pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic11pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC11PT7B_H_
