#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC45PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x0C, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x18, 0x20, 0x40,
  0x83, 0x06, 0x0C, 0x10, 0x20, 0xC1, 0x83, 0x06, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x38, 0x60, 0x63, 0x62, 0x62, 0x46, 0x46, 0xC6, 0xC4,
  0xC4, 0x84, 0x00, 0x08, 0x18, 0x00, 0x20, 0x60, 0x01, 0x81, 0x00, 0x04,
  0x0C, 0x00, 0x10, 0x30, 0x00, 0xC0, 0x80, 0x03, 0x06, 0x00, 0x08, 0x18,
  0x00, 0x60, 0x40, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x30, 0x20, 0x00,
  0xC0, 0x80, 0x02, 0x06, 0x00, 0x18, 0x10, 0x00, 0x60, 0x40, 0x01, 0x03,
  0x00, 0x0C, 0x08, 0x00, 0x30, 0x20, 0x00, 0x81, 0x80, 0x06, 0x04, 0x00,
  0x18, 0x10, 0x0F, 0xFF, 0xFE, 0x03, 0x03, 0x00, 0x0C, 0x08, 0x00, 0x20,
  0x60, 0x00, 0x81, 0x80, 0x06, 0x04, 0x00, 0x10, 0x30, 0x00, 0x40, 0xC0,
  0x03, 0x02, 0x00, 0x08, 0x18, 0x00, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x30, 0x38, 0x18, 0x06,
  0x0C, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6,
  0x00, 0x31, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC8, 0x00, 0x32, 0x00, 0x0C, 0x80, 0x03, 0x30,
  0x00, 0xCC, 0x00, 0x63, 0x00, 0x18, 0x60, 0x0C, 0x1C, 0x0E, 0x03, 0xFF,
  0x00, 0x3F, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x0F, 0x00, 0x00, 0xEE, 0x00, 0x0C, 0x10, 0x00, 0x40, 0x80, 0x06, 0x06,
  0x02, 0x20, 0x30, 0x31, 0x01, 0x81, 0x18, 0x0C, 0x10, 0xC0, 0x41, 0x86,
  0x02, 0x18, 0x30, 0x30, 0x80, 0x81, 0x0C, 0x04, 0x18, 0xC0, 0x3B, 0x84,
  0x00, 0x78, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x0F, 0x00,
  0x31, 0xDC, 0x03, 0x18, 0x20, 0x10, 0x81, 0x81, 0x8C, 0x04, 0x18, 0x60,
  0x21, 0x82, 0x03, 0x08, 0x10, 0x18, 0xC0, 0x80, 0xCC, 0x04, 0x04, 0x40,
  0x20, 0x22, 0x01, 0x03, 0x00, 0x0C, 0x30, 0x00, 0x3F, 0x00, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x01, 0xC1, 0x80, 0x18, 0x18, 0x03, 0x01,
  0x80, 0x30, 0x18, 0x02, 0x01, 0x80, 0x20, 0x18, 0x02, 0x03, 0x00, 0x20,
  0x60, 0x03, 0x0E, 0x00, 0x31, 0xC0, 0x01, 0x30, 0x00, 0x1E, 0x00, 0x00,
  0xC0, 0x00, 0x3C, 0x00, 0x06, 0x60, 0x00, 0xC6, 0x01, 0x18, 0x30, 0x33,
  0x03, 0x03, 0x30, 0x18, 0x26, 0x01, 0x86, 0x60, 0x0C, 0x64, 0x00, 0x44,
  0x40, 0x06, 0xC4, 0x00, 0x38, 0x40, 0x03, 0x86, 0x00, 0x38, 0x60, 0x07,
  0x83, 0x01, 0xCC, 0x1F, 0xF0, 0x40, 0x7C, 0x06, 0x33, 0x22, 0x66, 0x64,
  0x40, 0x00, 0x08, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x03, 0x02, 0x0F, 0xF1, 0x1E,
  0x1F, 0xF8, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0xD8, 0x00, 0xC4, 0x00, 0x63,
  0x00, 0x60, 0x80, 0x60, 0x60, 0x60, 0x18, 0x20, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x18, 0xCC, 0x63, 0x31, 0x98, 0x80, 0x7F, 0xBF,
  0xC0, 0x7F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x30, 0x30, 0x18, 0x06,
  0x0C, 0x00, 0x83, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x10, 0x00, 0xCC,
  0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x20, 0x00, 0xC8, 0x00, 0x36, 0x00,
  0x09, 0x80, 0x06, 0x60, 0x01, 0x90, 0x00, 0x64, 0x00, 0x1B, 0x00, 0x04,
  0xC0, 0x01, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x08, 0xC0, 0x06, 0x30,
  0x01, 0x84, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x18, 0x0C, 0x0C, 0x03, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0xC0, 0xF1, 0xE9, 0xE2, 0xE1, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x00, 0x7E, 0x00, 0x3F, 0xE0,
  0x0E, 0x06, 0x03, 0x80, 0x60, 0x60, 0x0C, 0x18, 0x00, 0x83, 0x00, 0x18,
  0x40, 0x03, 0x18, 0x00, 0x43, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xF0, 0x0E, 0x07, 0x01, 0x80, 0x60, 0x60, 0x06, 0x18,
  0x00, 0xC3, 0x00, 0x18, 0x40, 0x03, 0x18, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x88, 0x00,
  0x21, 0x80, 0x0C, 0x30, 0x03, 0x07, 0x00, 0x60, 0x70, 0x38, 0x07, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0x60, 0x00, 0x68, 0x00, 0x19, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x31,
  0x80, 0x0C, 0x30, 0x01, 0x04, 0x00, 0x61, 0x80, 0x18, 0x30, 0x06, 0x06,
  0x00, 0x80, 0xC0, 0x30, 0x10, 0x0C, 0x02, 0x03, 0x00, 0xC0, 0x60, 0x18,
  0x18, 0x03, 0x06, 0x00, 0x61, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x07, 0xFF, 0xE0, 0xFF, 0xF8,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x1F, 0x00, 0x6F, 0xF0, 0x0E, 0x03, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC4, 0x00, 0x10, 0x80, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x10, 0x60,
  0x06, 0x06, 0x01, 0x80, 0xE0, 0x60, 0x0F, 0xF8, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x1F,
  0x03, 0x3F, 0xC1, 0x70, 0x31, 0xA0, 0x0C, 0xE0, 0x06, 0x60, 0x01, 0x30,
  0x00, 0x90, 0x00, 0x68, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0B, 0x00, 0x05,
  0x80, 0x06, 0xC0, 0x03, 0x20, 0x01, 0x18, 0x01, 0x8C, 0x01, 0x87, 0x00,
  0xC1, 0x80, 0xC0, 0x7F, 0xC0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF0,
  0x06, 0x07, 0x01, 0x80, 0x70, 0x60, 0x06, 0x08, 0x00, 0xC3, 0x00, 0x08,
  0x60, 0x01, 0x08, 0x00, 0x61, 0x00, 0x0C, 0x20, 0x01, 0x06, 0x00, 0x60,
  0xC0, 0x18, 0x0C, 0x06, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x0E, 0x0E, 0x03,
  0x00, 0x60, 0xC0, 0x04, 0x18, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x01, 0x10,
  0x00, 0x26, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x0C, 0x30,
  0x01, 0x86, 0x00, 0x60, 0x60, 0x38, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x03, 0xFE, 0x03, 0x81, 0x83, 0x80, 0x61, 0x80, 0x31, 0x80, 0x08,
  0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x16, 0x00, 0x1B, 0x00, 0x0C, 0x80, 0x0E, 0x60, 0x0F, 0x30,
  0x05, 0x8C, 0x0C, 0x83, 0xFC, 0xC0, 0xFC, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x0C, 0x70, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0E,
  0x30, 0x01, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x40, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x02,
  0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xBF, 0xFF,
  0xC0, 0x10, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x40, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0x8E, 0x0C, 0x60, 0x36, 0x01,
  0xB0, 0x07, 0x00, 0x38, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x04,
  0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x06, 0x00, 0xF8, 0x02,
  0x06, 0x01, 0xFC, 0x02, 0x0C, 0x03, 0x06, 0x02, 0x08, 0x06, 0x02, 0x02,
  0x18, 0x0C, 0x06, 0x02, 0x18, 0x18, 0x06, 0x02, 0x10, 0x18, 0x04, 0x02,
  0x30, 0x10, 0x04, 0x02, 0x20, 0x30, 0x0C, 0x02, 0x20, 0x20, 0x0C, 0x02,
  0x60, 0x60, 0x08, 0x06, 0x60, 0x60, 0x08, 0x06, 0x60, 0x60, 0x18, 0x04,
  0x40, 0x40, 0x18, 0x04, 0x40, 0x40, 0x10, 0x0C, 0x40, 0x40, 0x30, 0x08,
  0x40, 0x40, 0x30, 0x18, 0x40, 0x40, 0x50, 0x10, 0x40, 0x40, 0xD0, 0x30,
  0x40, 0x61, 0x90, 0x60, 0x40, 0x7F, 0x1D, 0xC0, 0x40, 0x3E, 0x0F, 0x80,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xA0,
  0x00, 0x0D, 0x00, 0x00, 0x68, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x03,
  0x18, 0x00, 0x18, 0xC0, 0x01, 0x82, 0x00, 0x0C, 0x10, 0x00, 0x40, 0x80,
  0x06, 0x04, 0x00, 0x20, 0x30, 0x03, 0x01, 0x80, 0x10, 0x0C, 0x01, 0x80,
  0x60, 0x08, 0x01, 0x00, 0xC0, 0x08, 0x04, 0x00, 0x40, 0x60, 0x03, 0x03,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0x80, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x00,
  0x8C, 0x00, 0x04, 0x60, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x04, 0x00, 0xC0,
  0x40, 0x06, 0x0C, 0x00, 0x20, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x08, 0x00, 0x31, 0x80, 0x02, 0x18, 0x00, 0x61, 0x80, 0x04, 0x18, 0x00,
  0xC1, 0x00, 0x38, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x30, 0x07, 0x03, 0x00,
  0x18, 0x30, 0x00, 0xC2, 0x00, 0x0C, 0x20, 0x00, 0xC6, 0x00, 0x04, 0x60,
  0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC4, 0x00, 0x0C, 0x40, 0x01, 0x8C,
  0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xE0, 0x38, 0x0C, 0x00, 0xE0, 0xC0,
  0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x19,
  0x80, 0x00, 0xD8, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x01,
  0x10, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x04, 0x30, 0x00, 0x60, 0x80,
  0x06, 0x06, 0x00, 0x70, 0x18, 0x07, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0x00, 0x38, 0x08, 0x00, 0xC0, 0xC0,
  0x03, 0x06, 0x00, 0x08, 0x30, 0x00, 0x61, 0x00, 0x03, 0x08, 0x00, 0x08,
  0xC0, 0x00, 0x46, 0x00, 0x02, 0x30, 0x00, 0x11, 0x80, 0x01, 0x88, 0x00,
  0x0C, 0x40, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x11, 0x80, 0x00, 0x8C,
  0x00, 0x0C, 0x40, 0x00, 0x62, 0x00, 0x03, 0x30, 0x00, 0x11, 0x80, 0x01,
  0x8C, 0x00, 0x0C, 0x60, 0x00, 0x42, 0x00, 0x06, 0x10, 0x00, 0x61, 0x80,
  0x06, 0x0C, 0x00, 0x70, 0x60, 0x0E, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0xE0, 0x18, 0x0E, 0x00, 0x60, 0x60,
  0x01, 0x86, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x01, 0x30, 0x00, 0x09,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0xFF, 0xB0,
  0x07, 0xFD, 0x80, 0x00, 0x6C, 0x00, 0x02, 0x60, 0x00, 0x33, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x02, 0x10, 0x00, 0x30, 0xC0,
  0x01, 0x83, 0x00, 0x1C, 0x1C, 0x03, 0xC0, 0x7F, 0xF8, 0x00, 0xFE, 0x00,
  0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x04, 0x00, 0x03, 0x04, 0x00, 0x03,
  0x0C, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x06,
  0x08, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x04, 0x18, 0x00, 0x04,
  0x18, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x30, 0x00, 0x08, 0x30, 0x00, 0x08, 0x30, 0x00, 0x18, 0x20, 0x00, 0x18,
  0x20, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x10, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x40, 0x00, 0x30, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x20,
  0xC0, 0x00, 0x20, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x80, 0x00, 0x60,
  0x02, 0x0C, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x83,
  0x06, 0x0C, 0x18, 0x20, 0xC1, 0x83, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x83,
  0x04, 0x08, 0x30, 0x60, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x20, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x04, 0x0C,
  0x00, 0xC0, 0x60, 0x18, 0x07, 0x03, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00,
  0x06, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x60, 0x20, 0x01, 0x80,
  0xC0, 0x06, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x04, 0x01, 0x80, 0x08,
  0x06, 0x00, 0x30, 0x18, 0x00, 0x60, 0x60, 0x00, 0xC1, 0x80, 0x01, 0x86,
  0x00, 0x02, 0x18, 0x00, 0x04, 0x60, 0x00, 0x19, 0xE0, 0x00, 0x36, 0x40,
  0x00, 0x78, 0xC0, 0x00, 0xE0, 0xC0, 0x01, 0x81, 0x80, 0x02, 0x01, 0x80,
  0x0C, 0x03, 0x00, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x80, 0x0C, 0x01, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x30, 0x00, 0x30, 0x40, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x68, 0x34, 0x00, 0x01, 0xE0, 0xD0, 0x00, 0x0D, 0x82, 0x60,
  0x00, 0x36, 0x09, 0x80, 0x01, 0x98, 0x66, 0x00, 0x04, 0x41, 0x88, 0x00,
  0x31, 0x06, 0x20, 0x00, 0x8C, 0x18, 0xC0, 0x06, 0x30, 0x43, 0x00, 0x10,
  0xC1, 0x0C, 0x00, 0xC3, 0x0C, 0x30, 0x02, 0x08, 0x30, 0x40, 0x18, 0x60,
  0xC1, 0x00, 0x41, 0x83, 0x06, 0x03, 0x06, 0x08, 0x18, 0x08, 0x18, 0x20,
  0x60, 0x60, 0x41, 0x80, 0x83, 0x01, 0x06, 0x02, 0x0C, 0x0C, 0x18, 0x08,
  0x60, 0x30, 0x60, 0x31, 0x80, 0xC1, 0x00, 0xCC, 0x03, 0x04, 0x03, 0x30,
  0x08, 0x30, 0x05, 0x80, 0x20, 0xC0, 0x16, 0x01, 0x83, 0x00, 0x70, 0x06,
  0x0C, 0x01, 0xC0, 0x18, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x01, 0x06,
  0x00, 0x03, 0x07, 0x00, 0x03, 0x0F, 0x00, 0x03, 0x0D, 0x00, 0x03, 0x0D,
  0x80, 0x02, 0x0C, 0x80, 0x02, 0x0C, 0xC0, 0x06, 0x08, 0xC0, 0x06, 0x18,
  0x40, 0x06, 0x18, 0x60, 0x06, 0x18, 0x60, 0x04, 0x18, 0x30, 0x04, 0x18,
  0x30, 0x0C, 0x10, 0x10, 0x0C, 0x30, 0x18, 0x0C, 0x30, 0x18, 0x0C, 0x30,
  0x08, 0x08, 0x30, 0x0C, 0x18, 0x30, 0x04, 0x18, 0x20, 0x06, 0x18, 0x60,
  0x06, 0x18, 0x60, 0x02, 0x18, 0x60, 0x03, 0x10, 0x60, 0x03, 0x30, 0x40,
  0x01, 0x30, 0x40, 0x01, 0xB0, 0xC0, 0x00, 0xB0, 0xC0, 0x00, 0xE0, 0xC0,
  0x00, 0xE0, 0xC0, 0x00, 0x60, 0x80, 0x00, 0x60, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x80, 0x1C, 0x07, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00,
  0x20, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x40, 0x00, 0x33,
  0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x32, 0x00,
  0x00, 0x98, 0x00, 0x02, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01,
  0x90, 0x00, 0x06, 0x40, 0x00, 0x11, 0x00, 0x00, 0xC4, 0x00, 0x03, 0x10,
  0x00, 0x0C, 0x40, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x0C, 0x18, 0x00,
  0x60, 0x30, 0x03, 0x80, 0x60, 0x1C, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0x00, 0x18, 0x08, 0x00, 0x60, 0xC0,
  0x03, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x08, 0x00, 0x18,
  0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x21, 0x80, 0x03, 0x08, 0x00,
  0x18, 0x40, 0x01, 0x86, 0x00, 0x18, 0x30, 0x03, 0x81, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1C, 0x07, 0x00, 0xC0, 0x0E, 0x06,
  0x00, 0x18, 0x30, 0x00, 0x20, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00,
  0x0C, 0x40, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C,
  0x80, 0x00, 0x32, 0x00, 0x00, 0x98, 0x00, 0x02, 0x60, 0x00, 0x19, 0x80,
  0x00, 0x66, 0x00, 0x01, 0x90, 0x00, 0x06, 0x40, 0x00, 0x13, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x30, 0x00, 0x08, 0x40, 0x00, 0x61, 0x80, 0x01, 0x86,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0x30, 0x03, 0x80, 0x60, 0x1C, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00,
  0x0C, 0x30, 0x00, 0x61, 0x00, 0x03, 0x08, 0x00, 0x18, 0xC0, 0x00, 0xC6,
  0x00, 0x04, 0x30, 0x00, 0x61, 0x80, 0x03, 0x08, 0x00, 0x30, 0x40, 0x03,
  0x06, 0x00, 0x30, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0C, 0x03, 0x00, 0x40,
  0x18, 0x06, 0x00, 0x40, 0x30, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0,
  0x40, 0x03, 0x02, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00,
  0x18, 0x60, 0x00, 0xC2, 0x00, 0x03, 0x10, 0x00, 0x18, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x1C, 0x07, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x18, 0x30,
  0x00, 0x60, 0xC0, 0x00, 0x83, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x06,
  0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x84, 0x00, 0x0C, 0x18,
  0x00, 0x70, 0x30, 0x03, 0x80, 0xE0, 0x1C, 0x00, 0xFF, 0xE0, 0x01, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x0C, 0x20, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x02,
  0x18, 0x00, 0x08, 0x60, 0x00, 0x61, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30,
  0x00, 0x18, 0xC0, 0x00, 0x43, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x20, 0x00,
  0x31, 0x80, 0x00, 0xC6, 0x00, 0x02, 0x18, 0x00, 0x08, 0x60, 0x00, 0x61,
  0x00, 0x01, 0x84, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x43, 0x00,
  0x01, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x30, 0x80, 0x00, 0xC3, 0x00, 0x06,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0xC0, 0x60, 0x06, 0x01, 0xC0, 0x38, 0x03,
  0xFF, 0x80, 0x03, 0xF8, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0D, 0x80, 0x00, 0x64, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x03, 0x0C,
  0x00, 0x18, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x08, 0x00, 0x40, 0x40, 0x06,
  0x03, 0x00, 0x20, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x30,
  0x0C, 0x00, 0x80, 0xC0, 0x04, 0x06, 0x00, 0x30, 0x20, 0x01, 0x83, 0x00,
  0x0C, 0x10, 0x00, 0x61, 0x80, 0x03, 0x08, 0x00, 0x08, 0xC0, 0x00, 0x44,
  0x00, 0x02, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x40, 0x01, 0x80,
  0x06, 0x40, 0x03, 0x80, 0x06, 0x40, 0x02, 0x80, 0x04, 0x40, 0x06, 0x80,
  0x0C, 0x40, 0x06, 0x80, 0x0C, 0x60, 0x04, 0x80, 0x18, 0x60, 0x0C, 0x80,
  0x18, 0x60, 0x08, 0xC0, 0x10, 0x60, 0x18, 0xC0, 0x30, 0x60, 0x18, 0xC0,
  0x30, 0x60, 0x10, 0xC0, 0x20, 0x60, 0x30, 0xC0, 0x60, 0x60, 0x20, 0x40,
  0x60, 0x60, 0x60, 0x40, 0xC0, 0x60, 0x60, 0x40, 0xC0, 0x60, 0x40, 0x40,
  0x80, 0x60, 0xC0, 0x41, 0x80, 0x20, 0x80, 0x41, 0x80, 0x21, 0x80, 0x61,
  0x00, 0x21, 0x80, 0x63, 0x00, 0x21, 0x00, 0x63, 0x00, 0x23, 0x00, 0x62,
  0x00, 0x32, 0x00, 0x66, 0x00, 0x36, 0x00, 0x66, 0x00, 0x36, 0x00, 0x6C,
  0x00, 0x34, 0x00, 0x2C, 0x00, 0x3C, 0x00, 0x28, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x60, 0x00, 0x10, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x08, 0x00, 0x06, 0x06,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x06, 0x01, 0x80, 0x01, 0x81, 0x80,
  0x00, 0xC0, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x1B, 0x00, 0x01, 0x98, 0x00,
  0x0C, 0xC0, 0x00, 0xC2, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x06, 0x02,
  0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x18, 0x18,
  0x00, 0xC1, 0x80, 0x06, 0x18, 0x00, 0x10, 0xC0, 0x00, 0xCC, 0x00, 0x06,
  0xC0, 0x00, 0x16, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x82, 0x0C, 0x30, 0xC3, 0x04, 0x10, 0x41,
  0x86, 0x18, 0x60, 0x82, 0x08, 0x30, 0xC3, 0x0C, 0x10, 0x41, 0x06, 0x18,
  0x61, 0x82, 0x08, 0x20, 0xC3, 0x0C, 0x30, 0xC0, 0x01, 0xF0, 0x0F, 0x80,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x70, 0x02, 0x80, 0x36, 0x01, 0x30, 0x19, 0x80, 0x84, 0x0C, 0x20, 0x41,
  0x06, 0x0C, 0x20, 0x63, 0x03, 0x10, 0x09, 0x80, 0x48, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0x18, 0x61, 0x0C, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0x80,
  0xC1, 0x80, 0x21, 0x80, 0x18, 0x80, 0x0C, 0xC0, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x80, 0xFF, 0xC1, 0xFF, 0xE3, 0x80, 0x33, 0x80, 0x19,
  0x80, 0x09, 0x80, 0x04, 0xC0, 0x06, 0x60, 0x03, 0x20, 0x03, 0x98, 0x01,
  0xCC, 0x01, 0x43, 0x03, 0x21, 0xFF, 0x10, 0x3E, 0x08, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC7, 0xE0, 0x37, 0xFC,
  0x0B, 0x01, 0x83, 0x80, 0x61, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6,
  0x00, 0x31, 0x00, 0x0C, 0x40, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00,
  0x08, 0x80, 0x02, 0x20, 0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x0C,
  0x60, 0x03, 0x18, 0x01, 0x87, 0x00, 0x63, 0x60, 0x70, 0xCF, 0xF8, 0x30,
  0xF8, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0x80, 0xC1, 0x80, 0x31, 0x80,
  0x18, 0x80, 0x0C, 0xC0, 0x02, 0x60, 0x01, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x03, 0x20, 0x01, 0x10, 0x01, 0x8C, 0x00, 0x86, 0x00, 0xC1, 0x80,
  0xC0, 0x7F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x07, 0xC3, 0x03, 0xFE, 0x40, 0xC0, 0x48,
  0x30, 0x07, 0x0C, 0x00, 0xE1, 0x80, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x21,
  0x80, 0x04, 0x20, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC6,
  0x00, 0x10, 0xC0, 0x02, 0x18, 0x00, 0xC2, 0x00, 0x18, 0x60, 0x03, 0x0C,
  0x00, 0x61, 0x80, 0x18, 0x30, 0x07, 0x03, 0x01, 0xE0, 0x3F, 0xCC, 0x03,
  0xF1, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0x80, 0xC1, 0x80, 0x21, 0x80,
  0x18, 0x80, 0x0C, 0xC0, 0x06, 0x40, 0x01, 0x60, 0x01, 0xB0, 0x00, 0xDF,
  0xFF, 0xEF, 0xFF, 0xF4, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x41, 0x80,
  0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0xC0, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x3F, 0xF1, 0xFF,
  0x81, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x00, 0x00, 0x7C, 0x30, 0x1F, 0xF2, 0x03, 0x01, 0x20, 0x60, 0x0E, 0x0C,
  0x00, 0xE0, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x04, 0x18, 0x00, 0x41,
  0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x08,
  0x30, 0x00, 0x83, 0x00, 0x18, 0x20, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01,
  0x83, 0x00, 0x30, 0x30, 0x07, 0x01, 0x80, 0xF0, 0x0F, 0xF3, 0x00, 0x7E,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x0C, 0x00, 0xC0, 0x60, 0x38, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x0F, 0x81,
  0x9F, 0xE0, 0x98, 0x18, 0x58, 0x0C, 0x78, 0x06, 0x38, 0x01, 0x18, 0x00,
  0x8C, 0x00, 0x44, 0x00, 0x62, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0,
  0x06, 0x60, 0x02, 0x20, 0x03, 0x10, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66,
  0x00, 0x23, 0x00, 0x11, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03,
  0x00, 0x02, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C,
  0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30,
  0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0x00, 0x04,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x1C, 0x30, 0x0E, 0x08, 0x07, 0x02, 0x03,
  0x81, 0x81, 0xC0, 0x60, 0xE0, 0x18, 0x70, 0x06, 0x38, 0x01, 0x1C, 0x00,
  0x4E, 0x00, 0x37, 0x00, 0x0F, 0xC0, 0x03, 0x98, 0x00, 0xC2, 0x00, 0x20,
  0xC0, 0x08, 0x10, 0x06, 0x06, 0x01, 0x80, 0x80, 0x60, 0x30, 0x10, 0x04,
  0x04, 0x01, 0x83, 0x00, 0x20, 0xC0, 0x0C, 0x30, 0x01, 0x00, 0x03, 0x03,
  0x02, 0x02, 0x06, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08,
  0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x30, 0x20,
  0x20, 0x60, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0x0C, 0x7E, 0x03, 0xE0,
  0x23, 0xFC, 0x3F, 0xE0, 0x98, 0x39, 0x81, 0x86, 0x80, 0x6C, 0x03, 0x1C,
  0x01, 0xA0, 0x0C, 0x70, 0x03, 0x00, 0x31, 0x80, 0x0C, 0x00, 0xC6, 0x00,
  0x20, 0x03, 0x10, 0x01, 0x80, 0x0C, 0xC0, 0x06, 0x00, 0x33, 0x00, 0x18,
  0x00, 0xCC, 0x00, 0x60, 0x02, 0x30, 0x01, 0x00, 0x08, 0x80, 0x04, 0x00,
  0x66, 0x00, 0x30, 0x01, 0x98, 0x00, 0xC0, 0x06, 0x60, 0x03, 0x00, 0x19,
  0x80, 0x0C, 0x00, 0x46, 0x00, 0x20, 0x01, 0x10, 0x00, 0x80, 0x0C, 0xC0,
  0x06, 0x00, 0x33, 0x00, 0x18, 0x00, 0xCC, 0x00, 0x60, 0x03, 0x30, 0x01,
  0x80, 0x08, 0x0C, 0x3E, 0x06, 0x7F, 0x82, 0x60, 0xE1, 0x60, 0x31, 0xE0,
  0x18, 0xE0, 0x04, 0x60, 0x02, 0x30, 0x01, 0x10, 0x01, 0x88, 0x00, 0xCC,
  0x00, 0x66, 0x00, 0x33, 0x00, 0x19, 0x80, 0x08, 0x80, 0x0C, 0xC0, 0x06,
  0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0x8C, 0x00, 0x44, 0x00, 0x66, 0x00,
  0x33, 0x00, 0x19, 0x80, 0x0C, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0x81, 0xC3,
  0x00, 0x61, 0x00, 0x11, 0x80, 0x0C, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01,
  0xA0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0A, 0x00,
  0x05, 0x00, 0x06, 0x80, 0x03, 0x60, 0x03, 0x30, 0x01, 0x98, 0x01, 0x86,
  0x01, 0xC3, 0x81, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x03, 0x1F, 0x80, 0x27,
  0xFC, 0x02, 0xC0, 0x60, 0x38, 0x06, 0x07, 0x00, 0x30, 0x60, 0x03, 0x06,
  0x00, 0x30, 0x60, 0x03, 0x04, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x61, 0x80, 0x06,
  0x18, 0x00, 0x61, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x18, 0x1C, 0x01,
  0x83, 0x60, 0x70, 0x33, 0xFE, 0x03, 0x0F, 0x80, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xF0, 0xC1, 0xFF, 0x20,
  0xC0, 0x68, 0x60, 0x0E, 0x30, 0x03, 0x8C, 0x00, 0x66, 0x00, 0x19, 0x80,
  0x04, 0x60, 0x01, 0x10, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x02,
  0x30, 0x00, 0x8C, 0x00, 0x23, 0x00, 0x18, 0x80, 0x06, 0x20, 0x01, 0x8C,
  0x00, 0x43, 0x00, 0x30, 0xC0, 0x1C, 0x18, 0x0F, 0x03, 0xFE, 0xC0, 0x7E,
  0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x78,
  0x6F, 0xC2, 0xC0, 0x14, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0E, 0x06, 0x18, 0x03, 0x18, 0x03, 0x10,
  0x01, 0x10, 0x01, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0xC0,
  0x06, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x0C, 0x60, 0x38, 0x3F, 0xF0, 0x0F,
  0xC0, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x07, 0xFD, 0xFF, 0x0C,
  0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x3E, 0x07, 0x80, 0x18, 0x00, 0xC4, 0x00, 0x21, 0x00, 0x08, 0xC0, 0x06,
  0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x10, 0x80, 0x04, 0x20, 0x03, 0x18,
  0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x02, 0x10, 0x00, 0x84, 0x00,
  0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x70,
  0x60, 0x1C, 0x18, 0x1B, 0x03, 0xFC, 0xC0, 0x7E, 0x30, 0xC0, 0x03, 0xC0,
  0x02, 0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0x40, 0x0C, 0x40, 0x18, 0x60,
  0x18, 0x60, 0x30, 0x60, 0x30, 0x60, 0x20, 0x20, 0x60, 0x20, 0x40, 0x20,
  0xC0, 0x30, 0x80, 0x31, 0x80, 0x31, 0x00, 0x13, 0x00, 0x13, 0x00, 0x16,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x80, 0x18, 0x01,
  0xC0, 0x0C, 0x01, 0xA0, 0x0E, 0x00, 0xD0, 0x05, 0x00, 0xC8, 0x06, 0x80,
  0x66, 0x03, 0x40, 0x23, 0x01, 0x20, 0x31, 0x81, 0x90, 0x18, 0xC0, 0x8C,
  0x18, 0x60, 0xC6, 0x0C, 0x30, 0x43, 0x04, 0x18, 0x61, 0x86, 0x0C, 0x30,
  0xC3, 0x06, 0x10, 0x63, 0x03, 0x18, 0x11, 0x80, 0x88, 0x08, 0x80, 0x4C,
  0x04, 0xC0, 0x24, 0x02, 0x60, 0x16, 0x01, 0x60, 0x0B, 0x00, 0xB0, 0x05,
  0x00, 0x50, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00,
  0x04, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x03, 0x03,
  0x00, 0x10, 0x30, 0x01, 0x86, 0x00, 0x18, 0xC0, 0x00, 0xC8, 0x00, 0x0D,
  0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x01,
  0xB0, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x60, 0x80, 0x0C, 0x0C, 0x01,
  0x80, 0x40, 0x18, 0x06, 0x03, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x30,
  0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x20,
  0x06, 0x01, 0x00, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x01, 0x80,
  0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x02, 0x06, 0x00, 0x10, 0x60, 0x00, 0xC3,
  0x00, 0x06, 0x10, 0x00, 0x31, 0x80, 0x01, 0x88, 0x00, 0x04, 0xC0, 0x00,
  0x24, 0x00, 0x01, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x00, 0x04, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x02, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x02, 0x0C, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0x81, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x41, 0x83, 0x06, 0x0C, 0x18, 0x00, 0x01, 0x00, 0x07, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x70, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x00, 0x1F,
  0x00, 0x13, 0xF8, 0x01, 0x60, 0xC0, 0x34, 0x06, 0x03, 0xC0, 0x60, 0x2C,
  0x03, 0x06, 0x80, 0x1F, 0xC0, 0x00, 0xF8,
};

const GFXglyph RobotoCondensed_ExtraLightItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 32, 9, 1, -32 },
  { 29, 8, 9, 12, 5, -34 },
  { 38, 22, 32, 22, 1, -32 },
  { 126, 18, 40, 21, 2, -36 },
  { 216, 21, 32, 28, 4, -32 },
  { 300, 20, 32, 23, 1, -32 },
  { 380, 4, 9, 7, 4, -34 },
  { 385, 13, 46, 12, 2, -36 },
  { 460, 13, 46, 12, -3, -36 },
  { 535, 17, 18, 18, 3, -32 },
  { 574, 18, 24, 22, 2, -27 },
  { 628, 5, 9, 8, -1, -4 },
  { 634, 9, 2, 12, 1, -16 },
  { 637, 3, 3, 10, 1, -3 },
  { 639, 19, 35, 15, -2, -32 },
  { 723, 18, 32, 21, 2, -32 },
  { 795, 10, 32, 21, 6, -32 },
  { 835, 19, 32, 21, 1, -32 },
  { 911, 19, 32, 21, 1, -32 },
  { 987, 19, 32, 21, 1, -32 },
  { 1063, 19, 32, 21, 3, -32 },
  { 1139, 17, 32, 21, 2, -32 },
  { 1207, 18, 32, 21, 4, -32 },
  { 1279, 19, 32, 21, 1, -32 },
  { 1355, 17, 32, 21, 3, -32 },
  { 1423, 6, 24, 8, 1, -24 },
  { 1441, 9, 29, 8, -2, -24 },
  { 1474, 17, 18, 20, 2, -24 },
  { 1513, 17, 11, 21, 2, -20 },
  { 1537, 17, 18, 20, 1, -24 },
  { 1576, 13, 32, 17, 4, -32 },
  { 1628, 32, 41, 35, 1, -31 },
  { 1792, 21, 32, 23, -1, -32 },
  { 1876, 20, 32, 23, 2, -32 },
  { 1956, 21, 32, 25, 3, -32 },
  { 2040, 21, 32, 25, 2, -32 },
  { 2124, 21, 32, 22, 2, -32 },
  { 2208, 21, 32, 22, 2, -32 },
  { 2292, 21, 32, 26, 3, -32 },
  { 2376, 24, 32, 27, 2, -32 },
  { 2472, 7, 32, 11, 2, -32 },
  { 2500, 20, 32, 21, 1, -32 },
  { 2580, 23, 32, 24, 2, -32 },
  { 2672, 15, 32, 20, 2, -32 },
  { 2732, 30, 32, 33, 2, -32 },
  { 2852, 24, 32, 27, 2, -32 },
  { 2948, 22, 32, 26, 2, -32 },
  { 3036, 21, 32, 23, 2, -32 },
  { 3120, 22, 38, 26, 2, -32 },
  { 3225, 21, 32, 25, 2, -32 },
  { 3309, 22, 32, 23, 1, -32 },
  { 3397, 21, 32, 23, 4, -32 },
  { 3481, 22, 32, 25, 3, -32 },
  { 3569, 21, 32, 23, 4, -32 },
  { 3653, 32, 32, 34, 4, -32 },
  { 3781, 25, 32, 23, -1, -32 },
  { 3881, 21, 32, 23, 4, -32 },
  { 3965, 24, 32, 23, 0, -32 },
  { 4061, 13, 44, 9, 0, -37 },
  { 4133, 6, 35, 15, 5, -32 },
  { 4160, 13, 44, 9, -3, -37 },
  { 4232, 13, 16, 16, 2, -32 },
  { 4258, 16, 2, 16, -2, 0 },
  { 4262, 5, 6, 12, 6, -34 },
  { 4266, 17, 24, 20, 1, -24 },
  { 4317, 18, 34, 21, 1, -34 },
  { 4394, 17, 24, 20, 1, -24 },
  { 4445, 19, 34, 21, 2, -34 },
  { 4526, 17, 24, 20, 1, -24 },
  { 4577, 13, 34, 13, 3, -34 },
  { 4633, 20, 33, 21, 0, -24 },
  { 4716, 17, 34, 21, 1, -34 },
  { 4789, 8, 33, 9, 1, -33 },
  { 4822, 15, 42, 9, -6, -33 },
  { 4901, 18, 34, 19, 1, -34 },
  { 4978, 8, 34, 9, 1, -34 },
  { 5012, 30, 24, 34, 1, -24 },
  { 5102, 17, 24, 21, 1, -24 },
  { 5153, 17, 24, 21, 2, -24 },
  { 5204, 20, 33, 21, -1, -24 },
  { 5287, 18, 33, 21, 2, -24 },
  { 5362, 13, 24, 13, 1, -24 },
  { 5401, 16, 24, 19, 1, -24 },
  { 5449, 10, 30, 13, 2, -30 },
  { 5487, 18, 24, 21, 2, -24 },
  { 5541, 16, 24, 19, 3, -24 },
  { 5589, 25, 24, 29, 4, -24 },
  { 5664, 20, 24, 19, -1, -24 },
  { 5724, 21, 33, 18, -2, -24 },
  { 5811, 18, 24, 19, 0, -24 },
  { 5865, 15, 44, 13, 1, -35 },
  { 5948, 7, 38, 9, 1, -32 },
  { 5982, 14, 44, 13, -3, -35 },
  { 6059, 20, 8, 26, 3, -18 },
};

const GFXfont RobotoCondensed_ExtraLightItalic45pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic45pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic45pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC45PT7B_H_
