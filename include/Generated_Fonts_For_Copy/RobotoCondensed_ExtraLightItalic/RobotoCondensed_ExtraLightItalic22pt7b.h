#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC22PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x22, 0x22, 0x22, 0x44, 0x00, 0x04, 0x55, 0x59, 0x90,
  0x02, 0x20, 0x48, 0x11, 0x02, 0x23, 0xFE, 0x09, 0x02, 0x20, 0x44, 0x09,
  0x02, 0x20, 0x44, 0x3F, 0xE2, 0x20, 0x44, 0x09, 0x02, 0x20, 0x02, 0x02,
  0x03, 0x82, 0x22, 0x09, 0x05, 0x02, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40,
  0x14, 0x0A, 0x05, 0x04, 0x46, 0x1C, 0x04, 0x02, 0x00, 0x30, 0x12, 0x08,
  0x8A, 0x22, 0x89, 0x22, 0x87, 0x20, 0x10, 0x08, 0x02, 0x61, 0x24, 0x91,
  0x24, 0x51, 0x10, 0x44, 0x0E, 0x0E, 0x08, 0x88, 0x44, 0x22, 0x21, 0x20,
  0x60, 0x20, 0x28, 0x24, 0x61, 0x30, 0x98, 0x34, 0x0A, 0x1C, 0xF1, 0x56,
  0x80, 0x04, 0x21, 0x04, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x10, 0x40, 0x80, 0x10, 0x20, 0x82, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x42, 0x08, 0x20, 0x84, 0x10, 0x42, 0x10, 0x42, 0x00, 0x04,
  0x04, 0x02, 0x19, 0x33, 0xE0, 0xC0, 0x90, 0x48, 0x42, 0x00, 0x04, 0x02,
  0x02, 0x01, 0x00, 0x87, 0xFC, 0x20, 0x20, 0x10, 0x08, 0x04, 0x00, 0x25,
  0x28, 0xF0, 0x40, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08,
  0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x00, 0x0E,
  0x08, 0x88, 0x28, 0x14, 0x0A, 0x05, 0x03, 0x02, 0x81, 0x40, 0xA0, 0x50,
  0x28, 0x24, 0x11, 0x10, 0xF0, 0x1B, 0x64, 0x21, 0x08, 0x42, 0x21, 0x08,
  0x42, 0x11, 0x08, 0x0F, 0x04, 0x21, 0x04, 0x81, 0x20, 0x40, 0x20, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x04, 0x01, 0xFC, 0x1E,
  0x10, 0x88, 0x28, 0x10, 0x08, 0x08, 0x0C, 0x38, 0x02, 0x00, 0x80, 0x50,
  0x28, 0x14, 0x13, 0x10, 0xF0, 0x00, 0x80, 0x60, 0x18, 0x0A, 0x04, 0x81,
  0x20, 0x90, 0x44, 0x11, 0x08, 0x44, 0x11, 0xFF, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x1F, 0x84, 0x01, 0x00, 0x80, 0x20, 0x08, 0x03, 0xE1, 0x84, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x81, 0x20, 0x84, 0x20, 0xF0, 0x07, 0x08, 0x10,
  0x20, 0x20, 0x40, 0x5E, 0x61, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x82, 0x46,
  0x38, 0xFF, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08,
  0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x0F, 0x18, 0x88, 0x28, 0x14,
  0x0A, 0x08, 0x84, 0x3C, 0x62, 0x40, 0xA0, 0x50, 0x28, 0x14, 0x12, 0x18,
  0xF0, 0x3C, 0x42, 0x42, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x86, 0x7A,
  0x04, 0x04, 0x08, 0x10, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x08, 0x84, 0x40, 0x01, 0x06, 0x18, 0x60,
  0x80, 0x60, 0x10, 0x0C, 0x02, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x40,
  0x30, 0x08, 0x06, 0x01, 0x06, 0x18, 0x60, 0x80, 0x38, 0x8A, 0x14, 0x10,
  0x40, 0x81, 0x04, 0x10, 0x40, 0x82, 0x00, 0x00, 0x00, 0x60, 0x03, 0xF0,
  0x08, 0x10, 0x20, 0x10, 0x80, 0x12, 0x00, 0x24, 0x38, 0x50, 0x88, 0xA2,
  0x11, 0x88, 0x43, 0x10, 0x86, 0x21, 0x14, 0x44, 0x28, 0x88, 0x51, 0x31,
  0x23, 0x9C, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x80, 0x30, 0x06, 0x01, 0x40, 0x28, 0x08, 0x81, 0x10, 0x42, 0x08,
  0x42, 0x08, 0x7F, 0x10, 0x22, 0x04, 0x80, 0x50, 0x0A, 0x01, 0x3F, 0x08,
  0x22, 0x04, 0x81, 0x20, 0x50, 0x24, 0x11, 0xF8, 0x41, 0x10, 0x24, 0x0A,
  0x02, 0x80, 0xA0, 0x48, 0x33, 0xF0, 0x0F, 0x82, 0x08, 0x81, 0x10, 0x14,
  0x02, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x48, 0x08,
  0x81, 0x10, 0x41, 0xF0, 0x3F, 0x08, 0x22, 0x04, 0x81, 0x20, 0x50, 0x14,
  0x05, 0x01, 0x40, 0x50, 0x14, 0x06, 0x02, 0x80, 0xA0, 0x48, 0x23, 0xF0,
  0x3F, 0xC8, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0xFC, 0x40, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFC, 0x3F, 0xC8, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x01, 0xFC, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x07, 0x83, 0x08, 0x80, 0x90, 0x12, 0x02, 0x80,
  0x10, 0x02, 0x00, 0x43, 0xC8, 0x0A, 0x01, 0x40, 0x24, 0x04, 0x81, 0x10,
  0x61, 0xF0, 0x20, 0x12, 0x01, 0x20, 0x22, 0x02, 0x20, 0x24, 0x02, 0x40,
  0x27, 0xFE, 0x40, 0x44, 0x04, 0x40, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80,
  0x88, 0x08, 0x12, 0x22, 0x22, 0x24, 0x44, 0x44, 0x48, 0x88, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x12,
  0x04, 0x81, 0x10, 0x84, 0x20, 0xF0, 0x20, 0x24, 0x08, 0x82, 0x10, 0x82,
  0x20, 0x88, 0x12, 0x02, 0xC0, 0x68, 0x08, 0x81, 0x10, 0x41, 0x08, 0x21,
  0x02, 0x20, 0x44, 0x04, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x04, 0x08, 0x10, 0x20, 0x7F, 0x30, 0x06, 0x60, 0x08, 0xC0, 0x31,
  0x80, 0x63, 0x01, 0x49, 0x02, 0x92, 0x09, 0x24, 0x14, 0x48, 0x48, 0x90,
  0x91, 0x22, 0x24, 0x24, 0x48, 0x50, 0x90, 0xA2, 0x21, 0x84, 0x42, 0x08,
  0x20, 0x13, 0x01, 0x30, 0x12, 0x82, 0x28, 0x24, 0x82, 0x44, 0x24, 0x42,
  0x42, 0x24, 0x24, 0x42, 0x48, 0x14, 0x81, 0x48, 0x14, 0x80, 0x88, 0x08,
  0x0F, 0x82, 0x08, 0x81, 0x10, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x80,
  0x50, 0x0A, 0x01, 0x40, 0x28, 0x08, 0x81, 0x10, 0x41, 0xF0, 0x3F, 0x88,
  0x12, 0x04, 0x81, 0x20, 0x50, 0x14, 0x05, 0x02, 0x7F, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x0F, 0x82, 0x08, 0x81, 0x10, 0x14,
  0x02, 0x80, 0x50, 0x0A, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x08,
  0x81, 0x10, 0x41, 0xF0, 0x02, 0x00, 0x20, 0x04, 0x00, 0x3F, 0x08, 0x32,
  0x04, 0x81, 0x20, 0x50, 0x14, 0x09, 0x06, 0x7E, 0x10, 0x84, 0x22, 0x08,
  0x81, 0x20, 0x48, 0x12, 0x02, 0x0F, 0x0C, 0x22, 0x05, 0x01, 0x40, 0x10,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0A, 0x02, 0x80, 0xA0, 0x4C, 0x30,
  0xF0, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x24, 0x04,
  0x80, 0x90, 0x14, 0x02, 0x80, 0x90, 0x12, 0x02, 0x40, 0x48, 0x0A, 0x01,
  0x40, 0x48, 0x09, 0x01, 0x10, 0x41, 0xF0, 0x80, 0x60, 0x18, 0x0A, 0x02,
  0x81, 0x10, 0x44, 0x21, 0x08, 0x42, 0x11, 0x04, 0x40, 0xA0, 0x28, 0x0C,
  0x03, 0x00, 0x80, 0x81, 0x03, 0x02, 0x06, 0x0A, 0x0C, 0x14, 0x28, 0x28,
  0x50, 0x91, 0x21, 0x22, 0x24, 0x44, 0x48, 0x90, 0x91, 0x21, 0x42, 0x42,
  0x85, 0x06, 0x0A, 0x0C, 0x14, 0x18, 0x10, 0x20, 0x20, 0x20, 0x11, 0x02,
  0x10, 0x40, 0x88, 0x08, 0x80, 0x90, 0x06, 0x00, 0x60, 0x06, 0x00, 0xA0,
  0x12, 0x01, 0x10, 0x21, 0x04, 0x08, 0x40, 0x88, 0x08, 0x80, 0x60, 0x24,
  0x09, 0x04, 0x42, 0x08, 0x82, 0x40, 0x90, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x08, 0x02, 0x00, 0x80, 0x1F, 0xE0, 0x02, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x0F, 0xF8, 0x1C, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20,
  0x82, 0x08, 0x41, 0x04, 0x10, 0x41, 0x08, 0x20, 0xE0, 0x92, 0x24, 0x92,
  0x48, 0x92, 0x49, 0x20, 0x1C, 0x10, 0x82, 0x08, 0x20, 0x82, 0x10, 0x41,
  0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0xC0, 0x08, 0x61, 0x8A, 0x25,
  0x14, 0x61, 0xFF, 0x94, 0x0F, 0x18, 0x88, 0x20, 0x10, 0x08, 0xF9, 0x84,
  0x82, 0x81, 0x41, 0x91, 0x4F, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01,
  0x78, 0xC2, 0x41, 0x20, 0x90, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x04, 0xC6,
  0x9C, 0x00, 0x1E, 0x22, 0x41, 0x81, 0x80, 0x80, 0x80, 0x80, 0x82, 0x82,
  0x84, 0x78, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0xE4, 0x8C, 0x82, 0x41,
  0x40, 0xA0, 0x50, 0x28, 0x24, 0x12, 0x09, 0x0C, 0x7A, 0x00, 0x1E, 0x22,
  0x41, 0x81, 0x81, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x86, 0x78, 0x0E, 0x20,
  0x41, 0x02, 0x0F, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40,
  0x80, 0x0E, 0x44, 0x62, 0x08, 0x82, 0x40, 0x90, 0x24, 0x09, 0x04, 0x41,
  0x10, 0x44, 0x30, 0xF4, 0x01, 0x00, 0x88, 0x61, 0xE0, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x4E, 0x71, 0x61, 0x41, 0x41, 0x41, 0x81, 0x82, 0x82, 0x82,
  0x82, 0x82, 0x20, 0x04, 0x92, 0x4A, 0x49, 0x24, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20,
  0x47, 0x00, 0x20, 0x20, 0x20, 0x20, 0x20, 0x41, 0x42, 0x44, 0x48, 0x50,
  0x60, 0xD0, 0x88, 0x88, 0x88, 0x84, 0x84, 0x24, 0x92, 0x92, 0x49, 0x49,
  0x24, 0x80, 0x2F, 0x1C, 0x61, 0x44, 0x83, 0x09, 0x04, 0x12, 0x08, 0x28,
  0x10, 0x50, 0x20, 0xA0, 0x81, 0x41, 0x02, 0x82, 0x09, 0x04, 0x14, 0x08,
  0x20, 0x4E, 0x71, 0x61, 0x41, 0x41, 0x41, 0x81, 0x82, 0x82, 0x82, 0x82,
  0x82, 0x1E, 0x21, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x84,
  0x78, 0x2F, 0x18, 0x48, 0x24, 0x12, 0x0A, 0x05, 0x02, 0x81, 0x40, 0xA0,
  0x98, 0xD3, 0x88, 0x04, 0x02, 0x01, 0x00, 0x1C, 0x91, 0x90, 0x48, 0x28,
  0x14, 0x0A, 0x05, 0x04, 0x82, 0x41, 0x21, 0x8F, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x5D, 0x84, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x20, 0x1E, 0x10,
  0x88, 0x24, 0x02, 0x00, 0xC0, 0x18, 0x04, 0x01, 0x40, 0x90, 0x87, 0x80,
  0x21, 0x09, 0xF2, 0x11, 0x08, 0x42, 0x10, 0x88, 0x41, 0x80, 0x40, 0xA0,
  0x90, 0x48, 0x24, 0x14, 0x0A, 0x05, 0x04, 0x82, 0x41, 0x21, 0x8F, 0x40,
  0x81, 0x81, 0x42, 0x42, 0x44, 0x44, 0x48, 0x48, 0x28, 0x30, 0x30, 0x20,
  0x84, 0x18, 0x42, 0x8A, 0x28, 0xA2, 0x92, 0x49, 0x24, 0x92, 0x4A, 0x28,
  0xA2, 0x8C, 0x30, 0xC3, 0x08, 0x20, 0x20, 0x90, 0x84, 0x82, 0x41, 0x40,
  0x40, 0x20, 0x28, 0x24, 0x22, 0x10, 0x90, 0x40, 0x20, 0x44, 0x11, 0x08,
  0x42, 0x11, 0x04, 0x41, 0x20, 0x48, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x02, 0x03, 0x00, 0x3F, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40,
  0x20, 0x20, 0x20, 0x10, 0x1F, 0xC0, 0x06, 0x10, 0x40, 0x81, 0x02, 0x08,
  0x10, 0x20, 0x82, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x04, 0x00, 0x11, 0x11, 0x12, 0x22, 0x22, 0x24, 0x44, 0x44, 0x44, 0x80,
  0x10, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x10, 0x41, 0x02,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x04, 0x10, 0x00, 0x38, 0x51, 0x14, 0x46,
  0x0E,
};

const GFXglyph RobotoCondensed_ExtraLightItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 16, 4, 0, -16 },
  { 9, 4, 5, 6, 2, -17 },
  { 12, 11, 16, 11, 0, -16 },
  { 34, 9, 20, 10, 1, -18 },
  { 57, 10, 16, 14, 2, -16 },
  { 77, 9, 16, 11, 1, -16 },
  { 95, 2, 5, 4, 2, -17 },
  { 97, 6, 22, 6, 1, -17 },
  { 114, 6, 22, 6, -1, -17 },
  { 131, 9, 9, 9, 1, -16 },
  { 142, 9, 11, 11, 1, -13 },
  { 155, 3, 5, 4, -1, -2 },
  { 157, 4, 1, 6, 1, -8 },
  { 158, 2, 1, 5, 0, -1 },
  { 159, 9, 17, 7, -1, -16 },
  { 179, 9, 16, 10, 1, -16 },
  { 197, 5, 16, 10, 3, -16 },
  { 207, 10, 16, 10, 0, -16 },
  { 227, 9, 16, 10, 1, -16 },
  { 245, 10, 16, 10, 0, -16 },
  { 265, 10, 16, 10, 1, -16 },
  { 285, 8, 16, 10, 1, -16 },
  { 301, 9, 16, 10, 2, -16 },
  { 319, 9, 16, 10, 1, -16 },
  { 337, 8, 16, 10, 2, -16 },
  { 353, 4, 11, 4, 0, -11 },
  { 359, 5, 14, 4, -1, -11 },
  { 368, 8, 9, 10, 1, -12 },
  { 377, 8, 6, 10, 1, -10 },
  { 383, 8, 9, 10, 1, -12 },
  { 392, 7, 16, 8, 2, -16 },
  { 406, 15, 20, 17, 1, -15 },
  { 444, 11, 16, 11, -1, -16 },
  { 466, 10, 16, 11, 1, -16 },
  { 486, 11, 16, 12, 1, -16 },
  { 508, 10, 16, 12, 1, -16 },
  { 528, 10, 16, 11, 1, -16 },
  { 548, 10, 16, 11, 1, -16 },
  { 568, 11, 16, 13, 1, -16 },
  { 590, 12, 16, 13, 1, -16 },
  { 614, 4, 16, 5, 1, -16 },
  { 622, 10, 16, 10, 0, -16 },
  { 642, 11, 16, 12, 1, -16 },
  { 664, 7, 16, 10, 1, -16 },
  { 678, 15, 16, 16, 1, -16 },
  { 708, 12, 16, 13, 1, -16 },
  { 732, 11, 16, 13, 1, -16 },
  { 754, 10, 16, 11, 1, -16 },
  { 774, 11, 19, 13, 1, -16 },
  { 801, 10, 16, 12, 1, -16 },
  { 821, 10, 16, 11, 1, -16 },
  { 841, 10, 16, 11, 2, -16 },
  { 861, 11, 16, 12, 1, -16 },
  { 883, 10, 16, 11, 2, -16 },
  { 903, 15, 16, 17, 2, -16 },
  { 933, 12, 16, 11, 0, -16 },
  { 957, 10, 16, 11, 2, -16 },
  { 977, 12, 16, 11, 0, -16 },
  { 1001, 6, 21, 5, 0, -18 },
  { 1017, 3, 17, 7, 2, -16 },
  { 1024, 6, 21, 5, -1, -18 },
  { 1040, 6, 8, 8, 1, -16 },
  { 1046, 8, 1, 8, -1, 0 },
  { 1047, 2, 3, 6, 3, -17 },
  { 1048, 9, 12, 10, 0, -12 },
  { 1062, 9, 17, 10, 0, -17 },
  { 1082, 8, 12, 10, 1, -12 },
  { 1094, 9, 17, 10, 1, -17 },
  { 1114, 8, 12, 10, 1, -12 },
  { 1126, 7, 17, 6, 1, -17 },
  { 1141, 10, 16, 10, 0, -12 },
  { 1161, 8, 17, 10, 1, -17 },
  { 1178, 3, 16, 4, 1, -16 },
  { 1184, 7, 20, 4, -3, -16 },
  { 1202, 8, 17, 9, 1, -17 },
  { 1219, 3, 17, 4, 1, -17 },
  { 1226, 15, 12, 16, 0, -12 },
  { 1249, 8, 12, 10, 1, -12 },
  { 1261, 8, 12, 10, 1, -12 },
  { 1273, 9, 16, 10, 0, -12 },
  { 1291, 9, 16, 10, 1, -12 },
  { 1309, 6, 12, 6, 1, -12 },
  { 1318, 9, 12, 9, 0, -12 },
  { 1332, 5, 15, 6, 1, -15 },
  { 1342, 9, 12, 10, 1, -12 },
  { 1356, 8, 12, 9, 1, -12 },
  { 1368, 12, 12, 14, 2, -12 },
  { 1386, 9, 12, 9, 0, -12 },
  { 1400, 10, 16, 9, -1, -12 },
  { 1420, 9, 12, 9, 0, -12 },
  { 1434, 7, 22, 6, 1, -17 },
  { 1454, 4, 19, 4, 0, -16 },
  { 1464, 7, 22, 6, -1, -17 },
  { 1484, 10, 4, 13, 1, -9 },
};

const GFXfont RobotoCondensed_ExtraLightItalic22pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic22pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC22PT7B_H_
