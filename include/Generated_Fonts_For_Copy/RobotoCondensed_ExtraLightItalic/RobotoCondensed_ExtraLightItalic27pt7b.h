#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC27PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x12, 0x22, 0x22, 0x44, 0x44, 0x40, 0x00, 0x08, 0x80, 0x4A,
  0xA5, 0x29, 0x48, 0x01, 0x10, 0x10, 0x80, 0x88, 0x04, 0x40, 0x42, 0x1F,
  0xFC, 0x11, 0x01, 0x08, 0x08, 0x40, 0x44, 0x04, 0x20, 0x21, 0x01, 0x10,
  0x7F, 0xF0, 0x84, 0x04, 0x40, 0x42, 0x02, 0x10, 0x11, 0x00, 0x01, 0x00,
  0x20, 0x04, 0x03, 0xC0, 0x84, 0x20, 0x48, 0x09, 0x01, 0x20, 0x24, 0x00,
  0x40, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x80, 0x50, 0x0A, 0x02,
  0x20, 0x46, 0x30, 0x7C, 0x02, 0x00, 0x40, 0x1C, 0x01, 0x20, 0x10, 0x84,
  0x84, 0x24, 0x22, 0x41, 0x21, 0x12, 0x08, 0x90, 0x39, 0x00, 0x10, 0x00,
  0x9C, 0x09, 0x10, 0x90, 0x88, 0x84, 0x44, 0x24, 0x21, 0x41, 0x10, 0x08,
  0x80, 0x38, 0x07, 0x80, 0x8C, 0x18, 0x41, 0x04, 0x10, 0xC1, 0x08, 0x11,
  0x00, 0xA0, 0x0C, 0x01, 0x40, 0x24, 0x14, 0x22, 0xC2, 0x28, 0x12, 0x81,
  0xC8, 0x0C, 0x80, 0xC4, 0x34, 0x3C, 0x20, 0x6A, 0xA0, 0x01, 0x02, 0x04,
  0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40, 0x20, 0x10,
  0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x10,
  0x20, 0x40, 0x80, 0x04, 0x01, 0x00, 0x40, 0x20, 0xC9, 0xCF, 0x81, 0x80,
  0x50, 0x24, 0x10, 0x88, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x00, 0x24, 0xB5, 0x00, 0xF8, 0xC0, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x00, 0x07,
  0x81, 0x08, 0x41, 0x90, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x40, 0x28,
  0x09, 0x01, 0x60, 0x28, 0x05, 0x00, 0xA0, 0x24, 0x04, 0x41, 0x0C, 0x60,
  0xF0, 0x00, 0x08, 0xEC, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x04, 0x20,
  0x82, 0x08, 0x21, 0x04, 0x00, 0x07, 0x83, 0x08, 0x41, 0x10, 0x12, 0x02,
  0x80, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x03, 0xFE, 0x00, 0x07, 0x83, 0x08, 0x40,
  0x90, 0x12, 0x02, 0x00, 0x40, 0x10, 0x02, 0x01, 0x81, 0xC0, 0x06, 0x00,
  0x40, 0x05, 0x00, 0xA0, 0x14, 0x04, 0xC0, 0x88, 0x60, 0xF8, 0x00, 0x00,
  0x40, 0x18, 0x03, 0x00, 0xA0, 0x24, 0x08, 0x81, 0x20, 0x44, 0x10, 0x86,
  0x10, 0x82, 0x20, 0x88, 0x11, 0xFF, 0xC0, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x00, 0x1F, 0xE2, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02,
  0xF0, 0x61, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x20, 0x24, 0x08,
  0x81, 0x08, 0x40, 0xF0, 0x00, 0x01, 0xC1, 0x80, 0x80, 0x40, 0x10, 0x08,
  0x02, 0x01, 0x3C, 0x50, 0x98, 0x14, 0x05, 0x01, 0x80, 0x60, 0x18, 0x05,
  0x02, 0x40, 0x98, 0x41, 0xE0, 0x7F, 0xE0, 0x04, 0x01, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x08, 0x03, 0x00, 0x00, 0x07, 0x81, 0x08, 0x40,
  0x90, 0x12, 0x02, 0x40, 0x48, 0x09, 0x02, 0x10, 0x81, 0xE0, 0xC6, 0x20,
  0x68, 0x05, 0x00, 0xA0, 0x14, 0x04, 0x80, 0x88, 0x60, 0xF8, 0x00, 0x0F,
  0x0C, 0x62, 0x09, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0xA0, 0x2C,
  0x19, 0x0A, 0x3C, 0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x0F, 0x00, 0x11,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x4C, 0x08, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x10, 0x88, 0x44, 0x00, 0x00, 0x40, 0x60, 0x60, 0x60, 0x60,
  0x20, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x10, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x40, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x30, 0x18, 0x18, 0x18, 0x18, 0x08, 0x00, 0x1E, 0x10, 0x90, 0x48, 0x28,
  0x10, 0x08, 0x04, 0x04, 0x06, 0x06, 0x02, 0x02, 0x02, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x7E, 0x00, 0x30, 0x60, 0x18, 0x02,
  0x06, 0x00, 0x20, 0x80, 0x04, 0x20, 0x00, 0x88, 0x1E, 0x11, 0x04, 0x61,
  0x41, 0x08, 0x28, 0x41, 0x05, 0x08, 0x21, 0x42, 0x04, 0x28, 0x41, 0x05,
  0x08, 0x20, 0xA1, 0x04, 0x24, 0x21, 0x84, 0x84, 0x30, 0x90, 0x8A, 0x22,
  0x0E, 0x38, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x81, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x60, 0x03, 0x00, 0x28, 0x01, 0x40,
  0x12, 0x00, 0x90, 0x08, 0x80, 0x42, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10,
  0x21, 0xFF, 0x08, 0x08, 0x80, 0x44, 0x01, 0x60, 0x0A, 0x00, 0x70, 0x02,
  0x1F, 0xC1, 0x02, 0x10, 0x11, 0x01, 0x30, 0x12, 0x01, 0x20, 0x12, 0x02,
  0x20, 0x43, 0xF8, 0x40, 0x44, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02,
  0x80, 0x48, 0x08, 0xFF, 0x00, 0x07, 0xC1, 0x82, 0x30, 0x12, 0x01, 0x40,
  0x14, 0x01, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x02, 0x80, 0x48, 0x04, 0x80, 0x84, 0x18, 0x3E, 0x00, 0x1F, 0xC0,
  0x81, 0x04, 0x04, 0x20, 0x32, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x20,
  0x09, 0x00, 0x50, 0x04, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x88, 0x0C,
  0x80, 0x44, 0x0C, 0x3F, 0x80, 0x1F, 0xF8, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0xFE, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0xFE, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x07, 0xC0, 0x41, 0x04, 0x04,
  0x40, 0x26, 0x01, 0xA0, 0x05, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0xFD, 0x00, 0x48, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04, 0xC0, 0x63, 0x0E,
  0x07, 0xC0, 0x10, 0x02, 0x20, 0x08, 0x40, 0x10, 0x80, 0x22, 0x00, 0x44,
  0x00, 0x88, 0x01, 0x10, 0x04, 0x20, 0x08, 0x7F, 0xF1, 0x00, 0x22, 0x00,
  0x44, 0x00, 0x88, 0x02, 0x10, 0x04, 0x20, 0x08, 0x80, 0x11, 0x00, 0x22,
  0x00, 0xC0, 0x08, 0x84, 0x21, 0x08, 0xC4, 0x21, 0x08, 0x44, 0x21, 0x08,
  0x42, 0x20, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x44, 0x04, 0x40,
  0x44, 0x08, 0x40, 0x86, 0x10, 0x3E, 0x00, 0x10, 0x0C, 0x40, 0x61, 0x03,
  0x04, 0x18, 0x20, 0xC0, 0x86, 0x02, 0x30, 0x09, 0x80, 0x2C, 0x00, 0xF0,
  0x07, 0x20, 0x18, 0x80, 0x41, 0x01, 0x04, 0x04, 0x08, 0x10, 0x20, 0x80,
  0x42, 0x01, 0x88, 0x02, 0x00, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x3F, 0xE0, 0x18, 0x00, 0x46, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x05,
  0x28, 0x02, 0x89, 0x00, 0xA2, 0x40, 0x48, 0x90, 0x12, 0x24, 0x08, 0x89,
  0x02, 0x24, 0x41, 0x11, 0x08, 0x44, 0x42, 0x21, 0x10, 0x88, 0x44, 0x24,
  0x11, 0x09, 0x0C, 0x81, 0x82, 0x20, 0x60, 0x88, 0x10, 0x20, 0x10, 0x02,
  0x30, 0x04, 0x60, 0x10, 0xA0, 0x23, 0x40, 0x44, 0x80, 0x88, 0x81, 0x11,
  0x06, 0x21, 0x08, 0x42, 0x11, 0x04, 0x22, 0x04, 0x44, 0x08, 0x88, 0x12,
  0x10, 0x14, 0x20, 0x28, 0x80, 0x31, 0x00, 0x62, 0x00, 0xC0, 0x03, 0xE0,
  0x30, 0x41, 0x80, 0x84, 0x02, 0x20, 0x08, 0x80, 0x22, 0x00, 0x90, 0x02,
  0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40, 0x11, 0x00, 0x44, 0x01,
  0x10, 0x08, 0x40, 0x60, 0x83, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x81, 0x84,
  0x04, 0x20, 0x13, 0x00, 0x90, 0x04, 0x80, 0x44, 0x02, 0x20, 0x31, 0x03,
  0x1F, 0xE0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x00, 0x03, 0xE0, 0x30, 0x41, 0x80, 0x84, 0x02, 0x20, 0x08,
  0x80, 0x22, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02,
  0xC0, 0x12, 0x00, 0x44, 0x01, 0x10, 0x08, 0x40, 0x60, 0x83, 0x01, 0xF0,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x1F, 0xC0, 0x81, 0x84, 0x04, 0x20,
  0x12, 0x00, 0x90, 0x04, 0x80, 0x44, 0x02, 0x20, 0x21, 0x03, 0x1F, 0xE0,
  0x83, 0x04, 0x08, 0x20, 0x41, 0x03, 0x08, 0x08, 0x80, 0x44, 0x03, 0x20,
  0x08, 0x07, 0xC0, 0x41, 0x04, 0x04, 0x40, 0x22, 0x01, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x80, 0x02, 0x40, 0x12,
  0x00, 0x90, 0x0C, 0xC0, 0x43, 0x0C, 0x0F, 0x80, 0xFF, 0xF0, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x00, 0x20, 0x09, 0x00, 0x48, 0x02, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00,
  0x48, 0x02, 0x40, 0x34, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x40, 0x12,
  0x01, 0x10, 0x08, 0x80, 0x82, 0x08, 0x0F, 0x80, 0xC0, 0x0A, 0x00, 0x90,
  0x04, 0x80, 0x64, 0x02, 0x20, 0x31, 0x01, 0x04, 0x08, 0x20, 0x81, 0x04,
  0x08, 0x40, 0x42, 0x02, 0x20, 0x11, 0x00, 0x50, 0x02, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x14, 0x0A, 0x05, 0x02,
  0x81, 0x40, 0xA0, 0x90, 0x48, 0x24, 0x12, 0x11, 0x04, 0x84, 0x42, 0x21,
  0x10, 0x88, 0x84, 0x42, 0x20, 0x90, 0x90, 0x24, 0x24, 0x0A, 0x05, 0x02,
  0x81, 0x80, 0xA0, 0x60, 0x30, 0x10, 0x0C, 0x04, 0x02, 0x00, 0x10, 0x04,
  0x30, 0x18, 0x20, 0x20, 0x40, 0x80, 0x42, 0x00, 0x8C, 0x01, 0x90, 0x01,
  0x40, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x24, 0x00, 0x88, 0x01, 0x18,
  0x04, 0x10, 0x10, 0x20, 0x60, 0x20, 0x80, 0x42, 0x00, 0xC0, 0x40, 0x0A,
  0x00, 0x90, 0x08, 0x40, 0x42, 0x04, 0x10, 0x40, 0x42, 0x02, 0x20, 0x12,
  0x00, 0x50, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x1F, 0xFC, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x80, 0xF0, 0x88, 0x88, 0x84, 0x44, 0x44, 0x44, 0x22,
  0x22, 0x22, 0x21, 0x10, 0x0F, 0x03, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x10, 0xF0, 0x04, 0x04, 0x0A, 0x0A, 0x12, 0x12,
  0x22, 0x22, 0x42, 0x41, 0xFF, 0x80, 0x99, 0x30, 0x07, 0x83, 0x08, 0x40,
  0x90, 0x10, 0x02, 0x00, 0x80, 0x10, 0x7E, 0x30, 0x48, 0x09, 0x01, 0x60,
  0x44, 0x18, 0x87, 0x0F, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x02, 0x78, 0xE3, 0x20, 0x48, 0x14, 0x05, 0x01, 0x40, 0x50, 0x14, 0x05,
  0x01, 0x80, 0xA0, 0x2C, 0x1A, 0x8C, 0x9E, 0x00, 0x0F, 0x0C, 0x22, 0x05,
  0x01, 0x40, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x0A, 0x02, 0x81,
  0x10, 0x83, 0xC0, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x0F, 0x21, 0x0A, 0x20, 0x44, 0x04, 0x40, 0x44, 0x04, 0x80, 0x48, 0x04,
  0x80, 0x88, 0x08, 0x80, 0x88, 0x08, 0x81, 0x84, 0x28, 0x3D, 0x00, 0x0F,
  0x04, 0x22, 0x05, 0x01, 0x40, 0x60, 0x1F, 0xFE, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x10, 0xC3, 0xE0, 0x07, 0x18, 0x10, 0x10, 0x20, 0x20,
  0xFC, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x07, 0x91, 0x85, 0x10, 0x22, 0x02, 0x20, 0x22, 0x02,
  0x40, 0x24, 0x02, 0x40, 0x44, 0x04, 0x40, 0x44, 0x04, 0x40, 0xC2, 0x14,
  0x1E, 0x80, 0x08, 0x00, 0x80, 0x10, 0x43, 0x03, 0xC0, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x78, 0xA3, 0x30, 0x48, 0x16, 0x05, 0x01,
  0x40, 0x50, 0x14, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x81, 0x00,
  0x11, 0x00, 0x00, 0x22, 0x22, 0x64, 0x44, 0x44, 0x48, 0x88, 0x80, 0x01,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x30,
  0xE0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x11, 0x04,
  0x21, 0x04, 0x41, 0x10, 0x24, 0x05, 0x00, 0xD0, 0x12, 0x02, 0x20, 0x84,
  0x10, 0x42, 0x08, 0x40, 0x88, 0x10, 0x11, 0x11, 0x12, 0x22, 0x22, 0x24,
  0x44, 0x44, 0x48, 0x88, 0x80, 0x27, 0x8F, 0x0A, 0x24, 0x23, 0x06, 0x0D,
  0x81, 0x81, 0x40, 0x40, 0x50, 0x10, 0x14, 0x04, 0x09, 0x02, 0x02, 0x40,
  0x80, 0xA0, 0x20, 0x28, 0x08, 0x0A, 0x02, 0x02, 0x80, 0x81, 0x20, 0x40,
  0x48, 0x10, 0x10, 0x27, 0x8A, 0x33, 0x04, 0x81, 0x60, 0x50, 0x14, 0x05,
  0x01, 0x40, 0x90, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x10, 0x0F, 0x04,
  0x22, 0x05, 0x01, 0x40, 0x50, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A,
  0x02, 0xC1, 0x90, 0xC3, 0xC0, 0x13, 0xC3, 0x8C, 0x40, 0x98, 0x12, 0x02,
  0x40, 0x48, 0x09, 0x01, 0x20, 0x28, 0x05, 0x01, 0x20, 0x26, 0x0C, 0xE3,
  0x13, 0xC4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x00, 0x0F, 0x22, 0x14,
  0x81, 0x20, 0x24, 0x04, 0x80, 0xB0, 0x14, 0x02, 0x80, 0x90, 0x12, 0x02,
  0x40, 0x48, 0x18, 0x86, 0x0F, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x26, 0x38, 0x30, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x0F, 0x83, 0x18, 0xC1, 0x10, 0x22, 0x00, 0x20,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x10, 0x02, 0x20, 0x44, 0x08, 0xC2, 0x0F,
  0x80, 0x10, 0x41, 0x1F, 0x10, 0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04,
  0x10, 0x40, 0xC0, 0x20, 0x24, 0x04, 0x81, 0x20, 0x24, 0x04, 0x80, 0x90,
  0x12, 0x02, 0x40, 0x90, 0x12, 0x02, 0x40, 0x44, 0x18, 0x85, 0x0F, 0x40,
  0x80, 0xC0, 0x60, 0x50, 0x28, 0x24, 0x11, 0x08, 0x88, 0x44, 0x24, 0x12,
  0x0A, 0x03, 0x01, 0x00, 0x80, 0x81, 0x03, 0x02, 0x06, 0x0C, 0x14, 0x18,
  0x28, 0x50, 0x90, 0x91, 0x12, 0x22, 0x24, 0x48, 0x48, 0x90, 0xA1, 0x61,
  0x42, 0x83, 0x05, 0x06, 0x0C, 0x0C, 0x18, 0x10, 0x30, 0x00, 0x20, 0x22,
  0x08, 0x42, 0x08, 0x40, 0x90, 0x14, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x40,
  0x48, 0x10, 0x84, 0x10, 0x83, 0x20, 0x20, 0x10, 0x10, 0x80, 0x84, 0x08,
  0x20, 0x41, 0x04, 0x04, 0x20, 0x22, 0x01, 0x10, 0x09, 0x80, 0x48, 0x02,
  0x40, 0x14, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x0C, 0x01, 0xC0, 0x00, 0x3F, 0xE0, 0x08, 0x03, 0x00, 0x40, 0x10, 0x04,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x3F,
  0xE0, 0x01, 0x02, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x30, 0x60, 0x80, 0x40, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x42, 0x31, 0x08, 0x42, 0x10, 0x88, 0x42,
  0x10, 0x84, 0x62, 0x10, 0x84, 0x21, 0x00, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x0C, 0x08,
  0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x10,
  0x30, 0x00, 0x38, 0x14, 0xC1, 0x84, 0x28, 0x22, 0x81, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 19, 5, 1, -19 },
  { 11, 5, 6, 7, 3, -20 },
  { 15, 13, 19, 13, 1, -19 },
  { 46, 11, 24, 13, 1, -22 },
  { 79, 13, 19, 17, 2, -19 },
  { 110, 12, 19, 14, 1, -19 },
  { 139, 2, 6, 4, 3, -20 },
  { 141, 8, 27, 7, 1, -21 },
  { 168, 8, 27, 7, -2, -21 },
  { 195, 10, 11, 11, 2, -19 },
  { 209, 11, 14, 13, 1, -15 },
  { 229, 3, 6, 5, -1, -2 },
  { 232, 5, 1, 7, 1, -9 },
  { 233, 1, 2, 6, 1, -2 },
  { 234, 11, 21, 9, -1, -19 },
  { 263, 11, 19, 13, 1, -19 },
  { 290, 6, 19, 13, 4, -19 },
  { 305, 11, 19, 13, 1, -19 },
  { 332, 11, 19, 13, 1, -19 },
  { 359, 11, 19, 13, 1, -19 },
  { 386, 11, 19, 13, 2, -19 },
  { 413, 10, 19, 13, 1, -19 },
  { 437, 11, 19, 13, 2, -19 },
  { 464, 11, 19, 13, 1, -19 },
  { 491, 10, 19, 13, 2, -19 },
  { 515, 4, 14, 5, 0, -14 },
  { 522, 5, 18, 5, -1, -14 },
  { 534, 10, 11, 12, 1, -14 },
  { 548, 11, 6, 13, 1, -12 },
  { 557, 10, 11, 12, 1, -14 },
  { 571, 9, 19, 10, 2, -19 },
  { 593, 19, 25, 21, 1, -19 },
  { 653, 13, 19, 14, -1, -19 },
  { 684, 12, 19, 14, 1, -19 },
  { 713, 12, 19, 15, 2, -19 },
  { 742, 13, 19, 15, 1, -19 },
  { 773, 13, 19, 13, 1, -19 },
  { 804, 13, 19, 13, 1, -19 },
  { 835, 13, 19, 16, 2, -19 },
  { 866, 15, 19, 16, 1, -19 },
  { 902, 5, 19, 6, 1, -19 },
  { 914, 12, 19, 13, 0, -19 },
  { 943, 14, 19, 14, 1, -19 },
  { 977, 9, 19, 12, 1, -19 },
  { 999, 18, 19, 20, 1, -19 },
  { 1042, 15, 19, 16, 1, -19 },
  { 1078, 14, 19, 15, 1, -19 },
  { 1112, 13, 19, 14, 1, -19 },
  { 1143, 14, 22, 15, 1, -19 },
  { 1182, 13, 19, 15, 1, -19 },
  { 1213, 13, 19, 14, 1, -19 },
  { 1244, 12, 19, 14, 3, -19 },
  { 1273, 13, 19, 15, 2, -19 },
  { 1304, 13, 19, 14, 2, -19 },
  { 1335, 18, 19, 20, 3, -19 },
  { 1378, 15, 19, 14, 0, -19 },
  { 1414, 13, 19, 14, 2, -19 },
  { 1445, 14, 19, 14, 0, -19 },
  { 1479, 8, 26, 6, 0, -22 },
  { 1505, 4, 21, 9, 3, -19 },
  { 1516, 8, 26, 6, -2, -22 },
  { 1542, 8, 10, 10, 1, -19 },
  { 1552, 9, 1, 10, -1, 0 },
  { 1554, 3, 4, 7, 4, -21 },
  { 1556, 11, 15, 12, 0, -15 },
  { 1577, 10, 21, 13, 1, -21 },
  { 1604, 10, 15, 12, 1, -15 },
  { 1623, 12, 21, 13, 1, -21 },
  { 1655, 10, 15, 12, 1, -15 },
  { 1674, 8, 21, 8, 2, -21 },
  { 1695, 12, 20, 13, 0, -15 },
  { 1725, 10, 21, 13, 1, -21 },
  { 1752, 4, 21, 5, 1, -21 },
  { 1763, 8, 26, 5, -3, -21 },
  { 1789, 11, 21, 11, 1, -21 },
  { 1818, 4, 21, 5, 1, -21 },
  { 1829, 18, 15, 20, 1, -15 },
  { 1863, 10, 15, 13, 1, -15 },
  { 1882, 10, 15, 13, 1, -15 },
  { 1901, 11, 20, 13, 0, -15 },
  { 1929, 11, 20, 13, 1, -15 },
  { 1957, 8, 15, 8, 1, -15 },
  { 1972, 11, 15, 12, 0, -15 },
  { 1993, 6, 18, 8, 1, -18 },
  { 2007, 11, 15, 13, 1, -15 },
  { 2028, 9, 15, 11, 2, -15 },
  { 2045, 15, 15, 17, 2, -15 },
  { 2074, 11, 15, 11, 0, -15 },
  { 2095, 13, 20, 11, -1, -15 },
  { 2128, 11, 15, 11, 0, -15 },
  { 2149, 8, 27, 8, 1, -21 },
  { 2176, 5, 23, 5, 0, -19 },
  { 2191, 9, 27, 8, -2, -21 },
  { 2222, 12, 5, 16, 2, -11 },
};

const GFXfont RobotoCondensed_ExtraLightItalic27pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic27pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC27PT7B_H_
