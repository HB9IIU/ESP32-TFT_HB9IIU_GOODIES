#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC16PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x94, 0x92, 0x40, 0x40, 0xBB, 0x00, 0x09, 0x09, 0x0A, 0x3F,
  0x12, 0x14, 0x24, 0x24, 0xFE, 0x48, 0x48, 0x48, 0x08, 0x23, 0x91, 0x45,
  0x04, 0x08, 0x10, 0x20, 0x62, 0x89, 0xC2, 0x00, 0x70, 0x50, 0x92, 0x94,
  0x64, 0x08, 0x10, 0x16, 0x29, 0x49, 0x09, 0x06, 0x1C, 0x12, 0x22, 0x24,
  0x28, 0x10, 0x30, 0x49, 0x86, 0x86, 0x44, 0x7A, 0xE0, 0x12, 0x24, 0x48,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x40, 0x20, 0x84, 0x10, 0x84, 0x21, 0x10,
  0x84, 0x22, 0x10, 0x88, 0x80, 0x10, 0x4D, 0xC8, 0x52, 0x20, 0x10, 0x41,
  0x04, 0xFC, 0x82, 0x08, 0x20, 0x54, 0xE0, 0x80, 0x02, 0x08, 0x10, 0x20,
  0x81, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x00, 0x39, 0x14, 0x61, 0x86,
  0x18, 0x61, 0x8A, 0x28, 0x9C, 0x3D, 0x22, 0x22, 0x22, 0x44, 0x44, 0x1C,
  0x45, 0x08, 0x10, 0x20, 0x82, 0x04, 0x10, 0x41, 0x07, 0xE0, 0x1C, 0x45,
  0x08, 0x10, 0x23, 0x81, 0x01, 0x03, 0x09, 0x13, 0xC0, 0x02, 0x0C, 0x28,
  0x61, 0x44, 0x89, 0x22, 0x7E, 0x10, 0x20, 0x40, 0x3E, 0x81, 0x02, 0x07,
  0x80, 0x81, 0x02, 0x05, 0x12, 0x23, 0x80, 0x1C, 0x84, 0x10, 0xBB, 0x18,
  0x61, 0x86, 0x28, 0x9C, 0x7E, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20,
  0x81, 0x04, 0x00, 0x1C, 0x44, 0x8A, 0x12, 0x23, 0x99, 0x21, 0x83, 0x09,
  0x13, 0xC0, 0x39, 0x18, 0x61, 0x86, 0x18, 0xDD, 0x08, 0x21, 0x38, 0x20,
  0x00, 0x04, 0x10, 0x00, 0x00, 0x04, 0x48, 0x0C, 0xCC, 0x30, 0x20, 0x60,
  0x7C, 0x00, 0x00, 0xF8, 0x60, 0x60, 0x43, 0x31, 0x00, 0x32, 0x62, 0x10,
  0x88, 0x84, 0x40, 0x00, 0x80, 0x0F, 0x82, 0x08, 0x81, 0x23, 0x14, 0x93,
  0x24, 0x64, 0x8D, 0x12, 0xA2, 0x54, 0x8A, 0x6E, 0x40, 0x08, 0x01, 0x00,
  0x1F, 0x00, 0x04, 0x18, 0x30, 0xA1, 0x44, 0x48, 0x9F, 0x43, 0x06, 0x0C,
  0x10, 0x7C, 0x85, 0x0A, 0x14, 0x4F, 0x21, 0x42, 0x85, 0x0A, 0x17, 0xC0,
  0x1C, 0x45, 0x0A, 0x18, 0x10, 0x20, 0x40, 0x83, 0x0A, 0x13, 0xC0, 0x7C,
  0x85, 0x0A, 0x14, 0x30, 0x60, 0xC1, 0x83, 0x0A, 0x37, 0x80, 0x7E, 0x81,
  0x02, 0x04, 0x0F, 0xA0, 0x40, 0x81, 0x02, 0x07, 0xC0, 0x7E, 0x81, 0x02,
  0x04, 0x0F, 0xA0, 0x40, 0x81, 0x02, 0x04, 0x00, 0x1E, 0x21, 0x41, 0x40,
  0x80, 0x80, 0x8E, 0x82, 0x82, 0x82, 0x86, 0x78, 0x41, 0x41, 0x41, 0x41,
  0x41, 0x7E, 0x82, 0x82, 0x82, 0x82, 0x82, 0x82, 0x55, 0x5A, 0xAA, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x05, 0x0A, 0x23, 0x80, 0x41, 0x42,
  0x44, 0x48, 0x50, 0xA0, 0xD0, 0x90, 0x88, 0x88, 0x84, 0x84, 0x42, 0x10,
  0x84, 0x42, 0x10, 0x84, 0x21, 0xF0, 0x40, 0x58, 0x16, 0x0D, 0x83, 0x61,
  0x68, 0x59, 0x26, 0x4A, 0x94, 0xA5, 0x28, 0x8A, 0x22, 0x41, 0x61, 0x61,
  0x51, 0x51, 0x91, 0x89, 0x8A, 0x8A, 0x86, 0x86, 0x82, 0x1C, 0x22, 0x41,
  0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x82, 0x84, 0x78, 0x7C, 0x85, 0x0A,
  0x14, 0x30, 0xBE, 0x40, 0x81, 0x02, 0x04, 0x00, 0x1C, 0x22, 0x41, 0x81,
  0x81, 0x81, 0x82, 0x82, 0x82, 0x82, 0x84, 0x78, 0x08, 0x04, 0x7C, 0x85,
  0x0A, 0x14, 0x30, 0xBE, 0x44, 0x89, 0x12, 0x14, 0x20, 0x1E, 0x21, 0x21,
  0x40, 0x20, 0x18, 0x04, 0x02, 0x02, 0x82, 0x42, 0x3C, 0xFE, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x00, 0x41, 0x41, 0x41, 0x41,
  0x82, 0x82, 0x82, 0x82, 0x82, 0x84, 0x84, 0x78, 0x81, 0x82, 0x42, 0x42,
  0x44, 0x44, 0x48, 0x48, 0x50, 0x30, 0x20, 0x20, 0x88, 0x31, 0x8A, 0x31,
  0x4A, 0x29, 0x49, 0x29, 0x29, 0x25, 0x28, 0xC5, 0x18, 0xA2, 0x08, 0x41,
  0x00, 0x21, 0x10, 0x88, 0x82, 0x81, 0x40, 0x40, 0x60, 0x30, 0x24, 0x22,
  0x10, 0x90, 0x40, 0x81, 0x42, 0x42, 0x44, 0x28, 0x28, 0x30, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x3F, 0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20,
  0x40, 0x40, 0xFE, 0x31, 0x08, 0x42, 0x21, 0x08, 0x42, 0x11, 0x08, 0x43,
  0x00, 0xAA, 0xAA, 0x55, 0x40, 0x31, 0x11, 0x11, 0x12, 0x22, 0x22, 0x24,
  0xC0, 0x22, 0x55, 0x99, 0xFC, 0x90, 0x3D, 0x10, 0x41, 0x3D, 0x18, 0x63,
  0x74, 0x20, 0x40, 0x81, 0xE2, 0x28, 0x50, 0xA1, 0x42, 0x89, 0x15, 0xC0,
  0x3C, 0x85, 0x0A, 0x08, 0x10, 0x21, 0x22, 0x78, 0x02, 0x04, 0x13, 0xE8,
  0x50, 0xA1, 0x44, 0x89, 0x12, 0x27, 0xC0, 0x3D, 0x14, 0x5F, 0x82, 0x08,
  0x10, 0x38, 0x19, 0x11, 0xE4, 0x21, 0x10, 0x84, 0x21, 0x00, 0x3E, 0x85,
  0x0A, 0x14, 0x50, 0xA1, 0x22, 0x7C, 0x0A, 0x23, 0x80, 0x20, 0x40, 0x81,
  0xE2, 0x28, 0x50, 0xA2, 0x44, 0x8A, 0x14, 0x20, 0x20, 0x14, 0x92, 0x49,
  0x40, 0x08, 0x00, 0x11, 0x08, 0x42, 0x10, 0x88, 0x42, 0x13, 0x00, 0x20,
  0x40, 0x81, 0x24, 0x49, 0x14, 0x38, 0x50, 0x92, 0x24, 0x20, 0x24, 0x92,
  0x92, 0x49, 0x40, 0x5D, 0xE4, 0x45, 0x08, 0xA1, 0x14, 0x42, 0x88, 0x51,
  0x0C, 0x21, 0x84, 0x40, 0x3C, 0x45, 0x0A, 0x14, 0x48, 0x91, 0x42, 0x84,
  0x39, 0x18, 0x61, 0x86, 0x18, 0xA2, 0x70, 0x3C, 0x45, 0x0A, 0x14, 0x28,
  0x61, 0x22, 0xB9, 0x02, 0x04, 0x00, 0x7E, 0x18, 0x61, 0x8A, 0x28, 0xA2,
  0xF8, 0x21, 0x04, 0x39, 0x10, 0x84, 0x21, 0x10, 0x80, 0x3D, 0x14, 0x08,
  0x10, 0x20, 0x62, 0x70, 0x4B, 0xA4, 0xA4, 0x93, 0x00, 0x46, 0x18, 0x61,
  0x8A, 0x28, 0xA2, 0xF8, 0x86, 0x28, 0xA4, 0x91, 0x46, 0x10, 0x40, 0x88,
  0xC4, 0x66, 0x53, 0x2A, 0x55, 0x32, 0x98, 0x88, 0x44, 0x00, 0x44, 0x48,
  0xA1, 0x81, 0x06, 0x12, 0x24, 0x88, 0x21, 0x22, 0x22, 0x24, 0x24, 0x18,
  0x18, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x7C, 0x10, 0x84, 0x10, 0x84, 0x10,
  0xF8, 0x11, 0x08, 0x44, 0x21, 0x10, 0x82, 0x21, 0x08, 0x42, 0x08, 0x24,
  0x92, 0x92, 0x49, 0x49, 0x00, 0x20, 0x84, 0x21, 0x08, 0x41, 0x11, 0x08,
  0x42, 0x22, 0x00, 0x63, 0x26, 0x30,
};

const GFXglyph RobotoCondensed_ExtraLightItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 12, 3, 0, -12 },
  { 6, 3, 3, 4, 2, -12 },
  { 8, 8, 12, 8, 0, -12 },
  { 20, 6, 15, 8, 1, -14 },
  { 32, 8, 12, 10, 1, -12 },
  { 44, 8, 12, 8, 0, -12 },
  { 56, 1, 3, 3, 2, -12 },
  { 57, 4, 17, 4, 1, -13 },
  { 66, 5, 17, 4, -1, -13 },
  { 77, 6, 6, 7, 1, -12 },
  { 82, 6, 9, 8, 1, -10 },
  { 89, 2, 3, 3, -1, -1 },
  { 90, 3, 1, 4, 1, -6 },
  { 91, 1, 1, 4, 0, -1 },
  { 92, 7, 13, 5, -1, -12 },
  { 104, 6, 12, 8, 1, -12 },
  { 113, 4, 12, 8, 2, -12 },
  { 119, 7, 12, 8, 0, -12 },
  { 130, 7, 12, 8, 0, -12 },
  { 141, 7, 12, 8, 0, -12 },
  { 152, 7, 12, 8, 1, -12 },
  { 163, 6, 12, 8, 1, -12 },
  { 172, 7, 12, 8, 1, -12 },
  { 183, 7, 12, 8, 0, -12 },
  { 194, 6, 12, 8, 1, -12 },
  { 203, 3, 8, 3, 0, -8 },
  { 206, 4, 10, 3, -1, -8 },
  { 211, 6, 6, 7, 1, -8 },
  { 216, 6, 5, 8, 1, -8 },
  { 220, 6, 6, 7, 0, -8 },
  { 225, 5, 12, 6, 1, -12 },
  { 233, 11, 15, 12, 1, -11 },
  { 254, 7, 12, 8, 0, -12 },
  { 265, 7, 12, 8, 1, -12 },
  { 276, 7, 12, 9, 1, -12 },
  { 287, 7, 12, 9, 1, -12 },
  { 298, 7, 12, 8, 1, -12 },
  { 309, 7, 12, 8, 1, -12 },
  { 320, 8, 12, 9, 1, -12 },
  { 332, 8, 12, 10, 1, -12 },
  { 344, 2, 12, 4, 1, -12 },
  { 347, 7, 12, 8, 0, -12 },
  { 358, 8, 12, 9, 1, -12 },
  { 370, 5, 12, 7, 1, -12 },
  { 378, 10, 12, 12, 1, -12 },
  { 393, 8, 12, 10, 1, -12 },
  { 405, 8, 12, 9, 1, -12 },
  { 417, 7, 12, 8, 1, -12 },
  { 428, 8, 14, 9, 1, -12 },
  { 442, 7, 12, 9, 1, -12 },
  { 453, 8, 12, 8, 0, -12 },
  { 465, 7, 12, 8, 2, -12 },
  { 476, 8, 12, 9, 1, -12 },
  { 488, 8, 12, 8, 1, -12 },
  { 500, 11, 12, 12, 2, -12 },
  { 517, 9, 12, 8, 0, -12 },
  { 531, 8, 12, 8, 1, -12 },
  { 543, 8, 12, 8, 0, -12 },
  { 555, 5, 15, 3, 0, -13 },
  { 565, 2, 13, 5, 2, -12 },
  { 569, 4, 15, 3, -1, -13 },
  { 577, 4, 6, 6, 1, -12 },
  { 580, 6, 1, 6, -1, 0 },
  { 581, 2, 2, 4, 2, -12 },
  { 582, 6, 9, 7, 0, -9 },
  { 589, 7, 12, 8, 0, -12 },
  { 600, 7, 9, 7, 0, -9 },
  { 608, 7, 12, 8, 1, -12 },
  { 619, 6, 9, 7, 0, -9 },
  { 626, 5, 12, 5, 1, -12 },
  { 634, 7, 12, 8, 0, -9 },
  { 645, 7, 12, 7, 0, -12 },
  { 656, 3, 12, 3, 0, -12 },
  { 661, 5, 15, 3, -2, -12 },
  { 671, 7, 12, 7, 0, -12 },
  { 682, 3, 12, 3, 0, -12 },
  { 687, 11, 9, 12, 0, -9 },
  { 700, 7, 9, 8, 0, -9 },
  { 708, 6, 9, 8, 1, -9 },
  { 715, 7, 12, 8, 0, -9 },
  { 726, 6, 12, 8, 1, -9 },
  { 735, 5, 9, 5, 0, -9 },
  { 741, 6, 9, 7, 0, -9 },
  { 748, 3, 11, 4, 1, -11 },
  { 753, 6, 9, 7, 1, -9 },
  { 760, 6, 9, 7, 1, -9 },
  { 767, 9, 9, 10, 1, -9 },
  { 778, 7, 9, 7, 0, -9 },
  { 786, 8, 12, 7, -1, -9 },
  { 798, 6, 9, 7, 0, -9 },
  { 805, 5, 16, 5, 1, -13 },
  { 815, 3, 14, 3, 0, -12 },
  { 821, 5, 15, 5, -1, -12 },
  { 831, 7, 3, 9, 1, -6 },
};

const GFXfont RobotoCondensed_ExtraLightItalic16pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic16pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC16PT7B_H_
