#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC59PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0xF0, 0x38, 0x04, 0x00, 0x30, 0xC6, 0x18, 0xC3, 0x18,
  0x63, 0x0C, 0xE1, 0x98, 0x63, 0x0C, 0x61, 0x8C, 0x31, 0x86, 0x60, 0x80,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x07, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x60, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x20, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x78, 0x0E, 0x00, 0x38, 0x03,
  0x80, 0x30, 0x00, 0xC0, 0x38, 0x00, 0x70, 0x18, 0x00, 0x18, 0x1C, 0x00,
  0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x30, 0x00,
  0x1C, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x01, 0xC0,
  0x0F, 0x00, 0x70, 0x0F, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0xC6, 0x00, 0xC0, 0x18, 0x60, 0x0C,
  0x03, 0x86, 0x00, 0xC0, 0x30, 0x60, 0x0C, 0x06, 0x06, 0x00, 0xC0, 0xC0,
  0x60, 0x0C, 0x0C, 0x04, 0x00, 0x81, 0x80, 0x60, 0x18, 0x30, 0x06, 0x01,
  0x83, 0x00, 0x60, 0x30, 0x60, 0x03, 0x07, 0x0C, 0x00, 0x3D, 0xE0, 0xC0,
  0x01, 0xFC, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x1F, 0x80, 0x01, 0x83,
  0x9C, 0x00, 0x30, 0x60, 0x60, 0x06, 0x0C, 0x06, 0x00, 0x60, 0xC0, 0x30,
  0x0C, 0x18, 0x03, 0x01, 0x81, 0x80, 0x30, 0x18, 0x18, 0x03, 0x03, 0x03,
  0x00, 0x30, 0x60, 0x30, 0x03, 0x0E, 0x03, 0x00, 0x60, 0xC0, 0x30, 0x06,
  0x18, 0x03, 0x00, 0x63, 0x80, 0x30, 0x06, 0x10, 0x03, 0x00, 0xC0, 0x00,
  0x18, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x18, 0x00, 0x38, 0x07, 0x00,
  0x0C, 0x01, 0xC0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x06,
  0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0xE0, 0x01, 0x80, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x18, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x39, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x0C,
  0x00, 0xC7, 0x03, 0x80, 0x31, 0x80, 0x60, 0x18, 0xC0, 0x1C, 0x06, 0x70,
  0x03, 0x01, 0x98, 0x00, 0x60, 0xE6, 0x00, 0x1C, 0x33, 0x80, 0x03, 0x0C,
  0xC0, 0x00, 0xE6, 0x30, 0x00, 0x1B, 0x8C, 0x00, 0x07, 0xC3, 0x00, 0x00,
  0xF0, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x06, 0x00, 0x06, 0xC1, 0xC0,
  0x07, 0x38, 0x3C, 0x03, 0x86, 0x07, 0xFF, 0xC1, 0xC0, 0x7F, 0xC0, 0x30,
  0x03, 0x00, 0x00, 0x33, 0x37, 0x66, 0x66, 0xEC, 0xCC, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x20, 0x0C, 0x01,
  0x70, 0x18, 0x1E, 0xFC, 0x31, 0xF8, 0x3E, 0x6F, 0x80, 0x1F, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xE6, 0x00, 0x03,
  0x8E, 0x00, 0x0E, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x18, 0x01, 0xC0,
  0x18, 0x07, 0x00, 0x38, 0x04, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0C, 0x38, 0xE3, 0x82,
  0x00, 0xFF, 0xEF, 0xFE, 0x7F, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x70, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x07, 0x0E,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0x63, 0x00, 0x00, 0xCE, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00,
  0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x66, 0x00, 0x00,
  0xCC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x1D,
  0xC0, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98,
  0x00, 0x07, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x71, 0x80,
  0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x07, 0x0E, 0x00, 0x0C, 0x0C, 0x00,
  0x38, 0x18, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x38, 0x0E, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x03, 0xC0, 0xFC,
  0x1F, 0x67, 0xE3, 0x78, 0x1B, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x0E, 0x03, 0xC0, 0x0E, 0x00, 0x60, 0x0E, 0x00, 0x38, 0x0E,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x07, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x0E, 0x03, 0x80,
  0x06, 0x03, 0x00, 0x06, 0x06, 0x00, 0x07, 0x06, 0x00, 0x03, 0x0E, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x30, 0x60, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x0F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xB0, 0x00, 0x01, 0x98, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x70, 0x70, 0x00, 0x30, 0x30, 0x00, 0x30, 0x18,
  0x00, 0x38, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03,
  0x80, 0x1C, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x0E, 0x00,
  0x30, 0x0E, 0x00, 0x18, 0x06, 0x00, 0x1C, 0x07, 0x00, 0x0C, 0x07, 0x00,
  0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x7E, 0x00, 0x19, 0xFF, 0x80, 0x1F, 0x83,
  0xC0, 0x1E, 0x00, 0xE0, 0x18, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0x60, 0x01,
  0x80, 0x70, 0x03, 0x80, 0x38, 0x0F, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x0F, 0xC0,
  0x30, 0xFF, 0xC0, 0xCF, 0x07, 0x83, 0x70, 0x07, 0x0F, 0x80, 0x0C, 0x6C,
  0x00, 0x39, 0xE0, 0x00, 0xE7, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00,
  0x1B, 0x80, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x33, 0x00,
  0x00, 0xCE, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0xC1, 0xC0, 0x07,
  0x03, 0x80, 0x38, 0x07, 0x01, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x04, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x07, 0x00, 0x30, 0x00, 0xE0,
  0x1C, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00,
  0x70, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x00,
  0xC0, 0x01, 0x80, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x70,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x30,
  0x00, 0x0E, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x06, 0x18, 0x00, 0x03, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x30, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0xE0, 0x3C, 0x07, 0x00, 0x70, 0x38, 0x00, 0xE1, 0xC0, 0x01, 0x86, 0x00,
  0x06, 0x38, 0x00, 0x1C, 0xC0, 0x00, 0x73, 0x00, 0x00, 0xDC, 0x00, 0x03,
  0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x06, 0x60, 0x00,
  0x39, 0x80, 0x01, 0xE6, 0x00, 0x07, 0x9C, 0x00, 0x3C, 0x30, 0x01, 0xB0,
  0xE0, 0x0C, 0xC1, 0xE0, 0xE3, 0x03, 0xFF, 0x1C, 0x03, 0xF0, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x07, 0x01,
  0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x70, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x08, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xC0, 0x08, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0xF0, 0x38, 0x1C, 0x1C, 0x03, 0x8E, 0x00, 0x63, 0x00, 0x19, 0xC0,
  0x07, 0x60, 0x01, 0xD8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x7E, 0x00, 0x30, 0x18, 0x00, 0xFF, 0x80, 0x18, 0x1C, 0x00,
  0xE0, 0xE0, 0x04, 0x0C, 0x00, 0xE0, 0x18, 0x02, 0x0C, 0x00, 0xE0, 0x0C,
  0x01, 0x86, 0x00, 0xE0, 0x0C, 0x00, 0xC7, 0x00, 0x60, 0x06, 0x00, 0x63,
  0x00, 0x60, 0x03, 0x00, 0x31, 0x80, 0x30, 0x01, 0x80, 0x19, 0x80, 0x30,
  0x01, 0x80, 0x08, 0xC0, 0x18, 0x00, 0xC0, 0x0C, 0x60, 0x0C, 0x00, 0x60,
  0x06, 0x60, 0x0C, 0x00, 0x30, 0x03, 0x30, 0x06, 0x00, 0x30, 0x01, 0x98,
  0x03, 0x00, 0x18, 0x00, 0xCC, 0x03, 0x00, 0x0C, 0x00, 0xC6, 0x01, 0x80,
  0x06, 0x00, 0x66, 0x00, 0xC0, 0x03, 0x00, 0x33, 0x00, 0x60, 0x03, 0x00,
  0x19, 0x80, 0x30, 0x01, 0x80, 0x18, 0xC0, 0x18, 0x00, 0xC0, 0x0C, 0x60,
  0x18, 0x00, 0xE0, 0x06, 0x30, 0x0C, 0x00, 0xF0, 0x06, 0x18, 0x02, 0x00,
  0x78, 0x03, 0x0C, 0x01, 0x80, 0x6C, 0x03, 0x06, 0x00, 0xC0, 0x66, 0x03,
  0x03, 0x00, 0x70, 0x63, 0x03, 0x81, 0x80, 0x1F, 0xE0, 0xE7, 0x80, 0xE0,
  0x0F, 0xE0, 0x7F, 0x00, 0x30, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x18, 0x30, 0x00, 0x03, 0x83, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00,
  0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x18, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x1C, 0x00,
  0x0C, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x37, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x06, 0x00, 0x3C,
  0x00, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x1C, 0x07, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x18,
  0x0C, 0x00, 0x03, 0x03, 0x80, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x60, 0x30, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x01,
  0xC0, 0x01, 0xC0, 0x30, 0x01, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x18, 0x00, 0x78, 0x07, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x18,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x18,
  0x30, 0x00, 0x07, 0x06, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x18, 0x00,
  0x1C, 0x03, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0x80, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x60, 0x70, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x18, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x60, 0x07, 0xC0, 0x03, 0x00, 0x07,
  0x00, 0x18, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x38, 0x1C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x1C, 0x01, 0x80, 0x03, 0xC0, 0x0C, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0x80, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x70, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x03, 0xFF, 0xCE, 0x00,
  0x3F, 0xFC, 0xE0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x03,
  0x80, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x1C, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18,
  0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x07,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x81, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x01, 0x83, 0x80, 0x00,
  0xE0, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x06, 0x01, 0x80,
  0x01, 0x80, 0x60, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x03, 0x00, 0x38, 0x00,
  0xE0, 0x1C, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x03, 0x80, 0x18, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x38, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x60, 0x0E, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x00, 0x63, 0xC0, 0x00, 0x00, 0xCF, 0xC0, 0x00, 0x01, 0xB9,
  0x80, 0x00, 0x07, 0xE3, 0x80, 0x00, 0x0F, 0x83, 0x00, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x01, 0xC0,
  0x0C, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x03, 0x60, 0x00, 0x00, 0x36, 0x03,
  0x60, 0x00, 0x00, 0x36, 0x03, 0x70, 0x00, 0x00, 0x66, 0x03, 0x30, 0x00,
  0x00, 0x6E, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x03, 0x30, 0x00, 0x01, 0xCC,
  0x06, 0x30, 0x00, 0x01, 0x8C, 0x06, 0x30, 0x00, 0x03, 0x8C, 0x06, 0x38,
  0x00, 0x03, 0x1C, 0x06, 0x18, 0x00, 0x07, 0x1C, 0x06, 0x18, 0x00, 0x06,
  0x18, 0x0E, 0x18, 0x00, 0x0E, 0x18, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x0C,
  0x18, 0x00, 0x1C, 0x18, 0x0C, 0x0C, 0x00, 0x18, 0x38, 0x0C, 0x0C, 0x00,
  0x38, 0x30, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x1C, 0x0C, 0x00, 0x60, 0x30,
  0x18, 0x0C, 0x00, 0x60, 0x30, 0x18, 0x0E, 0x00, 0xC0, 0x30, 0x18, 0x06,
  0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x38, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30,
  0x03, 0x06, 0x00, 0x60, 0x30, 0x03, 0x06, 0x00, 0xE0, 0x30, 0x03, 0x0C,
  0x00, 0xC0, 0x30, 0x03, 0x1C, 0x00, 0xC0, 0x70, 0x03, 0x18, 0x00, 0xC0,
  0x60, 0x03, 0x38, 0x00, 0xC0, 0x60, 0x01, 0xB0, 0x01, 0xC0, 0x60, 0x01,
  0xF0, 0x01, 0xC0, 0x60, 0x01, 0xE0, 0x01, 0x80, 0x60, 0x01, 0xE0, 0x01,
  0x80, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0xC0,
  0x3C, 0x00, 0x00, 0x60, 0x1E, 0x00, 0x00, 0x30, 0x1F, 0x80, 0x00, 0x38,
  0x0E, 0xC0, 0x00, 0x18, 0x06, 0x60, 0x00, 0x0C, 0x03, 0x18, 0x00, 0x06,
  0x01, 0x8C, 0x00, 0x03, 0x01, 0xC6, 0x00, 0x01, 0x80, 0xE1, 0x80, 0x01,
  0xC0, 0x60, 0xC0, 0x00, 0xC0, 0x30, 0x70, 0x00, 0x60, 0x18, 0x18, 0x00,
  0x30, 0x0C, 0x0C, 0x00, 0x18, 0x0E, 0x03, 0x00, 0x1C, 0x07, 0x01, 0x80,
  0x0E, 0x03, 0x00, 0xE0, 0x06, 0x01, 0x80, 0x30, 0x03, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x60, 0x0E, 0x00, 0xC0, 0x70, 0x03, 0x00, 0xE0, 0x38, 0x01,
  0x80, 0x70, 0x18, 0x00, 0x60, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x06, 0x00,
  0x1C, 0x0C, 0x03, 0x00, 0x06, 0x06, 0x03, 0x80, 0x03, 0x07, 0x01, 0xC0,
  0x01, 0xC3, 0x80, 0xC0, 0x00, 0x61, 0x80, 0x60, 0x00, 0x30, 0xC0, 0x30,
  0x00, 0x0C, 0x60, 0x18, 0x00, 0x06, 0x30, 0x1C, 0x00, 0x03, 0xB8, 0x0C,
  0x00, 0x00, 0xD8, 0x06, 0x00, 0x00, 0x6C, 0x03, 0x00, 0x00, 0x1E, 0x01,
  0x80, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x70, 0x0E, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03, 0x1C, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60, 0x18, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0x70, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0x80, 0x07, 0x80, 0x18, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0xE0, 0x38, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C,
  0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x80, 0xC0,
  0x00, 0xF0, 0x1C, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xF0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x06, 0x38, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0x80, 0x07, 0x80, 0x18, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x30,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x30, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0xC0, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x07, 0x00, 0x38, 0x00, 0x70, 0x03, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x38, 0x03, 0x00, 0x03, 0x80, 0x30, 0x00, 0x18,
  0x07, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x30, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x07, 0x80, 0x0E, 0x00, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x60, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x03, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x06, 0x03, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x18, 0x03, 0x80, 0x01, 0x80, 0x18, 0x00, 0x30, 0x01, 0x80,
  0x03, 0x00, 0x18, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0,
  0x01, 0xC0, 0x0C, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x63, 0x80, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0xB0, 0x00, 0x0F, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x80, 0x00, 0xCC, 0x00,
  0x06, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x60, 0x00, 0x73, 0x00, 0x01, 0xB0,
  0x00, 0x31, 0x80, 0x01, 0x98, 0x00, 0x18, 0xE0, 0x00, 0xCC, 0x00, 0x1C,
  0x70, 0x00, 0xC6, 0x00, 0x0C, 0x38, 0x00, 0x63, 0x00, 0x0E, 0x1C, 0x00,
  0x31, 0x80, 0x06, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x03, 0x00, 0x18, 0x20,
  0x03, 0x81, 0x80, 0x18, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0xC0,
  0x60, 0x06, 0x06, 0x00, 0xE0, 0x30, 0x06, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x00,
  0xC0, 0x60, 0x0C, 0x06, 0x00, 0x60, 0x60, 0x06, 0x07, 0x00, 0x38, 0x30,
  0x01, 0x83, 0x00, 0x1C, 0x18, 0x00, 0xC1, 0x80, 0x0E, 0x18, 0x00, 0x61,
  0x80, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x8E, 0x00, 0x18, 0x60, 0x00,
  0xC6, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x33, 0x00,
  0x03, 0x38, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x0D, 0xC0, 0x00, 0xCC,
  0x00, 0x06, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x01,
  0xE0, 0x00, 0x0B, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x01, 0x80,
  0x1C, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x70, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x30, 0x18, 0x00, 0x07, 0x01, 0x80, 0x00, 0x60,
  0x1C, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0x70, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x38, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x19, 0xC0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xC0, 0x60, 0x38, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xC8, 0x01, 0xCC, 0x01, 0x8C, 0x03, 0x8C, 0x03, 0x0C, 0x07, 0x0C,
  0x06, 0x0C, 0x0E, 0x06, 0x0C, 0x06, 0x1C, 0x06, 0x18, 0x06, 0x38, 0x06,
  0x30, 0x06, 0x70, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xE0, 0xC1, 0xC1, 0x83, 0x83, 0x03, 0x06, 0x00, 0x02, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0E, 0x01, 0xC0, 0x38, 0x01, 0xC0,
  0xE0, 0x01, 0x83, 0x80, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x38,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0x80, 0x18, 0x3C, 0x00,
  0x30, 0xE0, 0x00, 0x61, 0x80, 0x01, 0x87, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x38, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x71, 0x80, 0x01, 0xC3,
  0x00, 0x03, 0x87, 0x00, 0x0F, 0x06, 0x00, 0x76, 0x0E, 0x01, 0xCC, 0x0F,
  0xFF, 0x18, 0x0F, 0xF8, 0x30, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x0F, 0xF0, 0x07, 0x3F, 0xF8, 0x06, 0x70, 0x1C, 0x06, 0xC0, 0x0E, 0x07,
  0x80, 0x06, 0x07, 0x00, 0x06, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x0C,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18,
  0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x70,
  0x00, 0x18, 0x70, 0x00, 0x30, 0x78, 0x00, 0x70, 0x6C, 0x00, 0xE0, 0x66,
  0x01, 0xC0, 0x63, 0xFF, 0x80, 0xE1, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xE0, 0x1C, 0x07, 0x00,
  0x38, 0x38, 0x00, 0x61, 0xC0, 0x01, 0xC6, 0x00, 0x07, 0x38, 0x00, 0x0C,
  0xC0, 0x00, 0x33, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x03, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x86, 0x00,
  0x0C, 0x18, 0x00, 0x70, 0x70, 0x03, 0x80, 0xE0, 0x1C, 0x01, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x3F, 0xE0, 0xC0, 0x1F, 0xFC, 0x70, 0x0E, 0x01, 0x98, 0x07, 0x00,
  0x36, 0x03, 0x80, 0x07, 0x80, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x18,
  0x00, 0x0E, 0x0E, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30,
  0x30, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x06,
  0x01, 0xC0, 0x03, 0x80, 0x30, 0x03, 0xE0, 0x0E, 0x01, 0xD8, 0x01, 0xFF,
  0xC6, 0x00, 0x3F, 0xE3, 0x80, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x38, 0x38,
  0x00, 0x61, 0xC0, 0x01, 0x86, 0x00, 0x07, 0x38, 0x00, 0x0C, 0xC0, 0x00,
  0x33, 0x00, 0x00, 0xDC, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x77,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0xF0, 0x0E, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x30, 0x07, 0xFF, 0x1C, 0x03, 0x80, 0x66, 0x01,
  0xC0, 0x0D, 0x80, 0xE0, 0x01, 0xE0, 0x30, 0x00, 0x78, 0x1C, 0x00, 0x0E,
  0x06, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x0C, 0x0C, 0x00, 0x03, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60,
  0x60, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x00,
  0xC0, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x01, 0x80,
  0x01, 0x80, 0x70, 0x00, 0xE0, 0x0C, 0x00, 0xF8, 0x03, 0x80, 0x76, 0x00,
  0x7F, 0xF1, 0x80, 0x0F, 0xF8, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x04, 0x00, 0x0C, 0x03, 0x80, 0x07, 0x00, 0x70, 0x03, 0x80, 0x0F,
  0x03, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x08, 0x00, 0x61,
  0xFE, 0x00, 0xC7, 0xFE, 0x03, 0xB8, 0x0E, 0x06, 0x60, 0x0C, 0x0D, 0x80,
  0x1C, 0x1E, 0x00, 0x18, 0x38, 0x00, 0x30, 0xF0, 0x00, 0x61, 0xC0, 0x00,
  0xC3, 0x80, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x1C,
  0x70, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86,
  0x00, 0x07, 0x0C, 0x00, 0x0E, 0x38, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x86, 0x00, 0x06, 0x1C, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01,
  0xC7, 0x00, 0x03, 0x00, 0x01, 0x80, 0xF0, 0x38, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x01, 0x80, 0x60, 0x38,
  0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x07, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x38,
  0x06, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x06, 0x01, 0xC0, 0x0E, 0x03, 0x80,
  0x0C, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0xE0, 0x00, 0x1D, 0xE0, 0x00, 0x1B, 0xE0, 0x00, 0x1F, 0x70, 0x00,
  0x1E, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x18, 0x00, 0x38, 0x1C, 0x00,
  0x30, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x06, 0x00, 0x30, 0x07, 0x00,
  0x30, 0x03, 0x00, 0x70, 0x03, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0xC0,
  0x60, 0x00, 0xC0, 0x60, 0x00, 0xE0, 0xE0, 0x00, 0x60, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x0F, 0xF0,
  0x0F, 0xF8, 0x06, 0x3F, 0xF8, 0x1F, 0xFC, 0x06, 0x70, 0x1C, 0x38, 0x0E,
  0x06, 0xC0, 0x0C, 0x60, 0x06, 0x06, 0xC0, 0x0E, 0xC0, 0x06, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x18, 0x00,
  0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x70, 0x00, 0x30, 0x00, 0x18, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x60, 0x00, 0x70, 0x00, 0x38, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x80, 0x06,
  0x1F, 0xE0, 0x1C, 0x7F, 0xE0, 0x31, 0x80, 0xE0, 0x66, 0x00, 0xC0, 0xD8,
  0x01, 0xC1, 0xE0, 0x01, 0x83, 0x80, 0x03, 0x0F, 0x00, 0x06, 0x1C, 0x00,
  0x0C, 0x38, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01,
  0xC7, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x70, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0x86, 0x00, 0x03, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x61, 0xC0,
  0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00,
  0x1C, 0x70, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x1E, 0x01, 0xC0, 0x70, 0x01, 0x80, 0xC0, 0x03, 0x83, 0x00, 0x03,
  0x0E, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x33, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0,
  0x00, 0x07, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x37, 0x00,
  0x00, 0x6E, 0x00, 0x01, 0xDC, 0x00, 0x03, 0x38, 0x00, 0x06, 0x70, 0x00,
  0x1C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0x83, 0x80, 0x07,
  0x03, 0x80, 0x1C, 0x07, 0x80, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xFF, 0x00, 0x1C, 0xFF,
  0xE0, 0x06, 0x70, 0x1C, 0x01, 0xB0, 0x03, 0x80, 0x78, 0x00, 0x60, 0x1C,
  0x00, 0x18, 0x06, 0x00, 0x07, 0x03, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30,
  0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x83,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x06,
  0x07, 0x00, 0x01, 0x81, 0xC0, 0x00, 0xC0, 0x78, 0x00, 0x70, 0x1B, 0x00,
  0x38, 0x06, 0x60, 0x1C, 0x01, 0x8F, 0xFE, 0x00, 0xE1, 0xFF, 0x00, 0x30,
  0x04, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x83, 0x01, 0xFF, 0xC6, 0x03,
  0x80, 0x66, 0x07, 0x00, 0x36, 0x0E, 0x00, 0x1E, 0x0C, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x38, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60,
  0x00, 0xE0, 0x30, 0x03, 0xE0, 0x38, 0x07, 0x60, 0x1F, 0xFE, 0xE0, 0x0F,
  0xF8, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC7, 0xE0, 0x73, 0xF8, 0x1D, 0xC0, 0x06,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xF0,
  0x1C, 0x07, 0x00, 0x38, 0x18, 0x00, 0x60, 0xC0, 0x01, 0xC3, 0x00, 0x03,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x80,
  0x01, 0x8E, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x70, 0x01, 0xC0, 0xE0, 0x1E,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC1, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x80, 0x0C, 0x00, 0x0E, 0x38, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x07, 0x1C, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00,
  0xC3, 0x00, 0x03, 0x8E, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x30, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0x86, 0x00, 0x03, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x70, 0xC0,
  0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x03, 0x00, 0x36, 0x07, 0x01,
  0xCC, 0x07, 0xFF, 0x38, 0x07, 0xFC, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0xCE, 0x00, 0x06, 0x30,
  0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x1C,
  0x18, 0x00, 0xC0, 0xE0, 0x0E, 0x03, 0x00, 0x60, 0x18, 0x07, 0x00, 0xC0,
  0x30, 0x06, 0x01, 0x80, 0x30, 0x18, 0x01, 0xC0, 0xC0, 0x06, 0x0C, 0x00,
  0x30, 0x60, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x03, 0x18,
  0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x60, 0x01, 0xC0, 0x01, 0xB0, 0x00, 0xE0, 0x01, 0xD8, 0x00, 0x70, 0x00,
  0xCC, 0x00, 0x78, 0x00, 0xE6, 0x00, 0x36, 0x00, 0x63, 0x00, 0x33, 0x00,
  0x31, 0x80, 0x19, 0x80, 0x38, 0xC0, 0x1C, 0xC0, 0x18, 0x60, 0x0C, 0x60,
  0x1C, 0x30, 0x06, 0x30, 0x0C, 0x1C, 0x06, 0x18, 0x06, 0x0E, 0x03, 0x0C,
  0x06, 0x03, 0x03, 0x06, 0x03, 0x01, 0x81, 0x83, 0x03, 0x80, 0xC1, 0x81,
  0x81, 0x80, 0x60, 0xC0, 0xC0, 0xC0, 0x30, 0xE0, 0x30, 0xC0, 0x18, 0x60,
  0x18, 0x60, 0x0C, 0x30, 0x0C, 0x70, 0x06, 0x30, 0x06, 0x30, 0x03, 0x18,
  0x03, 0x38, 0x01, 0x98, 0x01, 0x98, 0x00, 0xCC, 0x00, 0xCC, 0x00, 0x6C,
  0x00, 0x6E, 0x00, 0x36, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x1B, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0x80, 0xE0,
  0x01, 0xC0, 0x30, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x06, 0x00, 0xC0, 0x03,
  0x00, 0xE0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0x60, 0x00, 0x38, 0x60, 0x00,
  0x0C, 0x70, 0x00, 0x07, 0x70, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x0C,
  0x00, 0x0E, 0x06, 0x00, 0x06, 0x03, 0x80, 0x06, 0x00, 0xC0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x03, 0x80,
  0x01, 0x83, 0x80, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x1C,
  0x0C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x18, 0x03, 0x00,
  0x07, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x38, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x30, 0x00, 0x60, 0x0E, 0x00, 0x0C, 0x01,
  0x80, 0x01, 0x80, 0x70, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x03, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x03, 0x80, 0xE0, 0x30, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0x1C, 0x38, 0x00, 0x63, 0x81,
  0xC0, 0x06, 0x30, 0x0E, 0x00, 0x67, 0x00, 0x70, 0x0C, 0x60, 0x03, 0x81,
  0xC6, 0x00, 0x1C, 0x38, 0x60, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 10, 43, 11, 1, -42 },
  { 55, 11, 12, 15, 6, -44 },
  { 72, 30, 42, 28, 1, -42 },
  { 230, 25, 55, 28, 2, -49 },
  { 402, 28, 44, 37, 5, -43 },
  { 556, 26, 44, 31, 2, -43 },
  { 699, 4, 12, 10, 6, -44 },
  { 705, 16, 61, 16, 3, -47 },
  { 827, 16, 61, 16, -3, -47 },
  { 949, 23, 23, 24, 3, -42 },
  { 1016, 24, 30, 28, 2, -34 },
  { 1106, 7, 12, 11, -2, -5 },
  { 1117, 12, 2, 15, 2, -20 },
  { 1120, 4, 4, 13, 1, -3 },
  { 1122, 24, 46, 20, -2, -42 },
  { 1260, 23, 44, 28, 3, -43 },
  { 1387, 13, 42, 28, 8, -42 },
  { 1456, 25, 43, 28, 1, -43 },
  { 1591, 24, 44, 28, 2, -43 },
  { 1723, 25, 42, 28, 1, -42 },
  { 1855, 24, 43, 28, 4, -42 },
  { 1984, 22, 43, 28, 3, -42 },
  { 2103, 23, 42, 28, 5, -42 },
  { 2224, 26, 44, 28, 1, -43 },
  { 2367, 22, 43, 28, 4, -43 },
  { 2486, 9, 31, 11, 1, -30 },
  { 2521, 11, 37, 10, -2, -30 },
  { 2572, 22, 24, 26, 2, -31 },
  { 2638, 22, 14, 28, 3, -26 },
  { 2677, 22, 24, 26, 2, -31 },
  { 2743, 18, 44, 23, 5, -43 },
  { 2842, 41, 54, 46, 2, -41 },
  { 3119, 28, 42, 31, -2, -42 },
  { 3266, 27, 42, 31, 2, -42 },
  { 3408, 28, 44, 32, 3, -43 },
  { 3562, 29, 42, 33, 2, -42 },
  { 3715, 28, 42, 29, 2, -42 },
  { 3862, 29, 42, 29, 2, -42 },
  { 4015, 28, 44, 34, 4, -43 },
  { 4169, 32, 42, 35, 2, -42 },
  { 4337, 9, 42, 14, 3, -42 },
  { 4385, 26, 43, 28, 1, -42 },
  { 4525, 31, 42, 32, 2, -42 },
  { 4688, 20, 42, 26, 2, -42 },
  { 4793, 40, 42, 43, 2, -42 },
  { 5003, 33, 42, 35, 2, -42 },
  { 5177, 29, 44, 34, 3, -43 },
  { 5337, 28, 42, 31, 2, -42 },
  { 5484, 29, 51, 34, 3, -43 },
  { 5669, 28, 42, 32, 2, -42 },
  { 5816, 29, 44, 30, 1, -43 },
  { 5976, 26, 42, 30, 6, -42 },
  { 6113, 30, 43, 33, 3, -42 },
  { 6275, 28, 42, 31, 5, -42 },
  { 6422, 41, 42, 45, 6, -42 },
  { 6638, 33, 42, 30, -1, -42 },
  { 6812, 28, 42, 30, 5, -42 },
  { 6959, 31, 42, 30, 0, -42 },
  { 7122, 17, 57, 12, 0, -48 },
  { 7244, 9, 46, 20, 6, -42 },
  { 7296, 17, 57, 12, -4, -48 },
  { 7418, 16, 21, 21, 3, -42 },
  { 7460, 21, 2, 22, -3, 0 },
  { 7466, 7, 8, 16, 8, -44 },
  { 7473, 23, 33, 27, 1, -32 },
  { 7568, 24, 45, 28, 1, -44 },
  { 7703, 22, 33, 26, 2, -32 },
  { 7794, 26, 45, 28, 2, -44 },
  { 7941, 22, 33, 26, 2, -32 },
  { 8032, 18, 45, 17, 3, -45 },
  { 8134, 26, 44, 28, 0, -32 },
  { 8277, 23, 44, 28, 1, -44 },
  { 8404, 10, 43, 12, 2, -43 },
  { 8458, 19, 55, 12, -7, -43 },
  { 8589, 24, 44, 24, 1, -44 },
  { 8721, 10, 44, 12, 2, -44 },
  { 8776, 40, 32, 44, 1, -32 },
  { 8936, 23, 32, 28, 1, -32 },
  { 9028, 23, 33, 28, 2, -32 },
  { 9123, 26, 44, 28, -1, -32 },
  { 9266, 24, 44, 28, 2, -32 },
  { 9398, 18, 32, 17, 1, -32 },
  { 9470, 22, 33, 25, 1, -32 },
  { 9561, 13, 40, 17, 3, -39 },
  { 9626, 23, 32, 28, 3, -31 },
  { 9718, 21, 31, 24, 4, -31 },
  { 9800, 33, 31, 38, 5, -31 },
  { 9928, 25, 31, 24, -1, -31 },
  { 10025, 27, 43, 24, -2, -31 },
  { 10171, 24, 31, 24, 0, -31 },
  { 10264, 18, 58, 17, 2, -46 },
  { 10395, 10, 50, 12, 1, -42 },
  { 10458, 19, 58, 17, -4, -46 },
  { 10596, 28, 10, 34, 3, -23 },
};

const GFXfont RobotoCondensed_ExtraLightItalic59pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic59pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic59pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC59PT7B_H_
