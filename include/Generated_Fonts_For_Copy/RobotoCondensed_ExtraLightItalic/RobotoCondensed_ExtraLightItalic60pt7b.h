#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC60PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x3C, 0x0E, 0x00, 0x00, 0x38, 0x66, 0x1C, 0xC3,
  0x18, 0x63, 0x0C, 0x61, 0x9C, 0x33, 0x06, 0x61, 0x8C, 0x31, 0x86, 0x30,
  0xC4, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x60, 0x07,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x30, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01,
  0x80, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xC0,
  0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x38, 0x0F, 0x00, 0x38, 0x01, 0x80, 0x38, 0x00, 0xE0, 0x38, 0x00,
  0x30, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x31, 0xC0, 0x00,
  0x18, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00,
  0x07, 0x07, 0x00, 0x07, 0x01, 0x80, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1C, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18,
  0x03, 0x00, 0x67, 0x00, 0x60, 0x0C, 0xC0, 0x0C, 0x03, 0x18, 0x01, 0x80,
  0xC3, 0x00, 0x60, 0x18, 0x60, 0x0C, 0x06, 0x0C, 0x01, 0x81, 0x81, 0x80,
  0x30, 0x30, 0x30, 0x0C, 0x0C, 0x06, 0x01, 0x83, 0x00, 0xC0, 0x70, 0x60,
  0x0C, 0x1C, 0x18, 0x01, 0xEF, 0x06, 0x00, 0x1F, 0xC1, 0xC0, 0x00, 0x40,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x07, 0xF0, 0x00, 0xC1, 0xEF, 0x00, 0x30,
  0x70, 0x60, 0x0C, 0x1C, 0x06, 0x01, 0x83, 0x00, 0xC0, 0x60, 0x60, 0x18,
  0x18, 0x18, 0x03, 0x03, 0x03, 0x00, 0x60, 0xC0, 0x60, 0x0C, 0x30, 0x0C,
  0x01, 0x86, 0x03, 0x00, 0x31, 0x80, 0x60, 0x06, 0x60, 0x0C, 0x00, 0xDC,
  0x01, 0x80, 0x31, 0x00, 0x18, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x70, 0x1C, 0x00, 0x38, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x06,
  0x00, 0x60, 0x01, 0x80, 0x38, 0x00, 0x60, 0x1C, 0x00, 0x18, 0x0E, 0x00,
  0x07, 0x07, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x06, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x83, 0x80, 0x31,
  0xC0, 0x60, 0x0C, 0xE0, 0x1C, 0x03, 0x30, 0x03, 0x01, 0xDC, 0x00, 0xE0,
  0x66, 0x00, 0x18, 0x19, 0x80, 0x03, 0x0E, 0xE0, 0x00, 0xE3, 0x30, 0x00,
  0x19, 0xCC, 0x00, 0x07, 0x63, 0x00, 0x00, 0xF8, 0xC0, 0x00, 0x3C, 0x38,
  0x00, 0x06, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x01, 0xF0, 0x70, 0x00, 0xC6,
  0x0F, 0x00, 0xE1, 0xC1, 0xFF, 0xF0, 0x30, 0x1F, 0xF0, 0x0E, 0x00, 0x40,
  0x00, 0x00, 0x33, 0x33, 0x76, 0x66, 0x6E, 0xCC, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x18, 0x0E, 0x7C, 0x18, 0x3E, 0x1F, 0x19,
  0xF8, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x86, 0x00, 0x07, 0x07,
  0x00, 0x0E, 0x03, 0x00, 0x0C, 0x03, 0x80, 0x1C, 0x01, 0x80, 0x38, 0x01,
  0xC0, 0x10, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x1C, 0x38, 0x60, 0xC1, 0x87, 0x0C, 0x38, 0x61, 0xC7, 0x04,
  0x00, 0xFF, 0xFF, 0xFE, 0x7F, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0xE0, 0x38, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x0C, 0x03, 0x00, 0x0E,
  0x07, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x1C, 0x00, 0x06, 0x18, 0x00, 0x07, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x38, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0C,
  0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70,
  0xC0, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0xC0, 0x60, 0x01, 0xC0,
  0x70, 0x03, 0x80, 0x30, 0x03, 0x00, 0x38, 0x0F, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x1F,
  0x73, 0xE3, 0x7C, 0x1B, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x18, 0x06,
  0x00, 0x0E, 0x06, 0x00, 0x07, 0x03, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1E, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x1C, 0x00, 0x38, 0x0C, 0x00, 0x0C, 0x0E, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x18,
  0x00, 0x03, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0x81, 0x80, 0x01, 0xC0,
  0xE0, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xB8, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x63, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x70, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x30, 0x00, 0x38, 0x18, 0x00, 0x38, 0x1C,
  0x00, 0x18, 0x0E, 0x00, 0x18, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x0C, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x07, 0x00, 0x18, 0x07, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x03, 0x80,
  0x07, 0x03, 0x80, 0x03, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x7E, 0x00, 0x0C, 0xFF, 0xC0, 0x07, 0xE0, 0xF0, 0x03, 0xC0, 0x1C,
  0x01, 0x80, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x06, 0x01, 0x80, 0x07, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x07, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x0F, 0xC0,
  0x18, 0xFF, 0xC0, 0xC7, 0x07, 0x83, 0x70, 0x07, 0x0D, 0x80, 0x0C, 0x7C,
  0x00, 0x39, 0xE0, 0x00, 0x67, 0x00, 0x01, 0x9C, 0x00, 0x07, 0x60, 0x00,
  0x1D, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00,
  0x00, 0xEE, 0x00, 0x03, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x61, 0xC0, 0x03,
  0x83, 0x00, 0x1C, 0x0E, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xE0, 0x3C, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x1C, 0x00,
  0x1C, 0x06, 0x00, 0x07, 0x03, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x0C, 0x1C, 0x00, 0x03, 0x07, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x01,
  0xC0, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0xF0, 0x78, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x07, 0x01, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x38, 0x38, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00,
  0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x38, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x07, 0x07, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xC0,
  0x38, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0xF0, 0x1C, 0x07, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xC0, 0x01,
  0x87, 0x00, 0x07, 0x18, 0x00, 0x0C, 0xE0, 0x00, 0x33, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0x70, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00,
  0x03, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x60, 0x00, 0x1D, 0x80, 0x00, 0xE6, 0x00, 0x03, 0x98, 0x00, 0x1E, 0x70,
  0x00, 0xD8, 0xE0, 0x07, 0xE3, 0x80, 0x3B, 0x07, 0x83, 0xCC, 0x0F, 0xFC,
  0x30, 0x0F, 0xC1, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x80,
  0x07, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x03, 0xC1, 0xC0, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x07, 0x83, 0x80, 0x80, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x70, 0x0E, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x40, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x38,
  0x0E, 0x1C, 0x01, 0x8E, 0x00, 0x73, 0x00, 0x1D, 0xC0, 0x03, 0x60, 0x00,
  0xD8, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x7E, 0x00, 0x18, 0x18, 0x00, 0x7F, 0xC0, 0x0C, 0x1C, 0x00,
  0xF0, 0x70, 0x06, 0x0C, 0x00, 0xE0, 0x18, 0x03, 0x0E, 0x00, 0xE0, 0x0C,
  0x01, 0x86, 0x00, 0x60, 0x06, 0x00, 0xC7, 0x00, 0x60, 0x03, 0x00, 0x63,
  0x00, 0x30, 0x03, 0x00, 0x31, 0x80, 0x30, 0x01, 0x80, 0x19, 0x80, 0x18,
  0x00, 0xC0, 0x0C, 0xC0, 0x18, 0x00, 0x60, 0x06, 0x60, 0x0C, 0x00, 0x60,
  0x03, 0x70, 0x0E, 0x00, 0x30, 0x01, 0xB0, 0x06, 0x00, 0x18, 0x00, 0xD8,
  0x03, 0x00, 0x0C, 0x00, 0xCC, 0x01, 0x80, 0x0E, 0x00, 0x66, 0x01, 0x80,
  0x06, 0x00, 0x32, 0x00, 0xC0, 0x03, 0x00, 0x1B, 0x00, 0x60, 0x01, 0x80,
  0x19, 0x80, 0x30, 0x01, 0xC0, 0x0C, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x60,
  0x0C, 0x00, 0xE0, 0x06, 0x30, 0x06, 0x00, 0x70, 0x03, 0x18, 0x03, 0x00,
  0x78, 0x03, 0x0C, 0x01, 0x80, 0x2C, 0x01, 0x86, 0x00, 0xC0, 0x36, 0x01,
  0x83, 0x00, 0x70, 0x71, 0x81, 0x81, 0x80, 0x1F, 0xF0, 0xF7, 0x80, 0x60,
  0x07, 0xE0, 0x3F, 0x80, 0x30, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x38, 0x01, 0x80,
  0x01, 0x80, 0x0C, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x38, 0x01, 0x80, 0x00, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x0E, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x06, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0xC0, 0x01,
  0xC0, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x38, 0x18,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x30, 0x70, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0,
  0x38, 0x00, 0x38, 0x06, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x03,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x18, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x86, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x03,
  0x86, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x07, 0x03, 0x00,
  0x03, 0xC0, 0x60, 0x01, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x06,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x38, 0x07, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x07, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x60, 0x03, 0xE0, 0x03, 0x00, 0x07, 0x80,
  0x18, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x70,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x1E, 0x00, 0x60, 0x07,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xF0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x03, 0xFF, 0xC3, 0x00, 0x1F, 0xFE, 0x38, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xE0, 0x1C, 0x00,
  0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x30, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E,
  0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x18,
  0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x38, 0x06, 0x00,
  0x06, 0x00, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x1C, 0x00,
  0x3C, 0x07, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x70, 0x01, 0x80, 0x00, 0xE0, 0x01, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x0C, 0x7C,
  0x00, 0x00, 0x0C, 0xEC, 0x00, 0x00, 0x0D, 0xCE, 0x00, 0x00, 0x1F, 0x86,
  0x00, 0x00, 0x1F, 0x07, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x07, 0x00, 0x60, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x00,
  0xD8, 0x0D, 0xC0, 0x00, 0x00, 0xFC, 0x06, 0x60, 0x00, 0x00, 0x6C, 0x03,
  0x30, 0x00, 0x00, 0x66, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0xCC, 0x00,
  0x00, 0x31, 0x80, 0x66, 0x00, 0x00, 0x18, 0xC0, 0x63, 0x80, 0x00, 0x18,
  0xE0, 0x30, 0xC0, 0x00, 0x0C, 0x60, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x0C,
  0x30, 0x00, 0x06, 0x18, 0x06, 0x18, 0x00, 0x06, 0x0C, 0x07, 0x0C, 0x00,
  0x03, 0x0E, 0x03, 0x83, 0x00, 0x03, 0x07, 0x01, 0x81, 0x80, 0x01, 0x83,
  0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x60, 0x60, 0x01, 0xC0, 0xC0, 0x30,
  0x30, 0x00, 0xC0, 0x60, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x1C, 0x06, 0x00,
  0x60, 0x38, 0x0C, 0x03, 0x00, 0x70, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x03, 0x01, 0xC0,
  0x38, 0x1C, 0x03, 0x80, 0xE0, 0x0C, 0x0C, 0x01, 0x80, 0x60, 0x06, 0x0E,
  0x00, 0xC0, 0x30, 0x03, 0x06, 0x00, 0x60, 0x18, 0x01, 0x87, 0x00, 0x30,
  0x0C, 0x00, 0xC3, 0x00, 0x18, 0x0E, 0x00, 0x33, 0x80, 0x1C, 0x06, 0x00,
  0x19, 0x80, 0x0C, 0x03, 0x00, 0x0D, 0x80, 0x06, 0x01, 0x80, 0x06, 0xC0,
  0x03, 0x00, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x60, 0x01, 0xE0, 0x00, 0xC0,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0xC0, 0x78, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x30, 0x0D, 0x80, 0x00, 0x18,
  0x0E, 0xC0, 0x00, 0x0C, 0x07, 0x70, 0x00, 0x06, 0x03, 0x18, 0x00, 0x07,
  0x01, 0x8C, 0x00, 0x03, 0x80, 0xC7, 0x00, 0x01, 0x80, 0xE1, 0x80, 0x00,
  0xC0, 0x70, 0xC0, 0x00, 0x60, 0x38, 0x30, 0x00, 0x30, 0x18, 0x18, 0x00,
  0x38, 0x0C, 0x0E, 0x00, 0x1C, 0x06, 0x03, 0x00, 0x0C, 0x07, 0x01, 0x80,
  0x06, 0x03, 0x80, 0xE0, 0x03, 0x01, 0x80, 0x30, 0x01, 0x80, 0xC0, 0x18,
  0x01, 0xC0, 0x60, 0x06, 0x00, 0xE0, 0x30, 0x03, 0x00, 0x60, 0x38, 0x01,
  0xC0, 0x30, 0x1C, 0x00, 0x60, 0x18, 0x0C, 0x00, 0x30, 0x0C, 0x06, 0x00,
  0x1C, 0x0E, 0x03, 0x00, 0x06, 0x07, 0x01, 0x80, 0x03, 0x03, 0x01, 0xC0,
  0x00, 0xC1, 0x80, 0xE0, 0x00, 0x60, 0xC0, 0x60, 0x00, 0x38, 0xE0, 0x30,
  0x00, 0x0C, 0x70, 0x18, 0x00, 0x06, 0x30, 0x0C, 0x00, 0x03, 0x98, 0x0E,
  0x00, 0x00, 0xCC, 0x07, 0x00, 0x00, 0x66, 0x03, 0x00, 0x00, 0x1F, 0x01,
  0x80, 0x00, 0x0F, 0x80, 0xC0, 0x00, 0x07, 0x80, 0x60, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xF0, 0x07, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x19, 0xC0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x73, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0E,
  0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x07, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x60, 0x01, 0xF0, 0x03, 0x00, 0x03, 0x80, 0x18, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x60, 0x70, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x30, 0x18, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x07,
  0x80, 0x30, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x30, 0x06, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x19, 0xC0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x1C, 0x00, 0x00,
  0x18, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x30, 0x38, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x07,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x60, 0x01,
  0xE0, 0x03, 0x00, 0x03, 0x80, 0x18, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x30,
  0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x60, 0x70, 0x00, 0x07, 0x03, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x07, 0x80, 0x30, 0x00,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0xE0, 0x06, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x18, 0x01, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x18,
  0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x07, 0x01, 0x80, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x78, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38,
  0x07, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x06, 0x03, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x1C, 0x07,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x38, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x83, 0x00,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x03, 0x80,
  0x01, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x30, 0x03, 0x00, 0x03, 0x80, 0x18, 0x00, 0x18, 0x00, 0xC0,
  0x01, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x06,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x60, 0x70, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x77, 0x00,
  0x03, 0x60, 0x00, 0x33, 0x80, 0x01, 0xB0, 0x00, 0x19, 0xC0, 0x00, 0xD8,
  0x00, 0x1C, 0xE0, 0x00, 0xC6, 0x00, 0x0C, 0x70, 0x00, 0x63, 0x00, 0x06,
  0x18, 0x00, 0x71, 0x80, 0x07, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x06, 0x00,
  0x18, 0x60, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0xC1, 0x80, 0x0C, 0x18,
  0x00, 0xC0, 0xC0, 0x0E, 0x0C, 0x00, 0xE0, 0x60, 0x06, 0x06, 0x00, 0x60,
  0x30, 0x03, 0x03, 0x00, 0x30, 0x18, 0x03, 0x01, 0x80, 0x38, 0x0C, 0x01,
  0x80, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x18,
  0x0E, 0x01, 0x80, 0x60, 0x0C, 0x06, 0x00, 0xE0, 0x60, 0x06, 0x03, 0x00,
  0x70, 0x30, 0x03, 0x03, 0x00, 0x38, 0x38, 0x01, 0x81, 0x80, 0x1C, 0x18,
  0x00, 0xC1, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x30,
  0x60, 0x01, 0x86, 0x00, 0x18, 0x70, 0x00, 0xC7, 0x00, 0x0C, 0x30, 0x00,
  0x63, 0x00, 0x07, 0x18, 0x00, 0x31, 0x80, 0x01, 0x9C, 0x00, 0x19, 0x80,
  0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x36,
  0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x70,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x18, 0x70, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x1C,
  0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0xC0, 0x0E, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xE0, 0x1C,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x60, 0x30, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x00, 0xC0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x70, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x68, 0x00, 0x6C, 0x00, 0xCC,
  0x00, 0xCC, 0x01, 0x8C, 0x01, 0x8C, 0x03, 0x0C, 0x03, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x0C, 0x06, 0x0C, 0x06, 0x18, 0x06, 0x18, 0x03, 0x30, 0x03,
  0x70, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE0, 0xE1, 0xC1, 0xC1, 0x83, 0x83, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0xE0, 0x01,
  0x81, 0x80, 0x03, 0x86, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0x80, 0x30, 0x78,
  0x00, 0x61, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x8E, 0x00, 0x07, 0x18, 0x00,
  0x0C, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x31, 0x80, 0x00, 0xE3, 0x00, 0x01,
  0xC6, 0x00, 0x07, 0x8E, 0x00, 0x1F, 0x0C, 0x00, 0x6E, 0x1C, 0x03, 0x98,
  0x1F, 0xFE, 0x30, 0x1F, 0xF0, 0x60, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x0F, 0xF0, 0x03, 0x3F, 0xFC, 0x07, 0x70, 0x1E, 0x07, 0xC0, 0x0E,
  0x07, 0x80, 0x06, 0x07, 0x00, 0x07, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x18, 0x00, 0x07,
  0x18, 0x00, 0x07, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x38, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x70, 0x00, 0x38, 0x68, 0x00, 0x70,
  0x6C, 0x00, 0xE0, 0x67, 0x01, 0xE0, 0x63, 0xFF, 0xC0, 0xE1, 0xFF, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0xF0, 0x1C, 0x07, 0x00, 0x38, 0x38, 0x00, 0x60, 0xC0, 0x01, 0xC7, 0x00,
  0x03, 0x18, 0x00, 0x0C, 0xE0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33,
  0x00, 0x01, 0x8E, 0x00, 0x06, 0x18, 0x00, 0x38, 0x60, 0x00, 0xC1, 0xC0,
  0x06, 0x03, 0x80, 0x70, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x40, 0x30, 0x00, 0xFF, 0x06,
  0x00, 0x7F, 0xF8, 0xC0, 0x1E, 0x03, 0x98, 0x07, 0x00, 0x33, 0x00, 0xC0,
  0x03, 0xE0, 0x30, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x00, 0x60,
  0x30, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0x60, 0x30, 0x00,
  0x0C, 0x06, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C,
  0x03, 0x00, 0x03, 0x80, 0x70, 0x00, 0xF0, 0x06, 0x00, 0x3C, 0x00, 0xE0,
  0x1D, 0x80, 0x0F, 0xFF, 0x30, 0x00, 0xFF, 0x86, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xF0, 0x1C,
  0x07, 0x00, 0x38, 0x38, 0x00, 0x60, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x18,
  0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xDC, 0x00, 0x03, 0x60, 0x00,
  0x0D, 0x80, 0x00, 0x37, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x40, 0xE0, 0x03, 0x83,
  0xC0, 0x3C, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x1F, 0xFF, 0x83, 0xFF,
  0xE0, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xF8, 0x30, 0x07, 0xFF, 0x8C, 0x03,
  0xC0, 0x73, 0x01, 0xC0, 0x0D, 0xC0, 0x60, 0x01, 0xE0, 0x30, 0x00, 0x38,
  0x1C, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0xE0, 0x00,
  0x38, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x07, 0x06, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0E, 0x00, 0x01,
  0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x06, 0x00,
  0x03, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x3C, 0x03,
  0x00, 0x1E, 0x00, 0xE0, 0x1D, 0x80, 0x1F, 0xFE, 0x60, 0x03, 0xFE, 0x18,
  0x00, 0x08, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x01, 0x00, 0x03, 0x80, 0x60,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x61, 0xFF, 0x00, 0xC7, 0xFF, 0x01,
  0x9C, 0x0E, 0x07, 0x60, 0x0E, 0x0D, 0x80, 0x0C, 0x1E, 0x00, 0x18, 0x38,
  0x00, 0x30, 0x70, 0x00, 0x61, 0xC0, 0x00, 0xC3, 0x80, 0x01, 0x86, 0x00,
  0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xE0, 0x00,
  0x71, 0x80, 0x00, 0xE3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x70, 0x00, 0x38, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3,
  0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x1C, 0x60,
  0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x8E, 0x00,
  0x03, 0x00, 0x01, 0x80, 0xF0, 0x3C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x7F, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x38, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x38, 0x07, 0x00, 0x38, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x38, 0x00, 0xC0, 0x38, 0x00, 0x60, 0x38, 0x00, 0x70,
  0x38, 0x00, 0x38, 0x38, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x06,
  0x38, 0x00, 0x03, 0x38, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xBF, 0x00, 0x00,
  0xF9, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x30, 0x30, 0x00, 0x18, 0x1C, 0x00,
  0x1C, 0x06, 0x00, 0x0C, 0x03, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x70,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0x60, 0x01,
  0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x0C, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x01, 0x87, 0xF8, 0x03, 0xFC, 0x01, 0xC7, 0xFE,
  0x07, 0xFF, 0x80, 0xCE, 0x03, 0x87, 0x01, 0xC0, 0x66, 0x00, 0xE7, 0x00,
  0x70, 0x36, 0x00, 0x33, 0x00, 0x18, 0x1E, 0x00, 0x1B, 0x00, 0x0C, 0x0E,
  0x00, 0x0F, 0x00, 0x06, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x83, 0x80, 0x01, 0xC0, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x00, 0x18, 0x70,
  0x00, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x0C,
  0x00, 0x07, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x87, 0x00, 0x01, 0x80, 0x00, 0xC3, 0x80, 0x01, 0xC0, 0x00, 0x61, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x00, 0x06,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x86, 0x00,
  0x03, 0x00, 0x01, 0xC3, 0x00, 0x01, 0x80, 0x00, 0xC1, 0x80, 0x00, 0xC0,
  0x00, 0x61, 0xC0, 0x00, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x1F, 0xE0, 0x0C, 0x7F, 0xF0, 0x39, 0xC0,
  0xE0, 0x66, 0x00, 0xE0, 0xD8, 0x00, 0xC1, 0xE0, 0x01, 0x83, 0xC0, 0x03,
  0x07, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x60, 0x00, 0x30,
  0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x8E, 0x00, 0x07, 0x18,
  0x00, 0x0E, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80,
  0x00, 0xC7, 0x00, 0x03, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x31, 0xC0, 0x00, 0x63, 0x80, 0x01, 0xC6, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x1E, 0x01, 0xC0,
  0x38, 0x01, 0xC0, 0xE0, 0x01, 0x83, 0x80, 0x03, 0x86, 0x00, 0x03, 0x1C,
  0x00, 0x06, 0x30, 0x00, 0x0C, 0xE0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0xDC, 0x00, 0x01, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x18,
  0xC0, 0x00, 0x71, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x87, 0x00, 0x0E, 0x07,
  0x00, 0x38, 0x07, 0x00, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xFF, 0x00, 0x0C, 0xFF, 0xF0,
  0x07, 0x70, 0x1C, 0x01, 0xB0, 0x03, 0x80, 0x78, 0x00, 0x60, 0x1C, 0x00,
  0x1C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x30,
  0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30,
  0x30, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x70, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0E, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x60, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x38, 0x1E, 0x00, 0x1C,
  0x06, 0xC0, 0x0E, 0x01, 0x98, 0x07, 0x80, 0x63, 0xFF, 0x80, 0x38, 0x7F,
  0xC0, 0x0C, 0x01, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0x83, 0x01,
  0xFF, 0xE3, 0x03, 0xC0, 0x73, 0x07, 0x00, 0x37, 0x06, 0x00, 0x1E, 0x0E,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x38,
  0x00, 0x0E, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x70,
  0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x30, 0x01, 0xE0, 0x38,
  0x07, 0x60, 0x1F, 0xFE, 0x60, 0x0F, 0xF8, 0x60, 0x00, 0x80, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC3,
  0xF0, 0x33, 0xFC, 0x1D, 0xC0, 0x07, 0xE0, 0x01, 0xB0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xF0, 0x1E, 0x07, 0x00,
  0x18, 0x18, 0x00, 0x70, 0xE0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x33, 0x80, 0x01, 0xCE, 0x00,
  0x06, 0x38, 0x00, 0x18, 0x60, 0x00, 0xE1, 0xC0, 0x07, 0x03, 0x80, 0x78,
  0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x7F, 0xFF,
  0xFF, 0xC1, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xFE,
  0x03, 0xF0, 0x04, 0x00, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x70, 0x00,
  0x38, 0xC0, 0x00, 0x71, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x38, 0x00, 0x1C, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x61,
  0x80, 0x00, 0xC3, 0x00, 0x01, 0x8E, 0x00, 0x03, 0x1C, 0x00, 0x0E, 0x30,
  0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC7, 0x00,
  0x01, 0x8E, 0x00, 0x07, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00,
  0x30, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0xC3, 0x80, 0x07, 0x83, 0x00, 0x1E,
  0x07, 0x00, 0x6C, 0x0F, 0x01, 0xD8, 0x0F, 0xFE, 0x30, 0x0F, 0xF8, 0x60,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0D, 0xC0,
  0x00, 0xEE, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x03, 0x0C, 0x00, 0x18,
  0x60, 0x01, 0xC3, 0x00, 0x0C, 0x1C, 0x00, 0xE0, 0x60, 0x06, 0x03, 0x00,
  0x70, 0x18, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x30,
  0x00, 0x61, 0x80, 0x03, 0x1C, 0x00, 0x0C, 0xC0, 0x00, 0x6E, 0x00, 0x03,
  0x60, 0x00, 0x1B, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xD8, 0x00, 0x78, 0x00, 0xEC, 0x00, 0x3C, 0x00, 0x66,
  0x00, 0x36, 0x00, 0x33, 0x00, 0x1B, 0x00, 0x39, 0x80, 0x19, 0x80, 0x18,
  0xC0, 0x0C, 0xC0, 0x1C, 0x70, 0x0E, 0x60, 0x0C, 0x38, 0x06, 0x30, 0x06,
  0x1C, 0x07, 0x18, 0x07, 0x06, 0x03, 0x0E, 0x03, 0x03, 0x01, 0x83, 0x03,
  0x81, 0x81, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x60,
  0xE0, 0x30, 0x60, 0x30, 0x60, 0x18, 0x70, 0x18, 0x70, 0x0C, 0x30, 0x0C,
  0x30, 0x06, 0x18, 0x06, 0x18, 0x03, 0x18, 0x03, 0x1C, 0x01, 0x8C, 0x01,
  0x8C, 0x00, 0xCC, 0x00, 0xCE, 0x00, 0x66, 0x00, 0x26, 0x00, 0x33, 0x00,
  0x1B, 0x00, 0x1B, 0x00, 0x0F, 0x00, 0x05, 0x80, 0x07, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00,
  0x70, 0x06, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x07, 0x00, 0x0E,
  0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x70, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x00, 0xC0,
  0x01, 0x80, 0x38, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x01, 0x80, 0x38, 0x00,
  0x70, 0x0C, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00,
  0x0C, 0x01, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x18, 0x01, 0x80, 0x03, 0x80,
  0x18, 0x00, 0x30, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0,
  0x0E, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0xC0, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x40,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01,
  0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01,
  0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0xF8,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x0C, 0xF1, 0xE0, 0x01, 0x98, 0x0E, 0x00, 0x36, 0x00,
  0xC0, 0x0D, 0xC0, 0x1C, 0x01, 0xB0, 0x01, 0xC0, 0x66, 0x00, 0x1E, 0x3C,
  0xC0, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoCondensed_ExtraLightItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 10, 44, 11, 1, -43 },
  { 56, 11, 13, 16, 6, -45 },
  { 74, 30, 43, 29, 1, -43 },
  { 236, 25, 56, 28, 2, -50 },
  { 411, 27, 45, 38, 6, -44 },
  { 563, 26, 45, 31, 2, -44 },
  { 710, 4, 12, 10, 6, -45 },
  { 716, 16, 62, 16, 3, -48 },
  { 840, 16, 62, 17, -3, -48 },
  { 964, 24, 24, 25, 3, -43 },
  { 1036, 24, 31, 29, 3, -35 },
  { 1129, 7, 13, 11, -2, -5 },
  { 1141, 12, 2, 15, 2, -20 },
  { 1144, 4, 4, 13, 1, -3 },
  { 1146, 24, 47, 20, -2, -43 },
  { 1287, 24, 45, 28, 3, -44 },
  { 1422, 13, 43, 28, 8, -43 },
  { 1492, 25, 44, 28, 1, -44 },
  { 1630, 25, 45, 28, 2, -44 },
  { 1771, 25, 43, 28, 1, -43 },
  { 1906, 25, 44, 28, 4, -43 },
  { 2044, 22, 44, 28, 3, -43 },
  { 2165, 24, 43, 28, 5, -43 },
  { 2294, 26, 45, 28, 1, -44 },
  { 2441, 22, 44, 28, 4, -44 },
  { 2562, 9, 32, 11, 1, -31 },
  { 2598, 12, 39, 11, -2, -31 },
  { 2657, 22, 25, 26, 3, -32 },
  { 2726, 23, 14, 28, 3, -27 },
  { 2767, 22, 25, 27, 2, -32 },
  { 2836, 18, 45, 23, 5, -44 },
  { 2938, 41, 54, 46, 2, -41 },
  { 3215, 29, 43, 31, -2, -43 },
  { 3371, 27, 43, 31, 2, -43 },
  { 3517, 29, 45, 33, 3, -44 },
  { 3681, 29, 43, 33, 2, -43 },
  { 3837, 29, 43, 29, 2, -43 },
  { 3993, 29, 43, 29, 2, -43 },
  { 4149, 29, 45, 35, 4, -44 },
  { 4313, 33, 43, 36, 2, -43 },
  { 4491, 10, 43, 14, 3, -43 },
  { 4545, 27, 44, 28, 1, -43 },
  { 4694, 32, 43, 32, 2, -43 },
  { 4866, 20, 43, 27, 2, -43 },
  { 4974, 41, 43, 43, 2, -43 },
  { 5195, 33, 43, 36, 2, -43 },
  { 5373, 29, 45, 34, 3, -44 },
  { 5537, 29, 43, 31, 2, -43 },
  { 5693, 29, 52, 34, 3, -44 },
  { 5882, 29, 43, 33, 2, -43 },
  { 6038, 29, 45, 30, 1, -44 },
  { 6202, 27, 43, 30, 6, -43 },
  { 6348, 30, 44, 34, 3, -43 },
  { 6513, 29, 43, 31, 5, -43 },
  { 6669, 41, 43, 45, 6, -43 },
  { 6890, 34, 43, 31, -1, -43 },
  { 7073, 28, 43, 31, 6, -43 },
  { 7224, 31, 43, 31, 0, -43 },
  { 7391, 17, 58, 12, 0, -49 },
  { 7515, 9, 47, 20, 6, -43 },
  { 7568, 17, 58, 12, -4, -49 },
  { 7692, 16, 21, 22, 3, -43 },
  { 7734, 21, 2, 22, -3, 0 },
  { 7740, 7, 8, 16, 8, -45 },
  { 7747, 23, 34, 27, 1, -33 },
  { 7845, 24, 46, 28, 1, -45 },
  { 7983, 22, 34, 26, 2, -33 },
  { 8077, 27, 46, 28, 2, -45 },
  { 8233, 22, 34, 26, 2, -33 },
  { 8327, 19, 46, 17, 3, -46 },
  { 8437, 26, 45, 28, 0, -33 },
  { 8584, 23, 45, 28, 1, -45 },
  { 8714, 10, 44, 12, 2, -44 },
  { 8769, 20, 56, 12, -8, -44 },
  { 8909, 25, 45, 25, 1, -45 },
  { 9050, 10, 45, 12, 2, -45 },
  { 9107, 41, 33, 45, 1, -33 },
  { 9277, 23, 33, 28, 1, -33 },
  { 9372, 23, 34, 28, 2, -33 },
  { 9470, 26, 45, 28, -1, -33 },
  { 9617, 24, 45, 28, 2, -33 },
  { 9752, 18, 33, 18, 1, -33 },
  { 9827, 22, 34, 26, 1, -33 },
  { 9921, 13, 41, 17, 3, -40 },
  { 9988, 23, 33, 28, 3, -32 },
  { 10083, 21, 32, 25, 4, -32 },
  { 10167, 33, 32, 38, 5, -32 },
  { 10299, 26, 32, 25, -1, -32 },
  { 10403, 28, 44, 25, -2, -32 },
  { 10557, 24, 32, 25, 0, -32 },
  { 10653, 19, 59, 17, 2, -47 },
  { 10794, 10, 51, 12, 1, -43 },
  { 10858, 19, 60, 17, -4, -47 },
  { 11001, 27, 10, 35, 4, -23 },
};

const GFXfont RobotoCondensed_ExtraLightItalic60pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic60pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic60pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC60PT7B_H_
