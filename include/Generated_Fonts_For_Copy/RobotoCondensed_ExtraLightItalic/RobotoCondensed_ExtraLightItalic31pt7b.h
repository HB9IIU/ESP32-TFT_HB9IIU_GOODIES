#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC31PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x21, 0x08, 0xC4, 0x21, 0x08, 0x46, 0x21, 0x08, 0x00,
  0x00, 0x08, 0x40, 0x4D, 0x24, 0x92, 0x4A, 0x20, 0x00, 0x84, 0x03, 0x08,
  0x04, 0x20, 0x08, 0x40, 0x10, 0x80, 0x42, 0x0F, 0xFF, 0x81, 0x08, 0x04,
  0x30, 0x08, 0x40, 0x10, 0x80, 0x43, 0x00, 0x84, 0x01, 0x08, 0x04, 0x30,
  0x7F, 0xFC, 0x10, 0x80, 0x43, 0x00, 0x84, 0x01, 0x08, 0x04, 0x10, 0x08,
  0x40, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x07, 0x80, 0x63, 0x04, 0x08,
  0x40, 0x62, 0x01, 0x10, 0x09, 0x80, 0x44, 0x00, 0x20, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02,
  0x20, 0x31, 0x01, 0x04, 0x30, 0x1F, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00,
  0x3C, 0x01, 0x98, 0x04, 0x20, 0x20, 0x82, 0x82, 0x12, 0x08, 0xC8, 0x22,
  0x21, 0x10, 0xCC, 0x81, 0xE2, 0x00, 0x10, 0x00, 0x80, 0x06, 0x78, 0x13,
  0x10, 0x88, 0x44, 0x41, 0x11, 0x04, 0x84, 0x14, 0x10, 0x50, 0x42, 0x00,
  0x98, 0x03, 0xC0, 0x03, 0xC0, 0x19, 0x80, 0xC2, 0x02, 0x08, 0x08, 0x20,
  0x20, 0x80, 0x84, 0x02, 0x20, 0x09, 0x00, 0x18, 0x00, 0xE0, 0x06, 0x80,
  0x23, 0x0D, 0x84, 0x24, 0x18, 0xB0, 0x26, 0x80, 0x52, 0x01, 0xC8, 0x02,
  0x30, 0x1C, 0x61, 0x90, 0xF8, 0x60, 0x55, 0xA0, 0x01, 0x02, 0x04, 0x0C,
  0x08, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x40, 0x40, 0x20, 0x20, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x04,
  0x03, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x08, 0x04, 0x06, 0x02, 0x02, 0x01,
  0x01, 0x01, 0x01, 0x00, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0xC4, 0x73,
  0xDC, 0x0E, 0x00, 0xE0, 0x12, 0x02, 0x10, 0x61, 0x04, 0x08, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x1F, 0xFF, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x32, 0x22, 0x64, 0x80, 0xFC, 0xF0, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x07, 0x80, 0xC6,
  0x10, 0x22, 0x02, 0x20, 0x36, 0x01, 0x40, 0x14, 0x03, 0x40, 0x3C, 0x02,
  0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x48, 0x0C,
  0x80, 0x88, 0x10, 0x43, 0x03, 0xC0, 0x06, 0x3D, 0x9C, 0x20, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x20, 0x41, 0x82,
  0x04, 0x00, 0x03, 0xC0, 0x61, 0x06, 0x04, 0x20, 0x23, 0x01, 0x10, 0x08,
  0x80, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00,
  0x7F, 0xF0, 0x03, 0xC0, 0x61, 0x86, 0x04, 0x20, 0x33, 0x00, 0x90, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x06, 0x01, 0xE0, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x80, 0x24, 0x01, 0x20, 0x10, 0x81, 0x86, 0x18,
  0x0F, 0x00, 0x00, 0x30, 0x01, 0x80, 0x14, 0x01, 0xE0, 0x0A, 0x00, 0x90,
  0x08, 0x80, 0xC4, 0x04, 0x20, 0x43, 0x06, 0x10, 0x20, 0x82, 0x04, 0x20,
  0x23, 0x01, 0x1F, 0xFE, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x0F, 0xF8, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x2F, 0x01, 0x86, 0x18, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x80, 0x44, 0x02, 0x20, 0x10, 0x81, 0x06, 0x30,
  0x1F, 0x00, 0x00, 0xF0, 0x38, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x27, 0x82, 0x86, 0x50, 0x26, 0x03, 0x40, 0x14, 0x01, 0x40,
  0x14, 0x03, 0x40, 0x24, 0x02, 0x40, 0x66, 0x04, 0x31, 0x81, 0xF0, 0xFF,
  0xF0, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x03, 0xE0, 0x71, 0x82,
  0x06, 0x20, 0x11, 0x00, 0x90, 0x04, 0x80, 0x66, 0x02, 0x10, 0x30, 0xC3,
  0x03, 0xE0, 0x21, 0x86, 0x02, 0x20, 0x13, 0x00, 0xD0, 0x06, 0x80, 0x24,
  0x01, 0x20, 0x19, 0x80, 0x86, 0x18, 0x0F, 0x80, 0x07, 0x81, 0x8C, 0x30,
  0x22, 0x02, 0x60, 0x24, 0x03, 0x40, 0x3C, 0x03, 0x80, 0x28, 0x02, 0xC0,
  0x24, 0x06, 0x40, 0xA2, 0x14, 0x1E, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01,
  0x00, 0x20, 0x0C, 0x07, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x18, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x82, 0x08, 0x21, 0x04, 0x20, 0x00, 0x10, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x04,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x20, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x40, 0x00, 0x1E, 0x30, 0x90, 0x70, 0x18, 0x08, 0x04, 0x06, 0x02,
  0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x80, 0x80, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x06, 0x00, 0x00, 0x3F, 0x80, 0x07, 0x07, 0x00, 0x40, 0x08,
  0x04, 0x00, 0x20, 0x40, 0x00, 0x84, 0x00, 0x04, 0x60, 0x70, 0x22, 0x0C,
  0x61, 0x20, 0xC1, 0x09, 0x04, 0x10, 0x58, 0x40, 0x82, 0x82, 0x04, 0x14,
  0x30, 0x20, 0xA1, 0x02, 0x06, 0x08, 0x10, 0x30, 0x40, 0x82, 0x82, 0x0C,
  0x14, 0x10, 0x41, 0x20, 0x87, 0x09, 0x04, 0x48, 0x88, 0x1C, 0x78, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x04, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x02, 0x80, 0x05, 0x00, 0x11, 0x00, 0x22, 0x00, 0x84, 0x01, 0x08, 0x04,
  0x10, 0x08, 0x20, 0x20, 0x40, 0x40, 0xC1, 0x00, 0x82, 0x01, 0x0F, 0xFE,
  0x10, 0x04, 0x40, 0x08, 0x80, 0x13, 0x00, 0x34, 0x00, 0x38, 0x00, 0x40,
  0x0F, 0xE0, 0x20, 0x61, 0x80, 0xC4, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00,
  0xC4, 0x02, 0x30, 0x18, 0x80, 0xC3, 0xFC, 0x08, 0x0C, 0x20, 0x10, 0x80,
  0x26, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x44, 0x01, 0x10, 0x08, 0xC0,
  0xC3, 0xFE, 0x00, 0x03, 0xE0, 0x38, 0x61, 0x80, 0xC4, 0x01, 0x20, 0x04,
  0x80, 0x14, 0x00, 0x50, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x02, 0x80, 0x12, 0x00, 0x4C, 0x02,
  0x10, 0x18, 0x60, 0xC0, 0x7C, 0x00, 0x0F, 0xE0, 0x10, 0x30, 0x60, 0x30,
  0x80, 0x21, 0x00, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x30, 0x02, 0x40,
  0x04, 0x80, 0x19, 0x00, 0x22, 0x00, 0x44, 0x00, 0x98, 0x01, 0x20, 0x06,
  0x40, 0x08, 0x80, 0x31, 0x00, 0x42, 0x01, 0x0C, 0x0C, 0x1F, 0xE0, 0x00,
  0x0F, 0xFE, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0xFF, 0xC1, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x00, 0xFF, 0xC1, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00,
  0x03, 0xF0, 0x0C, 0x30, 0x20, 0x10, 0x80, 0x23, 0x00, 0x24, 0x00, 0x48,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x1F,
  0xD0, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x80, 0x11, 0x00, 0x62,
  0x01, 0x83, 0x0E, 0x03, 0xF0, 0x00, 0x08, 0x00, 0x84, 0x00, 0x46, 0x00,
  0x62, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02, 0x30,
  0x03, 0x10, 0x01, 0x0F, 0xFF, 0x84, 0x00, 0x42, 0x00, 0x21, 0x00, 0x11,
  0x80, 0x18, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02, 0x10, 0x01, 0x08, 0x00,
  0x8C, 0x00, 0xC4, 0x00, 0x40, 0x08, 0x42, 0x10, 0x8C, 0x42, 0x10, 0x8C,
  0x42, 0x10, 0x84, 0x62, 0x10, 0x84, 0x20, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x80, 0x44, 0x02,
  0x20, 0x21, 0x03, 0x04, 0x30, 0x1F, 0x00, 0x08, 0x03, 0x08, 0x06, 0x18,
  0x0C, 0x10, 0x18, 0x10, 0x30, 0x10, 0x20, 0x10, 0x40, 0x10, 0x80, 0x31,
  0x00, 0x22, 0x00, 0x26, 0x00, 0x2B, 0x00, 0x31, 0x00, 0x21, 0x80, 0x60,
  0x80, 0x40, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x40, 0x20, 0x40, 0x30, 0xC0,
  0x10, 0x80, 0x08, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0xFF, 0x80, 0x0C, 0x00,
  0x18, 0x60, 0x00, 0xC7, 0x00, 0x0A, 0x28, 0x00, 0x61, 0x40, 0x05, 0x0A,
  0x00, 0x28, 0x58, 0x02, 0x42, 0x40, 0x12, 0x32, 0x01, 0x31, 0x10, 0x19,
  0x08, 0x80, 0x88, 0x44, 0x0C, 0x42, 0x10, 0x42, 0x10, 0x86, 0x11, 0x84,
  0x21, 0x88, 0x23, 0x08, 0x41, 0x10, 0x42, 0x09, 0x82, 0x10, 0x28, 0x10,
  0x81, 0x80, 0x8C, 0x0C, 0x0C, 0x40, 0x40, 0x40, 0x08, 0x00, 0x86, 0x00,
  0x47, 0x00, 0x23, 0x80, 0x31, 0x20, 0x10, 0x90, 0x08, 0x4C, 0x04, 0x22,
  0x02, 0x31, 0x01, 0x10, 0x41, 0x88, 0x20, 0x84, 0x10, 0x42, 0x04, 0x21,
  0x02, 0x11, 0x81, 0x98, 0x80, 0x4C, 0x40, 0x24, 0x20, 0x0A, 0x10, 0x05,
  0x08, 0x02, 0x8C, 0x00, 0xC4, 0x00, 0x40, 0x03, 0xF0, 0x1C, 0x30, 0x60,
  0x30, 0x80, 0x22, 0x00, 0x44, 0x00, 0xD0, 0x01, 0xA0, 0x03, 0x40, 0x04,
  0x80, 0x0B, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50, 0x01, 0xA0, 0x02, 0x40,
  0x04, 0x80, 0x19, 0x00, 0x22, 0x00, 0xC2, 0x03, 0x07, 0x0C, 0x03, 0xE0,
  0x00, 0x0F, 0xF0, 0x10, 0x30, 0x60, 0x10, 0x80, 0x31, 0x00, 0x22, 0x00,
  0x44, 0x00, 0x88, 0x02, 0x30, 0x04, 0x40, 0x18, 0x80, 0x61, 0x01, 0x83,
  0xFC, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x03, 0xE0, 0x1C, 0x30, 0x60,
  0x30, 0x80, 0x22, 0x00, 0x44, 0x00, 0xD0, 0x01, 0xA0, 0x03, 0x40, 0x04,
  0x80, 0x0B, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50, 0x01, 0xA0, 0x02, 0x40,
  0x04, 0x80, 0x19, 0x00, 0x22, 0x00, 0xC2, 0x03, 0x07, 0x0C, 0x03, 0xF0,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x0F, 0xF0, 0x10, 0x30,
  0x60, 0x10, 0x80, 0x21, 0x00, 0x62, 0x00, 0x44, 0x01, 0x88, 0x02, 0x30,
  0x04, 0x40, 0x18, 0x80, 0x61, 0x01, 0x83, 0xFC, 0x04, 0x08, 0x10, 0x10,
  0x20, 0x30, 0x40, 0x20, 0x80, 0x41, 0x00, 0xC6, 0x00, 0x88, 0x01, 0x10,
  0x03, 0x00, 0x03, 0xF0, 0x0C, 0x30, 0x20, 0x30, 0x80, 0x23, 0x00, 0x44,
  0x00, 0x88, 0x00, 0x18, 0x00, 0x10, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x40, 0x04, 0x80, 0x19, 0x00, 0x23,
  0x00, 0x42, 0x01, 0x03, 0x0C, 0x03, 0xE0, 0x00, 0xFF, 0xFC, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x10,
  0x02, 0x60, 0x04, 0x80, 0x09, 0x00, 0x32, 0x00, 0x44, 0x00, 0x88, 0x01,
  0x30, 0x02, 0x40, 0x04, 0x80, 0x19, 0x00, 0x22, 0x00, 0x4C, 0x00, 0x90,
  0x01, 0x20, 0x02, 0x40, 0x0C, 0x80, 0x11, 0x00, 0x22, 0x00, 0x82, 0x03,
  0x06, 0x0C, 0x03, 0xE0, 0x00, 0x80, 0x06, 0x00, 0x38, 0x00, 0xA0, 0x06,
  0xC0, 0x11, 0x00, 0x44, 0x02, 0x10, 0x08, 0x40, 0x41, 0x01, 0x04, 0x0C,
  0x18, 0x20, 0x21, 0x80, 0x84, 0x02, 0x30, 0x08, 0x80, 0x22, 0x00, 0x90,
  0x01, 0x40, 0x06, 0x00, 0x18, 0x00, 0x40, 0x00, 0x80, 0x20, 0x0A, 0x00,
  0x80, 0x28, 0x05, 0x01, 0xA0, 0x14, 0x04, 0x80, 0xD0, 0x13, 0x02, 0x40,
  0x8C, 0x09, 0x02, 0x30, 0x44, 0x08, 0x41, 0x10, 0x41, 0x0C, 0x41, 0x04,
  0x21, 0x0C, 0x10, 0x84, 0x20, 0x44, 0x10, 0x81, 0x10, 0x46, 0x04, 0xC0,
  0x90, 0x12, 0x02, 0x40, 0x48, 0x0A, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0,
  0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x18, 0x01, 0x04,
  0x01, 0x83, 0x00, 0x80, 0x80, 0x80, 0x40, 0xC0, 0x30, 0xC0, 0x08, 0x40,
  0x06, 0x40, 0x01, 0x60, 0x00, 0xA0, 0x00, 0x20, 0x00, 0x30, 0x00, 0x3C,
  0x00, 0x12, 0x00, 0x11, 0x00, 0x18, 0x40, 0x18, 0x20, 0x08, 0x18, 0x08,
  0x04, 0x0C, 0x03, 0x04, 0x00, 0x84, 0x00, 0x40, 0x80, 0x07, 0x00, 0x24,
  0x01, 0x90, 0x04, 0x60, 0x20, 0x81, 0x82, 0x04, 0x08, 0x20, 0x11, 0x80,
  0x44, 0x01, 0x20, 0x06, 0x80, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF, 0xF8, 0x07, 0x82, 0x01, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x60, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x0C, 0x07, 0x80, 0x86, 0x10, 0x84, 0x21, 0x08, 0x61, 0x08,
  0x42, 0x10, 0x84, 0x10, 0x84, 0x21, 0x08, 0x41, 0x07, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x0C, 0x04, 0x02, 0x01, 0x07, 0x80, 0x04, 0x0C, 0x0A, 0x1A, 0x12, 0x32,
  0x22, 0x62, 0x41, 0xC1, 0x81, 0x7F, 0xE0, 0xC4, 0x22, 0x03, 0xC0, 0xC2,
  0x18, 0x11, 0x01, 0x20, 0x10, 0x01, 0x00, 0x10, 0x7F, 0x18, 0x32, 0x02,
  0x40, 0x24, 0x02, 0x40, 0x24, 0x06, 0x40, 0xE6, 0x36, 0x3E, 0x60, 0x08,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x13, 0xC3, 0xC6, 0x30,
  0x32, 0x01, 0x20, 0x12, 0x01, 0x20, 0x16, 0x01, 0x40, 0x14, 0x03, 0x40,
  0x24, 0x02, 0xC0, 0x2C, 0x04, 0xC0, 0xCB, 0x18, 0x9F, 0x00, 0x07, 0x81,
  0x86, 0x30, 0x22, 0x02, 0x40, 0x34, 0x03, 0x40, 0x0C, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x48, 0x04, 0x40, 0x86, 0x18, 0x3E, 0x00,
  0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x79,
  0x86, 0x14, 0x30, 0x30, 0x80, 0xC6, 0x01, 0x10, 0x04, 0x40, 0x31, 0x00,
  0x84, 0x02, 0x30, 0x08, 0x80, 0x22, 0x00, 0x88, 0x06, 0x30, 0x10, 0x40,
  0xC1, 0x85, 0x03, 0xE4, 0x00, 0x07, 0x81, 0x86, 0x30, 0x22, 0x02, 0x40,
  0x24, 0x02, 0x40, 0x2F, 0xFE, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x06, 0x18, 0x1E, 0x00, 0x07, 0x86, 0x02, 0x03, 0x01,
  0x00, 0x83, 0xF8, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x00, 0x03, 0xC8, 0x30,
  0xA1, 0x81, 0x84, 0x06, 0x30, 0x08, 0x80, 0x62, 0x01, 0x08, 0x04, 0x20,
  0x11, 0x80, 0x44, 0x01, 0x10, 0x0C, 0x40, 0x21, 0x80, 0x82, 0x06, 0x0C,
  0x28, 0x1F, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x80, 0x81, 0x86, 0x03,
  0xE0, 0x00, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x13,
  0xC3, 0x46, 0x28, 0x23, 0x03, 0x20, 0x32, 0x03, 0x20, 0x26, 0x02, 0x40,
  0x24, 0x02, 0x40, 0x24, 0x06, 0x40, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80,
  0x40, 0x08, 0xC0, 0x00, 0x00, 0x46, 0x21, 0x08, 0x42, 0x31, 0x08, 0x42,
  0x11, 0x88, 0x42, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02,
  0x00, 0x80, 0x40, 0xE0, 0x00, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x33, 0x06, 0x20, 0xC2, 0x18, 0x23, 0x02, 0x60, 0x2C,
  0x07, 0x80, 0x7C, 0x06, 0x40, 0x46, 0x04, 0x20, 0x43, 0x08, 0x10, 0x81,
  0x88, 0x08, 0x80, 0xC0, 0x08, 0x46, 0x21, 0x08, 0x42, 0x31, 0x08, 0x42,
  0x11, 0x88, 0x42, 0x10, 0x88, 0x42, 0x00, 0x33, 0xC1, 0xE2, 0xC6, 0x63,
  0x28, 0x28, 0x13, 0x03, 0x81, 0x20, 0x30, 0x12, 0x03, 0x01, 0x60, 0x20,
  0x14, 0x02, 0x01, 0x40, 0x20, 0x14, 0x02, 0x01, 0x40, 0x20, 0x34, 0x06,
  0x02, 0xC0, 0x40, 0x28, 0x04, 0x02, 0x80, 0x40, 0x28, 0x04, 0x02, 0x80,
  0x40, 0x60, 0x33, 0xC2, 0x46, 0x28, 0x23, 0x03, 0x20, 0x32, 0x03, 0x60,
  0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x06, 0xC0, 0x48, 0x04, 0x80,
  0x48, 0x04, 0x80, 0x40, 0x07, 0xC1, 0x86, 0x10, 0x22, 0x01, 0x60, 0x14,
  0x01, 0x40, 0x14, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x2C,
  0x04, 0x40, 0xC6, 0x18, 0x1E, 0x00, 0x19, 0xE0, 0xB1, 0x86, 0x06, 0x20,
  0x11, 0x00, 0x88, 0x04, 0xC0, 0x24, 0x01, 0x20, 0x09, 0x00, 0xC8, 0x04,
  0x40, 0x26, 0x01, 0x30, 0x11, 0x81, 0x8A, 0x18, 0x4F, 0x82, 0x00, 0x30,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x00, 0x07, 0x90, 0xC2, 0x8C,
  0x0C, 0x40, 0x66, 0x01, 0x20, 0x19, 0x00, 0x88, 0x04, 0x40, 0x26, 0x01,
  0x20, 0x09, 0x00, 0xC8, 0x04, 0x60, 0x21, 0x03, 0x0C, 0x28, 0x3E, 0x40,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x33, 0x96,
  0x0A, 0x06, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0C,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x0F, 0x83, 0x18, 0x81, 0x90, 0x16,
  0x02, 0x40, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x02, 0x00, 0x20, 0x05,
  0x01, 0x20, 0x22, 0x18, 0x3E, 0x00, 0x10, 0x41, 0x04, 0xFC, 0x82, 0x08,
  0x20, 0x86, 0x10, 0x41, 0x04, 0x30, 0x82, 0x08, 0x30, 0x70, 0x60, 0x28,
  0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0xF0, 0x14, 0x02, 0x80, 0x50, 0x0A,
  0x01, 0x40, 0x68, 0x09, 0x01, 0x20, 0x66, 0x34, 0x7C, 0x80, 0x80, 0x30,
  0x0A, 0x01, 0x60, 0x64, 0x08, 0x83, 0x10, 0x42, 0x08, 0x42, 0x08, 0x40,
  0x90, 0x12, 0x02, 0xC0, 0x50, 0x0A, 0x01, 0x80, 0x30, 0x00, 0xC0, 0xC0,
  0xD0, 0x30, 0x24, 0x0C, 0x09, 0x05, 0x04, 0x41, 0x41, 0x10, 0x90, 0xC4,
  0x24, 0x21, 0x19, 0x08, 0x44, 0x44, 0x11, 0x11, 0x04, 0x84, 0xC1, 0x20,
  0xA0, 0x50, 0x28, 0x14, 0x0C, 0x05, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20,
  0x00, 0x18, 0x08, 0x20, 0x60, 0xC1, 0x01, 0x08, 0x04, 0x60, 0x09, 0x00,
  0x28, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x48, 0x03, 0x20, 0x08, 0xC0,
  0x41, 0x03, 0x04, 0x08, 0x08, 0x40, 0x20, 0x10, 0x04, 0x40, 0x31, 0x80,
  0x82, 0x06, 0x08, 0x10, 0x20, 0xC0, 0x82, 0x02, 0x18, 0x08, 0x40, 0x31,
  0x00, 0x48, 0x01, 0x20, 0x05, 0x00, 0x14, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x0E, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00,
  0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x18, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x60, 0x20, 0x18, 0x04, 0x01, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x06, 0x03, 0x00,
  0x60, 0x08, 0x02, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x08, 0xC4, 0x21, 0x08, 0x46, 0x21,
  0x08, 0x42, 0x11, 0x88, 0x42, 0x10, 0x8C, 0x42, 0x10, 0x84, 0x00, 0x04,
  0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0,
  0x30, 0x08, 0x02, 0x00, 0x40, 0x18, 0x03, 0x03, 0x00, 0x80, 0x40, 0x10,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x40, 0x30, 0x18,
  0x08, 0x00, 0x3C, 0x05, 0x98, 0x14, 0x30, 0xA0, 0x66, 0x80, 0xF0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 22, 6, 1, -22 },
  { 15, 6, 6, 8, 3, -23 },
  { 20, 15, 22, 15, 1, -22 },
  { 62, 13, 28, 15, 1, -25 },
  { 108, 14, 22, 19, 3, -22 },
  { 147, 14, 22, 16, 1, -22 },
  { 186, 2, 6, 5, 3, -23 },
  { 188, 8, 32, 8, 2, -25 },
  { 220, 9, 32, 9, -2, -25 },
  { 256, 12, 12, 13, 2, -22 },
  { 274, 13, 16, 15, 1, -18 },
  { 300, 4, 7, 6, -1, -3 },
  { 304, 6, 1, 8, 1, -10 },
  { 305, 2, 2, 7, 1, -2 },
  { 306, 13, 24, 10, -1, -22 },
  { 345, 12, 22, 15, 2, -22 },
  { 378, 7, 22, 15, 4, -22 },
  { 398, 13, 22, 15, 1, -22 },
  { 434, 13, 22, 15, 1, -22 },
  { 470, 13, 22, 15, 1, -22 },
  { 506, 13, 22, 15, 2, -22 },
  { 542, 12, 22, 15, 1, -22 },
  { 575, 12, 22, 15, 3, -22 },
  { 608, 13, 22, 15, 1, -22 },
  { 644, 12, 22, 15, 2, -22 },
  { 677, 5, 16, 6, 0, -16 },
  { 687, 6, 20, 5, -1, -16 },
  { 702, 12, 12, 14, 1, -16 },
  { 720, 11, 7, 15, 2, -14 },
  { 730, 11, 12, 14, 1, -16 },
  { 747, 9, 22, 12, 3, -22 },
  { 772, 21, 28, 24, 1, -21 },
  { 846, 15, 22, 16, -1, -22 },
  { 888, 14, 22, 16, 1, -22 },
  { 927, 14, 22, 17, 2, -22 },
  { 966, 15, 22, 17, 1, -22 },
  { 1008, 15, 22, 15, 1, -22 },
  { 1050, 15, 22, 15, 1, -22 },
  { 1092, 15, 22, 18, 2, -22 },
  { 1134, 17, 22, 18, 1, -22 },
  { 1181, 5, 22, 7, 1, -22 },
  { 1195, 13, 22, 15, 1, -22 },
  { 1231, 16, 22, 17, 1, -22 },
  { 1275, 11, 22, 14, 1, -22 },
  { 1306, 21, 22, 22, 1, -22 },
  { 1364, 17, 22, 19, 1, -22 },
  { 1411, 15, 22, 18, 2, -22 },
  { 1453, 15, 22, 16, 1, -22 },
  { 1495, 15, 26, 18, 2, -22 },
  { 1544, 15, 22, 17, 1, -22 },
  { 1586, 15, 22, 16, 1, -22 },
  { 1628, 14, 22, 16, 3, -22 },
  { 1667, 15, 22, 17, 2, -22 },
  { 1709, 14, 22, 16, 3, -22 },
  { 1748, 22, 22, 23, 3, -22 },
  { 1809, 17, 22, 16, 0, -22 },
  { 1856, 14, 22, 16, 3, -22 },
  { 1895, 16, 22, 16, 0, -22 },
  { 1939, 9, 30, 6, 0, -25 },
  { 1973, 5, 24, 10, 3, -22 },
  { 1988, 9, 30, 6, -2, -25 },
  { 2022, 8, 11, 11, 2, -22 },
  { 2033, 11, 1, 11, -2, 0 },
  { 2035, 4, 4, 8, 4, -23 },
  { 2037, 12, 17, 14, 0, -17 },
  { 2063, 12, 23, 15, 1, -23 },
  { 2098, 12, 17, 14, 1, -17 },
  { 2124, 14, 23, 15, 1, -23 },
  { 2165, 12, 17, 14, 1, -17 },
  { 2191, 9, 23, 9, 2, -23 },
  { 2217, 14, 23, 15, 0, -17 },
  { 2258, 12, 23, 14, 1, -23 },
  { 2293, 5, 23, 6, 1, -23 },
  { 2308, 10, 29, 6, -4, -23 },
  { 2345, 12, 23, 13, 1, -23 },
  { 2380, 5, 23, 6, 1, -23 },
  { 2395, 20, 17, 23, 1, -17 },
  { 2438, 12, 17, 15, 1, -17 },
  { 2464, 12, 17, 15, 1, -17 },
  { 2490, 13, 23, 15, 0, -17 },
  { 2528, 13, 23, 15, 1, -17 },
  { 2566, 9, 17, 9, 1, -17 },
  { 2586, 11, 17, 13, 1, -17 },
  { 2610, 6, 21, 9, 2, -21 },
  { 2626, 11, 17, 15, 2, -17 },
  { 2650, 11, 17, 13, 2, -17 },
  { 2674, 18, 17, 20, 2, -17 },
  { 2713, 14, 17, 13, -1, -17 },
  { 2743, 14, 23, 13, -1, -17 },
  { 2784, 13, 17, 13, 0, -17 },
  { 2812, 10, 30, 9, 1, -24 },
  { 2850, 5, 26, 6, 1, -22 },
  { 2867, 10, 31, 9, -2, -24 },
  { 2906, 14, 5, 18, 2, -12 },
};

const GFXfont RobotoCondensed_ExtraLightItalic31pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic31pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic31pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC31PT7B_H_
