#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC14PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x80, 0x10, 0x74, 0x00, 0x02, 0x24, 0xF8, 0xA2, 0x45,
  0x0A, 0x2E, 0x50, 0x20, 0x11, 0xD3, 0x18, 0x30, 0x41, 0x8C, 0xB8, 0x80,
  0x61, 0x26, 0x54, 0xC7, 0x03, 0xCA, 0xA9, 0x12, 0x18, 0x18, 0x48, 0x91,
  0x43, 0x0A, 0x52, 0xC6, 0x88, 0xE8, 0xE0, 0x12, 0x44, 0x88, 0x88, 0x88,
  0x88, 0x84, 0x21, 0x11, 0x11, 0x11, 0x12, 0x22, 0x48, 0x25, 0x5C, 0xC9,
  0x00, 0x21, 0x09, 0xF2, 0x11, 0x00, 0xE0, 0x40, 0x80, 0x04, 0x10, 0x82,
  0x10, 0x42, 0x08, 0x41, 0x08, 0x00, 0x3A, 0x63, 0x18, 0xC6, 0x31, 0x97,
  0x00, 0x74, 0x94, 0x92, 0x48, 0x18, 0x94, 0x41, 0x08, 0x21, 0x08, 0x43,
  0xE0, 0x1C, 0x94, 0x41, 0x18, 0x20, 0x61, 0x89, 0xC0, 0x04, 0x31, 0x45,
  0x29, 0x2F, 0x82, 0x08, 0x20, 0x3D, 0x04, 0x10, 0x70, 0x20, 0x82, 0x89,
  0xC0, 0x32, 0x11, 0xE8, 0xC6, 0x31, 0x93, 0x00, 0x7C, 0x20, 0x84, 0x10,
  0x82, 0x10, 0x42, 0x00, 0x1C, 0x94, 0x51, 0x39, 0x28, 0x61, 0x89, 0xC0,
  0x32, 0x63, 0x18, 0xC5, 0xE2, 0x17, 0x00, 0x40, 0x08, 0x40, 0x0A, 0x80,
  0x1B, 0x20, 0x83, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x60, 0x40, 0xCC, 0xC0,
  0x79, 0x11, 0x24, 0x40, 0x00, 0x0F, 0x84, 0x12, 0x05, 0x19, 0x48, 0x54,
  0x99, 0x26, 0x49, 0x92, 0xA7, 0xE4, 0x01, 0x00, 0x3C, 0x00, 0x08, 0x61,
  0x89, 0x24, 0x97, 0xD1, 0x86, 0x10, 0x3C, 0x44, 0x8A, 0x15, 0xC8, 0x90,
  0xA2, 0x45, 0xF0, 0x3D, 0x18, 0x60, 0x82, 0x08, 0x21, 0x89, 0xC0, 0x3C,
  0x44, 0x8A, 0x14, 0x28, 0x50, 0xA1, 0x45, 0xF0, 0x3C, 0x40, 0x82, 0x07,
  0xC8, 0x10, 0x20, 0x40, 0xF8, 0x3C, 0x40, 0x82, 0x07, 0xC8, 0x10, 0x20,
  0x41, 0x00, 0x3C, 0x85, 0x0C, 0x08, 0x13, 0xA1, 0x42, 0x84, 0xF0, 0x21,
  0x21, 0x21, 0x41, 0x7E, 0x42, 0x42, 0x42, 0x42, 0x82, 0x55, 0xAA, 0xA0,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x62, 0x89, 0xC0, 0x21, 0x22, 0x24, 0x48,
  0x50, 0x70, 0x48, 0x48, 0x44, 0x84, 0x21, 0x08, 0x84, 0x21, 0x08, 0x43,
  0xC0, 0x20, 0x48, 0x32, 0x0D, 0x45, 0x51, 0x94, 0xA5, 0x29, 0x52, 0x48,
  0xA2, 0x20, 0x21, 0x21, 0x31, 0x51, 0x49, 0x4A, 0x4A, 0x46, 0x46, 0x82,
  0x3C, 0x8A, 0x0C, 0x18, 0x30, 0xA1, 0x42, 0x88, 0xE0, 0x3C, 0x44, 0x8A,
  0x14, 0x2F, 0x90, 0x20, 0x41, 0x00, 0x3C, 0x8A, 0x0C, 0x18, 0x30, 0xA1,
  0x42, 0x88, 0xE0, 0x40, 0x40, 0x3C, 0x44, 0x8A, 0x14, 0x2F, 0x92, 0x22,
  0x85, 0x08, 0x1C, 0x45, 0x0A, 0x03, 0x01, 0x81, 0x42, 0x84, 0xF0, 0x7C,
  0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x80, 0x42, 0x86, 0x0C, 0x28,
  0x50, 0xA1, 0x42, 0x88, 0xE0, 0x83, 0x0A, 0x12, 0x44, 0x89, 0x14, 0x28,
  0x20, 0x00, 0x84, 0x63, 0x18, 0xCA, 0x52, 0x94, 0xA5, 0x46, 0x51, 0x14,
  0x42, 0x10, 0x80, 0x42, 0x22, 0x24, 0x18, 0x10, 0x10, 0x28, 0x48, 0x44,
  0x84, 0x82, 0x89, 0x22, 0x45, 0x04, 0x08, 0x10, 0x20, 0x80, 0x1E, 0x04,
  0x10, 0x41, 0x02, 0x08, 0x20, 0x41, 0xF8, 0x22, 0x24, 0x44, 0x44, 0x48,
  0x88, 0xC0, 0xA5, 0x55, 0x54, 0x11, 0x11, 0x22, 0x22, 0x22, 0x24, 0xC0,
  0x22, 0x69, 0x80, 0xF8, 0xA0, 0x39, 0x10, 0x5D, 0x8A, 0x28, 0x9E, 0x20,
  0x84, 0x1E, 0x45, 0x14, 0x51, 0x86, 0x2F, 0x00, 0x39, 0x14, 0x60, 0x82,
  0x08, 0x9C, 0x04, 0x10, 0x9E, 0x8A, 0x28, 0xA2, 0x92, 0x4F, 0x00, 0x39,
  0x14, 0x7F, 0x82, 0x08, 0x1C, 0x34, 0x44, 0x48, 0x88, 0x88, 0x80, 0x39,
  0x14, 0x51, 0x86, 0x28, 0x9E, 0x08, 0x27, 0x00, 0x20, 0x84, 0x1E, 0x45,
  0x14, 0x51, 0x8A, 0x28, 0x80, 0x20, 0x24, 0x92, 0x52, 0x00, 0x08, 0x00,
  0x21, 0x08, 0x42, 0x11, 0x08, 0x42, 0x60, 0x20, 0x84, 0x11, 0x49, 0x46,
  0x18, 0x92, 0x48, 0x80, 0x24, 0xA4, 0x92, 0x52, 0x00, 0x7B, 0x91, 0x14,
  0x45, 0x11, 0x44, 0x62, 0x28, 0x8A, 0x22, 0x79, 0x14, 0x51, 0x46, 0x28,
  0xA2, 0x74, 0x63, 0x18, 0xC6, 0x5C, 0x39, 0x14, 0x51, 0x46, 0x18, 0xBC,
  0x82, 0x08, 0x00, 0x74, 0x63, 0x18, 0xCA, 0x5E, 0x10, 0x84, 0x74, 0x44,
  0x48, 0x88, 0x3A, 0x50, 0x41, 0x06, 0x2E, 0x49, 0x49, 0x24, 0xC0, 0x8C,
  0x63, 0x18, 0xCA, 0x5E, 0x8C, 0x65, 0x2A, 0x51, 0x08, 0x81, 0x91, 0x92,
  0xAA, 0xAC, 0xCC, 0xC8, 0x08, 0x45, 0x23, 0x08, 0x21, 0x45, 0x22, 0x22,
  0x44, 0x91, 0x22, 0x85, 0x04, 0x08, 0x20, 0x43, 0x00, 0x7C, 0x21, 0x04,
  0x21, 0x04, 0x3E, 0x08, 0x88, 0x42, 0x13, 0x08, 0x42, 0x10, 0x84, 0x10,
  0x25, 0x24, 0x92, 0x52, 0x40, 0x20, 0x84, 0x21, 0x08, 0x62, 0x21, 0x08,
  0x44, 0x40, 0x62, 0x70,
};

const GFXglyph RobotoCondensed_ExtraLightItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 10, 3, 0, -10 },
  { 5, 3, 3, 4, 1, -11 },
  { 7, 7, 10, 7, 0, -10 },
  { 16, 5, 12, 7, 1, -11 },
  { 24, 7, 10, 9, 1, -10 },
  { 33, 7, 10, 7, 0, -10 },
  { 42, 1, 3, 2, 1, -11 },
  { 43, 4, 14, 4, 1, -11 },
  { 50, 4, 14, 4, -1, -11 },
  { 57, 5, 5, 6, 1, -10 },
  { 61, 5, 7, 7, 1, -8 },
  { 66, 1, 3, 3, 0, -1 },
  { 67, 3, 1, 4, 0, -5 },
  { 68, 1, 1, 3, 0, -1 },
  { 69, 6, 11, 5, -1, -10 },
  { 78, 5, 10, 7, 1, -10 },
  { 85, 3, 10, 7, 2, -10 },
  { 89, 6, 10, 7, 0, -10 },
  { 97, 6, 10, 7, 0, -10 },
  { 105, 6, 10, 7, 0, -10 },
  { 113, 6, 10, 7, 1, -10 },
  { 121, 5, 10, 7, 1, -10 },
  { 128, 6, 10, 7, 1, -10 },
  { 136, 6, 10, 7, 0, -10 },
  { 144, 5, 10, 7, 1, -10 },
  { 151, 2, 7, 3, 0, -7 },
  { 153, 2, 9, 2, 0, -7 },
  { 156, 5, 5, 6, 1, -7 },
  { 160, 5, 5, 7, 1, -7 },
  { 164, 6, 5, 6, 0, -7 },
  { 168, 4, 10, 5, 1, -10 },
  { 173, 10, 13, 11, 0, -10 },
  { 190, 6, 10, 7, 0, -10 },
  { 198, 7, 10, 7, 0, -10 },
  { 207, 6, 10, 8, 1, -10 },
  { 215, 7, 10, 8, 0, -10 },
  { 224, 7, 10, 7, 0, -10 },
  { 233, 7, 10, 7, 0, -10 },
  { 242, 7, 10, 8, 1, -10 },
  { 251, 8, 10, 8, 0, -10 },
  { 261, 2, 10, 3, 1, -10 },
  { 264, 6, 10, 7, 0, -10 },
  { 272, 8, 10, 8, 0, -10 },
  { 282, 5, 10, 6, 0, -10 },
  { 289, 10, 10, 10, 0, -10 },
  { 302, 8, 10, 8, 0, -10 },
  { 312, 7, 10, 8, 1, -10 },
  { 321, 7, 10, 7, 0, -10 },
  { 330, 7, 12, 8, 1, -10 },
  { 341, 7, 10, 8, 0, -10 },
  { 350, 7, 10, 7, 0, -10 },
  { 359, 7, 10, 7, 1, -10 },
  { 368, 7, 10, 8, 1, -10 },
  { 377, 7, 10, 7, 1, -10 },
  { 386, 10, 10, 11, 1, -10 },
  { 399, 8, 10, 7, 0, -10 },
  { 409, 7, 10, 7, 1, -10 },
  { 418, 7, 10, 7, 0, -10 },
  { 427, 4, 13, 3, 0, -11 },
  { 434, 2, 11, 5, 1, -10 },
  { 437, 4, 13, 3, -1, -11 },
  { 444, 4, 5, 5, 1, -10 },
  { 447, 5, 1, 5, -1, 0 },
  { 448, 2, 2, 4, 2, -11 },
  { 449, 6, 8, 6, 0, -8 },
  { 455, 6, 11, 7, 0, -11 },
  { 464, 6, 8, 6, 0, -8 },
  { 470, 6, 11, 7, 1, -11 },
  { 479, 6, 8, 6, 0, -8 },
  { 485, 4, 11, 4, 1, -11 },
  { 491, 6, 11, 7, 0, -8 },
  { 500, 6, 11, 7, 0, -11 },
  { 509, 3, 11, 3, 0, -11 },
  { 514, 5, 14, 3, -2, -11 },
  { 523, 6, 11, 6, 0, -11 },
  { 532, 3, 11, 3, 0, -11 },
  { 537, 10, 8, 10, 0, -8 },
  { 547, 6, 8, 7, 0, -8 },
  { 553, 5, 8, 7, 1, -8 },
  { 558, 6, 11, 7, 0, -8 },
  { 567, 5, 11, 7, 1, -8 },
  { 574, 4, 8, 4, 0, -8 },
  { 578, 5, 8, 6, 0, -8 },
  { 583, 3, 9, 4, 1, -9 },
  { 587, 5, 8, 7, 1, -8 },
  { 592, 5, 8, 6, 1, -8 },
  { 597, 8, 8, 9, 1, -8 },
  { 605, 6, 8, 6, 0, -8 },
  { 611, 7, 11, 6, -1, -8 },
  { 621, 6, 8, 6, 0, -8 },
  { 627, 5, 14, 4, 0, -11 },
  { 636, 3, 12, 3, 0, -10 },
  { 641, 5, 14, 4, -1, -11 },
  { 650, 6, 2, 8, 1, -5 },
};

const GFXfont RobotoCondensed_ExtraLightItalic14pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic14pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic14pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC14PT7B_H_
