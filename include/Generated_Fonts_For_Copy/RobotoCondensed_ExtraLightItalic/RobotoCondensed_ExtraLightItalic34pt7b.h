#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC34PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x31, 0x88, 0x42, 0x11, 0x88, 0x42, 0x10, 0x8C, 0x40,
  0x00, 0x00, 0x03, 0x18, 0x49, 0x2C, 0xA2, 0x8A, 0x69, 0x00, 0x00, 0x43,
  0x00, 0x61, 0x00, 0x20, 0x80, 0x10, 0xC0, 0x18, 0x40, 0x08, 0x20, 0x04,
  0x30, 0x7F, 0xFF, 0x02, 0x08, 0x01, 0x0C, 0x01, 0x84, 0x00, 0x82, 0x00,
  0x43, 0x00, 0x61, 0x00, 0x20, 0x80, 0x10, 0xC0, 0xFF, 0xFC, 0x08, 0x20,
  0x04, 0x10, 0x02, 0x10, 0x02, 0x08, 0x01, 0x04, 0x00, 0x84, 0x00, 0x82,
  0x00, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x7C, 0x07, 0x18, 0x30, 0x30,
  0x80, 0x46, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0xC0, 0x1B, 0x00, 0x4C, 0x01, 0x10, 0x0C, 0x60, 0x60, 0xC3, 0x01, 0xF0,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x1E, 0x00, 0x32, 0x00, 0x61, 0x00,
  0x41, 0x02, 0xC1, 0x04, 0x81, 0x08, 0x81, 0x18, 0x83, 0x10, 0xC2, 0x20,
  0x44, 0x40, 0x38, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0x1C, 0x02, 0x22,
  0x04, 0x41, 0x08, 0x41, 0x18, 0x81, 0x10, 0x81, 0x20, 0x83, 0x60, 0x82,
  0x00, 0x82, 0x00, 0x44, 0x00, 0x78, 0x01, 0xE0, 0x06, 0x60, 0x10, 0x40,
  0x60, 0xC0, 0x81, 0x81, 0x02, 0x02, 0x0C, 0x04, 0x10, 0x0C, 0xC0, 0x0B,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xB0, 0x02, 0x20, 0x48, 0x20, 0xA0, 0x63,
  0x40, 0x45, 0x80, 0xDA, 0x00, 0xA6, 0x01, 0xCC, 0x03, 0x08, 0x0F, 0x1C,
  0x72, 0x0F, 0x82, 0x2D, 0x24, 0xB0, 0x00, 0x80, 0x80, 0x80, 0xC0, 0x40,
  0x40, 0x20, 0x20, 0x10, 0x18, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x00, 0x04, 0x01,
  0x00, 0xC0, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04,
  0x06, 0x02, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x60, 0x20, 0x20,
  0x20, 0x00, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x0C, 0x21, 0xB9, 0x38,
  0x7E, 0x00, 0xC0, 0x0F, 0x00, 0xC8, 0x0C, 0x60, 0xC1, 0x84, 0x04, 0x00,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x7F, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x33, 0x22, 0x64, 0x80, 0xFE, 0xF0,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x03, 0xE0,
  0x71, 0x86, 0x04, 0x20, 0x33, 0x00, 0x90, 0x05, 0x80, 0x28, 0x01, 0x40,
  0x0A, 0x00, 0x50, 0x07, 0x80, 0x3C, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x06,
  0x80, 0x34, 0x01, 0x20, 0x09, 0x00, 0x88, 0x0C, 0x60, 0x41, 0x8C, 0x07,
  0xC0, 0x06, 0x3D, 0xDC, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x40,
  0x83, 0x04, 0x08, 0x10, 0x20, 0x41, 0x82, 0x04, 0x08, 0x10, 0x03, 0xE0,
  0x18, 0xE0, 0xC0, 0x86, 0x03, 0x10, 0x0C, 0xC0, 0x32, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x3F, 0xFC, 0x01, 0xE0, 0x18, 0x60, 0xC0, 0x86, 0x03, 0x10,
  0x04, 0x40, 0x13, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x06, 0x01,
  0xF0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x1A, 0x00, 0x48,
  0x01, 0x30, 0x04, 0x40, 0x21, 0x81, 0x83, 0x0C, 0x07, 0xC0, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x80, 0x0A, 0x00, 0x58, 0x02, 0x60, 0x19, 0x00, 0x44,
  0x02, 0x10, 0x18, 0x40, 0x43, 0x02, 0x08, 0x18, 0x20, 0xC0, 0x82, 0x02,
  0x18, 0x18, 0xC0, 0x63, 0xFF, 0xF0, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x0F, 0xFC, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x9E, 0x03, 0x8E, 0x08,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x12, 0x00, 0x48,
  0x03, 0x30, 0x08, 0x40, 0x61, 0x01, 0x03, 0x18, 0x07, 0xC0, 0x00, 0xF0,
  0x38, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x02, 0x00, 0x67, 0x85,
  0x8E, 0x70, 0x2E, 0x03, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x80, 0x28, 0x02, 0xC0, 0x44, 0x0C, 0x71, 0x81, 0xE0, 0xFF, 0xF8,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x01, 0xF0, 0x18, 0x60, 0xC0, 0xC2, 0x01, 0x10, 0x04, 0x40, 0x11,
  0x00, 0x44, 0x03, 0x10, 0x08, 0x60, 0x60, 0xC7, 0x01, 0xF0, 0x18, 0x60,
  0x80, 0xC6, 0x01, 0x10, 0x06, 0xC0, 0x0A, 0x00, 0x68, 0x01, 0x20, 0x04,
  0xC0, 0x31, 0x01, 0x87, 0x1C, 0x07, 0xC0, 0x07, 0xC0, 0x63, 0x06, 0x0C,
  0x60, 0x22, 0x01, 0xB0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0E, 0x00, 0xD0,
  0x06, 0x80, 0x24, 0x03, 0x30, 0x28, 0xC6, 0xC3, 0xE4, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x0F, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x30, 0x82, 0x18, 0xC2, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x01, 0x80, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x10, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x20, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x00, 0x40, 0x00, 0x0F, 0x0C, 0x66, 0x0D, 0x01, 0xC0, 0x60, 0x10,
  0x04, 0x03, 0x00, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x70, 0x30, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x04, 0x02, 0x00,
  0x06, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x02, 0x08, 0x0F, 0x02, 0x10, 0x31,
  0x82, 0x10, 0x60, 0x83, 0x20, 0x40, 0x83, 0x20, 0x80, 0x82, 0x60, 0x81,
  0x02, 0x41, 0x81, 0x02, 0x41, 0x01, 0x02, 0x41, 0x01, 0x02, 0xC3, 0x02,
  0x06, 0x82, 0x02, 0x04, 0x82, 0x06, 0x04, 0x82, 0x06, 0x08, 0x83, 0x0A,
  0x18, 0x81, 0x13, 0x30, 0x81, 0xE1, 0xE0, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x28, 0x00, 0x6C, 0x00, 0x44, 0x00, 0xC4, 0x00, 0x84, 0x00,
  0x84, 0x01, 0x04, 0x01, 0x04, 0x02, 0x04, 0x02, 0x06, 0x04, 0x02, 0x04,
  0x02, 0x08, 0x02, 0x0F, 0xFE, 0x10, 0x02, 0x10, 0x02, 0x30, 0x03, 0x20,
  0x03, 0x60, 0x01, 0x40, 0x01, 0xC0, 0x01, 0x0F, 0xF8, 0x08, 0x0C, 0x08,
  0x06, 0x08, 0x02, 0x08, 0x02, 0x18, 0x02, 0x18, 0x02, 0x10, 0x02, 0x10,
  0x06, 0x10, 0x0C, 0x10, 0x38, 0x3F, 0xF0, 0x20, 0x18, 0x20, 0x0C, 0x20,
  0x04, 0x20, 0x04, 0x60, 0x04, 0x60, 0x04, 0x40, 0x04, 0x40, 0x0C, 0x40,
  0x08, 0x40, 0x10, 0xC0, 0x60, 0xFF, 0xC0, 0x01, 0xF8, 0x07, 0x0C, 0x0C,
  0x06, 0x18, 0x02, 0x10, 0x03, 0x30, 0x03, 0x20, 0x01, 0x60, 0x01, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0xC0, 0x08, 0x40,
  0x10, 0x60, 0x30, 0x30, 0xE0, 0x1F, 0x80, 0x0F, 0xF0, 0x04, 0x06, 0x02,
  0x01, 0x81, 0x00, 0x60, 0x80, 0x10, 0xC0, 0x08, 0x60, 0x06, 0x20, 0x03,
  0x10, 0x01, 0x88, 0x00, 0x84, 0x00, 0x46, 0x00, 0x22, 0x00, 0x11, 0x00,
  0x08, 0x80, 0x0C, 0x40, 0x04, 0x60, 0x02, 0x30, 0x03, 0x10, 0x01, 0x08,
  0x01, 0x84, 0x01, 0x82, 0x01, 0x83, 0x03, 0x81, 0xFF, 0x00, 0x0F, 0xFF,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x07, 0xFF, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x84, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x07, 0xFF, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xF8, 0x03, 0x0E, 0x0C, 0x02, 0x08, 0x03,
  0x10, 0x01, 0x30, 0x01, 0x20, 0x01, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0xFE, 0xC0, 0x02, 0xC0, 0x02,
  0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x04, 0x40, 0x04, 0x40, 0x04, 0x20, 0x18,
  0x38, 0x70, 0x0F, 0xC0, 0x0C, 0x00, 0x61, 0x00, 0x0C, 0x20, 0x01, 0x04,
  0x00, 0x20, 0x80, 0x04, 0x30, 0x00, 0x86, 0x00, 0x30, 0x80, 0x06, 0x10,
  0x00, 0x82, 0x00, 0x10, 0x40, 0x02, 0x1F, 0xFF, 0xC2, 0x00, 0x18, 0x40,
  0x02, 0x08, 0x00, 0x41, 0x00, 0x08, 0x60, 0x01, 0x0C, 0x00, 0x61, 0x00,
  0x0C, 0x20, 0x01, 0x04, 0x00, 0x20, 0x80, 0x04, 0x30, 0x00, 0x86, 0x00,
  0x30, 0x08, 0x46, 0x21, 0x08, 0x46, 0x31, 0x08, 0x42, 0x31, 0x88, 0x42,
  0x11, 0x8C, 0x42, 0x10, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x31,
  0x00, 0x42, 0x00, 0x84, 0x03, 0x08, 0x04, 0x18, 0x18, 0x18, 0x60, 0x1F,
  0x00, 0x0C, 0x00, 0xC2, 0x00, 0x60, 0x80, 0x30, 0x20, 0x18, 0x08, 0x0C,
  0x06, 0x06, 0x01, 0x83, 0x00, 0x41, 0x80, 0x10, 0xC0, 0x04, 0x60, 0x01,
  0x30, 0x00, 0xDC, 0x00, 0x2D, 0x00, 0x0E, 0x20, 0x03, 0x0C, 0x00, 0x81,
  0x00, 0x60, 0x60, 0x18, 0x08, 0x04, 0x03, 0x01, 0x00, 0x40, 0x40, 0x18,
  0x10, 0x02, 0x0C, 0x00, 0xC3, 0x00, 0x10, 0x0C, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x0F, 0xFF, 0x0C, 0x00, 0x06, 0x18, 0x00,
  0x0C, 0x38, 0x00, 0x28, 0x70, 0x00, 0x70, 0xA0, 0x01, 0x43, 0x40, 0x02,
  0x84, 0x80, 0x09, 0x09, 0x00, 0x32, 0x13, 0x00, 0x4C, 0x22, 0x01, 0x98,
  0x44, 0x02, 0x21, 0x88, 0x0C, 0x42, 0x10, 0x10, 0x84, 0x20, 0x61, 0x08,
  0x60, 0x86, 0x10, 0x43, 0x0C, 0x60, 0x84, 0x10, 0xC1, 0x18, 0x21, 0x02,
  0x20, 0x42, 0x04, 0xC0, 0x84, 0x05, 0x03, 0x08, 0x0C, 0x04, 0x30, 0x18,
  0x08, 0x60, 0x20, 0x10, 0x0C, 0x00, 0x21, 0x80, 0x0C, 0x38, 0x01, 0x85,
  0x00, 0x20, 0xA0, 0x04, 0x36, 0x00, 0x86, 0x40, 0x10, 0x8C, 0x06, 0x10,
  0x80, 0x82, 0x10, 0x10, 0x43, 0x02, 0x18, 0x20, 0x43, 0x04, 0x18, 0x40,
  0x43, 0x08, 0x08, 0x41, 0x01, 0x88, 0x60, 0x11, 0x0C, 0x02, 0x21, 0x00,
  0x6C, 0x20, 0x05, 0x84, 0x00, 0xA0, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00,
  0x30, 0x01, 0xF8, 0x07, 0x0C, 0x0C, 0x06, 0x18, 0x03, 0x10, 0x01, 0x30,
  0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40,
  0x03, 0xC0, 0x02, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80,
  0x04, 0x80, 0x04, 0xC0, 0x08, 0x40, 0x18, 0x60, 0x30, 0x30, 0xE0, 0x1F,
  0x80, 0x0F, 0xF8, 0x08, 0x0E, 0x08, 0x02, 0x08, 0x01, 0x08, 0x01, 0x18,
  0x01, 0x18, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x03, 0x10, 0x06, 0x30,
  0x0C, 0x20, 0x38, 0x3F, 0xF0, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x01, 0xF8, 0x07, 0x0C, 0x0C, 0x06, 0x18, 0x02, 0x10, 0x01, 0x30,
  0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x03, 0x40,
  0x03, 0xC0, 0x02, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80,
  0x04, 0x80, 0x04, 0xC0, 0x08, 0x40, 0x18, 0x60, 0x30, 0x30, 0xE0, 0x1F,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x0F, 0xF8, 0x08,
  0x0E, 0x08, 0x02, 0x08, 0x03, 0x08, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10,
  0x01, 0x10, 0x03, 0x10, 0x02, 0x30, 0x06, 0x30, 0x0C, 0x20, 0x18, 0x3F,
  0xE0, 0x20, 0x20, 0x20, 0x20, 0x60, 0x30, 0x60, 0x10, 0x40, 0x10, 0x40,
  0x18, 0x40, 0x08, 0x40, 0x08, 0xC0, 0x0C, 0xC0, 0x04, 0x01, 0xF8, 0x07,
  0x0C, 0x0C, 0x06, 0x18, 0x02, 0x10, 0x03, 0x10, 0x01, 0x10, 0x01, 0x10,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x0C, 0xC0, 0x08, 0x60, 0x30, 0x38, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x88,
  0x00, 0xC4, 0x00, 0x42, 0x00, 0x23, 0x00, 0x11, 0x00, 0x08, 0x80, 0x0C,
  0x40, 0x06, 0x20, 0x02, 0x30, 0x01, 0x18, 0x00, 0x88, 0x00, 0x44, 0x00,
  0x62, 0x00, 0x31, 0x00, 0x11, 0x80, 0x08, 0xC0, 0x04, 0x40, 0x02, 0x20,
  0x03, 0x18, 0x01, 0x0C, 0x01, 0x83, 0x01, 0x80, 0xC3, 0x80, 0x3F, 0x00,
  0x80, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x04, 0x40, 0x04, 0x40, 0x0C,
  0x40, 0x08, 0x40, 0x18, 0x60, 0x10, 0x60, 0x30, 0x20, 0x20, 0x20, 0x60,
  0x20, 0x40, 0x20, 0xC0, 0x20, 0x80, 0x30, 0x80, 0x31, 0x00, 0x11, 0x00,
  0x12, 0x00, 0x12, 0x00, 0x16, 0x00, 0x14, 0x00, 0x1C, 0x00, 0x08, 0x00,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x02, 0xC0, 0x18, 0x02, 0x40, 0x28, 0x06,
  0x40, 0x28, 0x04, 0x40, 0x48, 0x04, 0x40, 0x48, 0x08, 0x40, 0xC8, 0x08,
  0x40, 0x88, 0x18, 0x40, 0x8C, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x30,
  0x43, 0x04, 0x20, 0x42, 0x04, 0x20, 0x62, 0x04, 0x40, 0x64, 0x04, 0x40,
  0x64, 0x04, 0xC0, 0x6C, 0x04, 0x80, 0x68, 0x04, 0x80, 0x28, 0x05, 0x80,
  0x30, 0x05, 0x00, 0x30, 0x07, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x04, 0x00, 0x20, 0xC0, 0x08, 0x08, 0x03, 0x01, 0x00, 0xC0, 0x30, 0x10,
  0x02, 0x06, 0x00, 0x61, 0x80, 0x04, 0x20, 0x00, 0x88, 0x00, 0x1B, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x64, 0x00,
  0x08, 0x80, 0x02, 0x18, 0x00, 0xC1, 0x00, 0x30, 0x30, 0x04, 0x02, 0x01,
  0x80, 0x40, 0x60, 0x0C, 0x08, 0x00, 0x82, 0x00, 0x18, 0xC0, 0x03, 0x40,
  0x02, 0x40, 0x04, 0x60, 0x0C, 0x20, 0x08, 0x20, 0x10, 0x30, 0x30, 0x10,
  0x20, 0x10, 0x40, 0x10, 0xC0, 0x18, 0x80, 0x09, 0x00, 0x0B, 0x00, 0x0E,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0xFF, 0xF0, 0x07, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0xF8, 0x00, 0x42, 0x10, 0x84,
  0x31, 0x84, 0x21, 0x08, 0x43, 0x18, 0x42, 0x10, 0x84, 0x31, 0x84, 0x21,
  0x08, 0x40, 0x07, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0x40, 0x20, 0xF0, 0x00, 0x02, 0x03, 0x01, 0x81, 0x60, 0x90, 0x88, 0x44,
  0x42, 0x21, 0x20, 0xD0, 0x30, 0x10, 0xFF, 0xF0, 0x46, 0x23, 0x10, 0x07,
  0xC0, 0x63, 0x84, 0x04, 0x40, 0x22, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x0F, 0xF1, 0xC1, 0x98, 0x09, 0x80, 0x48, 0x02, 0x40, 0x12, 0x01, 0x90,
  0x1C, 0xE3, 0x61, 0xE3, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x13, 0xE0, 0xB1, 0x8E, 0x06, 0x60,
  0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x60, 0x0A, 0x00, 0x50, 0x06,
  0x80, 0x24, 0x01, 0x20, 0x0B, 0x00, 0x94, 0x0C, 0xB0, 0xC4, 0x7C, 0x00,
  0x07, 0xC0, 0x61, 0x84, 0x04, 0x40, 0x32, 0x01, 0xA0, 0x0D, 0x00, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x02, 0x40, 0x13, 0x01,
  0x88, 0x08, 0x71, 0x80, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x07, 0xCC, 0x18,
  0xD8, 0x60, 0x61, 0x80, 0xC2, 0x00, 0x8C, 0x01, 0x10, 0x06, 0x20, 0x0C,
  0x40, 0x10, 0x80, 0x23, 0x00, 0x46, 0x00, 0x8C, 0x03, 0x18, 0x06, 0x10,
  0x08, 0x20, 0x30, 0x71, 0xA0, 0x3C, 0x40, 0x07, 0xC0, 0x63, 0x84, 0x04,
  0x60, 0x22, 0x01, 0xA0, 0x0D, 0x00, 0x68, 0x03, 0xFF, 0xF6, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x08, 0x31, 0xC0, 0xF8,
  0x00, 0x03, 0xC1, 0x80, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0xFF,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x00, 0x03, 0xE2,
  0x0C, 0x6C, 0x20, 0x30, 0xC0, 0x61, 0x00, 0x46, 0x00, 0x88, 0x03, 0x10,
  0x06, 0x20, 0x08, 0x40, 0x11, 0x80, 0x23, 0x00, 0x46, 0x01, 0x8C, 0x03,
  0x08, 0x04, 0x10, 0x18, 0x38, 0xD0, 0x1E, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x30, 0x10, 0x30, 0xC0, 0x1F, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x11, 0xE0,
  0xB1, 0x8F, 0x06, 0x70, 0x33, 0x00, 0x98, 0x04, 0x80, 0x64, 0x03, 0x60,
  0x13, 0x00, 0x90, 0x04, 0x80, 0x24, 0x03, 0x20, 0x1B, 0x00, 0x98, 0x04,
  0x80, 0x24, 0x01, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x01, 0x04, 0x10, 0xC3,
  0x08, 0x20, 0x82, 0x18, 0x61, 0x04, 0x10, 0x43, 0x0C, 0x20, 0x00, 0x60,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30,
  0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x60, 0x38, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x18, 0x40, 0xC3, 0x06,
  0x0C, 0x30, 0x21, 0x80, 0x8C, 0x02, 0x60, 0x0B, 0x00, 0x7C, 0x01, 0xD8,
  0x06, 0x20, 0x10, 0xC0, 0x41, 0x01, 0x06, 0x0C, 0x08, 0x20, 0x30, 0x80,
  0x42, 0x01, 0x80, 0x0C, 0x20, 0x82, 0x08, 0x61, 0x84, 0x10, 0x41, 0x0C,
  0x30, 0x82, 0x08, 0x21, 0x86, 0x10, 0x41, 0x04, 0x30, 0xC2, 0x00, 0x11,
  0xE0, 0xF8, 0x6C, 0x63, 0x18, 0xE0, 0x48, 0x11, 0x40, 0xE0, 0x23, 0x00,
  0xC0, 0x64, 0x03, 0x00, 0xC8, 0x06, 0x01, 0x30, 0x08, 0x02, 0x60, 0x10,
  0x04, 0x80, 0x20, 0x09, 0x00, 0x40, 0x32, 0x00, 0x80, 0x64, 0x03, 0x00,
  0x98, 0x04, 0x01, 0x30, 0x08, 0x02, 0x40, 0x10, 0x04, 0x80, 0x20, 0x19,
  0x00, 0x40, 0x30, 0x11, 0xE0, 0xB1, 0x8F, 0x06, 0x70, 0x33, 0x00, 0x98,
  0x04, 0x80, 0x64, 0x03, 0x60, 0x13, 0x00, 0x90, 0x04, 0x80, 0x24, 0x03,
  0x20, 0x1B, 0x00, 0x98, 0x04, 0x80, 0x24, 0x01, 0x00, 0x03, 0xE0, 0x61,
  0x86, 0x06, 0x60, 0x12, 0x00, 0xB0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0A,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0x60, 0x19, 0x00, 0x8C, 0x0C, 0x31,
  0xC0, 0xF8, 0x00, 0x09, 0xF0, 0x2C, 0x61, 0xC0, 0xC6, 0x01, 0x10, 0x04,
  0x40, 0x11, 0x00, 0x44, 0x01, 0x30, 0x04, 0xC0, 0x12, 0x00, 0xC8, 0x02,
  0x20, 0x08, 0x80, 0x26, 0x01, 0x14, 0x0C, 0x58, 0x61, 0x1E, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x07,
  0xC4, 0x31, 0xB1, 0x01, 0x8C, 0x02, 0x20, 0x09, 0x80, 0x24, 0x01, 0x90,
  0x06, 0x40, 0x11, 0x00, 0x4C, 0x01, 0x30, 0x04, 0xC0, 0x33, 0x00, 0xC4,
  0x02, 0x10, 0x18, 0x61, 0xA0, 0x78, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x13, 0xC5, 0x83, 0x80, 0xC0,
  0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x0C, 0x03, 0x00, 0x80, 0x20, 0x00, 0x07, 0xC1, 0xC6, 0x30, 0x32, 0x01,
  0x20, 0x12, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x68, 0x06, 0x80, 0x4C, 0x0C, 0x63, 0x83, 0xE0, 0x08, 0x30, 0x40,
  0x81, 0x1F, 0xCC, 0x18, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x40,
  0x83, 0x06, 0x0C, 0x08, 0x1E, 0x00, 0x20, 0x19, 0x00, 0xD8, 0x04, 0x80,
  0x24, 0x01, 0x20, 0x09, 0x00, 0xC8, 0x06, 0xC0, 0x24, 0x01, 0x20, 0x09,
  0x00, 0x48, 0x06, 0x40, 0x22, 0x03, 0x18, 0x38, 0x63, 0x41, 0xE2, 0x00,
  0x80, 0x1C, 0x03, 0xC0, 0x24, 0x06, 0x40, 0x44, 0x04, 0x40, 0x86, 0x08,
  0x61, 0x02, 0x10, 0x23, 0x02, 0x20, 0x26, 0x02, 0x40, 0x3C, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x80, 0xC0, 0x70, 0x18, 0x0A, 0x07, 0x03, 0x40, 0xA0,
  0x48, 0x14, 0x19, 0x04, 0x82, 0x20, 0x90, 0x44, 0x32, 0x18, 0x84, 0x42,
  0x19, 0x8C, 0xC3, 0x21, 0x90, 0x64, 0x12, 0x05, 0x02, 0xC0, 0xA0, 0x50,
  0x18, 0x0A, 0x03, 0x01, 0x80, 0x60, 0x30, 0x08, 0x06, 0x00, 0x08, 0x06,
  0x18, 0x18, 0x10, 0x20, 0x20, 0xC0, 0x63, 0x00, 0x44, 0x00, 0xD0, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x0A, 0x00, 0x36, 0x00, 0xC4, 0x01, 0x0C,
  0x04, 0x08, 0x18, 0x10, 0x60, 0x30, 0x80, 0x20, 0x18, 0x02, 0x18, 0x06,
  0x08, 0x04, 0x08, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x0C, 0x10,
  0x0C, 0x30, 0x04, 0x20, 0x04, 0x60, 0x04, 0x40, 0x04, 0xC0, 0x04, 0x80,
  0x07, 0x80, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x80, 0x60, 0x18, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x08, 0x42, 0x11, 0x88, 0x42, 0x10, 0x8C,
  0x62, 0x10, 0x84, 0x63, 0x10, 0x84, 0x23, 0x18, 0x84, 0x21, 0x00, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0xC0, 0x18,
  0x06, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30,
  0x06, 0x00, 0x80, 0x10, 0x04, 0x01, 0x80, 0x60, 0x10, 0x00, 0x1C, 0x01,
  0x22, 0x02, 0x41, 0x02, 0x40, 0x86, 0x80, 0xCC, 0x80, 0x78,
};

const GFXglyph RobotoCondensed_ExtraLightItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 24, 7, 1, -24 },
  { 16, 6, 7, 9, 4, -26 },
  { 22, 17, 24, 16, 1, -24 },
  { 73, 14, 30, 16, 1, -27 },
  { 126, 16, 24, 21, 3, -24 },
  { 174, 15, 24, 18, 1, -24 },
  { 219, 3, 7, 6, 3, -26 },
  { 222, 9, 35, 9, 2, -27 },
  { 262, 9, 35, 9, -2, -27 },
  { 302, 13, 13, 14, 2, -24 },
  { 324, 14, 17, 16, 1, -20 },
  { 354, 4, 7, 6, -1, -3 },
  { 358, 7, 1, 9, 1, -11 },
  { 359, 2, 2, 7, 1, -2 },
  { 360, 14, 26, 11, -1, -24 },
  { 406, 13, 24, 16, 2, -24 },
  { 445, 7, 24, 16, 5, -24 },
  { 466, 14, 24, 16, 1, -24 },
  { 508, 14, 24, 16, 1, -24 },
  { 550, 14, 24, 16, 1, -24 },
  { 592, 14, 24, 16, 2, -24 },
  { 634, 12, 24, 16, 2, -24 },
  { 670, 13, 24, 16, 3, -24 },
  { 709, 14, 24, 16, 1, -24 },
  { 751, 13, 24, 16, 2, -24 },
  { 790, 6, 18, 6, 0, -18 },
  { 804, 6, 22, 6, -1, -18 },
  { 821, 13, 14, 15, 1, -18 },
  { 844, 13, 8, 16, 2, -15 },
  { 857, 13, 14, 15, 1, -18 },
  { 880, 10, 24, 13, 3, -24 },
  { 910, 24, 31, 26, 1, -23 },
  { 1003, 16, 24, 18, -1, -24 },
  { 1051, 16, 24, 18, 1, -24 },
  { 1099, 16, 24, 19, 2, -24 },
  { 1147, 17, 24, 19, 1, -24 },
  { 1198, 17, 24, 16, 1, -24 },
  { 1249, 17, 24, 16, 1, -24 },
  { 1300, 16, 24, 20, 2, -24 },
  { 1348, 19, 24, 20, 1, -24 },
  { 1405, 5, 24, 8, 2, -24 },
  { 1420, 15, 24, 16, 1, -24 },
  { 1465, 18, 24, 18, 1, -24 },
  { 1519, 12, 24, 15, 1, -24 },
  { 1555, 23, 24, 25, 1, -24 },
  { 1624, 19, 24, 20, 1, -24 },
  { 1681, 16, 24, 19, 2, -24 },
  { 1729, 16, 24, 18, 1, -24 },
  { 1777, 16, 28, 19, 2, -24 },
  { 1833, 16, 24, 19, 1, -24 },
  { 1881, 16, 24, 17, 1, -24 },
  { 1929, 16, 24, 17, 3, -24 },
  { 1977, 17, 24, 19, 2, -24 },
  { 2028, 16, 24, 18, 3, -24 },
  { 2076, 24, 24, 26, 3, -24 },
  { 2148, 19, 24, 17, -1, -24 },
  { 2205, 16, 24, 17, 3, -24 },
  { 2253, 18, 24, 17, 0, -24 },
  { 2307, 10, 33, 7, 0, -28 },
  { 2349, 5, 26, 11, 3, -24 },
  { 2366, 9, 33, 7, -2, -28 },
  { 2404, 9, 12, 12, 2, -24 },
  { 2418, 12, 1, 12, -2, 0 },
  { 2420, 4, 5, 9, 4, -26 },
  { 2423, 13, 18, 15, 1, -18 },
  { 2453, 13, 26, 16, 1, -26 },
  { 2496, 13, 18, 15, 1, -18 },
  { 2526, 15, 26, 16, 1, -26 },
  { 2575, 13, 18, 15, 1, -18 },
  { 2605, 10, 26, 10, 2, -26 },
  { 2638, 15, 25, 16, 0, -18 },
  { 2685, 13, 26, 16, 1, -26 },
  { 2728, 6, 24, 7, 1, -24 },
  { 2746, 11, 31, 7, -4, -24 },
  { 2789, 14, 26, 14, 1, -26 },
  { 2835, 6, 26, 7, 1, -26 },
  { 2855, 23, 18, 25, 1, -18 },
  { 2907, 13, 18, 16, 1, -18 },
  { 2937, 13, 18, 16, 1, -18 },
  { 2967, 14, 25, 16, 0, -18 },
  { 3011, 14, 25, 16, 1, -18 },
  { 3055, 10, 18, 10, 1, -18 },
  { 3078, 12, 18, 15, 1, -18 },
  { 3105, 7, 23, 10, 2, -23 },
  { 3126, 13, 18, 16, 2, -18 },
  { 3156, 12, 18, 14, 2, -18 },
  { 3183, 19, 18, 22, 3, -18 },
  { 3226, 15, 18, 14, -1, -18 },
  { 3260, 16, 25, 14, -1, -18 },
  { 3310, 14, 18, 14, 0, -18 },
  { 3342, 11, 34, 10, 1, -27 },
  { 3389, 5, 28, 7, 1, -24 },
  { 3407, 11, 34, 10, -2, -27 },
  { 3454, 16, 6, 20, 2, -13 },
};

const GFXfont RobotoCondensed_ExtraLightItalic34pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic34pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic34pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC34PT7B_H_
