#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC58PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x03, 0xC0, 0xE0, 0x10, 0x00, 0x30, 0xCC, 0x33, 0x0C, 0xC3, 0x71,
  0xD8, 0x66, 0x19, 0x86, 0x61, 0x98, 0x6C, 0x33, 0x0C, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x18, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x00, 0x60, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x0C, 0x02, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x30, 0x08, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x04, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03,
  0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC0, 0x0C, 0x03,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x0E, 0x01, 0x80, 0x06, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x07, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0xE0,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x38,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x80, 0x80, 0x00, 0x60, 0x18,
  0x00, 0x18, 0x03, 0x00, 0x63, 0x00, 0x60, 0x0C, 0x60, 0x0C, 0x03, 0x0C,
  0x01, 0x80, 0xC1, 0x80, 0x30, 0x38, 0x20, 0x04, 0x06, 0x0C, 0x01, 0x81,
  0x80, 0x80, 0x30, 0x60, 0x18, 0x06, 0x0C, 0x03, 0x01, 0x83, 0x00, 0x70,
  0x60, 0xC0, 0x07, 0xBC, 0x18, 0x00, 0x7E, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x3F, 0x80, 0x06, 0x0F, 0x78, 0x01, 0x83, 0x83,
  0x00, 0x30, 0x60, 0x30, 0x0C, 0x18, 0x06, 0x03, 0x03, 0x00, 0xC0, 0x60,
  0xC0, 0x18, 0x18, 0x18, 0x03, 0x06, 0x03, 0x00, 0x61, 0xC0, 0x60, 0x0C,
  0x30, 0x0C, 0x01, 0x8C, 0x01, 0x80, 0x33, 0x00, 0x30, 0x0C, 0x60, 0x06,
  0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x01, 0x80, 0x06,
  0x00, 0xC0, 0x07, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x0E, 0x00, 0x30, 0x06, 0x00, 0x18, 0x06, 0x00,
  0x0C, 0x07, 0x00, 0x06, 0x07, 0x00, 0x03, 0x87, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x0C,
  0x01, 0x8C, 0x07, 0x00, 0xCE, 0x01, 0x80, 0x66, 0x00, 0x60, 0x36, 0x00,
  0x38, 0x33, 0x00, 0x0C, 0x1B, 0x80, 0x07, 0x1D, 0x80, 0x01, 0x8C, 0xC0,
  0x00, 0xEE, 0x60, 0x00, 0x36, 0x30, 0x00, 0x1E, 0x18, 0x00, 0x07, 0x0E,
  0x00, 0x03, 0x83, 0x00, 0x03, 0xE1, 0xC0, 0x07, 0x30, 0x70, 0x07, 0x1C,
  0x1F, 0xFE, 0x06, 0x07, 0xFE, 0x03, 0x80, 0x30, 0x00, 0x00, 0x33, 0x76,
  0x66, 0x66, 0xCC, 0xCC, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x20, 0x0C, 0x02, 0x70,
  0x18, 0x1C, 0xFC, 0x31, 0xF8, 0x3E, 0xDF, 0x80, 0x1F, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x36, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x8C,
  0x00, 0x0E, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x18, 0x01, 0x80, 0x38,
  0x07, 0x00, 0x30, 0x04, 0x00, 0x40, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x30, 0xE3, 0x82, 0x00,
  0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x60,
  0x03, 0x81, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x70, 0x00, 0x38, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x01,
  0xCC, 0x00, 0x03, 0x98, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x19,
  0xC0, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x98,
  0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00,
  0x00, 0x66, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC3, 0x00, 0x03,
  0x07, 0x00, 0x0E, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x70, 0x1C, 0x01, 0xC0,
  0x1C, 0x07, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x10, 0x0F, 0x03, 0xF1, 0xF3, 0x7C, 0x3F, 0x07, 0x80, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x70, 0x1C, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x06, 0x03, 0x80, 0x07, 0x03,
  0x00, 0x03, 0x07, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0E,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x0C, 0x03,
  0x80, 0x0E, 0x07, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0C,
  0x00, 0x07, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x60, 0x60,
  0x00, 0xE0, 0x70, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x1F, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x36, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x8C, 0x00,
  0x03, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x18, 0x00, 0x70, 0x18, 0x00, 0x60, 0x38, 0x00,
  0xC0, 0x30, 0x01, 0x80, 0x30, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x30, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x60, 0x18, 0x00, 0x60, 0x30,
  0x00, 0x60, 0x70, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x7E, 0x00, 0x1B, 0xFF, 0x80, 0x1F,
  0x83, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0xE0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0x60, 0x01, 0x80, 0x70,
  0x03, 0x00, 0x38, 0x0F, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0xFC, 0x06, 0x1F, 0xF8, 0x33, 0xC1, 0xE1, 0xB8,
  0x07, 0x0F, 0x00, 0x1C, 0xF0, 0x00, 0x67, 0x00, 0x03, 0x38, 0x00, 0x1D,
  0x80, 0x00, 0x6C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0xD8,
  0x00, 0x06, 0xC0, 0x00, 0x77, 0x00, 0x03, 0x18, 0x00, 0x38, 0xC0, 0x01,
  0x87, 0x00, 0x1C, 0x1C, 0x01, 0xC0, 0xF0, 0x1C, 0x03, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x18, 0x06, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x01, 0xC0, 0x06, 0x00,
  0x70, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0x03, 0x80, 0x0E, 0x00, 0x60, 0x0E, 0x00, 0x18, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x07, 0x00, 0x03, 0x81, 0x80,
  0x03, 0x80, 0xE0, 0x03, 0x80, 0x38, 0x07, 0x80, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xF0, 0x07, 0x01, 0xC0, 0x70, 0x07, 0x07, 0x00, 0x18, 0x70, 0x00,
  0xE3, 0x00, 0x03, 0x38, 0x00, 0x19, 0x80, 0x00, 0xDC, 0x00, 0x06, 0xC0,
  0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x76, 0x00,
  0x07, 0xB0, 0x00, 0x39, 0x80, 0x03, 0xC6, 0x00, 0x36, 0x38, 0x07, 0x30,
  0xE0, 0xF3, 0x03, 0xFF, 0x18, 0x07, 0xE0, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x07, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0xF0, 0xE0, 0x40, 0x00, 0xE0, 0x3C, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0x70, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x70,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0xFF, 0x00, 0x7F, 0xE0,
  0x38, 0x1C, 0x1C, 0x03, 0x0E, 0x00, 0x63, 0x00, 0x19, 0x80, 0x06, 0x60,
  0x01, 0xB8, 0x00, 0x6C, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x00, 0x06, 0x03, 0x00, 0x07, 0xC0, 0x02, 0x07,
  0x00, 0x1F, 0xF0, 0x03, 0x06, 0x00, 0x38, 0x38, 0x03, 0x0E, 0x00, 0x60,
  0x18, 0x03, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x0C, 0x01, 0x80, 0x18, 0x03,
  0x18, 0x03, 0x80, 0x18, 0x03, 0x18, 0x03, 0x00, 0x30, 0x03, 0x30, 0x06,
  0x00, 0x30, 0x03, 0x30, 0x06, 0x00, 0x30, 0x03, 0x30, 0x06, 0x00, 0x30,
  0x03, 0x20, 0x0C, 0x00, 0x60, 0x02, 0x60, 0x0C, 0x00, 0x60, 0x06, 0x60,
  0x0C, 0x00, 0x60, 0x06, 0x60, 0x18, 0x00, 0x60, 0x06, 0x60, 0x18, 0x00,
  0xC0, 0x06, 0xC0, 0x18, 0x00, 0xC0, 0x0C, 0xC0, 0x18, 0x00, 0xC0, 0x0C,
  0xC0, 0x30, 0x00, 0xC0, 0x0C, 0xC0, 0x30, 0x01, 0x80, 0x18, 0xC0, 0x30,
  0x01, 0x80, 0x18, 0xC0, 0x30, 0x03, 0x80, 0x18, 0xC0, 0x30, 0x03, 0x80,
  0x30, 0xC0, 0x30, 0x07, 0x80, 0x60, 0xC0, 0x18, 0x0D, 0x80, 0x60, 0xC0,
  0x18, 0x18, 0xC0, 0xC0, 0xC0, 0x1F, 0xF0, 0xE7, 0x80, 0xC0, 0x0F, 0xE0,
  0x7F, 0x00, 0x60, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x18,
  0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xC0, 0x0C,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x30, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x06, 0x38, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x30, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x18, 0x01, 0xF0, 0x06, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x80,
  0xC0, 0x00, 0x70, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x07, 0x80, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x07, 0x00, 0x0F, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00,
  0x38, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0xE0,
  0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x1C, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x86, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x70, 0x60, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x0E, 0x00,
  0x3E, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0x80, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x07,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x1C, 0x03, 0x80, 0x01, 0x80, 0x18, 0x00,
  0x70, 0x01, 0xE0, 0x0E, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0x80, 0x1F, 0x00, 0x18, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x30, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x07, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x03, 0x83, 0x00, 0x00, 0x30, 0x30, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x78, 0x06, 0x00, 0x0F, 0x00, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x01, 0x80, 0x38, 0x00,
  0x1C, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x3F, 0xF8, 0xE0, 0x07, 0xFF, 0x8E, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x06, 0x03, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x07, 0x01, 0x80, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x0E,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1C,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x38,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x01, 0x80, 0xC0, 0xE0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x38,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x07, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x18, 0x0E, 0x00, 0x0E, 0x01,
  0x80, 0x03, 0x00, 0x60, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x70,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x06, 0x00, 0x01, 0xC0, 0x0C,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x00, 0x60, 0x1C,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x00, 0x63, 0xC0, 0x00, 0x00, 0xCD, 0xC0, 0x00, 0x03, 0xB1, 0x80, 0x00,
  0x06, 0xC3, 0x80, 0x00, 0x0F, 0x03, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x03,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x70, 0x01, 0x80,
  0x00, 0x60, 0x03, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x36, 0x00, 0x00, 0x03, 0xE0, 0x6C, 0x00,
  0x00, 0x0F, 0x80, 0xD8, 0x00, 0x00, 0x1B, 0x01, 0xB0, 0x00, 0x00, 0x76,
  0x03, 0x70, 0x00, 0x00, 0xCC, 0x06, 0x60, 0x00, 0x03, 0x98, 0x18, 0xC0,
  0x00, 0x06, 0x60, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x63, 0x00, 0x00, 0x31,
  0x80, 0xC6, 0x00, 0x00, 0xC3, 0x01, 0x86, 0x00, 0x01, 0x86, 0x07, 0x0C,
  0x00, 0x06, 0x1C, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x18, 0x30, 0x00, 0x30,
  0x60, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x60, 0xC0, 0x01, 0x81, 0x80, 0xC0,
  0xC0, 0x03, 0x03, 0x03, 0x81, 0x80, 0x0C, 0x0E, 0x06, 0x03, 0x00, 0x38,
  0x18, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x18, 0x0C, 0x01, 0xC0, 0x60, 0x30,
  0x18, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x81, 0xC0, 0x30, 0x18,
  0x07, 0x03, 0x00, 0x60, 0x70, 0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x0C,
  0x01, 0x83, 0x00, 0x30, 0x18, 0x01, 0x86, 0x00, 0x60, 0x30, 0x03, 0x18,
  0x01, 0xC0, 0xE0, 0x06, 0x30, 0x03, 0x01, 0x80, 0x0C, 0xC0, 0x06, 0x03,
  0x00, 0x19, 0x80, 0x0C, 0x06, 0x00, 0x36, 0x00, 0x18, 0x0C, 0x00, 0x3C,
  0x00, 0x30, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0x01, 0x80,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x01, 0x80, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x06, 0x03, 0xE0, 0x00,
  0x06, 0x03, 0x60, 0x00, 0x06, 0x03, 0x30, 0x00, 0x06, 0x03, 0x30, 0x00,
  0x06, 0x03, 0x38, 0x00, 0x0E, 0x07, 0x18, 0x00, 0x0C, 0x07, 0x18, 0x00,
  0x0C, 0x06, 0x0C, 0x00, 0x0C, 0x06, 0x0C, 0x00, 0x0C, 0x06, 0x0C, 0x00,
  0x1C, 0x06, 0x06, 0x00, 0x1C, 0x0E, 0x06, 0x00, 0x18, 0x0E, 0x07, 0x00,
  0x18, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x01, 0x80,
  0x38, 0x0C, 0x01, 0x80, 0x30, 0x1C, 0x01, 0xC0, 0x30, 0x1C, 0x00, 0xC0,
  0x30, 0x18, 0x00, 0xC0, 0x30, 0x18, 0x00, 0x60, 0x30, 0x18, 0x00, 0x60,
  0x70, 0x18, 0x00, 0x60, 0x60, 0x38, 0x00, 0x30, 0x60, 0x30, 0x00, 0x30,
  0x60, 0x30, 0x00, 0x38, 0x60, 0x30, 0x00, 0x18, 0xE0, 0x30, 0x00, 0x18,
  0xE0, 0x30, 0x00, 0x0C, 0xC0, 0x70, 0x00, 0x0C, 0xC0, 0x60, 0x00, 0x0C,
  0xC0, 0x60, 0x00, 0x06, 0xC0, 0x60, 0x00, 0x07, 0xC0, 0x60, 0x00, 0x07,
  0xC0, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0x80, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x33, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0C, 0x03, 0x80,
  0x01, 0x80, 0x18, 0x00, 0x78, 0x01, 0xE0, 0x0E, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0x80, 0x07, 0x80, 0x18, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x0C,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x01, 0xC0, 0x07,
  0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0x80, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x07, 0x30,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x06, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x1C, 0x03, 0x00, 0x01, 0x80, 0x38, 0x00, 0x70,
  0x01, 0xE0, 0x1E, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0x80, 0x0F, 0x80, 0x38,
  0x00, 0x38, 0x03, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x70, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x06, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x0E, 0x01, 0x80, 0x03, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x18, 0x00, 0xC0, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x03, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x70, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0x30,
  0x03, 0x00, 0x03, 0x80, 0x70, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0x80, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x07, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x86, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x01,
  0xC0, 0x1C, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x01, 0x83, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x38, 0x00, 0x78, 0x07, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x86, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x1C, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x38, 0x03, 0x80,
  0x03, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0xC0, 0x00, 0x38, 0x00, 0x06, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0xC0, 0x00, 0x78, 0x00, 0x0C, 0xC0, 0x00, 0x78, 0x00, 0x0C,
  0xC0, 0x00, 0xC8, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x01,
  0x8C, 0x00, 0x38, 0xC0, 0x01, 0x8C, 0x00, 0x30, 0xE0, 0x01, 0x8C, 0x00,
  0x30, 0xE0, 0x03, 0x0C, 0x00, 0x70, 0xE0, 0x03, 0x0C, 0x00, 0x60, 0x60,
  0x06, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x0C, 0x00, 0xC0, 0x60, 0x0E, 0x0C,
  0x00, 0xC0, 0x60, 0x0C, 0x0C, 0x01, 0xC0, 0x60, 0x0C, 0x0C, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0x60, 0x38,
  0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x07,
  0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60,
  0xE0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x70, 0xC0, 0x06,
  0x1C, 0x00, 0x71, 0x80, 0x06, 0x18, 0x00, 0x71, 0x80, 0x06, 0x18, 0x00,
  0x33, 0x80, 0x03, 0x38, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00,
  0x03, 0x30, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60,
  0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80,
  0x06, 0x00, 0x01, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0xC0,
  0x00, 0x60, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x0E, 0x30,
  0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x18, 0x00, 0x03, 0x80, 0x06, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x60, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x70,
  0x18, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x00, 0x30, 0x00, 0xE0, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x06, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0x80, 0x70, 0x00,
  0x38, 0x0C, 0x00, 0x03, 0x03, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60,
  0x60, 0x60, 0x60, 0x60, 0x70, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x38,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0E, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xD8, 0x00, 0xD8, 0x01, 0x98, 0x01, 0x88, 0x03,
  0x0C, 0x03, 0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x18,
  0x06, 0x18, 0x06, 0x30, 0x06, 0x30, 0x06, 0x60, 0x06, 0x60, 0x06, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE1, 0x87, 0x0C, 0x38, 0x61,
  0xC3, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xF0, 0x0E,
  0x07, 0x00, 0x18, 0x18, 0x00, 0x70, 0xE0, 0x00, 0xC3, 0x00, 0x03, 0x0C,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0x80, 0x38,
  0x78, 0x00, 0xC3, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80,
  0x00, 0xCE, 0x00, 0x03, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x03,
  0x8C, 0x00, 0x1E, 0x38, 0x00, 0xD8, 0x60, 0x07, 0x61, 0xC0, 0x7B, 0x83,
  0xFF, 0x8E, 0x07, 0xFC, 0x38, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x63, 0xFE,
  0x01, 0xCF, 0xFE, 0x03, 0x30, 0x0E, 0x06, 0xC0, 0x0C, 0x0F, 0x00, 0x1C,
  0x1C, 0x00, 0x18, 0x70, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3,
  0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x60,
  0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00,
  0x03, 0x9C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x71, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0C,
  0x3C, 0x00, 0x30, 0x6C, 0x00, 0xE0, 0xCC, 0x03, 0x81, 0x8F, 0xFE, 0x06,
  0x0F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0xE0, 0x1C, 0x06, 0x00, 0x30, 0x30, 0x00, 0xE1, 0xC0,
  0x01, 0x86, 0x00, 0x06, 0x38, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01,
  0x9C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x18,
  0xC0, 0x00, 0x63, 0x00, 0x01, 0x8E, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x70,
  0x03, 0x80, 0xE0, 0x1C, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x3F, 0xE1, 0x80, 0x1F,
  0xFC, 0x60, 0x0E, 0x01, 0x98, 0x07, 0x00, 0x36, 0x03, 0x80, 0x07, 0x80,
  0xC0, 0x01, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x03,
  0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x18, 0x18, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18,
  0x00, 0x0E, 0x06, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30,
  0x38, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x0E, 0x01, 0x80, 0x07, 0x80, 0x70,
  0x03, 0x60, 0x0E, 0x01, 0xB8, 0x01, 0xFF, 0xCC, 0x00, 0x3F, 0xC3, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0xE0, 0x1C, 0x07, 0x00, 0x30, 0x38, 0x00, 0xE1, 0xC0, 0x01, 0x86,
  0x00, 0x06, 0x38, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x98, 0x00,
  0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x6F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0xE0, 0x0E, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0xC0,
  0x1F, 0xFC, 0x60, 0x1C, 0x03, 0x30, 0x1C, 0x00, 0xD8, 0x1C, 0x00, 0x3C,
  0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x07, 0x00, 0x01,
  0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00,
  0x07, 0x06, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x80, 0x00, 0xC1, 0x80,
  0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x38, 0x38, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x0F, 0x01, 0xC0, 0x0D, 0x80,
  0x70, 0x1D, 0xC0, 0x1F, 0xFC, 0xC0, 0x07, 0xFC, 0x60, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x01, 0x00, 0x03, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x03,
  0x80, 0x1E, 0x07, 0x80, 0x07, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x61, 0xFE, 0x01, 0xCF, 0xFE, 0x03, 0x38, 0x0E, 0x06, 0xC0, 0x0C,
  0x0D, 0x80, 0x18, 0x1E, 0x00, 0x30, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xE1,
  0xC0, 0x01, 0xC3, 0x00, 0x03, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x70, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC3, 0x00,
  0x03, 0x06, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00,
  0x30, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x0E, 0x00, 0x06,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x70, 0xC0, 0x00, 0xC1,
  0x80, 0x01, 0x87, 0x00, 0x03, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x30, 0x18, 0x1C,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x38, 0x06,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x06, 0x01, 0xC0, 0x06, 0x03, 0x80, 0x0E,
  0x07, 0x00, 0x0C, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x0C,
  0x70, 0x00, 0x0C, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x1B, 0xE0, 0x00, 0x1F,
  0x60, 0x00, 0x1E, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x38, 0x18, 0x00, 0x30,
  0x18, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x30,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x01, 0x80, 0x60,
  0x01, 0x80, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x0C, 0x1F, 0xE0, 0x1F, 0xE0, 0x18,
  0xFF, 0xE0, 0xFF, 0xE0, 0x33, 0x80, 0xC3, 0x80, 0xE0, 0x6C, 0x01, 0xCE,
  0x00, 0xC0, 0xF0, 0x01, 0x98, 0x00, 0xC3, 0xC0, 0x03, 0x60, 0x01, 0x87,
  0x80, 0x07, 0x80, 0x03, 0x0E, 0x00, 0x0F, 0x00, 0x06, 0x1C, 0x00, 0x1C,
  0x00, 0x0C, 0x30, 0x00, 0x38, 0x00, 0x18, 0x60, 0x00, 0x60, 0x00, 0x31,
  0xC0, 0x00, 0xC0, 0x00, 0x63, 0x80, 0x01, 0x80, 0x01, 0xC6, 0x00, 0x03,
  0x00, 0x03, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x60, 0x00, 0x31, 0x80, 0x00,
  0xC0, 0x00, 0xE3, 0x00, 0x01, 0x80, 0x01, 0x86, 0x00, 0x03, 0x00, 0x03,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x70, 0x00,
  0x30, 0x00, 0x18, 0xC0, 0x00, 0x60, 0x00, 0x71, 0x80, 0x00, 0xC0, 0x00,
  0xC3, 0x00, 0x01, 0x80, 0x01, 0x86, 0x00, 0x06, 0x00, 0x03, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x06, 0x1F, 0xE0, 0x18, 0xFF, 0xE0, 0x33, 0x80,
  0xE0, 0x6E, 0x00, 0xC0, 0xD8, 0x01, 0x81, 0xE0, 0x03, 0x03, 0x80, 0x07,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x60,
  0xC0, 0x00, 0xC3, 0x80, 0x01, 0x87, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18,
  0x00, 0x1C, 0x30, 0x00, 0x30, 0x60, 0x00, 0x61, 0xC0, 0x00, 0xC3, 0x00,
  0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x30, 0xE0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x07,
  0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x70, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1E, 0x03, 0x80, 0x70, 0x03, 0x81,
  0xC0, 0x03, 0x83, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x70,
  0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x67, 0x00, 0x00, 0xCC, 0x00,
  0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00,
  0x1B, 0x80, 0x00, 0x37, 0x00, 0x00, 0xEC, 0x00, 0x01, 0x98, 0x00, 0x03,
  0x30, 0x00, 0x0E, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x30, 0xC0, 0x00, 0xC1,
  0x80, 0x03, 0x83, 0x80, 0x06, 0x03, 0x00, 0x1C, 0x07, 0x80, 0xF0, 0x07,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x63, 0xFE, 0x00, 0x63, 0xFF, 0x80, 0x37, 0x00, 0xE0, 0x1B, 0x00, 0x30,
  0x0F, 0x00, 0x1C, 0x07, 0x00, 0x06, 0x07, 0x00, 0x03, 0x03, 0x80, 0x01,
  0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00,
  0x18, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00,
  0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x03, 0x03, 0xC0, 0x03, 0x01,
  0xB0, 0x03, 0x80, 0xDC, 0x03, 0x80, 0x67, 0xFF, 0x80, 0x70, 0xFF, 0x00,
  0x30, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x0C, 0x07, 0xFF, 0x18, 0x1C,
  0x03, 0x30, 0x70, 0x03, 0x61, 0xC0, 0x03, 0xC3, 0x00, 0x07, 0x0E, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x70, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00,
  0xE3, 0x00, 0x01, 0x8E, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C,
  0x60, 0x00, 0x18, 0xC0, 0x00, 0x71, 0x80, 0x00, 0xC7, 0x00, 0x01, 0x8E,
  0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x30, 0xE0,
  0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x0F, 0x07, 0x00,
  0x36, 0x07, 0x00, 0xD8, 0x07, 0xFF, 0x30, 0x07, 0xFC, 0x60, 0x01, 0x80,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x01,
  0x8F, 0xC1, 0xCF, 0xE0, 0xCC, 0x00, 0x6C, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x38, 0x38, 0x00, 0x60, 0xC0, 0x01,
  0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x63, 0x00, 0x01, 0x8E, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x70, 0x01,
  0x80, 0xE0, 0x1C, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x80, 0x1C, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80,
  0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x18, 0x60, 0x00, 0x63, 0x80, 0x01,
  0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x0C,
  0x00, 0x0C, 0x70, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00,
  0x1C, 0x60, 0x00, 0x61, 0x80, 0x01, 0x8E, 0x00, 0x06, 0x30, 0x00, 0x18,
  0xC0, 0x00, 0x63, 0x00, 0x03, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0,
  0x01, 0xC3, 0x00, 0x07, 0x0E, 0x00, 0x3C, 0x18, 0x01, 0xF0, 0x70, 0x1D,
  0x80, 0xFF, 0xE6, 0x01, 0xFE, 0x18, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x36,
  0x00, 0x01, 0xB0, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x0E, 0x70, 0x00,
  0x61, 0x80, 0x07, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x83, 0x00, 0x18, 0x18,
  0x00, 0xC0, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x03, 0x00, 0x30, 0x18, 0x01, 0x81, 0xC0, 0x0E, 0x0C, 0x00, 0x30,
  0xE0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00,
  0x19, 0x80, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x07, 0xC0,
  0x03, 0x80, 0x06, 0xC0, 0x03, 0x80, 0x06, 0xC0, 0x07, 0x80, 0x0E, 0xC0,
  0x07, 0x80, 0x0C, 0xC0, 0x0D, 0x80, 0x1C, 0xC0, 0x0D, 0x80, 0x18, 0xC0,
  0x0D, 0x80, 0x18, 0xC0, 0x19, 0x80, 0x38, 0xC0, 0x19, 0xC0, 0x30, 0xC0,
  0x30, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0xE0,
  0x60, 0xC0, 0xE0, 0x60, 0x60, 0xC0, 0xC0, 0x60, 0xC0, 0xC1, 0xC0, 0x60,
  0xC0, 0xC1, 0x80, 0x61, 0x80, 0xC1, 0x80, 0x61, 0x80, 0xC3, 0x00, 0x63,
  0x00, 0xC3, 0x00, 0x63, 0x00, 0xC7, 0x00, 0x67, 0x00, 0x66, 0x00, 0x66,
  0x00, 0x66, 0x00, 0x66, 0x00, 0x6C, 0x00, 0x6C, 0x00, 0x6C, 0x00, 0x6C,
  0x00, 0x6C, 0x00, 0x68, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x03, 0x81, 0x80, 0x03, 0x80, 0xE0, 0x01, 0x80, 0x30, 0x01, 0x80,
  0x1C, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0xC0, 0xE0,
  0x00, 0x60, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x70,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x1C,
  0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x06, 0x00, 0x0E,
  0x03, 0x00, 0x06, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x07, 0x00, 0x38, 0x03,
  0x00, 0x0C, 0x03, 0x00, 0x07, 0x03, 0x80, 0x01, 0x83, 0x80, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x01, 0x80,
  0x00, 0xC0, 0x38, 0x00, 0x38, 0x03, 0x00, 0x06, 0x00, 0x60, 0x01, 0xC0,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xE0, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x1C,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x18, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x40, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x0C, 0x70, 0xE0, 0x01, 0x9C, 0x0E, 0x00,
  0x33, 0x00, 0xE0, 0x0C, 0xC0, 0x0E, 0x01, 0x98, 0x00, 0xE0, 0x63, 0x00,
  0x0E, 0x1C, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoCondensed_ExtraLightItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 10, 42, 11, 1, -41 },
  { 54, 10, 12, 15, 6, -44 },
  { 69, 29, 41, 28, 1, -41 },
  { 218, 24, 53, 27, 2, -47 },
  { 377, 27, 43, 36, 5, -42 },
  { 523, 25, 43, 30, 2, -42 },
  { 658, 4, 12, 9, 6, -44 },
  { 664, 16, 59, 16, 3, -46 },
  { 782, 16, 59, 16, -3, -46 },
  { 900, 23, 23, 24, 3, -41 },
  { 967, 24, 30, 28, 2, -34 },
  { 1057, 7, 12, 11, -2, -5 },
  { 1068, 11, 2, 15, 2, -20 },
  { 1071, 4, 4, 13, 1, -3 },
  { 1073, 24, 45, 20, -2, -41 },
  { 1208, 23, 43, 27, 3, -42 },
  { 1332, 12, 41, 27, 8, -41 },
  { 1394, 24, 42, 27, 1, -42 },
  { 1520, 24, 43, 27, 2, -42 },
  { 1649, 24, 41, 27, 1, -41 },
  { 1772, 24, 42, 27, 4, -41 },
  { 1898, 21, 42, 27, 3, -41 },
  { 2009, 23, 41, 27, 5, -41 },
  { 2127, 25, 43, 27, 1, -42 },
  { 2262, 21, 42, 27, 4, -42 },
  { 2373, 8, 31, 11, 1, -30 },
  { 2404, 11, 37, 10, -2, -30 },
  { 2455, 22, 24, 25, 2, -31 },
  { 2521, 22, 14, 27, 3, -26 },
  { 2560, 21, 23, 26, 2, -30 },
  { 2621, 18, 43, 22, 5, -42 },
  { 2718, 40, 53, 45, 2, -40 },
  { 2983, 28, 41, 30, -2, -41 },
  { 3127, 26, 41, 30, 2, -41 },
  { 3261, 28, 43, 32, 3, -42 },
  { 3412, 28, 41, 32, 2, -41 },
  { 3556, 28, 41, 28, 2, -41 },
  { 3700, 28, 41, 28, 2, -41 },
  { 3844, 28, 43, 34, 4, -42 },
  { 3995, 32, 41, 35, 2, -41 },
  { 4159, 9, 41, 14, 3, -41 },
  { 4206, 26, 42, 27, 1, -41 },
  { 4343, 31, 41, 31, 2, -41 },
  { 4502, 20, 41, 26, 2, -41 },
  { 4605, 39, 41, 42, 2, -41 },
  { 4805, 32, 41, 35, 2, -41 },
  { 4969, 28, 43, 33, 3, -42 },
  { 5120, 28, 41, 30, 2, -41 },
  { 5264, 28, 49, 33, 3, -42 },
  { 5436, 28, 41, 32, 2, -41 },
  { 5580, 28, 43, 29, 1, -42 },
  { 5731, 26, 41, 29, 6, -41 },
  { 5865, 29, 42, 33, 3, -41 },
  { 6018, 28, 41, 30, 5, -41 },
  { 6162, 40, 41, 44, 6, -41 },
  { 6367, 33, 41, 30, -1, -41 },
  { 6537, 27, 41, 29, 5, -41 },
  { 6676, 30, 41, 30, 0, -41 },
  { 6830, 16, 56, 12, 0, -47 },
  { 6942, 8, 45, 19, 6, -41 },
  { 6987, 16, 56, 12, -4, -47 },
  { 7099, 16, 21, 21, 3, -41 },
  { 7141, 21, 2, 21, -3, 0 },
  { 7147, 6, 8, 15, 8, -44 },
  { 7153, 22, 33, 26, 1, -32 },
  { 7244, 23, 45, 27, 1, -44 },
  { 7374, 22, 33, 25, 2, -32 },
  { 7465, 26, 45, 27, 2, -44 },
  { 7612, 22, 33, 26, 2, -32 },
  { 7703, 18, 45, 16, 3, -45 },
  { 7805, 25, 44, 27, 0, -32 },
  { 7943, 23, 44, 27, 1, -44 },
  { 8070, 9, 43, 11, 2, -43 },
  { 8119, 18, 55, 12, -7, -43 },
  { 8243, 24, 44, 24, 1, -44 },
  { 8375, 9, 44, 11, 2, -44 },
  { 8425, 39, 32, 43, 1, -32 },
  { 8581, 23, 32, 27, 1, -32 },
  { 8673, 23, 33, 27, 2, -32 },
  { 8768, 25, 44, 27, -1, -32 },
  { 8906, 23, 44, 27, 2, -32 },
  { 9033, 17, 32, 17, 1, -32 },
  { 9101, 22, 33, 25, 1, -32 },
  { 9192, 13, 40, 16, 3, -39 },
  { 9257, 22, 32, 27, 3, -31 },
  { 9345, 21, 31, 24, 4, -31 },
  { 9427, 32, 31, 37, 5, -31 },
  { 9551, 25, 31, 24, -1, -31 },
  { 9648, 27, 43, 24, -2, -31 },
  { 9794, 23, 31, 24, 0, -31 },
  { 9884, 18, 57, 17, 2, -45 },
  { 10013, 10, 49, 12, 1, -41 },
  { 10075, 19, 57, 17, -4, -45 },
  { 10211, 27, 10, 34, 3, -22 },
};

const GFXfont RobotoCondensed_ExtraLightItalic58pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic58pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic58pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC58PT7B_H_
