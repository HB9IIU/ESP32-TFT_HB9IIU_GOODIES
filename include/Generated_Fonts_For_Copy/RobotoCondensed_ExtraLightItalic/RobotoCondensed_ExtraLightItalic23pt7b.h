#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC23PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x12, 0x22, 0x22, 0x22, 0x40, 0x00, 0x40, 0x55, 0x55,
  0x90, 0x02, 0x20, 0x22, 0x02, 0x20, 0x44, 0x04, 0x43, 0xFF, 0x04, 0x80,
  0x88, 0x08, 0x80, 0x90, 0x11, 0x07, 0xFC, 0x11, 0x02, 0x20, 0x22, 0x02,
  0x20, 0x44, 0x00, 0x02, 0x01, 0x03, 0xC2, 0x12, 0x09, 0x04, 0x82, 0x40,
  0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x0A, 0x05, 0x02, 0x81, 0x21, 0x0F,
  0x02, 0x01, 0x00, 0x38, 0x09, 0x02, 0x11, 0x42, 0x48, 0x89, 0x12, 0x22,
  0x83, 0x90, 0x04, 0x01, 0x38, 0x28, 0x89, 0x12, 0x42, 0x48, 0x51, 0x10,
  0x12, 0x03, 0x80, 0x0E, 0x04, 0x41, 0x10, 0x84, 0x21, 0x08, 0x81, 0x40,
  0x60, 0x38, 0x12, 0x04, 0x46, 0x11, 0x82, 0xA0, 0xA8, 0x12, 0x0A, 0x7C,
  0x80, 0x56, 0x80, 0x04, 0x10, 0x84, 0x10, 0x82, 0x10, 0x41, 0x04, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x10, 0x41, 0x02, 0x00, 0x10, 0x20, 0x81,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x10, 0x41, 0x08,
  0x41, 0x08, 0x00, 0x04, 0x02, 0x02, 0x19, 0x33, 0xE0, 0xC0, 0x50, 0x44,
  0x42, 0x00, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x43, 0xFE, 0x10, 0x08,
  0x04, 0x04, 0x02, 0x01, 0x00, 0x25, 0x28, 0xF0, 0x40, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x00, 0x0F, 0x08, 0x48, 0x24,
  0x14, 0x0A, 0x05, 0x02, 0x81, 0x80, 0xC0, 0x60, 0x50, 0x28, 0x14, 0x0A,
  0x08, 0x88, 0x38, 0x00, 0x0B, 0xE2, 0x11, 0x08, 0x42, 0x10, 0x88, 0x42,
  0x10, 0x84, 0x40, 0x07, 0x82, 0x21, 0x04, 0x81, 0x20, 0x40, 0x10, 0x08,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x7F,
  0x80, 0x0F, 0x08, 0xC8, 0x24, 0x14, 0x08, 0x04, 0x04, 0x06, 0x1C, 0x01,
  0x00, 0x40, 0x28, 0x14, 0x0A, 0x04, 0x84, 0x3C, 0x00, 0x00, 0xC0, 0x30,
  0x18, 0x0A, 0x02, 0x81, 0x20, 0x88, 0x42, 0x11, 0x08, 0x44, 0x11, 0xFF,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x1F, 0xC4, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x03, 0xE0, 0x84, 0x01, 0x00, 0x20, 0x08, 0x02, 0x81, 0x20,
  0x44, 0x11, 0x08, 0x3C, 0x00, 0x03, 0x06, 0x04, 0x04, 0x02, 0x02, 0x01,
  0x78, 0xC2, 0x41, 0x40, 0x60, 0x30, 0x28, 0x14, 0x0A, 0x08, 0x84, 0x3C,
  0x00, 0xFF, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04,
  0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x00, 0x0F, 0x08, 0x48,
  0x24, 0x14, 0x0A, 0x04, 0x82, 0x42, 0x1E, 0x31, 0x10, 0x50, 0x28, 0x14,
  0x0A, 0x05, 0x04, 0x7C, 0x00, 0x1C, 0x22, 0x41, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x83, 0x85, 0x7A, 0x02, 0x02, 0x04, 0x08, 0x10, 0xE0, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x44,
  0x22, 0x00, 0x01, 0x03, 0x06, 0x0C, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x40, 0x30, 0x0C, 0x02, 0x01,
  0x06, 0x18, 0x60, 0x80, 0x3C, 0x86, 0x0C, 0x10, 0x20, 0x81, 0x04, 0x10,
  0x40, 0x82, 0x00, 0x00, 0x00, 0x00, 0x40, 0x01, 0xF8, 0x06, 0x04, 0x08,
  0x02, 0x10, 0x02, 0x20, 0x02, 0x21, 0xE1, 0x42, 0x21, 0x44, 0x21, 0x44,
  0x21, 0x84, 0x22, 0x88, 0x42, 0x88, 0x42, 0x88, 0x42, 0x88, 0xC4, 0x88,
  0xC4, 0x8F, 0x38, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x80, 0x1F,
  0x00, 0x00, 0x80, 0x30, 0x05, 0x01, 0x20, 0x24, 0x04, 0x81, 0x10, 0x22,
  0x08, 0x41, 0x08, 0x40, 0x8F, 0xF2, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x40,
  0x20, 0x1F, 0x08, 0x32, 0x04, 0x81, 0x20, 0x48, 0x14, 0x09, 0x06, 0x7E,
  0x10, 0x64, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0xFE, 0x00, 0x07,
  0x83, 0x08, 0x40, 0x90, 0x12, 0x02, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x08, 0x05, 0x00, 0x90, 0x22, 0x08, 0x3E, 0x00, 0x1F,
  0x04, 0x18, 0x81, 0x10, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x40, 0x28,
  0x09, 0x01, 0x20, 0x28, 0x05, 0x01, 0x20, 0x64, 0x18, 0xFC, 0x00, 0x1F,
  0xE4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x7F, 0x88,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF, 0x00, 0x1F,
  0xE4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x7F, 0x88,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x00, 0x07,
  0x81, 0x0C, 0x40, 0x90, 0x12, 0x02, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x7D, 0x00, 0xC0, 0x28, 0x04, 0x80, 0x90, 0x11, 0x04, 0x1F, 0x00, 0x20,
  0x12, 0x01, 0x20, 0x12, 0x01, 0x20, 0x12, 0x01, 0x40, 0x24, 0x02, 0x7F,
  0xE4, 0x02, 0x40, 0x24, 0x02, 0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80,
  0x40, 0x11, 0x22, 0x22, 0x22, 0x44, 0x44, 0x44, 0x88, 0x80, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x48, 0x11, 0x02, 0x10, 0x42, 0x10, 0x3C, 0x00, 0x20, 0x22,
  0x06, 0x20, 0xC2, 0x08, 0x21, 0x02, 0x20, 0x44, 0x04, 0x80, 0x58, 0x06,
  0x40, 0x44, 0x04, 0x20, 0x82, 0x08, 0x10, 0x81, 0x08, 0x08, 0x80, 0x80,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x80, 0xFE, 0x10, 0x02, 0x60, 0x0C, 0xC0, 0x19, 0x80,
  0x52, 0x80, 0xA5, 0x02, 0x52, 0x05, 0x24, 0x12, 0x48, 0x24, 0x90, 0x89,
  0x11, 0x12, 0x24, 0x28, 0x48, 0x90, 0xA1, 0x21, 0x42, 0x41, 0x04, 0x82,
  0x08, 0x10, 0x13, 0x01, 0x30, 0x12, 0x81, 0x28, 0x12, 0x41, 0x44, 0x24,
  0x42, 0x42, 0x24, 0x22, 0x42, 0x24, 0x12, 0x81, 0x48, 0x14, 0x80, 0xC8,
  0x0C, 0x80, 0x40, 0x07, 0x83, 0x08, 0x40, 0x90, 0x12, 0x02, 0x80, 0x50,
  0x0A, 0x01, 0x40, 0x30, 0x06, 0x00, 0xC0, 0x28, 0x05, 0x00, 0x90, 0x22,
  0x08, 0x3E, 0x00, 0x1F, 0x84, 0x08, 0x81, 0x10, 0x12, 0x02, 0x40, 0x50,
  0x12, 0x02, 0x40, 0x8F, 0xE1, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x00, 0x07, 0x83, 0x08, 0x40, 0x90, 0x14, 0x02, 0x80, 0x50,
  0x0A, 0x01, 0x40, 0x30, 0x06, 0x00, 0xC0, 0x28, 0x05, 0x00, 0x90, 0x22,
  0x08, 0x3E, 0x00, 0x20, 0x04, 0x00, 0x40, 0x1F, 0x84, 0x08, 0x81, 0x10,
  0x12, 0x02, 0x40, 0x50, 0x12, 0x02, 0x40, 0x8F, 0xE1, 0x08, 0x21, 0x08,
  0x11, 0x02, 0x20, 0x44, 0x04, 0x80, 0x80, 0x0F, 0x82, 0x18, 0x81, 0x10,
  0x24, 0x04, 0x80, 0x08, 0x00, 0x80, 0x0E, 0x00, 0x20, 0x02, 0x00, 0x48,
  0x09, 0x01, 0x20, 0x22, 0x18, 0x3C, 0x00, 0xFF, 0xE0, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x00, 0x20, 0x12, 0x01, 0x20, 0x22,
  0x02, 0x20, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x44, 0x04, 0x40, 0x48,
  0x04, 0x80, 0x48, 0x08, 0x40, 0x84, 0x10, 0x3E, 0x00, 0x80, 0x30, 0x0A,
  0x01, 0x40, 0x44, 0x08, 0x82, 0x10, 0x42, 0x08, 0x42, 0x08, 0x41, 0x10,
  0x12, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x80, 0x30, 0x00, 0x80, 0x81, 0x81,
  0x81, 0x81, 0x82, 0x82, 0x82, 0x82, 0x82, 0x42, 0x84, 0x44, 0x84, 0x44,
  0x84, 0x48, 0x88, 0x48, 0x48, 0x48, 0x48, 0x50, 0x50, 0x50, 0x50, 0x50,
  0x60, 0x60, 0x60, 0x60, 0x60, 0x40, 0x40, 0x10, 0x11, 0x02, 0x10, 0x20,
  0x84, 0x08, 0x80, 0x88, 0x05, 0x00, 0x60, 0x02, 0x00, 0x60, 0x09, 0x01,
  0x10, 0x11, 0x02, 0x08, 0x40, 0x84, 0x08, 0x80, 0x40, 0x80, 0x28, 0x09,
  0x02, 0x20, 0x44, 0x10, 0x44, 0x08, 0x81, 0x20, 0x14, 0x03, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0xFF, 0xC0, 0x0C,
  0x41, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41,
  0x04, 0x10, 0x82, 0x0E, 0x00, 0x88, 0x44, 0x44, 0x44, 0x42, 0x22, 0x22,
  0x22, 0x11, 0x1C, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10,
  0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0x8C, 0x00, 0x08, 0x61, 0x49, 0x25,
  0x14, 0x61, 0xFF, 0x88, 0x80, 0x0F, 0x08, 0x48, 0x24, 0x10, 0x08, 0xFD,
  0x82, 0x82, 0x81, 0x40, 0x91, 0xCF, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x38, 0xE2, 0x40, 0xA0, 0x50, 0x30, 0x18, 0x14, 0x0A, 0x05,
  0x04, 0xC2, 0x5E, 0x00, 0x1E, 0x21, 0x41, 0x81, 0x80, 0x80, 0x80, 0x80,
  0x82, 0x82, 0x84, 0x78, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x21,
  0xE8, 0x86, 0x40, 0x90, 0x48, 0x12, 0x04, 0x81, 0x20, 0x48, 0x12, 0x08,
  0x86, 0x1E, 0x80, 0x1E, 0x21, 0x41, 0x81, 0x81, 0xFF, 0x80, 0x80, 0x80,
  0x80, 0xC2, 0x7C, 0x0E, 0x30, 0x40, 0x82, 0x04, 0x1F, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x00, 0x0F, 0x44, 0x32, 0x0C, 0x82,
  0x40, 0x90, 0x24, 0x09, 0x02, 0x40, 0x90, 0x44, 0x30, 0xF4, 0x01, 0x00,
  0x40, 0x22, 0x08, 0x7C, 0x00, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x4E,
  0x51, 0x61, 0x41, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x20,
  0x00, 0x24, 0x44, 0x44, 0x48, 0x88, 0x88, 0x02, 0x00, 0x00, 0x00, 0x02,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x10, 0xE0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x04,
  0x84, 0x44, 0x24, 0x14, 0x0E, 0x0D, 0x04, 0x42, 0x21, 0x08, 0x84, 0x41,
  0x00, 0x22, 0x22, 0x22, 0x44, 0x44, 0x44, 0x88, 0x88, 0x88, 0x27, 0x1E,
  0x28, 0xA1, 0x30, 0xC1, 0x20, 0xC1, 0x20, 0x81, 0x20, 0x81, 0x40, 0x81,
  0x40, 0x82, 0x40, 0x82, 0x41, 0x02, 0x41, 0x02, 0x81, 0x02, 0x4E, 0x51,
  0x61, 0x41, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x82, 0x1E, 0x10,
  0x90, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x02, 0x81, 0x41, 0x10, 0x8F, 0x80,
  0x2F, 0x0C, 0x22, 0x04, 0x81, 0x20, 0x48, 0x14, 0x09, 0x02, 0x40, 0x90,
  0x46, 0x11, 0x78, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x1E, 0x90,
  0xD0, 0x28, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x41, 0x21, 0x8F, 0x40,
  0x20, 0x10, 0x08, 0x08, 0x04, 0x00, 0x4D, 0x46, 0x10, 0x41, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x0F, 0x18, 0x48, 0x24, 0x02, 0x00, 0xC0, 0x18, 0x02,
  0x01, 0x40, 0x90, 0x87, 0x80, 0x11, 0x09, 0xF2, 0x10, 0x88, 0x42, 0x10,
  0x84, 0x21, 0x80, 0x40, 0xA0, 0x50, 0x28, 0x24, 0x12, 0x0A, 0x05, 0x02,
  0x81, 0x41, 0x31, 0x8F, 0x40, 0x80, 0xA0, 0x90, 0x48, 0x44, 0x22, 0x21,
  0x10, 0x50, 0x28, 0x18, 0x0C, 0x04, 0x00, 0x82, 0x14, 0x30, 0xA1, 0x85,
  0x14, 0x48, 0xA2, 0x49, 0x22, 0x49, 0x14, 0x48, 0xA2, 0x85, 0x0C, 0x10,
  0x40, 0x82, 0x00, 0x20, 0x88, 0x41, 0x10, 0x48, 0x0C, 0x02, 0x00, 0x80,
  0x50, 0x24, 0x10, 0x84, 0x22, 0x04, 0x10, 0x22, 0x08, 0x41, 0x08, 0x41,
  0x08, 0x22, 0x04, 0x40, 0x50, 0x0A, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x01, 0x00, 0xC0, 0x00, 0x3F, 0x80, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x20, 0x20, 0x20, 0x20, 0x10, 0x1F, 0xE0, 0x02, 0x08, 0x20, 0x81,
  0x02, 0x04, 0x08, 0x20, 0x41, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x04, 0x0C, 0x00, 0x11, 0x11, 0x11, 0x22, 0x22, 0x22, 0x44,
  0x44, 0x44, 0x48, 0x10, 0x10, 0x20, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x30, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x08, 0x20, 0x00,
  0x38, 0x28, 0x85, 0x09, 0x40, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 17, 4, 0, -17 },
  { 10, 4, 5, 6, 2, -17 },
  { 13, 12, 17, 11, 0, -17 },
  { 39, 9, 21, 11, 1, -19 },
  { 63, 11, 17, 14, 2, -17 },
  { 87, 10, 17, 12, 1, -17 },
  { 109, 2, 5, 4, 2, -17 },
  { 111, 6, 23, 6, 1, -18 },
  { 129, 6, 23, 6, -1, -18 },
  { 147, 9, 9, 9, 1, -17 },
  { 158, 9, 13, 11, 1, -14 },
  { 173, 3, 5, 4, -1, -2 },
  { 175, 4, 1, 6, 1, -8 },
  { 176, 2, 1, 5, 0, -1 },
  { 177, 10, 18, 8, -1, -17 },
  { 200, 9, 17, 11, 1, -17 },
  { 220, 5, 17, 11, 3, -17 },
  { 231, 10, 17, 11, 0, -17 },
  { 253, 9, 17, 11, 1, -17 },
  { 273, 10, 17, 11, 0, -17 },
  { 295, 10, 17, 11, 1, -17 },
  { 317, 9, 17, 11, 1, -17 },
  { 337, 9, 17, 11, 2, -17 },
  { 357, 9, 17, 11, 1, -17 },
  { 377, 8, 17, 11, 2, -17 },
  { 394, 4, 12, 4, 0, -12 },
  { 400, 5, 15, 4, -1, -12 },
  { 410, 9, 9, 10, 1, -12 },
  { 421, 9, 5, 11, 1, -10 },
  { 427, 8, 9, 10, 1, -12 },
  { 436, 7, 17, 9, 2, -17 },
  { 451, 16, 21, 18, 1, -16 },
  { 493, 11, 17, 12, -1, -17 },
  { 517, 10, 17, 12, 1, -17 },
  { 539, 11, 17, 13, 1, -17 },
  { 563, 11, 17, 13, 1, -17 },
  { 587, 11, 17, 11, 1, -17 },
  { 611, 11, 17, 11, 1, -17 },
  { 635, 11, 17, 13, 1, -17 },
  { 659, 12, 17, 14, 1, -17 },
  { 685, 4, 17, 5, 1, -17 },
  { 694, 11, 17, 11, 0, -17 },
  { 718, 12, 17, 12, 1, -17 },
  { 744, 8, 17, 10, 1, -17 },
  { 761, 15, 17, 17, 1, -17 },
  { 793, 12, 17, 14, 1, -17 },
  { 819, 11, 17, 13, 1, -17 },
  { 843, 11, 17, 12, 1, -17 },
  { 867, 11, 20, 13, 1, -17 },
  { 895, 11, 17, 13, 1, -17 },
  { 919, 11, 17, 12, 1, -17 },
  { 943, 11, 17, 12, 2, -17 },
  { 967, 12, 17, 13, 1, -17 },
  { 993, 11, 17, 12, 2, -17 },
  { 1017, 16, 17, 17, 2, -17 },
  { 1051, 12, 17, 12, 0, -17 },
  { 1077, 11, 17, 12, 2, -17 },
  { 1101, 12, 17, 12, 0, -17 },
  { 1127, 6, 23, 5, 0, -19 },
  { 1145, 4, 18, 8, 2, -17 },
  { 1154, 6, 23, 5, -1, -19 },
  { 1172, 6, 8, 8, 1, -17 },
  { 1178, 8, 1, 8, -1, 0 },
  { 1179, 3, 3, 6, 3, -17 },
  { 1181, 9, 12, 10, 0, -12 },
  { 1195, 9, 18, 11, 1, -18 },
  { 1216, 8, 12, 10, 1, -12 },
  { 1228, 10, 18, 11, 1, -18 },
  { 1251, 8, 12, 10, 1, -12 },
  { 1263, 7, 18, 7, 1, -18 },
  { 1279, 10, 17, 11, 0, -12 },
  { 1301, 8, 18, 11, 1, -18 },
  { 1319, 4, 16, 5, 1, -16 },
  { 1327, 8, 21, 5, -3, -16 },
  { 1348, 9, 18, 10, 1, -18 },
  { 1369, 4, 18, 5, 1, -18 },
  { 1378, 16, 12, 17, 0, -12 },
  { 1402, 8, 12, 11, 1, -12 },
  { 1414, 9, 12, 11, 1, -12 },
  { 1428, 10, 17, 11, 0, -12 },
  { 1450, 9, 17, 11, 1, -12 },
  { 1470, 6, 12, 7, 1, -12 },
  { 1479, 9, 12, 10, 0, -12 },
  { 1493, 5, 15, 6, 1, -15 },
  { 1503, 9, 12, 11, 1, -12 },
  { 1517, 9, 12, 9, 1, -12 },
  { 1531, 13, 12, 15, 2, -12 },
  { 1551, 10, 12, 10, 0, -12 },
  { 1566, 11, 17, 9, -1, -12 },
  { 1590, 9, 12, 10, 0, -12 },
  { 1604, 7, 23, 7, 1, -18 },
  { 1625, 4, 20, 5, 0, -17 },
  { 1635, 7, 23, 7, -1, -18 },
  { 1656, 11, 4, 13, 1, -9 },
};

const GFXfont RobotoCondensed_ExtraLightItalic23pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic23pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic23pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC23PT7B_H_
