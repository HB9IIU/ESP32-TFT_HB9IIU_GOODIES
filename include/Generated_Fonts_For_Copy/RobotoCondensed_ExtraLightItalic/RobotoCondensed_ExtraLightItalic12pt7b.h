#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC12PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x15, 0x40, 0x80, 0x38, 0x14, 0x53, 0xCA, 0x29, 0x47, 0x94, 0x00,
  0x01, 0xD2, 0x84, 0x18, 0x31, 0x8B, 0x80, 0x62, 0xAA, 0xAC, 0x20, 0xF5,
  0x45, 0x18, 0x38, 0xA4, 0x8C, 0x21, 0x59, 0x62, 0x70, 0x60, 0x29, 0x49,
  0x24, 0x92, 0x40, 0x21, 0x11, 0x11, 0x11, 0x22, 0x24, 0x80, 0x22, 0x66,
  0xA0, 0x22, 0x64, 0x44, 0xE0, 0x40, 0x80, 0x01, 0x12, 0x24, 0x48, 0x80,
  0x79, 0x99, 0x99, 0x99, 0xE0, 0x55, 0x5A, 0x80, 0x3A, 0x52, 0x11, 0x08,
  0x88, 0xF0, 0x3A, 0x42, 0x13, 0x04, 0x31, 0x70, 0x08, 0x46, 0x54, 0xAB,
  0xC2, 0x10, 0x72, 0x21, 0xE1, 0x08, 0x42, 0xE0, 0x24, 0x8F, 0x99, 0x99,
  0xE0, 0x78, 0x84, 0x42, 0x21, 0x10, 0x80, 0x3A, 0x52, 0x93, 0x26, 0x31,
  0x70, 0x79, 0x99, 0x9F, 0x12, 0xC0, 0x40, 0x08, 0x40, 0x0A, 0x80, 0x16,
  0x84, 0x20, 0x66, 0x41, 0x82, 0x6C, 0x00, 0x69, 0x11, 0x24, 0x00, 0x80,
  0x1F, 0x10, 0x52, 0x2A, 0x15, 0x4D, 0x26, 0x95, 0x7E, 0x80, 0x20, 0x0E,
  0x00, 0x10, 0x8A, 0x54, 0xBD, 0x31, 0x00, 0x39, 0x14, 0x51, 0x79, 0x24,
  0x62, 0x30, 0x3A, 0x61, 0x08, 0x42, 0x32, 0xE0, 0x19, 0x14, 0x51, 0x45,
  0x14, 0x62, 0x30, 0x19, 0x04, 0x10, 0x71, 0x04, 0x20, 0x30, 0x19, 0x04,
  0x10, 0x71, 0x04, 0x20, 0x00, 0x39, 0x08, 0x20, 0x82, 0x28, 0xA2, 0x70,
  0x02, 0x85, 0x0A, 0x17, 0xA8, 0x91, 0x42, 0x04, 0x1A, 0xAA, 0x00, 0x00,
  0x10, 0x82, 0x08, 0x20, 0xA4, 0x60, 0x04, 0x89, 0x22, 0x86, 0x0A, 0x14,
  0x44, 0x08, 0x04, 0x44, 0x44, 0x48, 0x20, 0x20, 0x10, 0x98, 0xCC, 0x65,
  0x52, 0xA9, 0x65, 0x32, 0x10, 0x00, 0x20, 0x45, 0x4A, 0x95, 0x29, 0x93,
  0x42, 0x04, 0x7C, 0x63, 0x18, 0xC6, 0x31, 0xF0, 0x3D, 0x14, 0x51, 0x79,
  0x04, 0x20, 0x00, 0x7C, 0x63, 0x18, 0xC6, 0x31, 0xF0, 0x84, 0x3D, 0x14,
  0x51, 0x79, 0x04, 0xA2, 0x88, 0x39, 0x14, 0x10, 0x30, 0x28, 0x62, 0x70,
  0x78, 0x82, 0x08, 0x20, 0x84, 0x10, 0x40, 0x06, 0x18, 0x62, 0x8A, 0x28,
  0xA4, 0xE0, 0x86, 0x28, 0xA4, 0x91, 0x46, 0x10, 0x40, 0x88, 0x44, 0xA6,
  0x55, 0x2A, 0xA5, 0x53, 0x30, 0x88, 0x04, 0x00, 0x44, 0x48, 0xA1, 0x81,
  0x06, 0x12, 0x24, 0x88, 0x86, 0x25, 0x14, 0x60, 0x84, 0x10, 0x40, 0x3C,
  0x10, 0x84, 0x10, 0x84, 0x10, 0xF0, 0x09, 0x24, 0x94, 0x92, 0x40, 0xAA,
  0x55, 0x50, 0x01, 0x22, 0x22, 0x22, 0x24, 0x44, 0x4A, 0x90, 0x70, 0xC0,
  0x32, 0x42, 0xD8, 0xCB, 0x80, 0x02, 0x1E, 0x94, 0xA6, 0x31, 0xF0, 0x3A,
  0x61, 0x08, 0x41, 0xC0, 0x04, 0x13, 0x52, 0x8A, 0x28, 0xA2, 0x70, 0x3A,
  0x6F, 0x08, 0x41, 0xC0, 0x49, 0x49, 0x24, 0x00, 0x32, 0x63, 0x18, 0xC5,
  0xC2, 0xE0, 0x02, 0x1E, 0x94, 0xA6, 0x31, 0x80, 0x01, 0x56, 0xA0, 0x00,
  0x01, 0x11, 0x12, 0x22, 0x24, 0x02, 0x12, 0xA6, 0x32, 0x92, 0x90, 0x15,
  0x56, 0x80, 0x7F, 0x49, 0x49, 0x89, 0x89, 0x89, 0x81, 0x7A, 0x52, 0x98,
  0xC6, 0x00, 0x3A, 0x63, 0x18, 0xC5, 0xC0, 0x7A, 0x53, 0x18, 0xC7, 0xD0,
  0x00, 0x32, 0x63, 0x18, 0xC5, 0xC2, 0x10, 0x64, 0x44, 0x88, 0x80, 0x72,
  0x50, 0x41, 0x49, 0x80, 0x2A, 0xAA, 0x89, 0x99, 0x9A, 0xE0, 0x19, 0xAA,
  0xC4, 0x00, 0x11, 0x2A, 0xD6, 0xAD, 0x91, 0x20, 0x00, 0x4A, 0x88, 0x46,
  0x2A, 0x40, 0x0A, 0x54, 0xA6, 0x11, 0x08, 0x80, 0x38, 0x84, 0x44, 0x43,
  0x80, 0x12, 0x22, 0x44, 0x44, 0x44, 0x44, 0x15, 0x56, 0xA8, 0x21, 0x12,
  0x21, 0x22, 0x22, 0x48, 0xC1, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 2, 0, -9 },
  { 4, 2, 3, 3, 1, -9 },
  { 5, 6, 9, 6, 0, -9 },
  { 12, 5, 11, 6, 0, -10 },
  { 19, 6, 9, 8, 1, -9 },
  { 26, 6, 9, 6, 0, -9 },
  { 33, 1, 3, 2, 1, -9 },
  { 34, 3, 13, 3, 1, -10 },
  { 39, 4, 13, 3, -1, -10 },
  { 46, 4, 5, 5, 1, -9 },
  { 49, 4, 6, 6, 1, -7 },
  { 52, 1, 3, 2, 0, -1 },
  { 53, 3, 1, 3, 0, -5 },
  { 54, 1, 1, 3, 0, -1 },
  { 55, 4, 10, 4, 0, -9 },
  { 60, 4, 9, 6, 1, -9 },
  { 65, 2, 9, 6, 2, -9 },
  { 68, 5, 9, 6, 0, -9 },
  { 74, 5, 9, 6, 0, -9 },
  { 80, 5, 9, 6, 0, -9 },
  { 86, 5, 9, 6, 1, -9 },
  { 92, 4, 9, 6, 1, -9 },
  { 97, 5, 9, 6, 1, -9 },
  { 103, 5, 9, 6, 0, -9 },
  { 109, 4, 9, 6, 1, -9 },
  { 114, 2, 7, 2, 0, -7 },
  { 116, 2, 9, 2, 0, -7 },
  { 119, 4, 5, 5, 1, -6 },
  { 122, 4, 2, 6, 1, -5 },
  { 123, 5, 5, 5, 0, -6 },
  { 127, 4, 9, 5, 1, -9 },
  { 132, 9, 11, 9, 0, -8 },
  { 145, 5, 9, 6, 0, -9 },
  { 151, 6, 9, 6, 0, -9 },
  { 158, 5, 9, 7, 1, -9 },
  { 164, 6, 9, 7, 0, -9 },
  { 171, 6, 9, 6, 0, -9 },
  { 178, 6, 9, 6, 0, -9 },
  { 185, 6, 9, 7, 1, -9 },
  { 192, 7, 9, 7, 0, -9 },
  { 200, 2, 9, 3, 1, -9 },
  { 203, 6, 9, 6, 0, -9 },
  { 210, 7, 9, 6, 0, -9 },
  { 218, 4, 9, 5, 0, -9 },
  { 223, 9, 9, 9, 0, -9 },
  { 234, 7, 9, 7, 0, -9 },
  { 242, 5, 9, 7, 1, -9 },
  { 248, 6, 9, 6, 0, -9 },
  { 255, 5, 11, 7, 1, -9 },
  { 262, 6, 9, 7, 0, -9 },
  { 269, 6, 9, 6, 0, -9 },
  { 276, 6, 9, 6, 1, -9 },
  { 283, 6, 9, 7, 1, -9 },
  { 290, 6, 9, 6, 1, -9 },
  { 297, 9, 9, 9, 1, -9 },
  { 308, 7, 9, 6, 0, -9 },
  { 316, 6, 9, 6, 1, -9 },
  { 323, 6, 9, 6, 0, -9 },
  { 330, 3, 12, 2, 0, -10 },
  { 335, 2, 10, 4, 1, -9 },
  { 338, 4, 12, 2, -1, -10 },
  { 344, 3, 4, 4, 1, -9 },
  { 346, 5, 1, 4, -1, 0 },
  { 347, 1, 2, 3, 2, -9 },
  { 348, 5, 7, 5, 0, -7 },
  { 353, 5, 9, 6, 0, -9 },
  { 359, 5, 7, 5, 0, -7 },
  { 364, 6, 9, 6, 0, -9 },
  { 371, 5, 7, 5, 0, -7 },
  { 376, 3, 9, 3, 1, -9 },
  { 380, 5, 9, 6, 0, -7 },
  { 386, 5, 9, 6, 0, -9 },
  { 392, 2, 10, 2, 0, -10 },
  { 395, 4, 12, 2, -2, -10 },
  { 401, 5, 9, 5, 0, -9 },
  { 407, 2, 9, 2, 0, -9 },
  { 410, 8, 7, 9, 0, -7 },
  { 417, 5, 7, 6, 0, -7 },
  { 422, 5, 7, 6, 0, -7 },
  { 427, 5, 9, 6, 0, -7 },
  { 433, 5, 9, 6, 0, -7 },
  { 439, 4, 7, 4, 0, -7 },
  { 443, 5, 7, 5, 0, -7 },
  { 448, 2, 8, 3, 1, -8 },
  { 450, 4, 7, 6, 1, -7 },
  { 454, 4, 7, 5, 1, -7 },
  { 458, 7, 7, 8, 1, -7 },
  { 465, 5, 7, 5, 0, -7 },
  { 470, 5, 9, 5, 0, -7 },
  { 476, 5, 7, 5, 0, -7 },
  { 481, 4, 12, 3, 0, -9 },
  { 487, 2, 11, 2, 0, -9 },
  { 490, 4, 12, 3, -1, -9 },
  { 496, 5, 2, 7, 1, -5 },
};

const GFXfont RobotoCondensed_ExtraLightItalic12pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic12pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC12PT7B_H_
