#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC51PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10,
  0x10, 0x30, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0,
  0xE0, 0x31, 0x98, 0xCC, 0x66, 0x32, 0x1B, 0x09, 0x8C, 0xC6, 0x63, 0x21,
  0x90, 0x80, 0x00, 0x02, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x60,
  0x00, 0x10, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x08, 0x00, 0x04, 0x06, 0x00, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x00, 0x20, 0x30, 0x00, 0x18, 0x0C, 0x00,
  0x06, 0x02, 0x00, 0x01, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x10,
  0x00, 0x08, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0x80, 0x00, 0x60,
  0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x04, 0x00, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x00, 0x60, 0x20, 0x00, 0x18, 0x18, 0x00, 0x04, 0x06, 0x00,
  0x03, 0x01, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x20, 0x30, 0x00, 0x18, 0x08,
  0x00, 0x06, 0x06, 0x00, 0x01, 0x01, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x38, 0x1C, 0x03, 0x80, 0x70, 0x38,
  0x01, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C,
  0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x70, 0xC0, 0x03, 0x06, 0x00, 0x38,
  0x38, 0x03, 0x80, 0xE0, 0x38, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xC1, 0x80, 0x01, 0x81, 0x00, 0x06,
  0x02, 0x00, 0x88, 0x06, 0x01, 0x30, 0x0C, 0x06, 0x60, 0x18, 0x18, 0xC0,
  0x20, 0x61, 0x80, 0x40, 0xC2, 0x01, 0x83, 0x04, 0x03, 0x0C, 0x0C, 0x04,
  0x10, 0x18, 0x18, 0x60, 0x18, 0x61, 0x80, 0x3F, 0x86, 0x00, 0x3E, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x07, 0xC0, 0x06, 0x1F,
  0xC0, 0x18, 0x60, 0xC0, 0x61, 0x81, 0x80, 0xC2, 0x01, 0x03, 0x0C, 0x02,
  0x0C, 0x18, 0x04, 0x10, 0x20, 0x08, 0x60, 0x40, 0x31, 0x80, 0x80, 0x66,
  0x03, 0x00, 0xCC, 0x02, 0x01, 0x30, 0x04, 0x06, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0x80, 0x01, 0xC3, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x30,
  0x04, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x30, 0x01, 0x00, 0x60, 0x02, 0x01,
  0x80, 0x04, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x31, 0xC0,
  0x00, 0x37, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0xE1, 0x80, 0x63, 0x81, 0x80, 0xC6,
  0x03, 0x01, 0x98, 0x03, 0x06, 0x30, 0x06, 0x0C, 0xC0, 0x06, 0x19, 0x80,
  0x0E, 0x63, 0x00, 0x0C, 0xC6, 0x00, 0x0F, 0x0C, 0x00, 0x1E, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x70, 0x30, 0x01, 0xB0, 0x70, 0x0E, 0x70, 0x78, 0x78,
  0x60, 0x7F, 0xC0, 0x60, 0x08, 0x00, 0x00, 0x33, 0x26, 0x66, 0x64, 0x4C,
  0xC0, 0x00, 0x08, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x2F, 0x06,
  0x0E, 0x7C, 0x67, 0xC0, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x33, 0x00, 0x06, 0x30, 0x00, 0xC1, 0x80, 0x18, 0x1C, 0x03,
  0x80, 0xC0, 0x70, 0x06, 0x02, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0xC3, 0x18, 0x61, 0x8C, 0x71, 0x84,
  0x00, 0xFF, 0xFF, 0xE0, 0x6F, 0x60, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x70, 0x38, 0x07, 0x00, 0xC0,
  0x30, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC1, 0x80, 0x02, 0x0C, 0x00,
  0x10, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x00, 0x01, 0x18,
  0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80,
  0x01, 0x8C, 0x00, 0x0C, 0x40, 0x00, 0xC2, 0x00, 0x06, 0x10, 0x00, 0x30,
  0x80, 0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0xC1, 0x80, 0x0C, 0x0C, 0x00,
  0xC0, 0x30, 0x0E, 0x01, 0xC0, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x60, 0x3C, 0x3F, 0x9E, 0x2F, 0x0D, 0x81, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x38, 0x1C, 0x03, 0x00,
  0x60, 0x30, 0x03, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x61, 0x80, 0x03, 0x0C,
  0x00, 0x18, 0x60, 0x00, 0xC2, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x0E, 0x07, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x18, 0x1C, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x02, 0x0C,
  0x00, 0x08, 0x30, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x61, 0x80, 0x01,
  0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x03, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x60, 0x38, 0x03, 0x80, 0x70, 0x1C, 0x00, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0x98, 0x00, 0x0C, 0xC0, 0x00,
  0xCC, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x06, 0x18, 0x00, 0x60, 0xC0,
  0x06, 0x06, 0x00, 0x30, 0x60, 0x03, 0x03, 0x00, 0x30, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x01, 0x80, 0x20, 0x18, 0x03, 0x01, 0xC0, 0x18, 0x0C,
  0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x63, 0xF0, 0x01, 0xBF, 0xE0, 0x07, 0x81, 0xC0, 0x18,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00,
  0x06, 0x06, 0x00, 0x30, 0x18, 0x01, 0xC0, 0x70, 0x06, 0x00, 0xE0, 0x70,
  0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x87,
  0xE0, 0x33, 0xFE, 0x0C, 0xC0, 0xE1, 0xB0, 0x0E, 0x3C, 0x00, 0xC7, 0x00,
  0x0D, 0xC0, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00,
  0x1B, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x0D, 0x00, 0x03, 0x30, 0x00,
  0x66, 0x00, 0x0C, 0xC0, 0x03, 0x18, 0x00, 0x61, 0x80, 0x18, 0x38, 0x06,
  0x03, 0x81, 0xC0, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0x80, 0x0E, 0x07, 0x00, 0x70, 0x0E, 0x03, 0x80, 0x18, 0x0C, 0x00, 0x30,
  0x60, 0x00, 0xC1, 0x80, 0x03, 0x04, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0xC3, 0x00, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x70, 0x06,
  0x00, 0xE0, 0x70, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x70, 0x38, 0x03,
  0x80, 0x30, 0x18, 0x00, 0xE0, 0xE0, 0x01, 0x83, 0x00, 0x06, 0x18, 0x00,
  0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC4, 0x00, 0x03, 0x30, 0x00, 0x18,
  0x40, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x30,
  0x03, 0x80, 0x70, 0x3C, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0x80, 0x70, 0x70, 0x30, 0x06, 0x18, 0x01, 0x8C, 0x00, 0x33,
  0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x39, 0x80, 0x1E, 0x60, 0x0D, 0x8E, 0x0E, 0x61,
  0xFF, 0x10, 0x3F, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x01, 0xE0, 0x0F, 0xF0, 0x03, 0xE0, 0x00, 0x0E, 0x1C, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0xE1, 0xC0, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x30,
  0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x07, 0x01, 0x80, 0x40, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x10, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x07, 0xFC, 0x0E, 0x0C, 0x18, 0x06, 0x30, 0x06, 0x30, 0x02,
  0x60, 0x03, 0x60, 0x03, 0x40, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x01,
  0x03, 0x00, 0x1F, 0x00, 0x30, 0xC0, 0x0F, 0xF0, 0x06, 0x18, 0x03, 0x03,
  0x00, 0xC6, 0x00, 0xC0, 0x20, 0x18, 0xC0, 0x30, 0x0C, 0x03, 0x30, 0x0C,
  0x01, 0x80, 0x66, 0x01, 0x80, 0x30, 0x0C, 0x80, 0x60, 0x04, 0x01, 0xB0,
  0x0C, 0x01, 0x80, 0x36, 0x01, 0x00, 0x30, 0x04, 0xC0, 0x60, 0x06, 0x00,
  0x90, 0x0C, 0x00, 0x80, 0x36, 0x01, 0x00, 0x30, 0x06, 0xC0, 0x60, 0x06,
  0x00, 0xD8, 0x0C, 0x00, 0xC0, 0x13, 0x01, 0x80, 0x10, 0x06, 0x60, 0x30,
  0x06, 0x00, 0xCC, 0x06, 0x00, 0xC0, 0x11, 0x00, 0x80, 0x38, 0x06, 0x20,
  0x18, 0x07, 0x00, 0x86, 0x03, 0x01, 0x60, 0x30, 0xC0, 0x60, 0x6C, 0x0C,
  0x18, 0x06, 0x38, 0xC7, 0x03, 0x00, 0xFC, 0x0F, 0xC0, 0x60, 0x00, 0x00,
  0x40, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x40, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x30, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x82, 0x00, 0x01, 0x81, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x60, 0x18,
  0x00, 0x30, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x18, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x04, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x01, 0x80, 0x01, 0x01, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0x98, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x30, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0C, 0x00, 0xE0,
  0x30, 0x00, 0xE0, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x83,
  0x00, 0x03, 0x04, 0x00, 0x06, 0x18, 0x00, 0x08, 0x30, 0x00, 0x30, 0x60,
  0x00, 0x60, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x02, 0x00, 0x1C, 0x0C, 0x00,
  0x70, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x60, 0x07, 0x80, 0xC0, 0x03,
  0x03, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x18, 0x60, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0x86,
  0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x18, 0x20, 0x00, 0x70, 0xC0,
  0x01, 0xC1, 0x80, 0x0F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x38, 0x03, 0x80, 0x0C, 0x03,
  0x00, 0x0E, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x70, 0x00, 0xC0, 0x30,
  0x01, 0x80, 0x1C, 0x07, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x03, 0x80,
  0x60, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x04, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x83, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80,
  0x80, 0x01, 0xC0, 0xC0, 0x03, 0x80, 0x60, 0x07, 0x80, 0x3F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x38, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x30, 0x00,
  0x70, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x02, 0x0C, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x01, 0xFF, 0xC6,
  0x00, 0xFF, 0xE3, 0x00, 0x00, 0x31, 0x80, 0x00, 0x31, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x86, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x70, 0x38, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x18, 0x08, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x18, 0x00, 0x01, 0x01, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x01, 0x81, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C,
  0x00, 0x30, 0x18, 0x01, 0x80, 0x60, 0x0E, 0x00, 0xE0, 0x70, 0x01, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x0C,
  0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x04, 0x00, 0xC0, 0x01, 0x80,
  0x30, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x18, 0x30, 0x00, 0x02, 0x0E, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x18, 0xE0,
  0x00, 0x03, 0x3E, 0x00, 0x00, 0x6C, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x03,
  0xC1, 0x80, 0x00, 0x70, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x30,
  0x02, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x06, 0x03, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x0F, 0x06, 0x80, 0x00, 0x06, 0xC1, 0xB0, 0x00, 0x01,
  0xA0, 0x6C, 0x00, 0x00, 0xD8, 0x1B, 0x00, 0x00, 0x36, 0x04, 0xC0, 0x00,
  0x19, 0x83, 0x30, 0x00, 0x06, 0x60, 0xC4, 0x00, 0x03, 0x10, 0x31, 0x80,
  0x00, 0xCC, 0x0C, 0x60, 0x00, 0x63, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x86,
  0x00, 0x0C, 0x30, 0x60, 0x80, 0x02, 0x0C, 0x18, 0x20, 0x01, 0x82, 0x06,
  0x0C, 0x00, 0xC1, 0x81, 0x83, 0x00, 0x30, 0x60, 0x60, 0xC0, 0x18, 0x18,
  0x30, 0x30, 0x06, 0x06, 0x0C, 0x04, 0x03, 0x01, 0x83, 0x01, 0x80, 0xC0,
  0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x0C,
  0x03, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x21, 0x80, 0x30, 0x60, 0x0C,
  0x60, 0x18, 0x18, 0x03, 0x30, 0x06, 0x06, 0x00, 0xCC, 0x01, 0x81, 0x80,
  0x36, 0x00, 0x60, 0xC0, 0x05, 0x80, 0x18, 0x30, 0x01, 0xC0, 0x04, 0x0C,
  0x00, 0x60, 0x03, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x03, 0x03, 0x80, 0x00, 0x20, 0x78, 0x00, 0x06, 0x06, 0xC0,
  0x00, 0x60, 0x6C, 0x00, 0x06, 0x06, 0x40, 0x00, 0x60, 0x66, 0x00, 0x06,
  0x06, 0x60, 0x00, 0xC0, 0xC3, 0x00, 0x0C, 0x0C, 0x30, 0x00, 0xC0, 0xC3,
  0x00, 0x0C, 0x0C, 0x18, 0x00, 0xC0, 0xC1, 0x80, 0x0C, 0x0C, 0x08, 0x01,
  0x81, 0x80, 0xC0, 0x18, 0x18, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x18, 0x18,
  0x06, 0x01, 0x81, 0x80, 0x20, 0x18, 0x30, 0x03, 0x03, 0x03, 0x00, 0x30,
  0x30, 0x30, 0x01, 0x83, 0x03, 0x00, 0x18, 0x30, 0x30, 0x01, 0x83, 0x03,
  0x00, 0x0C, 0x60, 0x60, 0x00, 0xC6, 0x06, 0x00, 0x04, 0x60, 0x60, 0x00,
  0x66, 0x06, 0x00, 0x06, 0x60, 0x60, 0x00, 0x36, 0x06, 0x00, 0x03, 0xC0,
  0xC0, 0x00, 0x3C, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x3C, 0x03,
  0x80, 0x0C, 0x07, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x60, 0x60,
  0x00, 0xE0, 0x30, 0x01, 0xC0, 0x1C, 0x07, 0x80, 0x0F, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0x00, 0x1C, 0x06,
  0x00, 0x0E, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x0E, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x18, 0x00, 0xF0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x38, 0x03,
  0x80, 0x0C, 0x07, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30,
  0x00, 0x03, 0x30, 0x00, 0x03, 0x20, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x60, 0x60,
  0x00, 0xE0, 0x30, 0x01, 0xC0, 0x1C, 0x07, 0x80, 0x0F, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x02, 0x00, 0x3C, 0x06, 0x00, 0x0C, 0x06,
  0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x30, 0x18, 0x00, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x20, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0x60, 0x00, 0xE0, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3C, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x38, 0x00, 0x60, 0x38, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x0F, 0x01, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60,
  0x00, 0x0C, 0x30, 0x00, 0x04, 0x18, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x20,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x03, 0x81, 0x80, 0x01,
  0x80, 0xC0, 0x01, 0x80, 0x30, 0x01, 0xC0, 0x1E, 0x03, 0xC0, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x70, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0x80, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x01,
  0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0x80, 0x60, 0x00, 0x60,
  0x30, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x06,
  0x0C, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x86, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x19, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x03, 0x60,
  0x00, 0xF0, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x0D, 0x80, 0x02, 0xC0, 0x03,
  0x30, 0x00, 0xC8, 0x00, 0x66, 0x00, 0x19, 0x00, 0x0C, 0x40, 0x06, 0x20,
  0x03, 0x0C, 0x00, 0xC4, 0x00, 0x61, 0x80, 0x10, 0xC0, 0x18, 0x30, 0x06,
  0x18, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x18,
  0x06, 0x0C, 0x03, 0x03, 0x00, 0x81, 0x80, 0x60, 0x60, 0x30, 0x30, 0x18,
  0x0C, 0x06, 0x06, 0x03, 0x01, 0x81, 0x80, 0x40, 0xC0, 0x30, 0x30, 0x08,
  0x18, 0x06, 0x0C, 0x01, 0x03, 0x00, 0xC1, 0x80, 0x20, 0xC0, 0x18, 0x30,
  0x06, 0x18, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x18, 0xC0, 0x04,
  0x60, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x62, 0x00, 0x19, 0x80, 0x0C, 0xC0,
  0x03, 0x60, 0x01, 0x98, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x0D, 0x00, 0x02,
  0xC0, 0x01, 0xE0, 0x00, 0x58, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x18, 0x01,
  0x80, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x01, 0xC0, 0x01, 0x80,
  0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x07, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x03, 0x80, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x60, 0x1C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x38, 0x70, 0x00, 0x30, 0x30, 0x00, 0x60, 0x30, 0x00, 0xE0, 0x30,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x00, 0x0C,
  0x06, 0x00, 0x0C, 0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x02, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60,
  0x20, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x10, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x02, 0x03, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x12, 0x01, 0x90, 0x08, 0xC0, 0xC6, 0x04, 0x30, 0x61,
  0x82, 0x0C, 0x30, 0x21, 0x01, 0x98, 0x0D, 0x80, 0x6C, 0x03, 0xC0, 0x1E,
  0x00, 0x40, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0xC1, 0x86, 0x0C, 0x30, 0x60,
  0x80, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0E, 0x07, 0x03, 0x00, 0x70, 0xC0,
  0x06, 0x18, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x1F, 0xFC, 0x0F, 0xFF, 0x87, 0x80,
  0x31, 0xC0, 0x06, 0x70, 0x00, 0xCC, 0x00, 0x13, 0x00, 0x06, 0x60, 0x00,
  0xCC, 0x00, 0x19, 0x80, 0x07, 0x30, 0x01, 0xE7, 0x00, 0x78, 0x70, 0x3B,
  0x07, 0xFC, 0x60, 0x7E, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x61, 0xF8,
  0x04, 0x7F, 0xC0, 0xDC, 0x0E, 0x0F, 0x00, 0x70, 0xE0, 0x03, 0x0C, 0x00,
  0x30, 0xC0, 0x03, 0x08, 0x00, 0x11, 0x80, 0x01, 0x18, 0x00, 0x11, 0x80,
  0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x10, 0x00, 0x33, 0x00, 0x03, 0x30,
  0x00, 0x33, 0x00, 0x02, 0x30, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0x66,
  0x00, 0x0C, 0x60, 0x00, 0xC7, 0x00, 0x18, 0x78, 0x03, 0x84, 0xC0, 0x70,
  0xC7, 0xFE, 0x0C, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1C, 0x0E,
  0x06, 0x00, 0xE1, 0x80, 0x0C, 0x70, 0x01, 0x8C, 0x00, 0x19, 0x00, 0x03,
  0x60, 0x00, 0x6C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x06, 0x60, 0x00, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01, 0x83,
  0x00, 0x60, 0x70, 0x1C, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x3F, 0x0C, 0x03, 0xFE, 0x30, 0x1C, 0x0C,
  0xC0, 0xE0, 0x1B, 0x07, 0x00, 0x3C, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x83,
  0x00, 0x06, 0x08, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x06, 0x00,
  0x0C, 0x18, 0x00, 0x30, 0x40, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0x60, 0xC0, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0xF0, 0x0C, 0x06,
  0xC0, 0x3F, 0xF3, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8,
  0x03, 0x81, 0xC0, 0x60, 0x0E, 0x0C, 0x00, 0x61, 0xC0, 0x06, 0x18, 0x00,
  0x23, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x27, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE6, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x30, 0x1C, 0x0F, 0x00, 0xFF, 0xC0,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0x88, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0x0C, 0x03, 0xFE, 0x30, 0x1C,
  0x0C, 0xC0, 0xC0, 0x1B, 0x07, 0x00, 0x3C, 0x18, 0x00, 0x60, 0xC0, 0x01,
  0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x06,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0x40, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00,
  0x0C, 0x30, 0x00, 0x20, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0x60, 0xC0, 0x03, 0x81, 0x80, 0x1C, 0x06, 0x00, 0xF0, 0x0C,
  0x06, 0xC0, 0x3F, 0xF3, 0x00, 0x3F, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x40, 0x03, 0x01,
  0x80, 0x18, 0x03, 0x01, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x61, 0xF8, 0x06, 0x7F, 0xC0, 0xCE, 0x0E, 0x0D, 0x80,
  0x60, 0xD0, 0x03, 0x0E, 0x00, 0x30, 0xE0, 0x03, 0x0C, 0x00, 0x31, 0xC0,
  0x03, 0x18, 0x00, 0x31, 0x80, 0x02, 0x18, 0x00, 0x61, 0x80, 0x06, 0x10,
  0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x04, 0x30, 0x00, 0xC3,
  0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x08,
  0x60, 0x01, 0x86, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0x03, 0x81,
  0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x04, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0xFC, 0x00,
  0xF0, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x60, 0x06,
  0x06, 0x00, 0x60, 0x30, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x06, 0x00, 0x60,
  0x60, 0x02, 0x06, 0x00, 0x30, 0x60, 0x01, 0x86, 0x00, 0x0C, 0x60, 0x00,
  0x66, 0x00, 0x03, 0x70, 0x00, 0x16, 0xC0, 0x01, 0xE7, 0x00, 0x0E, 0x18,
  0x00, 0x60, 0xE0, 0x03, 0x03, 0x00, 0x18, 0x1C, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x70, 0x18, 0x01, 0x80, 0xC0, 0x0E,
  0x0C, 0x00, 0x30, 0x60, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02,
  0x00, 0x04, 0x1F, 0x00, 0x7E, 0x03, 0x1F, 0xF0, 0x7F, 0xE0, 0xCC, 0x0E,
  0x38, 0x18, 0x36, 0x01, 0x98, 0x03, 0x0F, 0x00, 0x64, 0x00, 0xC3, 0x80,
  0x0F, 0x00, 0x30, 0xE0, 0x03, 0x80, 0x0C, 0x70, 0x00, 0xC0, 0x03, 0x18,
  0x00, 0x30, 0x00, 0xC6, 0x00, 0x0C, 0x00, 0x31, 0x80, 0x06, 0x00, 0x0C,
  0x60, 0x01, 0x80, 0x03, 0x10, 0x00, 0x60, 0x00, 0xCC, 0x00, 0x18, 0x00,
  0x23, 0x00, 0x06, 0x00, 0x18, 0xC0, 0x01, 0x00, 0x06, 0x30, 0x00, 0xC0,
  0x01, 0x8C, 0x00, 0x30, 0x00, 0x66, 0x00, 0x0C, 0x00, 0x19, 0x80, 0x03,
  0x00, 0x0C, 0x60, 0x00, 0xC0, 0x03, 0x18, 0x00, 0x20, 0x00, 0xC6, 0x00,
  0x18, 0x00, 0x31, 0x80, 0x06, 0x00, 0x0C, 0xC0, 0x01, 0x80, 0x03, 0x30,
  0x00, 0x60, 0x01, 0x8C, 0x00, 0x18, 0x00, 0x60, 0x06, 0x1F, 0x80, 0x47,
  0xFC, 0x0C, 0xE0, 0xE0, 0xD8, 0x06, 0x0D, 0x00, 0x30, 0xE0, 0x03, 0x0E,
  0x00, 0x30, 0xC0, 0x03, 0x1C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x21,
  0x80, 0x06, 0x18, 0x00, 0x61, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06,
  0x30, 0x00, 0x43, 0x00, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00,
  0xC6, 0x00, 0x0C, 0x60, 0x00, 0x86, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00,
  0x18, 0xC0, 0x01, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0x01, 0xC0,
  0xE0, 0x0C, 0x1C, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0x63, 0x00, 0x02,
  0x30, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x26, 0x00, 0x02, 0x40, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00,
  0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x38, 0x60,
  0x03, 0x07, 0x00, 0x60, 0x38, 0x1C, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00,
  0x01, 0x87, 0xE0, 0x04, 0x7F, 0xC0, 0x37, 0x03, 0x80, 0xF0, 0x07, 0x03,
  0x80, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x80, 0x01, 0x06, 0x00,
  0x04, 0x18, 0x00, 0x10, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x08, 0x30,
  0x00, 0x60, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x30, 0x60, 0x00,
  0xC1, 0xC0, 0x06, 0x07, 0x80, 0x38, 0x13, 0x01, 0xC0, 0xC7, 0xFE, 0x03,
  0x07, 0xE0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x30, 0x3F, 0xE3, 0x07,
  0x03, 0x30, 0xE0, 0x0B, 0x1C, 0x00, 0xE1, 0x80, 0x06, 0x30, 0x00, 0x63,
  0x00, 0x06, 0x30, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x46, 0x00, 0x0C,
  0x60, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00,
  0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00,
  0x38, 0x60, 0x03, 0x06, 0x00, 0xF0, 0x30, 0x1B, 0x03, 0xFF, 0x30, 0x0F,
  0xC3, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x06, 0x3E, 0x08, 0xFC, 0x33, 0x00, 0x6C, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1C,
  0x06, 0x07, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xCC, 0x00, 0x11, 0x80, 0x06, 0x30, 0x00,
  0xC3, 0x00, 0x30, 0x30, 0x1C, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x07, 0xFF, 0xFF, 0xE1,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x7E, 0x07, 0xC0, 0x18, 0x00,
  0x66, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x04, 0x60, 0x01,
  0x8C, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x11, 0x80, 0x06,
  0x30, 0x00, 0xC4, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x08,
  0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x71,
  0x80, 0x0C, 0x30, 0x03, 0x86, 0x00, 0xF0, 0x60, 0x76, 0x0F, 0xFC, 0xC0,
  0x7E, 0x00, 0x00, 0xC0, 0x00, 0xD8, 0x00, 0x19, 0x00, 0x06, 0x30, 0x00,
  0xC6, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x30, 0x60, 0x06,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x60,
  0x0C, 0x0C, 0x00, 0x83, 0x00, 0x18, 0x60, 0x03, 0x08, 0x00, 0x63, 0x00,
  0x0C, 0x60, 0x01, 0x98, 0x00, 0x13, 0x00, 0x02, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x36,
  0x00, 0x30, 0x01, 0xB0, 0x03, 0x80, 0x1D, 0x80, 0x1C, 0x00, 0xCC, 0x01,
  0xA0, 0x06, 0x60, 0x0D, 0x80, 0x63, 0x00, 0x4C, 0x03, 0x08, 0x06, 0x60,
  0x30, 0x40, 0x33, 0x01, 0x82, 0x03, 0x18, 0x0C, 0x18, 0x18, 0xC0, 0xC0,
  0xC1, 0x86, 0x06, 0x06, 0x0C, 0x30, 0x60, 0x30, 0xC1, 0x83, 0x01, 0x86,
  0x04, 0x18, 0x0C, 0x20, 0x21, 0x80, 0x63, 0x01, 0x0C, 0x03, 0x18, 0x0C,
  0xC0, 0x19, 0x80, 0x66, 0x00, 0xCC, 0x03, 0x30, 0x06, 0xC0, 0x1B, 0x00,
  0x36, 0x00, 0xD8, 0x01, 0xA0, 0x06, 0x80, 0x07, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x1C, 0x1C, 0x00, 0x60, 0x30, 0x03, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x60,
  0x06, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xE0, 0x00, 0xC3, 0x00, 0x01,
  0x98, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x30, 0x00,
  0x38, 0x60, 0x00, 0xC1, 0x80, 0x06, 0x06, 0x00, 0x30, 0x0C, 0x01, 0xC0,
  0x30, 0x06, 0x00, 0x60, 0x30, 0x01, 0x81, 0xC0, 0x07, 0x0E, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00,
  0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x30, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80,
  0xC0, 0x01, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC3,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x58, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x00, 0x01, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x20, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x00, 0x80,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x00, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x02, 0x38, 0x60,
  0x02, 0x60, 0x30, 0x06, 0x60, 0x18, 0x06, 0x40, 0x1C, 0x0C, 0xC0, 0x0E,
  0x18, 0xC0, 0x07, 0xF8, 0x00, 0x01, 0xE0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 36, 10, 1, -36 },
  { 37, 9, 11, 13, 5, -38 },
  { 50, 26, 36, 25, 1, -36 },
  { 167, 21, 46, 24, 2, -41 },
  { 288, 23, 36, 32, 5, -36 },
  { 392, 23, 37, 27, 1, -36 },
  { 499, 4, 11, 8, 5, -38 },
  { 505, 14, 53, 14, 3, -41 },
  { 598, 14, 52, 14, -3, -40 },
  { 689, 20, 20, 21, 3, -36 },
  { 739, 21, 26, 24, 2, -30 },
  { 808, 6, 11, 9, -2, -4 },
  { 817, 10, 2, 13, 2, -17 },
  { 820, 4, 3, 11, 1, -3 },
  { 822, 21, 39, 17, -2, -36 },
  { 925, 21, 36, 24, 2, -36 },
  { 1020, 11, 36, 24, 7, -36 },
  { 1070, 21, 36, 24, 1, -36 },
  { 1165, 22, 36, 24, 1, -36 },
  { 1264, 21, 36, 24, 1, -36 },
  { 1359, 22, 36, 24, 3, -36 },
  { 1458, 19, 36, 24, 2, -36 },
  { 1544, 21, 36, 24, 4, -36 },
  { 1639, 22, 36, 24, 1, -36 },
  { 1738, 18, 36, 24, 4, -36 },
  { 1819, 7, 26, 9, 1, -26 },
  { 1842, 10, 33, 9, -2, -26 },
  { 1884, 19, 21, 22, 2, -27 },
  { 1934, 19, 12, 24, 3, -23 },
  { 1963, 20, 21, 23, 1, -27 },
  { 2016, 16, 36, 20, 4, -36 },
  { 2088, 35, 46, 39, 2, -35 },
  { 2290, 25, 36, 27, -2, -36 },
  { 2403, 23, 36, 26, 2, -36 },
  { 2507, 24, 36, 28, 3, -36 },
  { 2615, 25, 36, 28, 2, -36 },
  { 2728, 24, 36, 25, 2, -36 },
  { 2836, 25, 36, 25, 2, -36 },
  { 2949, 25, 36, 30, 3, -36 },
  { 3062, 28, 36, 30, 2, -36 },
  { 3188, 9, 36, 12, 2, -36 },
  { 3229, 22, 36, 24, 1, -36 },
  { 3328, 27, 36, 27, 2, -36 },
  { 3450, 17, 36, 23, 2, -36 },
  { 3527, 34, 36, 37, 2, -36 },
  { 3680, 28, 36, 31, 2, -36 },
  { 3806, 24, 36, 29, 3, -36 },
  { 3914, 24, 36, 26, 2, -36 },
  { 4022, 24, 43, 29, 3, -36 },
  { 4151, 24, 36, 28, 2, -36 },
  { 4259, 25, 36, 26, 1, -36 },
  { 4372, 23, 36, 26, 5, -36 },
  { 4476, 25, 36, 29, 3, -36 },
  { 4589, 25, 36, 26, 4, -36 },
  { 4702, 35, 36, 39, 5, -36 },
  { 4860, 29, 36, 26, -1, -36 },
  { 4991, 24, 36, 26, 5, -36 },
  { 5099, 27, 36, 26, 0, -36 },
  { 5221, 14, 49, 10, 0, -41 },
  { 5307, 8, 39, 17, 5, -36 },
  { 5346, 14, 49, 10, -3, -41 },
  { 5432, 13, 18, 18, 3, -36 },
  { 5462, 18, 2, 19, -2, 0 },
  { 5467, 6, 7, 14, 7, -39 },
  { 5473, 19, 27, 23, 1, -27 },
  { 5538, 20, 38, 24, 1, -38 },
  { 5633, 19, 27, 22, 2, -27 },
  { 5698, 22, 38, 24, 2, -38 },
  { 5803, 20, 27, 22, 1, -27 },
  { 5871, 15, 39, 14, 3, -39 },
  { 5945, 22, 37, 24, 0, -27 },
  { 6047, 20, 38, 24, 1, -38 },
  { 6142, 9, 37, 10, 1, -37 },
  { 6184, 16, 47, 10, -6, -37 },
  { 6278, 21, 38, 21, 1, -38 },
  { 6378, 9, 38, 10, 1, -38 },
  { 6421, 34, 27, 38, 1, -27 },
  { 6536, 20, 27, 24, 1, -27 },
  { 6604, 20, 27, 24, 2, -27 },
  { 6672, 22, 37, 24, -1, -27 },
  { 6774, 20, 37, 24, 2, -27 },
  { 6867, 15, 27, 15, 1, -27 },
  { 6918, 19, 27, 22, 1, -27 },
  { 6983, 11, 34, 14, 3, -34 },
  { 7030, 19, 27, 24, 3, -27 },
  { 7095, 19, 27, 21, 3, -27 },
  { 7160, 29, 27, 33, 4, -27 },
  { 7258, 22, 27, 21, -1, -27 },
  { 7333, 24, 37, 21, -2, -27 },
  { 7444, 21, 27, 21, 0, -27 },
  { 7515, 16, 51, 15, 2, -40 },
  { 7617, 9, 43, 10, 1, -36 },
  { 7666, 16, 51, 15, -3, -40 },
  { 7768, 24, 9, 30, 3, -20 },
};

const GFXfont RobotoCondensed_ExtraLightItalic51pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic51pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic51pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC51PT7B_H_
