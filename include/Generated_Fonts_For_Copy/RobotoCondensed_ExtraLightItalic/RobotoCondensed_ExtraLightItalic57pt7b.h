#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC57PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x03, 0xC0, 0xE0, 0x10, 0x00, 0x30, 0xCC, 0x33, 0x0C, 0xC6, 0x61,
  0x98, 0x66, 0x19, 0x86, 0x61, 0x90, 0xCC, 0x33, 0x0C, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x18, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x04, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03,
  0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0x0C, 0x06,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x10, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x0C, 0x03, 0x80, 0x0E, 0x03,
  0x00, 0x06, 0x07, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06,
  0x00, 0x06, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xE0,
  0x00, 0x30, 0x60, 0x00, 0x70, 0x60, 0x00, 0x60, 0x70, 0x00, 0xE0, 0x38,
  0x01, 0xC0, 0x1C, 0x07, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x10,
  0x02, 0x18, 0x03, 0x00, 0x63, 0x00, 0x60, 0x18, 0x60, 0x0C, 0x06, 0x0C,
  0x01, 0x00, 0xC1, 0x00, 0x20, 0x30, 0x60, 0x0C, 0x0C, 0x0C, 0x01, 0x81,
  0x81, 0x80, 0x30, 0x60, 0x10, 0x0C, 0x18, 0x03, 0x01, 0x83, 0x00, 0x60,
  0x60, 0xC0, 0x07, 0x38, 0x30, 0x00, 0x7E, 0x06, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x3F, 0x00, 0x06, 0x0E, 0x70, 0x01, 0x83, 0x03,
  0x00, 0x60, 0xC0, 0x60, 0x0C, 0x18, 0x04, 0x03, 0x06, 0x00, 0xC0, 0xC0,
  0xC0, 0x18, 0x18, 0x18, 0x03, 0x06, 0x03, 0x00, 0x41, 0x80, 0x40, 0x08,
  0x30, 0x18, 0x03, 0x0C, 0x03, 0x00, 0x63, 0x00, 0x60, 0x0C, 0x60, 0x04,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x18, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x06,
  0x00, 0xC0, 0x07, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x1C, 0x00, 0xE0, 0x0C, 0x00, 0x60, 0x0E, 0x00, 0x38, 0x06, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x07, 0x00, 0x03, 0x07, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x0C,
  0x01, 0x8C, 0x07, 0x00, 0xCE, 0x01, 0x80, 0xCE, 0x00, 0xE0, 0x66, 0x00,
  0x30, 0x33, 0x00, 0x1C, 0x3B, 0x00, 0x06, 0x19, 0x80, 0x03, 0x8C, 0xC0,
  0x00, 0xCC, 0x60, 0x00, 0x3E, 0x30, 0x00, 0x1E, 0x18, 0x00, 0x06, 0x0E,
  0x00, 0x07, 0x83, 0x00, 0x07, 0xC1, 0xC0, 0x07, 0x70, 0x70, 0x0F, 0x18,
  0x1F, 0xFE, 0x0E, 0x07, 0xFC, 0x03, 0x00, 0x30, 0x00, 0x00, 0x37, 0x66,
  0x66, 0x6E, 0xCC, 0xCC, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x06, 0x03, 0xF8,
  0x30, 0x7C, 0xFC, 0xC7, 0xC0, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x70,
  0x00, 0x03, 0x60, 0x00, 0x1D, 0x80, 0x00, 0xE3, 0x00, 0x07, 0x0E, 0x00,
  0x38, 0x18, 0x01, 0xC0, 0x70, 0x06, 0x00, 0xC0, 0x30, 0x03, 0x80, 0xC0,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x1C, 0x30, 0x60,
  0xC3, 0x86, 0x0C, 0x30, 0xE3, 0x82, 0x00, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x70, 0x1C, 0x03, 0x80, 0x38, 0x0C, 0x00, 0x60,
  0x60, 0x01, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x31, 0x80,
  0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0xE0, 0x00, 0x33, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xD8,
  0x00, 0x07, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00,
  0x06, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C,
  0xC0, 0x00, 0x33, 0x00, 0x01, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0,
  0x00, 0x63, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x60, 0x01,
  0x81, 0x80, 0x0C, 0x07, 0x00, 0x70, 0x0E, 0x03, 0x80, 0x1F, 0x7C, 0x00,
  0x3F, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x0F, 0x03, 0xF1, 0xF7,
  0x7C, 0x6F, 0x06, 0x80, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x0E, 0x01,
  0x80, 0x06, 0x03, 0x80, 0x06, 0x03, 0x00, 0x07, 0x06, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x07,
  0x01, 0xC0, 0x18, 0x01, 0xC0, 0x60, 0x01, 0x81, 0xC0, 0x03, 0x83, 0x00,
  0x03, 0x0E, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x60, 0x00, 0x1C, 0xC0, 0x00,
  0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x0E, 0x00, 0x06,
  0x0C, 0x00, 0x18, 0x1C, 0x00, 0x60, 0x1C, 0x03, 0xC0, 0x1F, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x1C,
  0x00, 0x07, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x30, 0x38, 0x00, 0x60, 0x30, 0x00, 0xE0, 0x30,
  0x00, 0xC0, 0x30, 0x01, 0x80, 0x30, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0x60, 0x1C, 0x00, 0x60, 0x18, 0x00, 0x60,
  0x30, 0x00, 0x60, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x3E, 0x00, 0x0D, 0xFF, 0x80,
  0x0F, 0x83, 0xC0, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x70,
  0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x30, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x61, 0xF8, 0x06, 0x3F, 0xF0, 0x33, 0x81, 0xC1,
  0xB0, 0x07, 0x1F, 0x00, 0x18, 0xF0, 0x00, 0xE7, 0x00, 0x03, 0x38, 0x00,
  0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0xD8, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x38, 0x00, 0x30, 0xC0,
  0x03, 0x87, 0x00, 0x18, 0x18, 0x01, 0xC0, 0xE0, 0x1C, 0x03, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x0E, 0x00, 0x38, 0x06,
  0x00, 0x0C, 0x07, 0x00, 0x06, 0x03, 0x00, 0x03, 0x83, 0x80, 0x00, 0xC1,
  0x80, 0x00, 0x60, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18,
  0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x0E, 0x01, 0x80, 0x0E,
  0x00, 0x60, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x0E, 0x00,
  0x0C, 0x0E, 0x00, 0x07, 0x06, 0x00, 0x01, 0x87, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x38, 0x07, 0x80, 0x0F, 0xDF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0x01, 0xC0, 0xE0, 0x06, 0x06, 0x00, 0x38, 0x70,
  0x00, 0xC3, 0x00, 0x06, 0x30, 0x00, 0x39, 0x80, 0x00, 0xDC, 0x00, 0x06,
  0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0x66,
  0x00, 0x07, 0x30, 0x00, 0x79, 0x80, 0x06, 0xCE, 0x00, 0x7E, 0x38, 0x07,
  0x60, 0xE0, 0xF3, 0x03, 0xFF, 0x18, 0x0F, 0xC1, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x0F,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0xF0, 0xE0, 0x00, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x30, 0x0E, 0x03, 0x80, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x10, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x03, 0xFF, 0x83, 0x80, 0xE3, 0x80, 0x31, 0x80, 0x19,
  0xC0, 0x06, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00,
  0x10, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0xFC, 0x00, 0x60, 0xC0,
  0x07, 0xFC, 0x00, 0xC1, 0x80, 0x1C, 0x1C, 0x01, 0x86, 0x00, 0x70, 0x0C,
  0x03, 0x0C, 0x01, 0xC0, 0x18, 0x06, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x60,
  0x0C, 0x00, 0xC0, 0x18, 0xC0, 0x38, 0x01, 0x80, 0x33, 0x00, 0x60, 0x03,
  0x00, 0x66, 0x00, 0xC0, 0x0C, 0x00, 0xCC, 0x03, 0x00, 0x18, 0x01, 0xB0,
  0x06, 0x00, 0x30, 0x03, 0x60, 0x1C, 0x00, 0x60, 0x04, 0xC0, 0x30, 0x01,
  0x80, 0x19, 0x80, 0x60, 0x03, 0x00, 0x32, 0x00, 0xC0, 0x06, 0x00, 0x6C,
  0x03, 0x00, 0x0C, 0x00, 0x98, 0x06, 0x00, 0x30, 0x03, 0x30, 0x0C, 0x00,
  0x60, 0x06, 0x60, 0x18, 0x01, 0xC0, 0x18, 0xC0, 0x30, 0x03, 0x80, 0x31,
  0x80, 0x60, 0x0F, 0x00, 0x43, 0x00, 0xC0, 0x16, 0x01, 0x86, 0x01, 0x80,
  0x6C, 0x06, 0x0C, 0x01, 0x81, 0x98, 0x18, 0x18, 0x03, 0xDE, 0x1C, 0xF0,
  0x30, 0x03, 0xF0, 0x3F, 0x80, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x04, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x70, 0x30, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00, 0x30, 0x01, 0x80, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x01,
  0x80, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x01, 0xC0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x60, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x18, 0x01, 0xE0, 0x0E, 0x00, 0x1C, 0x03, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x03,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06,
  0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x30, 0x38, 0x00,
  0x1C, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x07, 0x80, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x06, 0x00, 0x1E, 0x01, 0x80, 0x01, 0xC0,
  0x60, 0x00, 0x38, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x06, 0x18, 0x00, 0x03, 0x06,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00, 0x38, 0x18, 0x00, 0x1C,
  0x0E, 0x00, 0x3E, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x38, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x38,
  0x00, 0x06, 0x06, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x30, 0x00, 0x06,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x00, 0xF0,
  0x0F, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0x80, 0x1E, 0x00,
  0x38, 0x00, 0x70, 0x03, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60, 0x70, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x70, 0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0x70, 0x06, 0x00,
  0x0E, 0x00, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0x38, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0E,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x3F, 0xFC, 0xE0, 0x07, 0xFF, 0x98, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x06, 0x18,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x38, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0,
  0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03,
  0x00, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x38, 0x00,
  0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x18, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x1C, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x38, 0x03, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x60, 0x07, 0x00, 0x01, 0x80, 0x38, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x60, 0x70, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x0C, 0x1C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x03,
  0x3E, 0x00, 0x00, 0x1D, 0xD8, 0x00, 0x00, 0x6E, 0x30, 0x00, 0x01, 0xF0,
  0xE0, 0x00, 0x07, 0x81, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x01, 0xC0,
  0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0x70, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x18,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x36, 0x00, 0x00, 0x06,
  0xC0, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0xD8, 0x00, 0x00, 0x36, 0x01, 0xB0,
  0x00, 0x00, 0x6C, 0x03, 0x60, 0x00, 0x01, 0x98, 0x0C, 0xC0, 0x00, 0x03,
  0x30, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x63,
  0x00, 0x00, 0x63, 0x00, 0xC6, 0x00, 0x00, 0xC6, 0x01, 0x8C, 0x00, 0x03,
  0x0C, 0x06, 0x18, 0x00, 0x06, 0x18, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x18,
  0x30, 0x00, 0x30, 0xE0, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x01,
  0x83, 0x01, 0xC1, 0x80, 0x06, 0x06, 0x03, 0x01, 0x80, 0x0C, 0x0C, 0x06,
  0x03, 0x00, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x60, 0x70, 0x18, 0x0C, 0x01,
  0x80, 0xC0, 0x30, 0x18, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01,
  0x80, 0x30, 0x38, 0x06, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x06, 0x00, 0xC1,
  0xC0, 0x38, 0x0C, 0x01, 0x83, 0x00, 0x60, 0x18, 0x03, 0x0E, 0x00, 0xC0,
  0x70, 0x06, 0x18, 0x01, 0x80, 0xC0, 0x06, 0x70, 0x03, 0x01, 0x80, 0x0C,
  0xC0, 0x06, 0x03, 0x00, 0x1B, 0x00, 0x1C, 0x06, 0x00, 0x36, 0x00, 0x30,
  0x0C, 0x00, 0x78, 0x00, 0x60, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x18, 0x1E, 0x00, 0x00, 0x30,
  0x36, 0x00, 0x00, 0xE0, 0x6C, 0x00, 0x01, 0xC0, 0xDC, 0x00, 0x03, 0x01,
  0x98, 0x00, 0x06, 0x03, 0x30, 0x00, 0x0C, 0x0E, 0x30, 0x00, 0x18, 0x18,
  0x60, 0x00, 0x70, 0x30, 0xC0, 0x00, 0xC0, 0x60, 0xC0, 0x01, 0x80, 0xC1,
  0x80, 0x03, 0x03, 0x83, 0x80, 0x06, 0x07, 0x03, 0x00, 0x0C, 0x0C, 0x06,
  0x00, 0x38, 0x18, 0x06, 0x00, 0x60, 0x30, 0x0C, 0x00, 0xC0, 0x60, 0x18,
  0x01, 0x81, 0xC0, 0x18, 0x03, 0x03, 0x80, 0x30, 0x06, 0x06, 0x00, 0x70,
  0x1C, 0x0C, 0x00, 0x60, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x30, 0x00, 0xC0,
  0xC0, 0xE0, 0x01, 0x81, 0x81, 0xC0, 0x03, 0x03, 0x03, 0x00, 0x03, 0x0E,
  0x06, 0x00, 0x06, 0x18, 0x0C, 0x00, 0x0E, 0x30, 0x18, 0x00, 0x0C, 0x60,
  0x70, 0x00, 0x18, 0xC0, 0xC0, 0x00, 0x19, 0x81, 0x80, 0x00, 0x37, 0x03,
  0x00, 0x00, 0x6C, 0x06, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x01, 0xE0, 0x60, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x06, 0x06, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x06, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0x70, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0E, 0x06, 0x00,
  0x03, 0x81, 0xC0, 0x01, 0xE0, 0x30, 0x00, 0xF8, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x18, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x03, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x21, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x0E, 0x00, 0x3C, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x06, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x07, 0x07, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x06, 0x0C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x70, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x18, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0xE0, 0x0C, 0x00,
  0x0C, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xC1, 0xC0, 0x00,
  0x18, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0x80, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0xE0, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x60, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x01,
  0xC0, 0x1C, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x38, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x03, 0x83, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x30, 0x03, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x07, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x06, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x38, 0x60, 0x00, 0x06,
  0x0E, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x0E, 0x03, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80,
  0x38, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x1C, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0xE0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x18,
  0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x05, 0x80,
  0x01, 0x98, 0x00, 0x1B, 0x00, 0x03, 0x30, 0x00, 0x36, 0x00, 0x0E, 0x60,
  0x00, 0xCC, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x31, 0x80, 0x03, 0x30,
  0x00, 0xE3, 0x00, 0x0C, 0x60, 0x01, 0x86, 0x00, 0x18, 0x40, 0x03, 0x0E,
  0x00, 0x60, 0x80, 0x0E, 0x1C, 0x00, 0xC1, 0x80, 0x18, 0x38, 0x01, 0x83,
  0x00, 0x30, 0x30, 0x06, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x0C, 0x01, 0x80,
  0xC0, 0x30, 0x18, 0x07, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x70, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x18, 0x18, 0x03, 0x01, 0x80, 0x30, 0x30, 0x06, 0x06, 0x00, 0x60, 0x60,
  0x06, 0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x18, 0x60,
  0x03, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x0C, 0x30,
  0x00, 0xC6, 0x00, 0x1C, 0xC0, 0x01, 0x8C, 0x00, 0x39, 0x80, 0x03, 0x38,
  0x00, 0x37, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x00, 0xD8,
  0x00, 0x1B, 0x00, 0x01, 0xE0, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0x2C,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x18, 0x03, 0x80, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x06, 0x38,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0xC0, 0x1C,
  0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x30, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x06, 0x38, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x0C, 0x0E, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x18, 0x03,
  0x80, 0x07, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x0E,
  0x00, 0x1C, 0x01, 0x80, 0x01, 0x80, 0x70, 0x00, 0x30, 0x1C, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x70,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x30,
  0x00, 0x60, 0x01, 0xC0, 0x02, 0xC0, 0x0D, 0x80, 0x33, 0x00, 0x66, 0x01,
  0x8C, 0x03, 0x08, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x60, 0xC0, 0xC3, 0x01,
  0x86, 0x03, 0x18, 0x03, 0x30, 0x06, 0xC0, 0x0D, 0x80, 0x1E, 0x00, 0x30,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0x86, 0x0C, 0x30, 0x61, 0x83, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xF0, 0x1C, 0x07, 0x00,
  0x38, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x1C, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0x80, 0x30, 0x70, 0x00,
  0xC3, 0x80, 0x03, 0x1C, 0x00, 0x0C, 0x60, 0x00, 0x61, 0x80, 0x01, 0x8C,
  0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xE3, 0x00, 0x07, 0x8C, 0x00,
  0x3E, 0x18, 0x01, 0xF0, 0x70, 0x1E, 0xC0, 0xFF, 0xE3, 0x01, 0xFF, 0x0C,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x10, 0x00, 0xC3, 0xFC, 0x01, 0x9F, 0xFE, 0x03, 0x70,
  0x1C, 0x07, 0x80, 0x1C, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x38, 0x70, 0x00,
  0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03,
  0x1C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x61,
  0x80, 0x00, 0xC3, 0x00, 0x01, 0x8E, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30,
  0x00, 0x1C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC7, 0x00,
  0x03, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x18, 0x34, 0x00, 0x70, 0x6E, 0x01,
  0xC0, 0xCF, 0xFF, 0x03, 0x07, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0x00, 0xC0, 0xE0, 0x03, 0x06,
  0x00, 0x18, 0x60, 0x00, 0x63, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00,
  0xDC, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x01, 0x98, 0x00,
  0x0C, 0xC0, 0x00, 0xC7, 0x00, 0x06, 0x18, 0x00, 0x60, 0xE0, 0x07, 0x03,
  0x80, 0x70, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x07, 0xF8, 0x30, 0x07, 0xFF, 0x18, 0x0F, 0x01, 0xD8,
  0x06, 0x00, 0x2C, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x03, 0x00, 0x03,
  0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x30, 0x70, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0E, 0x0C, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x80, 0x00, 0xC1, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x07, 0x01, 0x80, 0x07, 0x80,
  0xE0, 0x07, 0x80, 0x38, 0x0E, 0xC0, 0x0F, 0xFE, 0x60, 0x03, 0xFC, 0x30,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8,
  0x07, 0x01, 0xC0, 0x60, 0x07, 0x06, 0x00, 0x18, 0x70, 0x00, 0x63, 0x00,
  0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xDC, 0x00, 0x06, 0xC0, 0x00, 0x36,
  0x00, 0x01, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x20, 0xE0, 0x03, 0x03, 0x80, 0x78, 0x0F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0xC0, 0x1F, 0xFC, 0x60, 0x3C, 0x07, 0x60, 0x18, 0x00, 0xB0, 0x18,
  0x00, 0x78, 0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x06,
  0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C,
  0x0C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x38, 0x00,
  0x18, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x1E, 0x03, 0x80, 0x1E, 0x00, 0xE0,
  0x3B, 0x00, 0x3F, 0xF9, 0x80, 0x0F, 0xF0, 0xC0, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x02, 0x00, 0x06, 0x03, 0x80, 0x06, 0x00, 0xE0, 0x07, 0x00,
  0x3C, 0x0F, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x3F,
  0xC0, 0x63, 0xFF, 0x81, 0x9C, 0x06, 0x06, 0xC0, 0x1C, 0x1E, 0x00, 0x30,
  0x70, 0x00, 0xC3, 0xC0, 0x03, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xC0,
  0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x01,
  0xC6, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x63, 0x80, 0x01, 0x8C,
  0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00,
  0x0C, 0x70, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x18,
  0x60, 0x00, 0x61, 0x80, 0x01, 0x8E, 0x00, 0x06, 0x00, 0x01, 0x01, 0xC0,
  0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x60,
  0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x01,
  0xC1, 0x80, 0x07, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x70, 0x0C, 0x01, 0xC0,
  0x18, 0x07, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x70, 0x01, 0x81, 0xC0, 0x03,
  0x07, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x70, 0x00, 0x31, 0xC0, 0x00, 0x67,
  0x80, 0x00, 0xDB, 0x00, 0x01, 0xE7, 0x00, 0x03, 0x86, 0x00, 0x0E, 0x0E,
  0x00, 0x18, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x38,
  0x01, 0x80, 0x30, 0x07, 0x00, 0x70, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xE0,
  0x30, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x80,
  0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x3F, 0xC0, 0x3F, 0xE0, 0x18,
  0xFF, 0xC0, 0xFF, 0xE0, 0x33, 0x01, 0xC3, 0x80, 0xC0, 0x6C, 0x01, 0xCC,
  0x01, 0xC0, 0xF0, 0x01, 0xB0, 0x01, 0x83, 0xC0, 0x03, 0xC0, 0x03, 0x07,
  0x80, 0x07, 0x80, 0x06, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x18, 0x00, 0x1C,
  0x00, 0x18, 0x30, 0x00, 0x30, 0x00, 0x30, 0xE0, 0x00, 0x60, 0x00, 0x61,
  0xC0, 0x00, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x80, 0x01, 0x86, 0x00, 0x06,
  0x00, 0x03, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x70, 0x00, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x60, 0x00, 0x61, 0x80, 0x01,
  0xC0, 0x00, 0xC3, 0x00, 0x03, 0x00, 0x01, 0x86, 0x00, 0x06, 0x00, 0x07,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x00, 0x18, 0x60, 0x00,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0xC0, 0x00, 0x61, 0x80, 0x01, 0x80, 0x00,
  0xC3, 0x00, 0x03, 0x00, 0x03, 0x06, 0x00, 0x06, 0x00, 0x06, 0x1C, 0x00,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x3F, 0x80, 0x63, 0xFF, 0x81, 0x9C, 0x0E, 0x06, 0xC0, 0x1C, 0x1A,
  0x00, 0x30, 0x70, 0x00, 0xC3, 0xC0, 0x03, 0x0E, 0x00, 0x0C, 0x38, 0x00,
  0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x70, 0x00, 0x31,
  0x80, 0x01, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80,
  0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03,
  0x0C, 0x00, 0x0C, 0x70, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x06, 0x18,
  0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x8E, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xE0, 0x1C, 0x07, 0x00,
  0x38, 0x38, 0x00, 0x60, 0xC0, 0x01, 0x86, 0x00, 0x03, 0x18, 0x00, 0x0C,
  0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80,
  0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x1F, 0x80, 0x00,
  0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0x38, 0x00, 0x1C, 0x60, 0x00, 0x61, 0x80, 0x03, 0x87, 0x00,
  0x1C, 0x0C, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0xC3, 0xFC, 0x00, 0x67, 0xFF,
  0x80, 0x37, 0x01, 0xC0, 0x1E, 0x00, 0x70, 0x0E, 0x00, 0x18, 0x06, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18,
  0x00, 0x06, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81,
  0x80, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x18, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x0E,
  0x07, 0x80, 0x06, 0x03, 0x40, 0x07, 0x01, 0xB8, 0x0F, 0x00, 0xCF, 0xFF,
  0x00, 0xE1, 0xFE, 0x00, 0x60, 0x10, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x0C,
  0x07, 0xFF, 0x18, 0x3C, 0x07, 0x60, 0x60, 0x02, 0xC1, 0xC0, 0x07, 0x87,
  0x00, 0x07, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x61, 0x80, 0x00, 0xC7, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00,
  0x06, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x63, 0x80, 0x00,
  0xC7, 0x00, 0x01, 0x8C, 0x00, 0x07, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x01, 0xC1, 0x80, 0x07, 0x83,
  0x80, 0x1E, 0x03, 0x80, 0xEC, 0x03, 0xEF, 0x98, 0x03, 0xFC, 0x30, 0x00,
  0xC0, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x8F, 0xC1, 0x9F, 0xE0, 0xDC, 0x00, 0x6C, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8,
  0x07, 0x00, 0xE0, 0x70, 0x03, 0x07, 0x00, 0x1C, 0x30, 0x00, 0x61, 0x80,
  0x03, 0x1C, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0xC7, 0x00, 0x06,
  0x18, 0x00, 0x70, 0xE0, 0x07, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x10, 0x00, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x70, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x3F, 0x03,
  0xF0, 0x04, 0x00, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x71, 0x80, 0x01, 0x86,
  0x00, 0x06, 0x18, 0x00, 0x18, 0xE0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00,
  0x0E, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x0C,
  0x60, 0x00, 0x31, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60,
  0x00, 0x63, 0x80, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0xC3, 0x00, 0x03, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x70, 0xC0, 0x03, 0xC3,
  0x80, 0x0E, 0x06, 0x00, 0x78, 0x1C, 0x07, 0x60, 0x3F, 0xF9, 0x80, 0x7F,
  0x86, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x0E, 0xC0, 0x00, 0xCE, 0x00, 0x1C, 0x60, 0x01, 0x86, 0x00,
  0x38, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x06, 0x06, 0x00, 0x60, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x03, 0x01, 0x80, 0x30, 0x30, 0x03,
  0x03, 0x00, 0x30, 0x60, 0x01, 0x86, 0x00, 0x18, 0xE0, 0x01, 0x8C, 0x00,
  0x18, 0xC0, 0x01, 0x98, 0x00, 0x19, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x60, 0x01, 0x80, 0x07, 0x60, 0x03, 0xC0, 0x06, 0x60, 0x03, 0xC0, 0x06,
  0x60, 0x06, 0xC0, 0x0E, 0x60, 0x06, 0xC0, 0x0C, 0x60, 0x06, 0xC0, 0x1C,
  0x60, 0x0C, 0xC0, 0x18, 0x60, 0x0C, 0xC0, 0x18, 0x60, 0x18, 0xC0, 0x30,
  0x60, 0x18, 0xC0, 0x30, 0x60, 0x30, 0xC0, 0x70, 0x60, 0x30, 0xC0, 0x60,
  0x60, 0x30, 0x40, 0x60, 0x70, 0x60, 0x60, 0xC0, 0x30, 0x60, 0x60, 0xC0,
  0x30, 0xC0, 0x61, 0xC0, 0x30, 0xC0, 0x61, 0x80, 0x31, 0x80, 0x61, 0x80,
  0x31, 0x80, 0x63, 0x00, 0x33, 0x80, 0x63, 0x00, 0x33, 0x00, 0x66, 0x00,
  0x33, 0x00, 0x66, 0x00, 0x36, 0x00, 0x66, 0x00, 0x36, 0x00, 0x2C, 0x00,
  0x3C, 0x00, 0x2C, 0x00, 0x3C, 0x00, 0x28, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x07, 0x00, 0x03, 0x01,
  0x80, 0x03, 0x00, 0xE0, 0x03, 0x80, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80,
  0x06, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x30, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x39, 0x80, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x30, 0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x03, 0x80, 0x0E,
  0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x38, 0x06, 0x00, 0x0C, 0x07,
  0x00, 0x07, 0x07, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x70, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x00, 0x60,
  0x01, 0xC0, 0x18, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x07, 0x00, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0x30, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0,
  0xE0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x80, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x80, 0x00, 0x01,
  0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01,
  0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x0C, 0x70, 0xE0, 0x03, 0x1C, 0x0E, 0x00, 0x63, 0x00, 0xC0, 0x0C,
  0xC0, 0x0C, 0x03, 0x18, 0x01, 0xC0, 0x63, 0x00, 0x1C, 0x38, 0xC0, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoCondensed_ExtraLightItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 10, 42, 11, 1, -41 },
  { 54, 10, 12, 15, 6, -43 },
  { 69, 29, 41, 27, 1, -41 },
  { 218, 24, 53, 27, 2, -47 },
  { 377, 27, 43, 36, 5, -42 },
  { 523, 25, 43, 30, 2, -42 },
  { 658, 4, 12, 9, 6, -43 },
  { 664, 16, 58, 16, 3, -45 },
  { 780, 15, 58, 16, -3, -45 },
  { 889, 22, 22, 23, 3, -41 },
  { 950, 24, 30, 27, 2, -34 },
  { 1040, 7, 12, 10, -2, -5 },
  { 1051, 11, 2, 15, 2, -19 },
  { 1054, 4, 4, 12, 1, -3 },
  { 1056, 23, 44, 19, -2, -41 },
  { 1183, 22, 43, 27, 3, -42 },
  { 1302, 12, 41, 27, 8, -41 },
  { 1364, 24, 42, 27, 1, -42 },
  { 1490, 23, 43, 27, 2, -42 },
  { 1614, 24, 41, 27, 1, -41 },
  { 1737, 24, 42, 27, 3, -41 },
  { 1863, 21, 42, 27, 3, -41 },
  { 1974, 23, 41, 27, 5, -41 },
  { 2092, 25, 43, 27, 1, -42 },
  { 2227, 21, 42, 27, 4, -42 },
  { 2338, 8, 30, 11, 1, -29 },
  { 2368, 11, 36, 10, -2, -29 },
  { 2418, 22, 23, 25, 2, -30 },
  { 2482, 22, 13, 27, 3, -25 },
  { 2518, 21, 23, 25, 2, -30 },
  { 2579, 17, 43, 22, 5, -42 },
  { 2671, 39, 52, 44, 2, -39 },
  { 2925, 28, 41, 30, -2, -41 },
  { 3069, 26, 41, 30, 2, -41 },
  { 3203, 27, 43, 31, 3, -42 },
  { 3349, 28, 41, 32, 2, -41 },
  { 3493, 27, 41, 28, 2, -41 },
  { 3632, 28, 41, 28, 2, -41 },
  { 3776, 27, 43, 33, 4, -42 },
  { 3922, 31, 41, 34, 2, -41 },
  { 4081, 9, 41, 13, 3, -41 },
  { 4128, 25, 42, 27, 1, -41 },
  { 4260, 30, 41, 31, 2, -41 },
  { 4414, 19, 41, 25, 2, -41 },
  { 4512, 39, 41, 41, 2, -41 },
  { 4712, 31, 41, 34, 2, -41 },
  { 4871, 28, 43, 32, 3, -42 },
  { 5022, 27, 41, 29, 2, -41 },
  { 5161, 28, 49, 32, 3, -42 },
  { 5333, 27, 41, 31, 2, -41 },
  { 5472, 28, 43, 29, 1, -42 },
  { 5623, 26, 41, 29, 5, -41 },
  { 5757, 29, 42, 32, 3, -41 },
  { 5910, 27, 41, 29, 5, -41 },
  { 6049, 39, 41, 43, 6, -41 },
  { 6249, 32, 41, 29, -1, -41 },
  { 6413, 27, 41, 29, 5, -41 },
  { 6552, 30, 41, 29, 0, -41 },
  { 6706, 16, 55, 12, 0, -46 },
  { 6816, 8, 44, 19, 6, -41 },
  { 6860, 16, 55, 12, -4, -46 },
  { 6970, 15, 20, 20, 3, -41 },
  { 7008, 20, 2, 21, -3, 0 },
  { 7013, 6, 8, 15, 8, -43 },
  { 7019, 22, 32, 26, 1, -31 },
  { 7107, 23, 44, 27, 1, -43 },
  { 7234, 21, 32, 25, 2, -31 },
  { 7318, 25, 44, 27, 2, -43 },
  { 7456, 21, 32, 25, 2, -31 },
  { 7540, 18, 44, 16, 3, -44 },
  { 7639, 25, 43, 27, 0, -31 },
  { 7774, 22, 43, 27, 1, -43 },
  { 7893, 9, 41, 11, 2, -41 },
  { 7940, 18, 53, 11, -7, -41 },
  { 8060, 23, 43, 24, 1, -43 },
  { 8184, 9, 43, 11, 2, -43 },
  { 8233, 39, 31, 43, 1, -31 },
  { 8385, 22, 31, 27, 1, -31 },
  { 8471, 22, 32, 27, 2, -31 },
  { 8559, 25, 43, 27, -1, -31 },
  { 8694, 23, 43, 27, 2, -31 },
  { 8818, 17, 31, 17, 1, -31 },
  { 8884, 21, 32, 25, 1, -31 },
  { 8968, 12, 39, 16, 3, -38 },
  { 9027, 22, 31, 27, 3, -30 },
  { 9113, 20, 30, 23, 4, -30 },
  { 9188, 32, 30, 36, 4, -30 },
  { 9308, 25, 30, 24, -1, -30 },
  { 9402, 26, 42, 23, -2, -30 },
  { 9539, 23, 30, 24, 0, -30 },
  { 9626, 18, 57, 16, 2, -45 },
  { 9755, 10, 49, 12, 1, -41 },
  { 9817, 18, 56, 16, -4, -44 },
  { 9943, 27, 10, 33, 3, -22 },
};

const GFXfont RobotoCondensed_ExtraLightItalic57pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic57pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic57pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC57PT7B_H_
