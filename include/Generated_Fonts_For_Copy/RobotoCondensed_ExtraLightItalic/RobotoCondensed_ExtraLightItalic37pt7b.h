#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC37PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0x82, 0x08, 0x21, 0x86, 0x10, 0x41, 0x04, 0x30, 0x82,
  0x08, 0x21, 0x86, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x65, 0x14, 0x53,
  0x4F, 0x28, 0xA2, 0x00, 0x20, 0x80, 0x18, 0x60, 0x04, 0x10, 0x01, 0x04,
  0x00, 0xC3, 0x00, 0x20, 0x80, 0x08, 0x20, 0x06, 0x18, 0x1F, 0xFF, 0xC0,
  0x41, 0x00, 0x30, 0xC0, 0x08, 0x20, 0x02, 0x08, 0x01, 0x86, 0x00, 0x41,
  0x00, 0x10, 0x40, 0x0C, 0x10, 0x3F, 0xFF, 0x80, 0x82, 0x00, 0x60, 0x80,
  0x10, 0x40, 0x04, 0x10, 0x03, 0x04, 0x00, 0x82, 0x00, 0x20, 0x80, 0x18,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0xF8, 0x03, 0x9C,
  0x06, 0x06, 0x0C, 0x02, 0x08, 0x02, 0x18, 0x02, 0x18, 0x03, 0x10, 0x02,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C,
  0x40, 0x08, 0x40, 0x08, 0x60, 0x18, 0x20, 0x30, 0x38, 0xE0, 0x0F, 0x80,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x40, 0x02, 0x08,
  0x01, 0x82, 0x04, 0x40, 0x83, 0x10, 0x20, 0x84, 0x08, 0x43, 0x06, 0x30,
  0x41, 0x08, 0x10, 0xC4, 0x06, 0x63, 0x00, 0xF1, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x18, 0xF0, 0x04, 0x66, 0x02, 0x30, 0x81, 0x08, 0x20, 0xC6,
  0x0C, 0x21, 0x02, 0x10, 0x40, 0x8C, 0x10, 0x26, 0x04, 0x08, 0x01, 0x04,
  0x00, 0x23, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x03, 0x98, 0x02, 0x0C, 0x06,
  0x0C, 0x04, 0x0C, 0x04, 0x0C, 0x0C, 0x08, 0x04, 0x18, 0x04, 0x30, 0x04,
  0x60, 0x06, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x0D, 0x80, 0x18, 0x81, 0x30,
  0xC1, 0x60, 0x41, 0x40, 0x63, 0xC0, 0x22, 0xC0, 0x36, 0xC0, 0x1C, 0xC0,
  0x0C, 0x40, 0x1C, 0x60, 0x34, 0x38, 0xC6, 0x1F, 0x82, 0x57, 0xEA, 0x00,
  0x40, 0x20, 0x10, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03,
  0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x0C, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x10, 0x00, 0x02, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00,
  0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x01, 0x80,
  0x40, 0x30, 0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x00, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x07, 0xC4, 0x71, 0xDF, 0x01, 0xE0,
  0x07, 0x00, 0x36, 0x01, 0x88, 0x0C, 0x30, 0x20, 0x61, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x01, 0xFF, 0xF8, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x13,
  0x32, 0x26, 0xC8, 0xFE, 0xF0, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x00, 0x01, 0xF0,
  0x1C, 0xE0, 0xC0, 0x86, 0x03, 0x10, 0x04, 0xC0, 0x12, 0x00, 0x48, 0x01,
  0x60, 0x05, 0x80, 0x14, 0x00, 0x50, 0x01, 0x40, 0x0F, 0x00, 0x3C, 0x00,
  0xA0, 0x02, 0x80, 0x0A, 0x00, 0x68, 0x01, 0xA0, 0x04, 0x80, 0x32, 0x00,
  0x8C, 0x06, 0x10, 0x30, 0x71, 0x80, 0x7C, 0x00, 0x03, 0x0F, 0x3B, 0xC2,
  0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08,
  0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x30, 0x01, 0xF0,
  0x06, 0x38, 0x10, 0x10, 0x40, 0x31, 0x80, 0x22, 0x00, 0x44, 0x00, 0x98,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0xFF, 0xF0, 0x01,
  0xF0, 0x06, 0x38, 0x10, 0x18, 0x40, 0x31, 0x80, 0x22, 0x00, 0x44, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x3E, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x1B, 0x00, 0x36, 0x00,
  0x6C, 0x00, 0x98, 0x03, 0x10, 0x04, 0x30, 0x18, 0x38, 0xE0, 0x1F, 0x00,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xA0, 0x02, 0x40, 0x0D, 0x80,
  0x33, 0x00, 0x44, 0x01, 0x08, 0x06, 0x10, 0x08, 0x20, 0x20, 0xC0, 0xC1,
  0x83, 0x02, 0x04, 0x04, 0x10, 0x08, 0x60, 0x31, 0x80, 0x63, 0xFF, 0xF8,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x07, 0xFF, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x13, 0xC0, 0x3C, 0x70, 0x30,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0x40, 0x10, 0x40, 0x30, 0x60,
  0x60, 0x39, 0xC0, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x1E, 0x1B, 0x1C, 0xA0,
  0x26, 0x01, 0xB0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x01, 0x60, 0x19, 0x00, 0x8C, 0x0C, 0x31, 0xC0, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x00, 0x01, 0xF8, 0x03, 0x9C, 0x06, 0x06, 0x0C, 0x02, 0x08, 0x03, 0x18,
  0x03, 0x10, 0x03, 0x10, 0x02, 0x10, 0x02, 0x18, 0x04, 0x08, 0x0C, 0x06,
  0x38, 0x07, 0xE0, 0x1C, 0x30, 0x30, 0x18, 0x60, 0x0C, 0x40, 0x0C, 0xC0,
  0x04, 0xC0, 0x04, 0x80, 0x0C, 0x80, 0x0C, 0xC0, 0x08, 0x40, 0x18, 0x60,
  0x30, 0x38, 0xE0, 0x1F, 0x80, 0x07, 0xC0, 0xE3, 0x0C, 0x0C, 0x40, 0x36,
  0x01, 0xA0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x03, 0xE0, 0x19, 0x03, 0x4E, 0x72, 0x1F, 0x30, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x60, 0xC1, 0x06, 0x0C, 0x30, 0x40,
  0x00, 0x08, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x10, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x20, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0xC0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x02,
  0x00, 0x00, 0x0F, 0x83, 0x18, 0xC1, 0xB0, 0x14, 0x03, 0x80, 0x40, 0x08,
  0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40,
  0x18, 0x02, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x07, 0x00, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x01, 0x00, 0x01, 0x00, 0x80, 0x00, 0x20, 0x60, 0x00,
  0x08, 0x30, 0x00, 0x02, 0x08, 0x07, 0x80, 0xC6, 0x03, 0x30, 0x31, 0x01,
  0x02, 0x04, 0xC0, 0x81, 0x81, 0x20, 0x60, 0x40, 0xC8, 0x10, 0x10, 0x36,
  0x0C, 0x04, 0x09, 0x02, 0x03, 0x02, 0x40, 0x80, 0x80, 0x90, 0x60, 0x20,
  0x24, 0x10, 0x08, 0x1B, 0x04, 0x06, 0x04, 0xC1, 0x01, 0x01, 0x30, 0x40,
  0xC0, 0xCC, 0x10, 0x30, 0x23, 0x04, 0x14, 0x10, 0xC1, 0x98, 0x8C, 0x10,
  0x3C, 0x3C, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x08, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x50, 0x00, 0x36, 0x00, 0x09, 0x80, 0x06, 0x20, 0x01, 0x08, 0x00,
  0xC2, 0x00, 0x20, 0x80, 0x18, 0x20, 0x04, 0x0C, 0x03, 0x03, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x10, 0x04, 0x04, 0x01, 0x03, 0xFF, 0xC0, 0x80, 0x18,
  0x60, 0x06, 0x10, 0x01, 0x8C, 0x00, 0x22, 0x00, 0x09, 0x80, 0x02, 0x40,
  0x00, 0xB0, 0x00, 0x20, 0x07, 0xFC, 0x02, 0x07, 0x03, 0x00, 0xC1, 0x80,
  0x30, 0x80, 0x18, 0x40, 0x0C, 0x20, 0x06, 0x10, 0x03, 0x18, 0x01, 0x0C,
  0x01, 0x84, 0x01, 0x82, 0x03, 0x81, 0xFF, 0x81, 0x80, 0x60, 0xC0, 0x18,
  0x60, 0x04, 0x20, 0x03, 0x10, 0x01, 0x88, 0x00, 0xCC, 0x00, 0x46, 0x00,
  0x22, 0x00, 0x31, 0x00, 0x30, 0x80, 0x30, 0x40, 0x70, 0x7F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0xE3, 0x80, 0x60, 0x30, 0x30, 0x06, 0x18, 0x00, 0x84,
  0x00, 0x23, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x33, 0x00, 0x08, 0xC0, 0x06, 0x10,
  0x01, 0x06, 0x00, 0xC0, 0x80, 0x60, 0x38, 0x70, 0x03, 0xF0, 0x00, 0x07,
  0xFC, 0x01, 0x03, 0x80, 0xC0, 0x30, 0x30, 0x06, 0x08, 0x00, 0xC2, 0x00,
  0x30, 0x80, 0x04, 0x20, 0x01, 0x18, 0x00, 0x46, 0x00, 0x11, 0x00, 0x04,
  0x40, 0x03, 0x10, 0x00, 0xCC, 0x00, 0x23, 0x00, 0x08, 0xC0, 0x02, 0x20,
  0x00, 0x88, 0x00, 0x62, 0x00, 0x11, 0x80, 0x0C, 0x60, 0x02, 0x10, 0x01,
  0x84, 0x00, 0xC1, 0x00, 0x60, 0x40, 0xF0, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0xC1, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x1F, 0xFC, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC1,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x1F, 0xFC, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xF1,
  0xC0, 0x60, 0x18, 0x30, 0x02, 0x08, 0x00, 0xC6, 0x00, 0x31, 0x00, 0x04,
  0xC0, 0x01, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x07, 0xF9, 0x00, 0x06, 0x40, 0x01, 0x30, 0x00,
  0x4C, 0x00, 0x11, 0x00, 0x0C, 0x40, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x20,
  0xC0, 0x38, 0x1C, 0x78, 0x03, 0xF8, 0x00, 0x04, 0x00, 0x10, 0x20, 0x00,
  0x83, 0x00, 0x04, 0x18, 0x00, 0x20, 0x80, 0x03, 0x04, 0x00, 0x18, 0x20,
  0x00, 0x81, 0x00, 0x04, 0x18, 0x00, 0x20, 0xC0, 0x01, 0x04, 0x00, 0x18,
  0x20, 0x00, 0xC1, 0xFF, 0xFC, 0x18, 0x00, 0x20, 0xC0, 0x01, 0x06, 0x00,
  0x18, 0x20, 0x00, 0xC1, 0x00, 0x04, 0x08, 0x00, 0x20, 0xC0, 0x01, 0x06,
  0x00, 0x08, 0x20, 0x00, 0xC1, 0x00, 0x06, 0x08, 0x00, 0x20, 0x40, 0x01,
  0x06, 0x00, 0x08, 0x00, 0x0C, 0x20, 0x82, 0x08, 0x61, 0x84, 0x10, 0x43,
  0x0C, 0x30, 0x82, 0x08, 0x61, 0x84, 0x10, 0x41, 0x0C, 0x30, 0x82, 0x00,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x80, 0x18, 0x80, 0x10, 0x80, 0x10, 0x80, 0x30, 0xC0, 0x20, 0x40, 0x40,
  0x71, 0x80, 0x1F, 0x00, 0x04, 0x00, 0x60, 0x40, 0x0C, 0x0C, 0x01, 0x80,
  0xC0, 0x30, 0x08, 0x06, 0x00, 0x80, 0x40, 0x08, 0x08, 0x00, 0x81, 0x00,
  0x18, 0x20, 0x01, 0x86, 0x00, 0x10, 0xC0, 0x01, 0x18, 0x00, 0x13, 0x80,
  0x03, 0x48, 0x00, 0x38, 0xC0, 0x03, 0x04, 0x00, 0x20, 0x60, 0x02, 0x02,
  0x00, 0x20, 0x30, 0x06, 0x01, 0x00, 0x60, 0x18, 0x04, 0x00, 0xC0, 0x40,
  0x0C, 0x04, 0x00, 0x60, 0x40, 0x06, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x07, 0xFF, 0xC0, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0x70, 0xA0, 0x00, 0x58, 0x58, 0x00, 0x28, 0x24,
  0x00, 0x24, 0x12, 0x00, 0x32, 0x19, 0x00, 0x13, 0x0C, 0x80, 0x19, 0x84,
  0x60, 0x08, 0xC2, 0x30, 0x0C, 0x41, 0x08, 0x04, 0x21, 0x84, 0x06, 0x10,
  0xC2, 0x02, 0x18, 0x61, 0x03, 0x0C, 0x20, 0xC1, 0x04, 0x10, 0x61, 0x82,
  0x08, 0x10, 0x81, 0x0C, 0x08, 0xC0, 0x86, 0x04, 0x40, 0xC2, 0x02, 0x40,
  0x61, 0x01, 0xA0, 0x20, 0x80, 0x60, 0x10, 0x40, 0x30, 0x08, 0x60, 0x10,
  0x0C, 0x00, 0x04, 0x00, 0x18, 0x30, 0x00, 0x83, 0x80, 0x04, 0x1E, 0x00,
  0x20, 0xD0, 0x01, 0x04, 0x80, 0x18, 0x26, 0x00, 0xC1, 0x10, 0x04, 0x18,
  0x80, 0x20, 0xC6, 0x01, 0x04, 0x10, 0x18, 0x20, 0xC0, 0xC1, 0x02, 0x06,
  0x18, 0x10, 0x20, 0xC0, 0xC1, 0x06, 0x02, 0x08, 0x20, 0x18, 0xC1, 0x00,
  0x46, 0x08, 0x02, 0x20, 0xC0, 0x19, 0x06, 0x00, 0x48, 0x30, 0x02, 0x41,
  0x00, 0x1E, 0x08, 0x00, 0x70, 0x40, 0x03, 0x06, 0x00, 0x08, 0x00, 0x00,
  0xFC, 0x00, 0xE3, 0x80, 0x60, 0x10, 0x30, 0x06, 0x18, 0x00, 0x84, 0x00,
  0x33, 0x00, 0x0C, 0x80, 0x03, 0x20, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D,
  0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x24, 0x00, 0x1B, 0x00, 0x06, 0xC0,
  0x01, 0x20, 0x00, 0x48, 0x00, 0x13, 0x00, 0x0C, 0xC0, 0x02, 0x10, 0x01,
  0x86, 0x00, 0xC0, 0x80, 0x60, 0x3C, 0x70, 0x03, 0xF0, 0x00, 0x07, 0xFC,
  0x01, 0x01, 0xC0, 0xC0, 0x18, 0x30, 0x02, 0x08, 0x00, 0xC2, 0x00, 0x30,
  0x80, 0x0C, 0x20, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x21, 0x00, 0x18, 0x40,
  0x0C, 0x10, 0x06, 0x0C, 0x07, 0x03, 0xFF, 0x80, 0xC0, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0xE3, 0x80, 0x60, 0x30, 0x30, 0x06, 0x18, 0x00, 0x84, 0x00, 0x33, 0x00,
  0x0C, 0x80, 0x03, 0x20, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x09, 0x00, 0x02,
  0x40, 0x00, 0x90, 0x00, 0x2C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0x20,
  0x00, 0x48, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x02, 0x10, 0x01, 0x84, 0x00,
  0xC1, 0x80, 0x60, 0x3C, 0x70, 0x03, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x07, 0xFC, 0x01, 0x01, 0xC0,
  0xC0, 0x18, 0x30, 0x02, 0x08, 0x00, 0xC2, 0x00, 0x30, 0x80, 0x0C, 0x60,
  0x03, 0x18, 0x00, 0x86, 0x00, 0x21, 0x00, 0x18, 0x40, 0x0C, 0x10, 0x06,
  0x0C, 0x07, 0x03, 0xFF, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x06, 0x02,
  0x01, 0x81, 0x80, 0x20, 0x60, 0x0C, 0x10, 0x03, 0x04, 0x00, 0x41, 0x00,
  0x18, 0x40, 0x06, 0x30, 0x00, 0x80, 0x00, 0xFC, 0x00, 0xE1, 0xC0, 0x60,
  0x10, 0x30, 0x06, 0x18, 0x00, 0x86, 0x00, 0x21, 0x00, 0x08, 0x40, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x88, 0x00,
  0x22, 0x00, 0x08, 0xC0, 0x02, 0x30, 0x01, 0x84, 0x00, 0xC1, 0x80, 0x60,
  0x38, 0x70, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x43,
  0x00, 0x08, 0x60, 0x01, 0x08, 0x00, 0x21, 0x00, 0x0C, 0x20, 0x01, 0x8C,
  0x00, 0x21, 0x80, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x06, 0x10,
  0x00, 0xC6, 0x00, 0x10, 0xC0, 0x02, 0x10, 0x00, 0x42, 0x00, 0x18, 0x40,
  0x03, 0x18, 0x00, 0x43, 0x00, 0x08, 0x60, 0x01, 0x0C, 0x00, 0x61, 0x80,
  0x08, 0x10, 0x03, 0x03, 0x00, 0xC0, 0x38, 0x70, 0x01, 0xF8, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0x24, 0x00, 0x19, 0x00, 0x04, 0x40, 0x03, 0x18, 0x00,
  0x86, 0x00, 0x61, 0x80, 0x10, 0x20, 0x0C, 0x08, 0x02, 0x02, 0x01, 0x80,
  0x80, 0x40, 0x30, 0x30, 0x0C, 0x08, 0x03, 0x02, 0x00, 0x41, 0x80, 0x10,
  0x40, 0x04, 0x30, 0x01, 0x08, 0x00, 0x66, 0x00, 0x19, 0x00, 0x02, 0xC0,
  0x00, 0xA0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x08,
  0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x50, 0x07, 0x00, 0x68, 0x02,
  0xC0, 0x34, 0x01, 0x60, 0x12, 0x01, 0x10, 0x19, 0x80, 0x88, 0x08, 0xC0,
  0xC4, 0x04, 0x60, 0x42, 0x06, 0x30, 0x21, 0x02, 0x18, 0x20, 0x81, 0x0C,
  0x10, 0x41, 0x86, 0x18, 0x20, 0x81, 0x08, 0x10, 0xC0, 0x8C, 0x08, 0x40,
  0x44, 0x06, 0x20, 0x22, 0x03, 0x30, 0x13, 0x01, 0x90, 0x09, 0x00, 0x48,
  0x05, 0x80, 0x2C, 0x02, 0x80, 0x14, 0x01, 0x40, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0x18, 0x30,
  0x01, 0x80, 0x80, 0x08, 0x06, 0x00, 0xC0, 0x10, 0x0C, 0x00, 0xC0, 0xC0,
  0x02, 0x04, 0x00, 0x10, 0x60, 0x00, 0xC6, 0x00, 0x02, 0x20, 0x00, 0x1A,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x40, 0x00,
  0x1B, 0x00, 0x01, 0x88, 0x00, 0x08, 0x60, 0x00, 0xC1, 0x00, 0x0C, 0x08,
  0x00, 0xC0, 0x60, 0x04, 0x01, 0x00, 0x60, 0x0C, 0x06, 0x00, 0x20, 0x20,
  0x01, 0x83, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x98, 0x00, 0x66, 0x00, 0x30,
  0x80, 0x08, 0x20, 0x06, 0x0C, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x18,
  0x30, 0x06, 0x08, 0x00, 0x86, 0x00, 0x21, 0x00, 0x0C, 0x80, 0x01, 0x60,
  0x00, 0x50, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xC0, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x03, 0xE0, 0x84, 0x21, 0x8C, 0x21, 0x08, 0x43, 0x18, 0xC2, 0x10,
  0x84, 0x31, 0x8C, 0x21, 0x08, 0x43, 0x18, 0x42, 0x10, 0x07, 0xC0, 0x30,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x18, 0x06, 0x01, 0x83, 0xC0, 0x03, 0x00, 0xC0, 0x70, 0x14, 0x0D,
  0x02, 0x61, 0x88, 0x42, 0x30, 0x88, 0x26, 0x0D, 0x03, 0xC0, 0x40, 0xFF,
  0xF8, 0xC4, 0x62, 0x10, 0x03, 0xE0, 0x38, 0xE1, 0x80, 0x84, 0x02, 0x20,
  0x0C, 0x80, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x1F, 0xE3, 0xC1, 0x98,
  0x06, 0xC0, 0x13, 0x00, 0x48, 0x01, 0x20, 0x0C, 0x80, 0x73, 0x03, 0xC6,
  0x3B, 0x0F, 0x8C, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x19, 0xF0, 0x26, 0x30, 0x70, 0x30,
  0xC0, 0x21, 0x00, 0x46, 0x00, 0xCC, 0x01, 0x90, 0x03, 0x20, 0x04, 0x40,
  0x09, 0x80, 0x13, 0x00, 0x26, 0x00, 0xC8, 0x01, 0x10, 0x02, 0x20, 0x0C,
  0xC0, 0x11, 0xC0, 0x62, 0x63, 0x84, 0x7C, 0x00, 0x03, 0xE0, 0x38, 0xE1,
  0x80, 0x84, 0x03, 0x30, 0x0C, 0x80, 0x16, 0x00, 0x50, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x01, 0xB0, 0x04,
  0x40, 0x31, 0x81, 0x83, 0x9C, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x07,
  0xC4, 0x1C, 0x64, 0x30, 0x1C, 0x20, 0x1C, 0x60, 0x08, 0x40, 0x08, 0x40,
  0x08, 0xC0, 0x08, 0x80, 0x18, 0x80, 0x18, 0x80, 0x10, 0x80, 0x10, 0x80,
  0x10, 0x80, 0x10, 0x80, 0x30, 0x80, 0x30, 0x80, 0x60, 0xC0, 0xE0, 0x63,
  0xA0, 0x3E, 0x20, 0x03, 0xE0, 0x38, 0xC1, 0x80, 0x84, 0x03, 0x30, 0x0C,
  0x80, 0x16, 0x00, 0x50, 0x01, 0x40, 0x0F, 0xFF, 0xFC, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0xC3, 0x8E,
  0x07, 0xE0, 0x01, 0xE0, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0x40, 0x7F, 0x83, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x60, 0x00, 0x01, 0xF1, 0x07, 0x19, 0x0C, 0x07, 0x08,
  0x07, 0x18, 0x02, 0x10, 0x02, 0x10, 0x02, 0x30, 0x02, 0x20, 0x06, 0x20,
  0x06, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x60, 0x04, 0x20, 0x0C, 0x20,
  0x0C, 0x20, 0x18, 0x30, 0x38, 0x18, 0xE8, 0x0F, 0x88, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0xC0, 0x60, 0x71, 0xC0, 0x1F,
  0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x19, 0xF0, 0x4C, 0x61, 0x40, 0xC6, 0x01, 0x18, 0x04,
  0xC0, 0x13, 0x00, 0x48, 0x03, 0x20, 0x0C, 0x80, 0x36, 0x00, 0x98, 0x02,
  0x60, 0x09, 0x00, 0x64, 0x01, 0x90, 0x06, 0xC0, 0x13, 0x00, 0x4C, 0x01,
  0x20, 0x0C, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x06, 0x18, 0x41, 0x04, 0x10,
  0xC3, 0x08, 0x20, 0x86, 0x18, 0x61, 0x04, 0x10, 0xC3, 0x0C, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C,
  0x01, 0x80, 0xF0, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x0C, 0x20, 0x30, 0x40,
  0xC0, 0x83, 0x01, 0x0C, 0x06, 0x30, 0x0C, 0xC0, 0x11, 0x00, 0x24, 0x00,
  0x5C, 0x01, 0xC8, 0x03, 0x18, 0x06, 0x10, 0x08, 0x30, 0x10, 0x20, 0x20,
  0x60, 0xC0, 0x41, 0x80, 0xC2, 0x00, 0x84, 0x01, 0x80, 0x04, 0x10, 0xC3,
  0x08, 0x20, 0x82, 0x18, 0x61, 0x04, 0x10, 0x43, 0x0C, 0x20, 0x82, 0x08,
  0x61, 0x84, 0x10, 0x41, 0x0C, 0x30, 0x11, 0xF0, 0x3E, 0x09, 0x8C, 0x73,
  0x85, 0x03, 0x60, 0x47, 0x01, 0xE0, 0x23, 0x80, 0x60, 0x19, 0x80, 0x20,
  0x0C, 0xC0, 0x10, 0x06, 0x40, 0x18, 0x02, 0x20, 0x0C, 0x01, 0x30, 0x04,
  0x00, 0x98, 0x02, 0x00, 0xCC, 0x01, 0x00, 0x64, 0x00, 0x80, 0x32, 0x00,
  0xC0, 0x11, 0x00, 0x60, 0x09, 0x80, 0x20, 0x04, 0xC0, 0x10, 0x06, 0x60,
  0x08, 0x03, 0x20, 0x04, 0x01, 0x90, 0x06, 0x00, 0x80, 0x10, 0xF0, 0x4C,
  0x61, 0x40, 0xC6, 0x01, 0x38, 0x04, 0xC0, 0x13, 0x00, 0x48, 0x03, 0x20,
  0x0C, 0x80, 0x36, 0x00, 0x98, 0x02, 0x60, 0x09, 0x00, 0x64, 0x01, 0x90,
  0x06, 0xC0, 0x13, 0x00, 0x48, 0x01, 0x20, 0x0C, 0x03, 0xF0, 0x0C, 0x70,
  0x30, 0x30, 0xC0, 0x23, 0x00, 0x44, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x40,
  0x06, 0x80, 0x09, 0x00, 0x12, 0x00, 0x2C, 0x00, 0xD8, 0x01, 0x90, 0x02,
  0x20, 0x0C, 0x40, 0x10, 0xC0, 0x40, 0xE3, 0x00, 0xFC, 0x00, 0x08, 0xF8,
  0x09, 0x8C, 0x0E, 0x06, 0x0C, 0x02, 0x18, 0x02, 0x18, 0x03, 0x18, 0x03,
  0x10, 0x03, 0x10, 0x02, 0x10, 0x02, 0x30, 0x02, 0x30, 0x02, 0x30, 0x06,
  0x20, 0x04, 0x20, 0x04, 0x20, 0x0C, 0x60, 0x08, 0x70, 0x18, 0x6C, 0x70,
  0x47, 0xC0, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x07, 0xC4, 0x71, 0x93, 0x01, 0xC8,
  0x07, 0x60, 0x09, 0x00, 0x24, 0x00, 0xB0, 0x02, 0x80, 0x1A, 0x00, 0x68,
  0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x03, 0x20, 0x0C, 0x80, 0x63,
  0x03, 0x86, 0x3A, 0x0F, 0x88, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x19, 0xE2, 0x60, 0x50, 0x0C,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x00, 0x07,
  0xE0, 0x73, 0x86, 0x06, 0x60, 0x12, 0x00, 0x90, 0x00, 0xC0, 0x02, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xD0,
  0x06, 0x80, 0x26, 0x03, 0x1C, 0xF0, 0x3E, 0x00, 0x08, 0x08, 0x08, 0x08,
  0x18, 0xFF, 0x10, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60,
  0x60, 0x60, 0x40, 0x40, 0x40, 0x40, 0x40, 0x60, 0x38, 0x20, 0x04, 0x80,
  0x32, 0x00, 0xC8, 0x03, 0x60, 0x09, 0x80, 0x24, 0x00, 0x90, 0x06, 0x40,
  0x19, 0x00, 0x6C, 0x01, 0x30, 0x04, 0x80, 0x12, 0x00, 0xC8, 0x03, 0x20,
  0x08, 0xC0, 0x63, 0x02, 0x86, 0x32, 0x0F, 0x98, 0xC0, 0x09, 0x00, 0x24,
  0x01, 0x90, 0x04, 0x40, 0x31, 0x00, 0x86, 0x06, 0x18, 0x10, 0x20, 0xC0,
  0x82, 0x02, 0x08, 0x08, 0x40, 0x31, 0x00, 0xCC, 0x01, 0x20, 0x05, 0x80,
  0x14, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x80, 0x60, 0x14, 0x03, 0x00,
  0xA0, 0x18, 0x0D, 0x01, 0x40, 0x4C, 0x0A, 0x06, 0x60, 0xD0, 0x23, 0x04,
  0x81, 0x18, 0x64, 0x18, 0xC2, 0x30, 0x82, 0x11, 0x8C, 0x11, 0x0C, 0x40,
  0x88, 0x22, 0x04, 0xC1, 0x30, 0x24, 0x09, 0x01, 0x60, 0x58, 0x0A, 0x02,
  0x80, 0x50, 0x14, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x00,
  0x08, 0x03, 0x0C, 0x02, 0x04, 0x06, 0x06, 0x0C, 0x02, 0x18, 0x02, 0x10,
  0x03, 0x30, 0x01, 0x60, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x40,
  0x02, 0x40, 0x06, 0x60, 0x0C, 0x20, 0x08, 0x30, 0x18, 0x10, 0x30, 0x10,
  0x60, 0x18, 0x40, 0x08, 0x0C, 0x00, 0xC1, 0x00, 0x20, 0x40, 0x18, 0x10,
  0x04, 0x04, 0x03, 0x01, 0x80, 0x80, 0x60, 0x60, 0x18, 0x10, 0x02, 0x0C,
  0x00, 0x82, 0x00, 0x20, 0x80, 0x08, 0x40, 0x03, 0x10, 0x00, 0xCC, 0x00,
  0x32, 0x00, 0x05, 0x80, 0x01, 0x40, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x07, 0x00,
  0xC0, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x0C, 0x30, 0xC2, 0x08, 0x21, 0x86, 0x18,
  0x41, 0x04, 0x10, 0xC3, 0x08, 0x20, 0x82, 0x18, 0x61, 0x84, 0x10, 0x41,
  0x0C, 0x30, 0x82, 0x08, 0x00, 0x04, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x1C, 0x01, 0x80, 0xC0, 0x10, 0x04, 0x00,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x40, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x08, 0x00, 0x1E, 0x00, 0x99, 0x80,
  0x58, 0x60, 0x68, 0x18, 0x2C, 0x06, 0x66, 0x01, 0xE0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 26, 7, 1, -26 },
  { 21, 6, 8, 10, 4, -28 },
  { 27, 18, 26, 18, 1, -26 },
  { 86, 16, 32, 17, 1, -29 },
  { 150, 18, 26, 23, 3, -26 },
  { 209, 16, 26, 19, 1, -26 },
  { 261, 2, 8, 6, 4, -28 },
  { 263, 10, 37, 10, 2, -29 },
  { 310, 10, 38, 10, -2, -29 },
  { 358, 14, 14, 15, 2, -26 },
  { 383, 15, 19, 18, 2, -22 },
  { 419, 4, 8, 7, -1, -3 },
  { 423, 7, 1, 10, 1, -12 },
  { 424, 2, 2, 8, 1, -2 },
  { 425, 15, 28, 12, -1, -26 },
  { 478, 14, 26, 17, 2, -26 },
  { 524, 8, 26, 17, 5, -26 },
  { 550, 15, 26, 17, 1, -26 },
  { 599, 15, 26, 17, 1, -26 },
  { 648, 15, 26, 17, 1, -26 },
  { 697, 16, 26, 17, 2, -26 },
  { 749, 13, 26, 17, 2, -26 },
  { 792, 15, 26, 17, 3, -26 },
  { 841, 16, 26, 17, 1, -26 },
  { 893, 13, 26, 17, 3, -26 },
  { 936, 6, 19, 7, 0, -19 },
  { 951, 7, 24, 7, -1, -19 },
  { 972, 13, 14, 16, 2, -19 },
  { 995, 14, 8, 18, 2, -16 },
  { 1009, 14, 14, 16, 1, -19 },
  { 1034, 11, 26, 14, 3, -26 },
  { 1070, 26, 34, 29, 1, -26 },
  { 1181, 18, 26, 19, -1, -26 },
  { 1240, 17, 26, 19, 1, -26 },
  { 1296, 18, 26, 20, 2, -26 },
  { 1355, 18, 26, 21, 1, -26 },
  { 1414, 18, 26, 18, 1, -26 },
  { 1473, 18, 26, 18, 1, -26 },
  { 1532, 18, 26, 21, 2, -26 },
  { 1591, 21, 26, 22, 1, -26 },
  { 1660, 6, 26, 9, 2, -26 },
  { 1680, 16, 26, 17, 1, -26 },
  { 1732, 20, 26, 20, 1, -26 },
  { 1797, 13, 26, 17, 1, -26 },
  { 1840, 25, 26, 27, 1, -26 },
  { 1922, 21, 26, 22, 1, -26 },
  { 1991, 18, 26, 21, 2, -26 },
  { 2050, 18, 26, 19, 1, -26 },
  { 2109, 18, 31, 21, 2, -26 },
  { 2179, 18, 26, 20, 1, -26 },
  { 2238, 18, 26, 19, 1, -26 },
  { 2297, 16, 26, 19, 4, -26 },
  { 2349, 19, 26, 21, 2, -26 },
  { 2411, 18, 26, 19, 3, -26 },
  { 2470, 25, 26, 28, 4, -26 },
  { 2552, 21, 26, 19, -1, -26 },
  { 2621, 18, 26, 19, 3, -26 },
  { 2680, 19, 26, 19, 0, -26 },
  { 2742, 10, 36, 8, 0, -30 },
  { 2787, 5, 28, 12, 4, -26 },
  { 2805, 10, 36, 8, -2, -30 },
  { 2850, 10, 13, 13, 2, -26 },
  { 2867, 13, 1, 14, -2, 0 },
  { 2869, 4, 5, 10, 5, -28 },
  { 2872, 14, 20, 17, 1, -20 },
  { 2907, 15, 28, 17, 1, -28 },
  { 2960, 14, 20, 16, 1, -20 },
  { 2995, 16, 28, 17, 2, -28 },
  { 3051, 14, 20, 16, 1, -20 },
  { 3086, 11, 28, 11, 2, -28 },
  { 3125, 16, 28, 17, 0, -20 },
  { 3181, 14, 28, 17, 1, -28 },
  { 3230, 6, 27, 7, 1, -27 },
  { 3251, 12, 35, 7, -5, -27 },
  { 3304, 15, 28, 15, 1, -28 },
  { 3357, 6, 28, 7, 1, -28 },
  { 3378, 25, 20, 28, 1, -20 },
  { 3441, 14, 20, 17, 1, -20 },
  { 3476, 15, 20, 17, 1, -20 },
  { 3514, 16, 28, 17, 0, -20 },
  { 3570, 14, 28, 17, 2, -20 },
  { 3619, 11, 20, 11, 1, -20 },
  { 3647, 13, 20, 16, 1, -20 },
  { 3680, 8, 25, 10, 2, -25 },
  { 3705, 14, 20, 17, 2, -20 },
  { 3740, 14, 20, 15, 2, -20 },
  { 3775, 21, 20, 24, 3, -20 },
  { 3828, 16, 20, 15, -1, -20 },
  { 3868, 18, 28, 15, -2, -20 },
  { 3931, 15, 20, 15, 0, -20 },
  { 3969, 12, 37, 11, 1, -29 },
  { 4025, 6, 31, 8, 1, -26 },
  { 4049, 11, 37, 11, -2, -29 },
  { 4100, 17, 6, 22, 2, -14 },
};

const GFXfont RobotoCondensed_ExtraLightItalic37pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic37pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic37pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC37PT7B_H_
