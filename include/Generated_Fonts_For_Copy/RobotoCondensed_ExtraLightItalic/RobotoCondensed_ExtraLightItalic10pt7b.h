#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC10PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x08, 0xD0, 0x09, 0x4C, 0xA5, 0x30, 0x80, 0x01, 0x90, 0x82,
  0x0A, 0x4E, 0x00, 0xC5, 0xB8, 0x47, 0x94, 0xC0, 0x32, 0x98, 0xCA, 0xCB,
  0x80, 0x80, 0x05, 0x29, 0x24, 0x88, 0x24, 0x92, 0x49, 0x40, 0x09, 0x40,
  0x06, 0x20, 0x80, 0x00, 0x80, 0x12, 0x24, 0x48, 0x80, 0x35, 0x59, 0x99,
  0x60, 0x45, 0x24, 0x80, 0x71, 0x11, 0x24, 0xE0, 0x71, 0x13, 0x19, 0x70,
  0x13, 0x35, 0xF1, 0x00, 0x68, 0x8E, 0x22, 0xE0, 0x24, 0x79, 0x99, 0x60,
  0x72, 0x24, 0x48, 0x00, 0x32, 0x52, 0xE9, 0x4B, 0xC0, 0xF6, 0xDE, 0x70,
  0x40, 0x20, 0x40, 0x20, 0x16, 0x42, 0x48, 0x43, 0x2C, 0xE4, 0xA0, 0x20,
  0x1C, 0x45, 0x4D, 0x1A, 0xB5, 0x6F, 0x40, 0x60, 0x13, 0x35, 0x79, 0x00,
  0x7A, 0x52, 0xE8, 0x46, 0xC0, 0x78, 0x88, 0x89, 0xE0, 0x5A, 0x52, 0x98,
  0xC6, 0xC0, 0x52, 0x10, 0xC8, 0x42, 0x80, 0x52, 0x10, 0xC8, 0x42, 0x00,
  0x78, 0x89, 0x89, 0xE0, 0x45, 0x14, 0x5D, 0x8A, 0x28, 0x80, 0x15, 0x60,
  0x08, 0x44, 0x21, 0x4B, 0x80, 0x49, 0x46, 0x18, 0x92, 0x48, 0x00, 0x44,
  0x44, 0x88, 0xA0, 0x42, 0x85, 0x9B, 0x5A, 0xB6, 0xA4, 0x00, 0x45, 0x96,
  0x55, 0x9A, 0x68, 0x80, 0x79, 0x99, 0x99, 0xE0, 0x7A, 0x52, 0xE8, 0x42,
  0x00, 0x79, 0x99, 0x99, 0xE0, 0x7A, 0x52, 0xC9, 0x4A, 0x00, 0x3A, 0x10,
  0x60, 0xC5, 0xC0, 0x72, 0x10, 0x84, 0x20, 0x00, 0x84, 0x65, 0x29, 0x4B,
  0x80, 0x04, 0xA5, 0x4A, 0x61, 0x00, 0x13, 0x26, 0xD5, 0xAD, 0x51, 0x20,
  0x00, 0x42, 0x4C, 0x45, 0x2A, 0x00, 0x84, 0xA8, 0x84, 0x20, 0x00, 0x38,
  0x44, 0x44, 0x23, 0x80, 0x09, 0x25, 0x24, 0x90, 0x7E, 0x04, 0x92, 0x52,
  0x48, 0x7C, 0x40, 0x00, 0x71, 0x79, 0xE0, 0x44, 0x47, 0x99, 0x9E, 0x78,
  0x89, 0xE0, 0x08, 0x42, 0xE9, 0x4A, 0x56, 0x7B, 0x88, 0xC0, 0x52, 0x49,
  0x20, 0x79, 0x99, 0xB1, 0xE0, 0x44, 0x47, 0x99, 0x99, 0x41, 0xA8, 0x20,
  0x14, 0x92, 0x00, 0x44, 0x45, 0xA4, 0xA8, 0x15, 0x6A, 0x7E, 0xA6, 0x4C,
  0x99, 0x00, 0x35, 0x99, 0x90, 0x79, 0x99, 0x60, 0x75, 0x99, 0xE8, 0x00,
  0x79, 0x99, 0xB1, 0x00, 0x4A, 0x48, 0x78, 0x61, 0xE0, 0x2A, 0xA0, 0x16,
  0xDE, 0x17, 0x68, 0x27, 0x7B, 0x28, 0x00, 0x16, 0x26, 0x80, 0x05, 0x66,
  0x44, 0x80, 0x32, 0x44, 0xC0, 0x25, 0x20, 0x12, 0x48, 0x55, 0xAA, 0x22,
  0x22, 0x02, 0x24, 0x48, 0xC3,
};

const GFXglyph RobotoCondensed_ExtraLightItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 2, 2, 3, 1, -8 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 5, 9, 5, 0, -8 },
  { 15, 5, 7, 6, 1, -7 },
  { 20, 5, 7, 5, 0, -7 },
  { 25, 1, 2, 2, 1, -8 },
  { 26, 3, 10, 3, 0, -8 },
  { 30, 3, 10, 3, -1, -8 },
  { 34, 3, 4, 4, 1, -7 },
  { 36, 4, 4, 5, 0, -5 },
  { 38, 1, 2, 2, 0, -1 },
  { 39, 2, 1, 3, 0, -4 },
  { 40, 1, 1, 2, 0, -1 },
  { 41, 4, 8, 3, 0, -7 },
  { 45, 4, 7, 5, 0, -7 },
  { 49, 3, 7, 5, 1, -7 },
  { 52, 4, 7, 5, 0, -7 },
  { 56, 4, 7, 5, 0, -7 },
  { 60, 4, 7, 5, 0, -7 },
  { 64, 4, 7, 5, 1, -7 },
  { 68, 4, 7, 5, 0, -7 },
  { 72, 4, 7, 5, 1, -7 },
  { 76, 5, 7, 5, 0, -7 },
  { 81, 3, 7, 5, 1, -7 },
  { 84, 2, 6, 2, 0, -6 },
  { 86, 2, 7, 2, 0, -6 },
  { 88, 4, 4, 4, 0, -5 },
  { 90, 3, 2, 5, 1, -4 },
  { 91, 4, 4, 4, 0, -5 },
  { 93, 3, 7, 4, 1, -7 },
  { 96, 7, 9, 8, 0, -7 },
  { 104, 4, 7, 5, 0, -7 },
  { 108, 5, 7, 5, 0, -7 },
  { 113, 4, 7, 6, 1, -7 },
  { 117, 5, 7, 6, 0, -7 },
  { 122, 5, 7, 5, 0, -7 },
  { 127, 5, 7, 5, 0, -7 },
  { 132, 4, 7, 6, 1, -7 },
  { 136, 6, 7, 6, 0, -7 },
  { 142, 2, 7, 2, 0, -7 },
  { 144, 5, 7, 5, 0, -7 },
  { 149, 6, 7, 5, 0, -7 },
  { 155, 4, 7, 4, 0, -7 },
  { 159, 7, 7, 7, 0, -7 },
  { 166, 6, 7, 6, 0, -7 },
  { 172, 4, 7, 6, 1, -7 },
  { 176, 5, 7, 5, 0, -7 },
  { 181, 4, 8, 6, 1, -7 },
  { 185, 5, 7, 5, 0, -7 },
  { 190, 5, 7, 5, 0, -7 },
  { 195, 5, 7, 5, 1, -7 },
  { 200, 5, 7, 6, 1, -7 },
  { 205, 5, 7, 5, 1, -7 },
  { 210, 7, 7, 8, 1, -7 },
  { 217, 5, 7, 5, 0, -7 },
  { 222, 5, 7, 5, 1, -7 },
  { 227, 5, 7, 5, 0, -7 },
  { 232, 3, 10, 2, 0, -8 },
  { 236, 1, 8, 3, 1, -7 },
  { 237, 3, 10, 2, -1, -8 },
  { 241, 2, 4, 4, 1, -7 },
  { 242, 3, 1, 4, 0, 0 },
  { 243, 2, 2, 3, 1, -8 },
  { 244, 4, 5, 5, 0, -5 },
  { 247, 4, 8, 5, 0, -8 },
  { 251, 4, 5, 4, 0, -5 },
  { 254, 5, 8, 5, 0, -8 },
  { 259, 4, 5, 4, 0, -5 },
  { 262, 3, 8, 3, 1, -8 },
  { 265, 4, 7, 5, 0, -5 },
  { 269, 4, 8, 5, 0, -8 },
  { 273, 2, 7, 2, 0, -7 },
  { 275, 3, 9, 2, -1, -7 },
  { 279, 4, 8, 4, 0, -8 },
  { 283, 2, 8, 2, 0, -8 },
  { 285, 7, 5, 7, 0, -5 },
  { 290, 4, 5, 5, 0, -5 },
  { 293, 4, 5, 5, 0, -5 },
  { 296, 4, 7, 5, 0, -5 },
  { 300, 4, 7, 5, 0, -5 },
  { 304, 3, 5, 3, 0, -5 },
  { 306, 4, 5, 4, 0, -5 },
  { 309, 2, 7, 3, 1, -7 },
  { 311, 3, 5, 5, 1, -5 },
  { 313, 3, 5, 4, 1, -5 },
  { 315, 5, 5, 6, 1, -5 },
  { 319, 4, 5, 4, 0, -5 },
  { 322, 4, 7, 4, 0, -5 },
  { 326, 4, 5, 4, 0, -5 },
  { 329, 3, 10, 3, 0, -8 },
  { 333, 2, 8, 2, 0, -7 },
  { 335, 4, 10, 3, -1, -8 },
  { 340, 4, 2, 6, 1, -4 },
};

const GFXfont RobotoCondensed_ExtraLightItalic10pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic10pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC10PT7B_H_
