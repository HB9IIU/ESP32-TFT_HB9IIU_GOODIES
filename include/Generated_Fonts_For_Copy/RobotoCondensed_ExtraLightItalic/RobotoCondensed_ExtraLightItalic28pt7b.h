#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC28PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x22, 0x22, 0x24, 0x44, 0x44, 0x00, 0x00, 0x88, 0x4A,
  0x55, 0x29, 0x48, 0x01, 0x08, 0x04, 0x40, 0x21, 0x00, 0x84, 0x02, 0x20,
  0x10, 0x83, 0xFF, 0xC1, 0x10, 0x08, 0x40, 0x21, 0x00, 0x88, 0x04, 0x20,
  0x10, 0x83, 0xFF, 0x82, 0x10, 0x08, 0x40, 0x22, 0x01, 0x08, 0x04, 0x20,
  0x11, 0x00, 0x00, 0x80, 0x10, 0x01, 0x00, 0x7C, 0x0C, 0x61, 0x02, 0x10,
  0x22, 0x02, 0x20, 0x22, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x04, 0x00, 0x48, 0x04, 0x80, 0x48, 0x04, 0x40, 0x86, 0x10, 0x3E,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x38, 0x02, 0x20, 0x21, 0x01, 0x08, 0x48,
  0x46, 0x42, 0x22, 0x12, 0x11, 0x20, 0x71, 0x00, 0x10, 0x01, 0x00, 0x09,
  0xC0, 0x91, 0x08, 0x84, 0x88, 0x24, 0x42, 0x42, 0x14, 0x10, 0x80, 0x88,
  0x03, 0x80, 0x07, 0x80, 0xC4, 0x08, 0x41, 0x04, 0x10, 0x41, 0x0C, 0x11,
  0x80, 0xB0, 0x0C, 0x00, 0xC0, 0x14, 0x02, 0x21, 0x42, 0x1C, 0x11, 0x81,
  0xA8, 0x0A, 0x80, 0xC8, 0x0C, 0x41, 0x23, 0xE2, 0x5A, 0xA0, 0x01, 0x02,
  0x04, 0x04, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40, 0x20,
  0x20, 0x10, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x20, 0x40, 0x80, 0x04, 0x01, 0x00, 0x40, 0x10, 0xE5,
  0xCF, 0x80, 0xC0, 0x50, 0x22, 0x10, 0x88, 0x10, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x0F, 0xFE, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x24, 0xB5, 0x00, 0xF8, 0xA0,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x00, 0x07, 0x81, 0x88, 0x40, 0x88,
  0x12, 0x02, 0x40, 0x48, 0x0A, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14,
  0x05, 0x00, 0xA0, 0x14, 0x06, 0x40, 0x88, 0x31, 0x8C, 0x1F, 0x00, 0x0C,
  0xDC, 0x82, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20,
  0x82, 0x08, 0x07, 0x81, 0x08, 0x40, 0x90, 0x12, 0x02, 0x40, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x03, 0x00, 0x7F, 0xE0, 0x07, 0x83, 0x0C, 0x40, 0x90, 0x12,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x81, 0xE0, 0x06, 0x00, 0x20, 0x04,
  0x00, 0xA0, 0x14, 0x02, 0x80, 0xD8, 0x11, 0x84, 0x1F, 0x00, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0xA0, 0x14, 0x04, 0x81, 0x10, 0x62, 0x08, 0x82, 0x10,
  0xC2, 0x10, 0x44, 0x09, 0x81, 0x3F, 0xF8, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x1F, 0xE2, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x02,
  0xF8, 0x61, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0xA0, 0x24, 0x04,
  0x80, 0x90, 0x21, 0x08, 0x1E, 0x00, 0x01, 0xC0, 0xC0, 0x30, 0x04, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x7C, 0x50, 0xCC, 0x09, 0x01, 0x20, 0x14, 0x03,
  0x00, 0xA0, 0x16, 0x02, 0x40, 0xC8, 0x10, 0x84, 0x0F, 0x00, 0x7F, 0xE0,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x07, 0xC0, 0x86, 0x10, 0x23, 0x03, 0x20, 0x12,
  0x02, 0x20, 0x22, 0x06, 0x10, 0xC0, 0xF0, 0x30, 0x84, 0x04, 0x40, 0x48,
  0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x43, 0x03, 0xE0, 0x0F, 0x04,
  0x22, 0x05, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x34, 0x15,
  0x8E, 0x3C, 0x80, 0x20, 0x18, 0x04, 0x02, 0x01, 0x80, 0xC3, 0xC0, 0x10,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x23, 0x00, 0x08, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x82, 0x08, 0x61, 0x08, 0x00,
  0x00, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x40, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x20, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0E, 0x02, 0x00, 0x1E, 0x18, 0x98, 0x28, 0x14, 0x08, 0x0C,
  0x04, 0x02, 0x02, 0x02, 0x02, 0x02, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x0C, 0x00, 0x00, 0x7E, 0x00, 0x30, 0x30, 0x08, 0x03, 0x02,
  0x00, 0x20, 0x80, 0x02, 0x20, 0x00, 0x44, 0x1E, 0x09, 0x04, 0x21, 0x21,
  0x04, 0x28, 0x20, 0x85, 0x08, 0x20, 0xA1, 0x04, 0x18, 0x40, 0x83, 0x08,
  0x10, 0xA1, 0x04, 0x14, 0x20, 0x82, 0x84, 0x30, 0x90, 0x8A, 0x22, 0x0E,
  0x38, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x81,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x28, 0x00,
  0xA0, 0x04, 0x40, 0x11, 0x00, 0x84, 0x02, 0x10, 0x10, 0x40, 0x41, 0x02,
  0x04, 0x08, 0x08, 0x7F, 0xE1, 0x00, 0x88, 0x02, 0x20, 0x09, 0x00, 0x24,
  0x00, 0xB0, 0x02, 0x1F, 0xC0, 0x81, 0x84, 0x04, 0x20, 0x21, 0x01, 0x98,
  0x08, 0x80, 0x44, 0x06, 0x20, 0x61, 0xFC, 0x08, 0x18, 0xC0, 0x44, 0x02,
  0x20, 0x09, 0x00, 0xC8, 0x04, 0x40, 0x24, 0x02, 0x20, 0x31, 0xFE, 0x00,
  0x07, 0xC0, 0x41, 0x84, 0x04, 0x40, 0x36, 0x00, 0xA0, 0x05, 0x00, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x90, 0x04, 0x80, 0x46, 0x02, 0x18, 0x60, 0x7C, 0x00, 0x1F, 0xC0, 0x40,
  0xC1, 0x01, 0x84, 0x02, 0x10, 0x08, 0xC0, 0x22, 0x00, 0x88, 0x02, 0x20,
  0x08, 0x80, 0x22, 0x00, 0x98, 0x02, 0x40, 0x09, 0x00, 0x44, 0x01, 0x10,
  0x0C, 0x40, 0x22, 0x01, 0x08, 0x18, 0x3F, 0x80, 0x1F, 0xF8, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0xFF,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0x82, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x03, 0xE0, 0x61, 0x84, 0x04, 0x40, 0x12, 0x00,
  0xA0, 0x05, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x07, 0xE8,
  0x01, 0x40, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x22, 0x01, 0x18, 0x30, 0x3E,
  0x00, 0x10, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x66, 0x00,
  0x88, 0x01, 0x10, 0x02, 0x20, 0x04, 0x7F, 0xF8, 0x80, 0x33, 0x00, 0x44,
  0x00, 0x88, 0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x11, 0x00, 0x22, 0x00,
  0x44, 0x00, 0x80, 0x08, 0x44, 0x21, 0x08, 0x46, 0x21, 0x08, 0x42, 0x31,
  0x08, 0x42, 0x11, 0x00, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x31, 0x01, 0x08, 0x08, 0x40, 0xC2, 0x04, 0x18, 0x40, 0x7C,
  0x00, 0x10, 0x04, 0x20, 0x10, 0x40, 0x40, 0x81, 0x01, 0x04, 0x06, 0x10,
  0x08, 0x40, 0x11, 0x80, 0x26, 0x00, 0x58, 0x00, 0xC8, 0x03, 0x10, 0x04,
  0x10, 0x08, 0x20, 0x10, 0x20, 0x20, 0x40, 0x40, 0x41, 0x00, 0x82, 0x00,
  0x84, 0x01, 0x80, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20,
  0x1F, 0xF0, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x03, 0x8C, 0x00, 0x61,
  0x40, 0x14, 0x48, 0x02, 0x89, 0x00, 0x91, 0x20, 0x12, 0x24, 0x04, 0x84,
  0x80, 0x90, 0x88, 0x22, 0x21, 0x04, 0x44, 0x21, 0x08, 0x84, 0x61, 0x10,
  0x88, 0x42, 0x0B, 0x08, 0x41, 0x41, 0x10, 0x30, 0x22, 0x06, 0x04, 0x40,
  0x80, 0x80, 0x18, 0x02, 0x30, 0x04, 0x60, 0x08, 0xA0, 0x11, 0x40, 0x26,
  0x40, 0x88, 0x81, 0x11, 0x02, 0x21, 0x04, 0x42, 0x08, 0x84, 0x13, 0x04,
  0x44, 0x08, 0x88, 0x09, 0x10, 0x12, 0x20, 0x24, 0x40, 0x39, 0x00, 0x62,
  0x00, 0xC4, 0x00, 0x80, 0x03, 0xE0, 0x10, 0x60, 0x80, 0x84, 0x01, 0x30,
  0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x40, 0x05, 0x00, 0x34, 0x00, 0x90,
  0x02, 0x40, 0x09, 0x00, 0x24, 0x01, 0x10, 0x04, 0x40, 0x31, 0x80, 0x83,
  0x0C, 0x07, 0xC0, 0x1F, 0xE0, 0x81, 0x84, 0x02, 0x20, 0x11, 0x00, 0x98,
  0x04, 0x80, 0x24, 0x01, 0x20, 0x11, 0x01, 0x88, 0x18, 0xFF, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x00,
  0x03, 0xE0, 0x10, 0x60, 0x80, 0x84, 0x01, 0x30, 0x04, 0x80, 0x12, 0x00,
  0x58, 0x01, 0x40, 0x05, 0x00, 0x34, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00,
  0x24, 0x01, 0x10, 0x04, 0x40, 0x31, 0x81, 0x83, 0x0C, 0x07, 0xE0, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x1F, 0xE0, 0x81, 0x84, 0x06, 0x20,
  0x11, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x20, 0x11, 0x01, 0x88, 0x18,
  0xFF, 0x04, 0x08, 0x20, 0x41, 0x03, 0x08, 0x08, 0x40, 0x44, 0x03, 0x20,
  0x09, 0x00, 0x40, 0x03, 0xC0, 0x61, 0x84, 0x04, 0x40, 0x12, 0x00, 0x90,
  0x04, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x02,
  0x00, 0x12, 0x00, 0x90, 0x04, 0x80, 0x26, 0x02, 0x18, 0x60, 0x3E, 0x00,
  0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x08, 0x80, 0x22, 0x00, 0x88,
  0x02, 0x40, 0x09, 0x00, 0x24, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x48,
  0x01, 0x20, 0x04, 0x80, 0x22, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x42,
  0x03, 0x06, 0x18, 0x0F, 0x80, 0x40, 0x09, 0x00, 0x24, 0x01, 0x90, 0x04,
  0x40, 0x31, 0x00, 0x84, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x02, 0x08,
  0x08, 0x40, 0x21, 0x00, 0x8C, 0x01, 0x20, 0x04, 0x80, 0x14, 0x00, 0x50,
  0x01, 0x80, 0x06, 0x00, 0x80, 0x40, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x40,
  0x60, 0x28, 0x14, 0x0D, 0x02, 0x81, 0x20, 0x88, 0x24, 0x11, 0x08, 0x82,
  0x21, 0x10, 0x84, 0x22, 0x10, 0x88, 0x44, 0x11, 0x04, 0x82, 0x60, 0x90,
  0x48, 0x14, 0x09, 0x02, 0x81, 0x40, 0x60, 0x28, 0x0C, 0x05, 0x01, 0x80,
  0x40, 0x20, 0x08, 0x00, 0x10, 0x02, 0x30, 0x08, 0x20, 0x20, 0x40, 0xC0,
  0x41, 0x00, 0x84, 0x00, 0x98, 0x01, 0x20, 0x02, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x14, 0x00, 0x48, 0x01, 0x18, 0x06, 0x10, 0x08, 0x20, 0x20, 0x20,
  0xC0, 0x41, 0x00, 0xC4, 0x00, 0x80, 0x80, 0x14, 0x01, 0xB0, 0x08, 0x80,
  0x84, 0x04, 0x20, 0x40, 0x84, 0x04, 0x20, 0x22, 0x00, 0xA0, 0x05, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x00, 0x0F, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x03, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xF0, 0x88, 0x88, 0x84, 0x44,
  0x44, 0x44, 0x22, 0x22, 0x22, 0x21, 0x11, 0x0F, 0x01, 0x01, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0xF0, 0x04, 0x06,
  0x0A, 0x0A, 0x12, 0x12, 0x22, 0x21, 0x41, 0x41, 0xFF, 0x80, 0x89, 0x10,
  0x07, 0x83, 0x0C, 0x40, 0x90, 0x10, 0x02, 0x00, 0x40, 0x08, 0x7E, 0x30,
  0x48, 0x09, 0x01, 0x20, 0x24, 0x0C, 0x87, 0x8F, 0x30, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x40, 0x09, 0xE1, 0x42, 0x30, 0x44, 0x05, 0x00,
  0xA0, 0x14, 0x02, 0x80, 0xD0, 0x12, 0x02, 0x80, 0x50, 0x13, 0x02, 0x50,
  0x89, 0xE0, 0x0F, 0x84, 0x32, 0x05, 0x01, 0x40, 0x50, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x0A, 0x02, 0x81, 0x10, 0xC3, 0xC0, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x0F, 0x21, 0x0A, 0x20, 0x66, 0x02,
  0x40, 0x64, 0x04, 0x40, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x88, 0x08,
  0xC0, 0x84, 0x38, 0x3C, 0x80, 0x0F, 0x84, 0x32, 0x05, 0x01, 0x40, 0x70,
  0x1F, 0xFE, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x43, 0xE0,
  0x07, 0x08, 0x10, 0x10, 0x30, 0x20, 0xFC, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x07, 0x90, 0x85,
  0x10, 0x33, 0x03, 0x20, 0x22, 0x02, 0x20, 0x24, 0x02, 0x40, 0x24, 0x02,
  0x40, 0x64, 0x04, 0x60, 0xC2, 0x14, 0x1E, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x81, 0x84, 0x30, 0x3E, 0x00, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x02, 0x78, 0xA1, 0x30, 0x48, 0x16, 0x05, 0x01, 0x40, 0x50, 0x14, 0x05,
  0x01, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0x80, 0x10, 0x80, 0x00, 0x00,
  0x84, 0x21, 0x08, 0x84, 0x21, 0x08, 0x44, 0x21, 0x08, 0x00, 0x00, 0x80,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x06, 0x06, 0x00, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x40, 0x08, 0x11, 0x04, 0x21, 0x04, 0x41, 0x90, 0x24,
  0x05, 0x80, 0xD0, 0x13, 0x02, 0x20, 0x86, 0x10, 0x42, 0x0C, 0x40, 0x88,
  0x18, 0x11, 0x11, 0x13, 0x22, 0x22, 0x24, 0x44, 0x44, 0x48, 0x88, 0x80,
  0x27, 0x87, 0x8A, 0x32, 0x13, 0x05, 0x05, 0x81, 0x81, 0x60, 0x60, 0x50,
  0x10, 0x14, 0x04, 0x05, 0x01, 0x01, 0x40, 0x40, 0x70, 0x30, 0x18, 0x08,
  0x0A, 0x02, 0x02, 0x80, 0x80, 0xA0, 0x20, 0x28, 0x08, 0x08, 0x27, 0x8A,
  0x13, 0x04, 0x81, 0x60, 0x50, 0x14, 0x05, 0x01, 0x40, 0x50, 0x18, 0x0A,
  0x02, 0x80, 0xA0, 0x28, 0x08, 0x0F, 0x82, 0x18, 0x81, 0x30, 0x14, 0x02,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x44, 0x08, 0xC6,
  0x0F, 0x80, 0x13, 0xC1, 0xC2, 0x18, 0x21, 0x01, 0x20, 0x12, 0x01, 0x20,
  0x12, 0x03, 0x20, 0x22, 0x02, 0x40, 0x24, 0x04, 0x60, 0x45, 0x08, 0x4F,
  0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x0F, 0x22,
  0x14, 0x81, 0xB0, 0x14, 0x04, 0x80, 0x90, 0x14, 0x02, 0x80, 0x50, 0x0A,
  0x02, 0x40, 0x4C, 0x08, 0x87, 0x0F, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x27, 0x28, 0x30, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x07, 0x83, 0x08, 0x40, 0x90, 0x12,
  0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x80, 0x10, 0x01, 0x20, 0x24, 0x08,
  0xC3, 0x07, 0x80, 0x10, 0x82, 0x08, 0xFC, 0x82, 0x10, 0x41, 0x04, 0x10,
  0xC2, 0x08, 0x20, 0x82, 0x06, 0x00, 0x20, 0x24, 0x04, 0x80, 0x90, 0x14,
  0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x48, 0x0A, 0x02, 0x60, 0x44, 0x18,
  0x85, 0x0F, 0x20, 0x80, 0x60, 0x28, 0x0A, 0x04, 0x81, 0x10, 0x84, 0x21,
  0x10, 0x44, 0x13, 0x04, 0x80, 0xA0, 0x30, 0x0C, 0x02, 0x00, 0x81, 0x81,
  0x81, 0x82, 0x82, 0x82, 0x82, 0x84, 0xC2, 0x84, 0x44, 0x84, 0x44, 0x88,
  0x48, 0x88, 0x48, 0x90, 0x50, 0x90, 0x50, 0x90, 0x50, 0xA0, 0x60, 0x60,
  0x60, 0x40, 0x40, 0x40, 0x10, 0x10, 0x41, 0x82, 0x08, 0x08, 0x80, 0x48,
  0x02, 0xC0, 0x0C, 0x00, 0x40, 0x05, 0x00, 0x68, 0x02, 0x60, 0x21, 0x03,
  0x08, 0x10, 0x21, 0x01, 0x00, 0x10, 0x08, 0x80, 0x84, 0x04, 0x20, 0x41,
  0x02, 0x04, 0x20, 0x21, 0x01, 0x10, 0x08, 0x80, 0x4C, 0x02, 0x40, 0x16,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x60, 0x0E, 0x00, 0x00, 0x1F, 0xE0, 0x04, 0x01, 0x00, 0x40, 0x10, 0x06,
  0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x3F,
  0xE0, 0x01, 0x81, 0x81, 0x80, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08,
  0x04, 0x02, 0x03, 0x03, 0x02, 0x00, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x00, 0x80, 0x20, 0x10, 0x0C, 0x03, 0x00, 0x08, 0x42, 0x11,
  0x88, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x23, 0x10, 0x84, 0x21, 0x08,
  0x0C, 0x03, 0x00, 0x80, 0x40, 0x20, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x08, 0x06, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x10, 0x18, 0x18, 0x18, 0x00, 0x38, 0x0A, 0x20, 0xA1,
  0x85, 0x06, 0x48, 0x1C, 0x00,
};

const GFXglyph RobotoCondensed_ExtraLightItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 20, 5, 1, -20 },
  { 11, 5, 6, 7, 3, -21 },
  { 15, 14, 20, 14, 1, -20 },
  { 50, 12, 26, 13, 1, -23 },
  { 89, 13, 20, 18, 3, -20 },
  { 122, 12, 20, 15, 1, -20 },
  { 152, 2, 6, 5, 3, -21 },
  { 154, 8, 28, 8, 1, -22 },
  { 182, 8, 28, 8, -2, -22 },
  { 210, 10, 11, 11, 2, -20 },
  { 224, 12, 15, 13, 1, -17 },
  { 247, 3, 6, 5, -1, -2 },
  { 250, 5, 1, 7, 1, -10 },
  { 251, 2, 2, 6, 1, -2 },
  { 252, 11, 22, 9, -1, -20 },
  { 283, 11, 20, 13, 1, -20 },
  { 311, 6, 20, 13, 4, -20 },
  { 326, 11, 20, 13, 1, -20 },
  { 354, 11, 20, 13, 1, -20 },
  { 382, 11, 20, 13, 1, -20 },
  { 410, 11, 20, 13, 2, -20 },
  { 438, 11, 20, 13, 1, -20 },
  { 466, 12, 20, 13, 2, -20 },
  { 496, 12, 20, 13, 1, -20 },
  { 526, 10, 20, 13, 2, -20 },
  { 551, 5, 15, 5, 0, -15 },
  { 561, 6, 19, 5, -1, -15 },
  { 576, 11, 12, 12, 1, -15 },
  { 593, 11, 6, 13, 1, -12 },
  { 602, 10, 12, 12, 1, -15 },
  { 617, 9, 20, 11, 2, -20 },
  { 640, 19, 25, 22, 1, -19 },
  { 700, 14, 20, 15, -1, -20 },
  { 735, 13, 20, 15, 1, -20 },
  { 768, 13, 20, 15, 2, -20 },
  { 801, 14, 20, 16, 1, -20 },
  { 836, 13, 20, 14, 1, -20 },
  { 869, 14, 20, 14, 1, -20 },
  { 904, 13, 20, 16, 2, -20 },
  { 937, 15, 20, 17, 1, -20 },
  { 975, 5, 20, 7, 1, -20 },
  { 988, 13, 20, 13, 0, -20 },
  { 1021, 15, 20, 15, 1, -20 },
  { 1059, 9, 20, 13, 1, -20 },
  { 1082, 19, 20, 20, 1, -20 },
  { 1130, 15, 20, 17, 1, -20 },
  { 1168, 14, 20, 16, 1, -20 },
  { 1203, 13, 20, 14, 1, -20 },
  { 1236, 14, 24, 16, 1, -20 },
  { 1278, 13, 20, 15, 1, -20 },
  { 1311, 13, 20, 14, 1, -20 },
  { 1344, 12, 20, 14, 3, -20 },
  { 1374, 14, 20, 16, 2, -20 },
  { 1409, 14, 20, 14, 2, -20 },
  { 1444, 19, 20, 21, 3, -20 },
  { 1492, 15, 20, 14, 0, -20 },
  { 1530, 13, 20, 14, 3, -20 },
  { 1563, 15, 20, 14, 0, -20 },
  { 1601, 8, 27, 6, 0, -23 },
  { 1628, 4, 22, 9, 3, -20 },
  { 1639, 8, 27, 6, -2, -23 },
  { 1666, 8, 10, 10, 1, -20 },
  { 1676, 10, 1, 10, -1, 0 },
  { 1678, 3, 4, 7, 4, -21 },
  { 1680, 11, 15, 13, 0, -15 },
  { 1701, 11, 21, 13, 1, -21 },
  { 1730, 10, 15, 12, 1, -15 },
  { 1749, 12, 21, 13, 1, -21 },
  { 1781, 10, 15, 12, 1, -15 },
  { 1800, 8, 21, 8, 2, -21 },
  { 1821, 12, 21, 13, 0, -15 },
  { 1853, 10, 21, 13, 1, -21 },
  { 1880, 5, 21, 5, 1, -21 },
  { 1894, 10, 27, 6, -4, -21 },
  { 1928, 11, 21, 12, 1, -21 },
  { 1957, 4, 21, 5, 1, -21 },
  { 1968, 18, 15, 21, 1, -15 },
  { 2002, 10, 15, 13, 1, -15 },
  { 2021, 11, 15, 13, 1, -15 },
  { 2042, 12, 21, 13, 0, -15 },
  { 2074, 11, 21, 13, 1, -15 },
  { 2103, 8, 15, 8, 1, -15 },
  { 2118, 11, 15, 12, 0, -15 },
  { 2139, 6, 19, 8, 2, -19 },
  { 2154, 11, 15, 13, 1, -15 },
  { 2175, 10, 15, 12, 2, -15 },
  { 2194, 16, 15, 18, 2, -15 },
  { 2224, 13, 15, 12, -1, -15 },
  { 2249, 13, 21, 11, -1, -15 },
  { 2284, 11, 15, 12, 0, -15 },
  { 2305, 9, 28, 8, 1, -22 },
  { 2337, 5, 24, 6, 0, -20 },
  { 2352, 9, 28, 8, -2, -22 },
  { 2384, 13, 5, 16, 2, -11 },
};

const GFXfont RobotoCondensed_ExtraLightItalic28pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic28pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic28pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC28PT7B_H_
