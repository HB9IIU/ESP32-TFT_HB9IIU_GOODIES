#ifndef _ROBOTOCONDENSED_EXTRALIGHTITALIC43PT7B_H_
#define _ROBOTOCONDENSED_EXTRALIGHTITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraLightItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraLightItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x20, 0x41, 0x83, 0x06, 0x08, 0x10, 0x20, 0xC1,
  0x83, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x18, 0x30, 0x00, 0x66, 0x8D, 0x1A, 0x3C, 0x58, 0xB3, 0x46,
  0x8C, 0x00, 0x18, 0x30, 0x00, 0x81, 0x80, 0x04, 0x08, 0x00, 0x60, 0x40,
  0x03, 0x06, 0x00, 0x10, 0x20, 0x01, 0x81, 0x00, 0x0C, 0x18, 0x00, 0x40,
  0x80, 0xFF, 0xFF, 0xC0, 0x30, 0x60, 0x01, 0x02, 0x00, 0x18, 0x10, 0x00,
  0xC1, 0x80, 0x04, 0x0C, 0x00, 0x20, 0x40, 0x03, 0x06, 0x00, 0x10, 0x30,
  0x00, 0x81, 0x00, 0x0C, 0x18, 0x00, 0x40, 0xC0, 0x7F, 0xFF, 0xE0, 0x30,
  0x60, 0x01, 0x03, 0x00, 0x08, 0x10, 0x00, 0xC0, 0x80, 0x04, 0x0C, 0x00,
  0x20, 0x40, 0x03, 0x02, 0x00, 0x18, 0x30, 0x00, 0x81, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x0F, 0xC0, 0x1F, 0xF0,
  0x1C, 0x0C, 0x18, 0x03, 0x0C, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x23, 0x00,
  0x11, 0x00, 0x08, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x20, 0x01, 0x90, 0x00, 0xC8, 0x00,
  0x66, 0x00, 0x23, 0x00, 0x30, 0x80, 0x30, 0x60, 0x38, 0x1F, 0xF8, 0x03,
  0xF0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0x00,
  0x01, 0xB8, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0x40, 0x40, 0x4C, 0x04,
  0x0C, 0xC0, 0x41, 0x8C, 0x0C, 0x10, 0x80, 0xC3, 0x08, 0x08, 0x60, 0xC1,
  0x84, 0x04, 0x10, 0xC0, 0x77, 0x18, 0x03, 0xC1, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x3C, 0x01, 0x8E, 0xE0, 0x30, 0x82,
  0x02, 0x18, 0x30, 0x61, 0x03, 0x0C, 0x30, 0x30, 0x83, 0x03, 0x10, 0x20,
  0x33, 0x02, 0x02, 0x20, 0x20, 0x20, 0x02, 0x06, 0x00, 0x30, 0xC0, 0x01,
  0x98, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x06, 0x0C, 0x01,
  0x81, 0x80, 0x30, 0x10, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06,
  0x06, 0x00, 0xC0, 0x80, 0x08, 0x70, 0x01, 0x98, 0x00, 0x36, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x0C, 0x40, 0x03, 0x0C, 0x04, 0x40,
  0x81, 0x98, 0x18, 0x36, 0x01, 0x84, 0xC0, 0x31, 0x90, 0x03, 0x36, 0x00,
  0x64, 0xC0, 0x07, 0x98, 0x00, 0x61, 0x00, 0x1C, 0x30, 0x06, 0x83, 0x01,
  0x98, 0x3F, 0xE1, 0x83, 0xF0, 0x30, 0x25, 0xB6, 0x92, 0xC0, 0x00, 0x10,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x10, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x30,
  0x0C, 0x03, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x05, 0xC3, 0x1E, 0x79, 0x3C, 0x07, 0xF0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0xCC, 0x00, 0xC6, 0x00, 0x61, 0x80, 0x60,
  0xC0, 0x60, 0x30, 0x20, 0x18, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x8C, 0x63, 0x31, 0x98, 0x80, 0xFF,
  0x80, 0x5F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x10, 0x40, 0x0C, 0x60, 0x06, 0x20,
  0x03, 0x30, 0x01, 0x98, 0x00, 0xC8, 0x00, 0x64, 0x00, 0x36, 0x00, 0x1B,
  0x00, 0x0D, 0x80, 0x04, 0xC0, 0x02, 0x40, 0x03, 0x20, 0x01, 0xB0, 0x00,
  0xD8, 0x00, 0x6C, 0x00, 0x26, 0x00, 0x33, 0x00, 0x19, 0x80, 0x08, 0xC0,
  0x0C, 0x60, 0x06, 0x10, 0x06, 0x0C, 0x02, 0x07, 0x07, 0x01, 0xFF, 0x00,
  0x3E, 0x00, 0x00, 0x83, 0xC7, 0xFE, 0x3C, 0x10, 0x08, 0x04, 0x06, 0x03,
  0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80,
  0xC0, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x30, 0x38, 0x18, 0x06, 0x0C, 0x00,
  0x83, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x10, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xE0, 0x00,
  0x7C, 0x00, 0x7F, 0xC0, 0x30, 0x18, 0x18, 0x06, 0x0C, 0x00, 0xC3, 0x00,
  0x31, 0x80, 0x0C, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x4C, 0x00, 0x13, 0x00, 0x0C, 0xC0, 0x03, 0x10, 0x00, 0x86, 0x00, 0x61,
  0x80, 0x30, 0x30, 0x18, 0x07, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0D, 0x80, 0x02, 0x40, 0x01,
  0x90, 0x00, 0xCC, 0x00, 0x23, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x06, 0x08,
  0x01, 0x02, 0x00, 0xC1, 0x80, 0x60, 0x60, 0x10, 0x18, 0x0C, 0x04, 0x06,
  0x01, 0x01, 0x00, 0x40, 0xC0, 0x30, 0x60, 0x0C, 0x30, 0x03, 0x0F, 0xFF,
  0xFC, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xCF, 0x80, 0x3F, 0xF8,
  0x0E, 0x07, 0x02, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x42, 0x00,
  0x10, 0x80, 0x0C, 0x20, 0x03, 0x0C, 0x01, 0x83, 0x00, 0x40, 0x60, 0x70,
  0x0F, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x31, 0xF0, 0x27, 0xFC, 0x6C, 0x0C, 0x78, 0x06, 0x70,
  0x02, 0x60, 0x03, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0x40, 0x04, 0x60, 0x0C, 0x60,
  0x18, 0x30, 0x30, 0x1F, 0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0E, 0x06, 0x03, 0x00, 0x60, 0x60,
  0x0C, 0x18, 0x00, 0x83, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x43, 0x00,
  0x18, 0x20, 0x03, 0x04, 0x00, 0xC0, 0xC0, 0x30, 0x0C, 0x0E, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x0E, 0x0C, 0x03, 0x00, 0xC0, 0xC0, 0x0C, 0x30, 0x01,
  0x86, 0x00, 0x10, 0x80, 0x02, 0x30, 0x00, 0x46, 0x00, 0x08, 0xC0, 0x03,
  0x18, 0x00, 0x61, 0x00, 0x18, 0x30, 0x06, 0x03, 0x01, 0x80, 0x3F, 0xE0,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0C, 0x0C, 0x18, 0x06, 0x30,
  0x02, 0x30, 0x03, 0x60, 0x03, 0x60, 0x03, 0x40, 0x03, 0x40, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0x40,
  0x0E, 0x60, 0x1E, 0x30, 0x34, 0x3F, 0xE4, 0x0F, 0x8C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x80, 0x7E, 0x00, 0x78, 0x00, 0x08, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x0C, 0x00, 0x01,
  0x01, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x30, 0x18, 0x18, 0x08, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x08, 0x3F, 0xFF, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x10, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xC0, 0xFF, 0x0C, 0x0C, 0xC0, 0x66,
  0x01, 0x60, 0x0F, 0x00, 0x70, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x02, 0x02, 0x00, 0x00, 0x0C, 0x18, 0x07, 0xC0, 0x30, 0xC0, 0x3B,
  0x80, 0x43, 0x01, 0x83, 0x01, 0x18, 0x0C, 0x04, 0x04, 0x60, 0x60, 0x30,
  0x11, 0x01, 0x00, 0xC0, 0x4C, 0x0C, 0x02, 0x01, 0x20, 0x20, 0x08, 0x0C,
  0x81, 0x80, 0x60, 0x36, 0x06, 0x01, 0x80, 0xD8, 0x10, 0x04, 0x02, 0x40,
  0x40, 0x10, 0x09, 0x03, 0x00, 0xC0, 0x64, 0x0C, 0x03, 0x01, 0x10, 0x30,
  0x08, 0x04, 0x40, 0xC0, 0x60, 0x33, 0x03, 0x03, 0x80, 0x8C, 0x0C, 0x0A,
  0x06, 0x10, 0x30, 0x48, 0x30, 0x40, 0x76, 0x3B, 0x81, 0x00, 0xF0, 0x7C,
  0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x58,
  0x00, 0x0D, 0x80, 0x00, 0x98, 0x00, 0x18, 0x80, 0x01, 0x08, 0x00, 0x30,
  0x80, 0x03, 0x08, 0x00, 0x60, 0x80, 0x06, 0x0C, 0x00, 0xC0, 0xC0, 0x0C,
  0x0C, 0x00, 0x80, 0x40, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x04, 0x02,
  0x00, 0x60, 0x60, 0x06, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x08, 0x00, 0x21,
  0x80, 0x02, 0x18, 0x00, 0x23, 0x00, 0x03, 0x30, 0x00, 0x36, 0x00, 0x03,
  0x60, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x10, 0x07, 0xFE, 0x00, 0xFF,
  0xF0, 0x30, 0x07, 0x06, 0x00, 0x60, 0xC0, 0x06, 0x10, 0x00, 0xC2, 0x00,
  0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x08, 0x60, 0x03, 0x08, 0x00,
  0x61, 0x00, 0x18, 0x60, 0x06, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x30, 0x07,
  0x04, 0x00, 0x60, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x08, 0xC0, 0x01,
  0x18, 0x00, 0x22, 0x00, 0x0C, 0x40, 0x01, 0x98, 0x00, 0x23, 0x00, 0x0C,
  0x60, 0x03, 0x0C, 0x00, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xFE, 0x00, 0xE0, 0x18, 0x06, 0x00, 0x60, 0x60, 0x03, 0x06,
  0x00, 0x08, 0x20, 0x00, 0x43, 0x00, 0x03, 0x10, 0x00, 0x19, 0x80, 0x00,
  0xCC, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00,
  0x18, 0x40, 0x00, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x40, 0x60, 0x06, 0x03,
  0x80, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0xF8, 0x0C, 0x01, 0xC0, 0xC0, 0x0E, 0x0C, 0x00, 0x60, 0x80, 0x03, 0x08,
  0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x11, 0x80, 0x01, 0x18, 0x00, 0x11,
  0x00, 0x01, 0x10, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03,
  0x30, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00,
  0x66, 0x00, 0x04, 0x60, 0x00, 0xC4, 0x00, 0x0C, 0x40, 0x01, 0x8C, 0x00,
  0x10, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x1C, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xF0,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0x00, 0xC0, 0x60, 0x06,
  0x0C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x33, 0x00, 0x01, 0x30, 0x00,
  0x12, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x3F, 0xEC, 0x03, 0xFE, 0xC0,
  0x00, 0x6C, 0x00, 0x04, 0xC0, 0x00, 0x48, 0x00, 0x0C, 0xC0, 0x00, 0xCC,
  0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x08, 0x60, 0x01, 0x86, 0x00, 0x38,
  0x30, 0x0F, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x04, 0x00, 0x06, 0x08,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x20, 0xC0, 0x00, 0x41, 0x00,
  0x01, 0x82, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x10, 0x60, 0x00, 0x20, 0x80, 0x00, 0xC1, 0x00, 0x01, 0x86, 0x00, 0x03,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x30, 0x00, 0x10, 0x40, 0x00, 0x60,
  0x80, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x04, 0x18,
  0x00, 0x08, 0x20, 0x00, 0x30, 0x40, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00,
  0x01, 0x86, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x10, 0x00, 0x18, 0x20, 0x00,
  0x30, 0x00, 0x06, 0x0C, 0x18, 0x20, 0x41, 0x83, 0x06, 0x0C, 0x10, 0x20,
  0xC1, 0x83, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x60,
  0xC1, 0x02, 0x0C, 0x18, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x30, 0x01,
  0x86, 0x00, 0x30, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x60, 0x20, 0x0C,
  0x06, 0x03, 0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x00, 0x04, 0x00, 0x1C, 0x10,
  0x00, 0xE0, 0xC0, 0x03, 0x03, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x20, 0x06,
  0x00, 0x80, 0x30, 0x06, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x01,
  0x83, 0x00, 0x04, 0x18, 0x00, 0x10, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x38,
  0x00, 0x0D, 0xB0, 0x00, 0x3C, 0xC0, 0x00, 0xE1, 0x80, 0x03, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x40, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x00,
  0xC0, 0xC0, 0x03, 0x02, 0x00, 0x06, 0x08, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x38, 0x30, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0F, 0x05,
  0x80, 0x00, 0x58, 0x2C, 0x00, 0x06, 0xC3, 0x20, 0x00, 0x24, 0x19, 0x00,
  0x03, 0x20, 0xCC, 0x00, 0x33, 0x06, 0x60, 0x01, 0x98, 0x23, 0x00, 0x18,
  0xC1, 0x08, 0x00, 0xC6, 0x18, 0x40, 0x0C, 0x20, 0xC2, 0x00, 0x61, 0x06,
  0x18, 0x06, 0x18, 0x30, 0xC0, 0x30, 0xC1, 0x06, 0x03, 0x06, 0x08, 0x10,
  0x18, 0x20, 0xC0, 0x81, 0x81, 0x06, 0x04, 0x08, 0x18, 0x30, 0x30, 0xC0,
  0xC1, 0x81, 0x84, 0x06, 0x08, 0x0C, 0x60, 0x30, 0x40, 0x22, 0x01, 0x06,
  0x01, 0x30, 0x08, 0x30, 0x09, 0x00, 0xC1, 0x80, 0x78, 0x06, 0x0C, 0x03,
  0x80, 0x30, 0x40, 0x0C, 0x01, 0x82, 0x00, 0x40, 0x08, 0x00, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x78, 0x00, 0x30, 0xF0, 0x00,
  0x41, 0xA0, 0x00, 0x82, 0x60, 0x03, 0x0C, 0x40, 0x06, 0x18, 0xC0, 0x0C,
  0x31, 0x80, 0x18, 0x61, 0x00, 0x20, 0xC3, 0x00, 0x41, 0x06, 0x01, 0x86,
  0x04, 0x03, 0x0C, 0x0C, 0x06, 0x18, 0x08, 0x0C, 0x30, 0x18, 0x10, 0x40,
  0x30, 0x20, 0x80, 0x20, 0xC3, 0x00, 0x61, 0x86, 0x00, 0xC3, 0x0C, 0x00,
  0x86, 0x18, 0x01, 0x88, 0x20, 0x01, 0x10, 0x40, 0x03, 0x61, 0x80, 0x06,
  0xC3, 0x00, 0x05, 0x86, 0x00, 0x0F, 0x0C, 0x00, 0x1C, 0x10, 0x00, 0x18,
  0x20, 0x00, 0x30, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xE0, 0x18,
  0x0E, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x0C, 0x20, 0x00, 0x63, 0x00,
  0x03, 0x10, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x32,
  0x00, 0x01, 0x90, 0x00, 0x0D, 0x80, 0x00, 0x4C, 0x00, 0x02, 0x60, 0x00,
  0x33, 0x00, 0x01, 0x90, 0x00, 0x0C, 0x80, 0x00, 0x6C, 0x00, 0x02, 0x60,
  0x00, 0x33, 0x00, 0x01, 0x88, 0x00, 0x08, 0x40, 0x00, 0xC3, 0x00, 0x04,
  0x18, 0x00, 0x60, 0x60, 0x06, 0x03, 0x80, 0xE0, 0x0F, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x0C, 0x00, 0xC0, 0xC0, 0x06,
  0x0C, 0x00, 0x20, 0x80, 0x03, 0x08, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00,
  0x31, 0x80, 0x03, 0x18, 0x00, 0x21, 0x00, 0x06, 0x10, 0x00, 0x63, 0x00,
  0x0C, 0x30, 0x01, 0xC3, 0x00, 0x38, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07,
  0xFE, 0x00, 0xE0, 0x18, 0x0E, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x08,
  0x60, 0x00, 0x63, 0x00, 0x03, 0x10, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00,
  0x06, 0x40, 0x00, 0x32, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x4C,
  0x00, 0x02, 0x60, 0x00, 0x33, 0x00, 0x01, 0x90, 0x00, 0x0D, 0x80, 0x00,
  0x4C, 0x00, 0x02, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x08, 0x40,
  0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x06, 0x03, 0x80, 0xE0,
  0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE,
  0x01, 0x80, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x02, 0x00, 0x0C, 0x10,
  0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x04,
  0x10, 0x00, 0x60, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x03, 0x00,
  0x30, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x04, 0x03, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x80, 0x08, 0x04, 0x00, 0x60, 0x20, 0x03,
  0x03, 0x00, 0x08, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x04, 0x00, 0x08, 0x20,
  0x00, 0x61, 0x00, 0x03, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xE0,
  0x38, 0x0E, 0x00, 0xC0, 0x60, 0x03, 0x06, 0x00, 0x18, 0x20, 0x00, 0x41,
  0x00, 0x02, 0x18, 0x00, 0x10, 0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00,
  0x04, 0x18, 0x00, 0x60, 0xC0, 0x06, 0x03, 0x80, 0xE0, 0x0F, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0x83, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20,
  0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x10, 0x40, 0x00,
  0x41, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3,
  0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00,
  0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x41, 0x00, 0x01, 0x04, 0x00, 0x0C,
  0x10, 0x00, 0x30, 0x40, 0x00, 0x81, 0x80, 0x06, 0x06, 0x00, 0x10, 0x0C,
  0x00, 0xC0, 0x38, 0x0E, 0x00, 0x7F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0xC0,
  0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xC4,
  0x00, 0x0C, 0x40, 0x01, 0x86, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0x30,
  0x60, 0x02, 0x06, 0x00, 0x60, 0x20, 0x04, 0x02, 0x00, 0xC0, 0x20, 0x0C,
  0x03, 0x01, 0x80, 0x30, 0x18, 0x03, 0x03, 0x00, 0x10, 0x30, 0x01, 0x02,
  0x00, 0x10, 0x60, 0x01, 0x04, 0x00, 0x18, 0xC0, 0x01, 0x88, 0x00, 0x19,
  0x80, 0x00, 0x98, 0x00, 0x0B, 0x00, 0x00, 0xB0, 0x00, 0x0A, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00,
  0x2C, 0x00, 0x70, 0x01, 0xB0, 0x01, 0x40, 0x06, 0xC0, 0x05, 0x00, 0x11,
  0x00, 0x34, 0x00, 0xC4, 0x00, 0x90, 0x03, 0x10, 0x06, 0x60, 0x08, 0x40,
  0x19, 0x80, 0x61, 0x00, 0x46, 0x01, 0x84, 0x03, 0x18, 0x04, 0x18, 0x08,
  0x60, 0x30, 0x60, 0x60, 0x80, 0x81, 0x81, 0x82, 0x06, 0x06, 0x04, 0x08,
  0x18, 0x18, 0x30, 0x20, 0x40, 0x60, 0x80, 0x83, 0x01, 0x86, 0x02, 0x0C,
  0x06, 0x18, 0x0C, 0x20, 0x18, 0x40, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x01,
  0x88, 0x03, 0x10, 0x02, 0x60, 0x0C, 0xC0, 0x09, 0x80, 0x32, 0x00, 0x24,
  0x00, 0x58, 0x00, 0xB0, 0x01, 0x60, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x03, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x01,
  0x80, 0x0C, 0x01, 0x80, 0x18, 0x00, 0x80, 0x30, 0x00, 0xC0, 0x30, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x21, 0x80, 0x00,
  0x33, 0x00, 0x00, 0x13, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x66, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x83, 0x00, 0x03, 0x01, 0x00, 0x03,
  0x01, 0x80, 0x06, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x18,
  0x00, 0x40, 0x30, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x3C, 0x00, 0x06, 0x60, 0x00, 0x46, 0x00, 0x0C, 0x60, 0x01, 0x82,
  0x00, 0x18, 0x30, 0x03, 0x03, 0x00, 0x60, 0x10, 0x06, 0x01, 0x80, 0xC0,
  0x18, 0x18, 0x00, 0x81, 0x80, 0x08, 0x30, 0x00, 0xC2, 0x00, 0x0C, 0x60,
  0x00, 0x4C, 0x00, 0x06, 0x80, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x7C, 0x0F, 0xC0, 0xC0, 0x81,
  0x02, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x40, 0x81, 0x83, 0x06, 0x0C, 0x08,
  0x10, 0x20, 0x60, 0xC1, 0x83, 0x02, 0x04, 0x08, 0x18, 0x30, 0x60, 0xC0,
  0x81, 0x02, 0x04, 0x0C, 0x01, 0xF0, 0x1F, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x7C, 0x0F, 0xC0, 0x00, 0x80, 0x1C, 0x01, 0xC0,
  0x34, 0x02, 0x40, 0x64, 0x04, 0x40, 0xC6, 0x08, 0x61, 0x86, 0x10, 0x23,
  0x02, 0x20, 0x26, 0x03, 0x40, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0xC2, 0x18,
  0x43, 0x08, 0x01, 0xF8, 0x07, 0xFC, 0x0E, 0x06, 0x18, 0x03, 0x18, 0x03,
  0x30, 0x03, 0x30, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x03, 0xFE,
  0x1F, 0x86, 0x38, 0x06, 0x60, 0x06, 0x40, 0x06, 0xC0, 0x04, 0xC0, 0x04,
  0x80, 0x0C, 0x80, 0x1C, 0xC0, 0x3C, 0xC0, 0x6C, 0x7F, 0xCC, 0x3F, 0x0C,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x3E, 0x02, 0x7F, 0x81,
  0x60, 0x61, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x20, 0x03, 0x10, 0x01,
  0x88, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x19, 0x00, 0x0C, 0x80,
  0x04, 0xC0, 0x02, 0x60, 0x03, 0x30, 0x01, 0x98, 0x01, 0x8C, 0x00, 0xC6,
  0x00, 0xC6, 0xC0, 0xC3, 0x3F, 0xC1, 0x8F, 0xC0, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0x81, 0x83, 0x00, 0x61, 0x80, 0x31, 0x80, 0x08, 0xC0, 0x04, 0x40,
  0x02, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x20, 0x02, 0x10, 0x03,
  0x0C, 0x01, 0x03, 0x03, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0xF8, 0x60, 0xFF, 0x98, 0x70, 0x34,
  0x18, 0x05, 0x0C, 0x00, 0xC2, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x10,
  0x00, 0x8C, 0x00, 0x23, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x88, 0x00,
  0x62, 0x00, 0x10, 0x80, 0x04, 0x20, 0x03, 0x08, 0x00, 0xC3, 0x00, 0x30,
  0xC0, 0x1C, 0x18, 0x1A, 0x03, 0xFC, 0x80, 0x7C, 0x60, 0x01, 0xF8, 0x03,
  0xFE, 0x0E, 0x06, 0x0C, 0x03, 0x18, 0x03, 0x30, 0x01, 0x30, 0x01, 0x20,
  0x01, 0x60, 0x01, 0x7F, 0xFF, 0x7F, 0xFF, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x18, 0x1F, 0xF0, 0x0F, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x38,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x01, 0xFF,
  0x80, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x00, 0xF8, 0x60, 0x7F, 0xCC, 0x1C, 0x0D, 0x03, 0x00,
  0xA0, 0xC0, 0x0C, 0x10, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x10, 0x00,
  0x86, 0x00, 0x10, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x40, 0x03,
  0x08, 0x00, 0x41, 0x00, 0x08, 0x20, 0x03, 0x04, 0x00, 0x60, 0xC0, 0x0C,
  0x18, 0x03, 0x81, 0x81, 0xA0, 0x3F, 0xE4, 0x01, 0xF1, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x0C, 0x01, 0x80,
  0xC0, 0x60, 0x0F, 0x78, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x3E, 0x02, 0x7F, 0x81, 0x60, 0x61, 0xA0, 0x10, 0xE0,
  0x08, 0x60, 0x06, 0x30, 0x03, 0x10, 0x01, 0x08, 0x00, 0x8C, 0x00, 0x46,
  0x00, 0x63, 0x00, 0x31, 0x00, 0x18, 0x80, 0x08, 0xC0, 0x04, 0x60, 0x02,
  0x30, 0x03, 0x18, 0x01, 0x88, 0x00, 0xC4, 0x00, 0x46, 0x00, 0x23, 0x00,
  0x31, 0x80, 0x18, 0x02, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x30, 0x40, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x41, 0x83, 0x06, 0x08, 0x10,
  0x20, 0xC1, 0x83, 0x04, 0x08, 0x30, 0x60, 0x00, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x1F, 0x00,
  0xF0, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0xC2,
  0x00, 0xC1, 0x00, 0xC1, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x20, 0xC0,
  0x10, 0xC0, 0x08, 0xC0, 0x0C, 0xC0, 0x06, 0xE0, 0x03, 0xD0, 0x01, 0xCC,
  0x00, 0x82, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x30, 0x18, 0x18, 0x08,
  0x06, 0x04, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x18, 0x02, 0x04,
  0x18, 0x30, 0x60, 0x81, 0x02, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x06, 0x0C,
  0x18, 0x20, 0x41, 0x83, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x83, 0x04, 0x08,
  0x10, 0x60, 0x08, 0x7C, 0x07, 0xC0, 0xCF, 0xF0, 0xFF, 0x06, 0xC0, 0xCC,
  0x0C, 0x3C, 0x06, 0xC0, 0x21, 0xC0, 0x14, 0x01, 0x8C, 0x00, 0xC0, 0x0C,
  0x60, 0x06, 0x00, 0x66, 0x00, 0x30, 0x03, 0x30, 0x01, 0x00, 0x19, 0x80,
  0x18, 0x00, 0x8C, 0x00, 0xC0, 0x04, 0x40, 0x06, 0x00, 0x62, 0x00, 0x30,
  0x03, 0x30, 0x01, 0x00, 0x19, 0x80, 0x08, 0x00, 0xCC, 0x00, 0xC0, 0x04,
  0x60, 0x06, 0x00, 0x22, 0x00, 0x30, 0x03, 0x10, 0x01, 0x00, 0x19, 0x80,
  0x08, 0x00, 0xCC, 0x00, 0x40, 0x06, 0x60, 0x06, 0x00, 0x23, 0x00, 0x30,
  0x01, 0x00, 0x08, 0x7C, 0x04, 0xFF, 0x06, 0xC0, 0xC3, 0x40, 0x61, 0xC0,
  0x10, 0xE0, 0x08, 0x60, 0x06, 0x20, 0x02, 0x30, 0x01, 0x18, 0x00, 0x8C,
  0x00, 0xC6, 0x00, 0x62, 0x00, 0x31, 0x00, 0x11, 0x80, 0x08, 0xC0, 0x04,
  0x60, 0x06, 0x30, 0x03, 0x10, 0x01, 0x88, 0x00, 0x8C, 0x00, 0x46, 0x00,
  0x63, 0x00, 0x30, 0x01, 0xF8, 0x07, 0xFC, 0x0C, 0x06, 0x18, 0x02, 0x30,
  0x03, 0x20, 0x03, 0x60, 0x03, 0x60, 0x01, 0x40, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80,
  0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0x40, 0x18, 0x60, 0x30, 0x3F, 0xE0, 0x1F,
  0x80, 0x02, 0x1F, 0x00, 0x4F, 0xF0, 0x1B, 0x03, 0x03, 0x80, 0x30, 0x60,
  0x06, 0x0C, 0x00, 0xC1, 0x00, 0x18, 0x20, 0x03, 0x0C, 0x00, 0x61, 0x80,
  0x0C, 0x30, 0x01, 0x86, 0x00, 0x30, 0x80, 0x06, 0x10, 0x00, 0x86, 0x00,
  0x10, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x01,
  0x83, 0x40, 0x60, 0x67, 0xF8, 0x0C, 0x7E, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x03, 0xE1, 0x87, 0xFC, 0xC7, 0x03, 0x43,
  0x00, 0xA3, 0x00, 0x31, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x40, 0x02,
  0x60, 0x01, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x64, 0x00, 0x22, 0x00,
  0x11, 0x00, 0x08, 0x80, 0x0C, 0x40, 0x06, 0x30, 0x03, 0x18, 0x03, 0x06,
  0x06, 0x83, 0xFE, 0x40, 0x7C, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x08, 0xF8, 0x4F, 0x86, 0xC0, 0x3C, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0C, 0x06, 0x18, 0x06, 0x10,
  0x02, 0x30, 0x03, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0x60, 0x30, 0x3F, 0xE0, 0x1F,
  0x80, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x07, 0xFC, 0x20, 0x08,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xF0,
  0x3C, 0x00, 0x10, 0x01, 0x88, 0x00, 0x8C, 0x00, 0x46, 0x00, 0x23, 0x00,
  0x31, 0x80, 0x18, 0x80, 0x0C, 0x40, 0x04, 0x60, 0x02, 0x30, 0x01, 0x18,
  0x01, 0x88, 0x00, 0xC4, 0x00, 0x62, 0x00, 0x23, 0x00, 0x11, 0x80, 0x18,
  0xC0, 0x0C, 0x60, 0x06, 0x30, 0x07, 0x08, 0x07, 0x06, 0x06, 0x81, 0xFE,
  0xC0, 0x7C, 0x60, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x36, 0x00, 0x6C, 0x01,
  0x88, 0x03, 0x10, 0x04, 0x20, 0x18, 0x60, 0x20, 0xC0, 0xC1, 0x81, 0x03,
  0x06, 0x02, 0x08, 0x04, 0x30, 0x08, 0x60, 0x19, 0x80, 0x33, 0x00, 0x64,
  0x00, 0x58, 0x00, 0xA0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x18, 0x03, 0xC0, 0x18, 0x03, 0x40, 0x18, 0x02, 0x40, 0x38, 0x06, 0x40,
  0x28, 0x06, 0x40, 0x6C, 0x0C, 0x40, 0x4C, 0x0C, 0x40, 0xCC, 0x08, 0x60,
  0xCC, 0x18, 0x60, 0x8C, 0x18, 0x61, 0x8C, 0x30, 0x61, 0x04, 0x30, 0x63,
  0x04, 0x20, 0x62, 0x04, 0x60, 0x66, 0x04, 0x60, 0x66, 0x04, 0xC0, 0x64,
  0x04, 0xC0, 0x2C, 0x06, 0x80, 0x28, 0x07, 0x80, 0x38, 0x07, 0x80, 0x30,
  0x07, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x0C, 0x00, 0xC0, 0xC0,
  0x18, 0x18, 0x06, 0x01, 0x01, 0x80, 0x30, 0x30, 0x06, 0x0C, 0x00, 0x63,
  0x00, 0x0C, 0x40, 0x00, 0x98, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x03, 0x60, 0x00, 0xCC, 0x00, 0x18, 0x80, 0x06, 0x18,
  0x01, 0x81, 0x00, 0x20, 0x30, 0x0C, 0x06, 0x03, 0x00, 0x60, 0xC0, 0x0C,
  0x18, 0x00, 0x80, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x20, 0x60,
  0x06, 0x06, 0x00, 0x40, 0x20, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x03,
  0x01, 0x00, 0x30, 0x30, 0x03, 0x02, 0x00, 0x30, 0x60, 0x01, 0x06, 0x00,
  0x10, 0xC0, 0x01, 0x0C, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x1B, 0x00,
  0x00, 0xB0, 0x00, 0x0A, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xFF, 0x87, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xF3, 0xFF, 0xF0,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x06, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x06, 0x0C,
  0x18, 0x20, 0x40, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x41, 0x83, 0x06, 0x0C,
  0x10, 0x20, 0x41, 0x83, 0x06, 0x0C, 0x10, 0x20, 0xC1, 0x83, 0x06, 0x08,
  0x00, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x70, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x38,
  0x01, 0x80, 0x04, 0x00, 0x00, 0x1E, 0x00, 0x27, 0xF0, 0x05, 0x87, 0x01,
  0xE0, 0x70, 0x28, 0x06, 0x0D, 0x00, 0x7F, 0x00, 0x03, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraLightItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 31, 8, 1, -31 },
  { 29, 7, 9, 11, 5, -32 },
  { 37, 21, 31, 21, 1, -31 },
  { 119, 17, 39, 20, 2, -35 },
  { 202, 20, 31, 27, 4, -31 },
  { 280, 19, 31, 22, 1, -31 },
  { 354, 3, 9, 7, 4, -32 },
  { 358, 12, 44, 12, 2, -34 },
  { 424, 11, 44, 12, -2, -34 },
  { 485, 17, 17, 18, 2, -31 },
  { 522, 17, 22, 21, 2, -25 },
  { 569, 5, 9, 8, -1, -4 },
  { 575, 9, 1, 11, 1, -14 },
  { 577, 3, 3, 9, 1, -3 },
  { 579, 18, 34, 15, -2, -31 },
  { 656, 17, 31, 20, 2, -31 },
  { 722, 9, 31, 20, 6, -31 },
  { 757, 18, 31, 20, 1, -31 },
  { 827, 18, 31, 20, 1, -31 },
  { 897, 18, 31, 20, 1, -31 },
  { 967, 18, 31, 20, 3, -31 },
  { 1037, 16, 31, 20, 2, -31 },
  { 1099, 17, 31, 20, 4, -31 },
  { 1165, 19, 31, 20, 1, -31 },
  { 1239, 16, 31, 20, 3, -31 },
  { 1301, 6, 23, 8, 1, -23 },
  { 1319, 9, 28, 8, -2, -23 },
  { 1351, 16, 18, 19, 2, -23 },
  { 1387, 16, 11, 20, 2, -20 },
  { 1409, 16, 18, 19, 1, -23 },
  { 1445, 13, 31, 16, 4, -31 },
  { 1496, 30, 40, 33, 1, -30 },
  { 1646, 20, 31, 22, -1, -31 },
  { 1724, 19, 31, 22, 2, -31 },
  { 1798, 21, 31, 24, 2, -31 },
  { 1880, 20, 31, 24, 2, -31 },
  { 1958, 20, 31, 21, 2, -31 },
  { 2036, 20, 31, 21, 2, -31 },
  { 2114, 20, 31, 25, 3, -31 },
  { 2192, 23, 31, 26, 2, -31 },
  { 2282, 7, 31, 10, 2, -31 },
  { 2310, 19, 31, 20, 1, -31 },
  { 2384, 22, 31, 23, 2, -31 },
  { 2470, 14, 31, 19, 2, -31 },
  { 2525, 29, 31, 31, 2, -31 },
  { 2638, 23, 31, 26, 2, -31 },
  { 2728, 21, 31, 24, 2, -31 },
  { 2810, 20, 31, 22, 2, -31 },
  { 2888, 21, 36, 24, 2, -31 },
  { 2983, 21, 31, 23, 1, -31 },
  { 3065, 21, 31, 22, 1, -31 },
  { 3147, 20, 31, 22, 4, -31 },
  { 3225, 22, 31, 24, 2, -31 },
  { 3311, 20, 31, 22, 4, -31 },
  { 3389, 30, 31, 33, 4, -31 },
  { 3506, 24, 31, 22, -1, -31 },
  { 3599, 20, 31, 22, 4, -31 },
  { 3677, 22, 31, 22, 0, -31 },
  { 3763, 12, 42, 9, 0, -35 },
  { 3826, 7, 34, 14, 4, -31 },
  { 3856, 12, 42, 9, -3, -35 },
  { 3919, 12, 15, 15, 2, -31 },
  { 3942, 15, 2, 16, -2, 0 },
  { 3946, 5, 6, 11, 6, -33 },
  { 3950, 16, 23, 20, 1, -23 },
  { 3996, 17, 32, 20, 1, -32 },
  { 4064, 17, 23, 19, 1, -23 },
  { 4113, 18, 32, 20, 2, -32 },
  { 4185, 16, 23, 19, 1, -23 },
  { 4231, 14, 32, 12, 2, -32 },
  { 4287, 19, 32, 20, 0, -23 },
  { 4363, 17, 32, 20, 1, -32 },
  { 4431, 7, 32, 8, 1, -32 },
  { 4459, 13, 41, 9, -5, -32 },
  { 4526, 17, 32, 18, 1, -32 },
  { 4594, 7, 32, 8, 1, -32 },
  { 4622, 29, 23, 32, 1, -23 },
  { 4706, 17, 23, 20, 1, -23 },
  { 4755, 16, 23, 20, 2, -23 },
  { 4801, 19, 32, 20, -1, -23 },
  { 4877, 17, 32, 20, 2, -23 },
  { 4945, 13, 23, 13, 1, -23 },
  { 4983, 16, 23, 19, 1, -23 },
  { 5029, 10, 29, 12, 2, -29 },
  { 5066, 17, 23, 20, 2, -23 },
  { 5115, 15, 23, 18, 3, -23 },
  { 5159, 24, 23, 27, 3, -23 },
  { 5228, 19, 23, 18, -1, -23 },
  { 5283, 20, 32, 18, -2, -23 },
  { 5363, 17, 23, 18, 0, -23 },
  { 5412, 14, 43, 12, 1, -34 },
  { 5488, 7, 37, 9, 1, -31 },
  { 5521, 14, 43, 12, -3, -34 },
  { 5597, 19, 7, 25, 3, -16 },
};

const GFXfont RobotoCondensed_ExtraLightItalic43pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraLightItalic43pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraLightItalic43pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOCONDENSED_EXTRALIGHTITALIC43PT7B_H_
