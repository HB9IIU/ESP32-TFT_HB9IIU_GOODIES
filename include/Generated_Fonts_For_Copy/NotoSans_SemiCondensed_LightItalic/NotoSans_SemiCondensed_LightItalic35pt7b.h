#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC35PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0xC1,
  0x86, 0x0C, 0x18, 0x30, 0x41, 0x00, 0x00, 0x00, 0x38, 0x70, 0xC0, 0x63,
  0x63, 0x63, 0x43, 0xC2, 0xC6, 0xC6, 0x86, 0x84, 0x00, 0x41, 0x80, 0x18,
  0x20, 0x03, 0x0C, 0x00, 0x41, 0x80, 0x18, 0x30, 0x03, 0x04, 0x00, 0x41,
  0x81, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x61, 0x80, 0x08, 0x30, 0x03, 0x04,
  0x00, 0x60, 0x80, 0x08, 0x30, 0x03, 0x06, 0x00, 0x60, 0x80, 0xFF, 0xFF,
  0x03, 0x06, 0x00, 0x60, 0x80, 0x0C, 0x30, 0x01, 0x06, 0x00, 0x60, 0x80,
  0x0C, 0x10, 0x01, 0x06, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x80, 0x3F, 0xE1, 0xCC, 0xC3, 0x10, 0x0C, 0x20, 0x18,
  0xC0, 0x31, 0x80, 0x62, 0x00, 0xC4, 0x00, 0xE8, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x01, 0x30, 0x02, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x21, 0x80,
  0x43, 0x21, 0x8C, 0x7B, 0xF0, 0xFF, 0xC0, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x0F, 0x80, 0x30, 0xCE, 0x03, 0x0C, 0x30, 0x30, 0x61,
  0x81, 0x82, 0x0C, 0x18, 0x30, 0x61, 0x81, 0x83, 0x0C, 0x08, 0x18, 0xC0,
  0x40, 0x8C, 0x06, 0x0C, 0x60, 0x30, 0x66, 0x7D, 0x82, 0x67, 0x74, 0x33,
  0x21, 0xB3, 0x33, 0x0C, 0xF1, 0x10, 0x60, 0x19, 0x83, 0x01, 0x8C, 0x18,
  0x08, 0x60, 0xC0, 0xC2, 0x04, 0x0C, 0x10, 0x60, 0x41, 0x83, 0x06, 0x0C,
  0x10, 0x60, 0x21, 0x82, 0x01, 0x98, 0x30, 0x07, 0x80, 0x01, 0xF8, 0x00,
  0xE7, 0x00, 0x30, 0xE0, 0x18, 0x18, 0x06, 0x06, 0x01, 0x81, 0x80, 0x60,
  0xC0, 0x18, 0x70, 0x06, 0x38, 0x01, 0x9C, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x0F, 0x80, 0x07, 0x30, 0x13, 0x0C, 0x09, 0x81, 0x86, 0xE0, 0x61, 0x30,
  0x0C, 0xCC, 0x03, 0xE3, 0x00, 0x78, 0xC0, 0x1C, 0x30, 0x0F, 0x0E, 0x07,
  0x61, 0xEF, 0x98, 0x3F, 0x83, 0x00, 0x6D, 0xAD, 0xB4, 0x80, 0x00, 0xC0,
  0x60, 0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0xC0, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x00, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x08, 0x00, 0x02, 0x80, 0x08, 0x00, 0xC1, 0x06, 0x0C, 0x30,
  0x39, 0x00, 0x7B, 0xE0, 0xFF, 0x0F, 0x00, 0xC8, 0x0C, 0x60, 0xC3, 0x04,
  0x0C, 0x00, 0x60, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x0C,
  0x71, 0x86, 0x30, 0xC6, 0x18, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x03,
  0xF0, 0x1C, 0xE0, 0xE0, 0xC7, 0x03, 0x18, 0x0C, 0xC0, 0x33, 0x00, 0xD8,
  0x03, 0x60, 0x0D, 0x80, 0x36, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x03, 0x30, 0x0C, 0xC0, 0x63,
  0x03, 0x8E, 0x0C, 0x1E, 0xE0, 0x3F, 0x00, 0x03, 0x83, 0x87, 0xC7, 0x6E,
  0x36, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x00,
  0x01, 0xFC, 0x07, 0xDE, 0x06, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xF8,
  0xFF, 0xF8, 0x01, 0xFC, 0x0F, 0x9E, 0x06, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C,
  0x03, 0xF0, 0x07, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x80, 0x38,
  0xF9, 0xF0, 0x7F, 0xC0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x1A,
  0x00, 0x36, 0x00, 0x36, 0x00, 0x66, 0x00, 0xC6, 0x01, 0x84, 0x03, 0x0C,
  0x03, 0x0C, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x30, 0x18,
  0x60, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x07, 0xFF, 0x07, 0xFE, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x80, 0x70, 0xF3, 0xC0, 0xFF, 0x80, 0x00, 0xFE, 0x03, 0xC4,
  0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC3, 0x01, 0x9F, 0x83, 0xE3, 0x8D, 0x03, 0x9C, 0x03, 0x30, 0x06,
  0x60, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x01, 0xCC, 0x03, 0x18,
  0x0E, 0x18, 0x38, 0x3C, 0xE0, 0x3F, 0x80, 0x7F, 0xFE, 0xFF, 0xF8, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x01, 0xFC, 0x07, 0x9E, 0x06, 0x06,
  0x0C, 0x03, 0x0C, 0x03, 0x08, 0x03, 0x08, 0x03, 0x0C, 0x06, 0x0C, 0x0E,
  0x06, 0x1C, 0x07, 0x70, 0x03, 0xE0, 0x07, 0xC0, 0x1C, 0x70, 0x38, 0x30,
  0x60, 0x18, 0xE0, 0x18, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18,
  0xC0, 0x18, 0x60, 0x30, 0x78, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0x78,
  0x38, 0x30, 0xE0, 0x31, 0x80, 0x67, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x30,
  0x06, 0x60, 0x0C, 0xC0, 0x39, 0x80, 0x73, 0x81, 0xE3, 0x8F, 0x83, 0xFB,
  0x01, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x70, 0x63, 0xC0, 0xFE, 0x00, 0x08, 0x71, 0xC2, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x8C, 0x00, 0x01, 0x81,
  0xC0, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x1C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x80, 0x01, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x00, 0x60, 0x00, 0x1F, 0xC7, 0xDE, 0x20, 0x60, 0x07,
  0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x02, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x0C, 0x06, 0x00, 0x06, 0x0C,
  0x00, 0x02, 0x0C, 0x00, 0x03, 0x18, 0x0F, 0x83, 0x10, 0x3D, 0xC3, 0x30,
  0x60, 0xC3, 0x30, 0xC0, 0x83, 0x60, 0xC1, 0x83, 0x61, 0x81, 0x83, 0x61,
  0x81, 0x82, 0x61, 0x01, 0x06, 0x43, 0x03, 0x06, 0x43, 0x03, 0x04, 0xC3,
  0x07, 0x0C, 0x41, 0x07, 0x18, 0x41, 0x99, 0xB8, 0x60, 0xF1, 0xE0, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x01, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0x60, 0x01, 0x90, 0x01, 0x88, 0x00,
  0xC6, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x30, 0x30,
  0x18, 0x18, 0x1F, 0xFC, 0x0F, 0xFE, 0x0C, 0x03, 0x06, 0x01, 0x86, 0x00,
  0x43, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0xC0,
  0x01, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0x80, 0xE0, 0xC0, 0x30, 0xC0,
  0x18, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x86,
  0x03, 0x83, 0xFF, 0x01, 0xFF, 0x81, 0x80, 0x60, 0xC0, 0x18, 0x60, 0x0C,
  0x30, 0x06, 0x18, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0xE3, 0x00,
  0x61, 0x80, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x7D,
  0xE0, 0x38, 0x08, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x7D, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x18, 0x1E,
  0x03, 0x00, 0xC0, 0xC0, 0x1C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06,
  0x18, 0x00, 0xC3, 0x00, 0x1C, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C,
  0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x71,
  0x80, 0x0C, 0x30, 0x03, 0x86, 0x00, 0xE0, 0xC0, 0x38, 0x18, 0x1E, 0x07,
  0xFF, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x3E, 0xFC, 0x0E, 0x01, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x03, 0xF9, 0x80, 0x7F, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0,
  0x01, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x30, 0xE0,
  0x0C, 0x0E, 0x01, 0x80, 0xFB, 0xF0, 0x0F, 0xFC, 0x00, 0x06, 0x00, 0x30,
  0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x02, 0x0C, 0x00, 0x60, 0xC0, 0x06,
  0x0C, 0x00, 0x60, 0xC0, 0x06, 0x08, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00,
  0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00,
  0x18, 0x30, 0x01, 0x83, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60,
  0x03, 0x06, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x00,
  0x07, 0xF0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0xFE, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x5E, 0x03, 0xE0, 0x00, 0x06, 0x00, 0xE0, 0xC0, 0x38, 0x18, 0x0E,
  0x03, 0x03, 0x80, 0xC0, 0xE0, 0x18, 0x38, 0x03, 0x0E, 0x00, 0x61, 0x80,
  0x18, 0x60, 0x03, 0x18, 0x00, 0x66, 0x00, 0x0D, 0xC0, 0x01, 0xF8, 0x00,
  0x79, 0x80, 0x0E, 0x30, 0x01, 0x86, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x01,
  0x81, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x06,
  0x00, 0xC0, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0,
  0x01, 0xE0, 0xA0, 0x01, 0xB0, 0xD8, 0x00, 0xD0, 0x6C, 0x00, 0xD8, 0x36,
  0x00, 0x6C, 0x1B, 0x00, 0x66, 0x19, 0x80, 0x33, 0x0C, 0xC0, 0x33, 0x06,
  0x60, 0x19, 0x83, 0x10, 0x18, 0xC1, 0x88, 0x0C, 0x61, 0x86, 0x0C, 0x30,
  0xC3, 0x06, 0x30, 0x61, 0x86, 0x18, 0x30, 0xC2, 0x0C, 0x10, 0x63, 0x06,
  0x18, 0x33, 0x02, 0x0C, 0x19, 0x83, 0x06, 0x05, 0x81, 0x83, 0x02, 0xC0,
  0xC1, 0x01, 0xC0, 0x61, 0x80, 0xE0, 0x60, 0xC0, 0x60, 0x30, 0x00, 0x07,
  0x00, 0x18, 0x38, 0x00, 0xC1, 0xC0, 0x0C, 0x0B, 0x00, 0x60, 0xD8, 0x03,
  0x06, 0xC0, 0x18, 0x32, 0x01, 0x81, 0x98, 0x0C, 0x18, 0xC0, 0x60, 0xC6,
  0x03, 0x06, 0x18, 0x18, 0x30, 0xC1, 0x81, 0x86, 0x0C, 0x18, 0x18, 0x60,
  0xC0, 0xC3, 0x06, 0x06, 0x18, 0x30, 0x19, 0x81, 0x80, 0xCC, 0x18, 0x06,
  0x60, 0xC0, 0x1B, 0x06, 0x00, 0xD0, 0x30, 0x07, 0x81, 0x00, 0x1C, 0x18,
  0x00, 0xE0, 0xC0, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x7D, 0xF0, 0x1C, 0x07,
  0x07, 0x00, 0x61, 0xC0, 0x0C, 0x30, 0x00, 0xCE, 0x00, 0x19, 0x80, 0x03,
  0x70, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x01, 0xD8, 0x00, 0x33,
  0x00, 0x06, 0x70, 0x01, 0x86, 0x00, 0x70, 0xC0, 0x1C, 0x0C, 0x07, 0x01,
  0xF7, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0x81, 0xC0,
  0xC0, 0x60, 0xC0, 0x30, 0x60, 0x1C, 0x30, 0x0E, 0x18, 0x06, 0x1C, 0x03,
  0x0C, 0x01, 0x86, 0x01, 0xC3, 0x01, 0xC1, 0x81, 0xC1, 0xFF, 0xC0, 0xFF,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x7D, 0xF0, 0x1C, 0x07, 0x07, 0x00, 0x61, 0xC0, 0x0C, 0x30,
  0x00, 0xCE, 0x00, 0x19, 0x80, 0x03, 0x70, 0x00, 0x6C, 0x00, 0x0D, 0x80,
  0x01, 0xB0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00,
  0x06, 0xC0, 0x01, 0xD8, 0x00, 0x33, 0x00, 0x06, 0x70, 0x01, 0x86, 0x00,
  0x70, 0xC0, 0x1C, 0x0C, 0x07, 0x01, 0xF7, 0xC0, 0x0F, 0xE0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0xC0, 0x30,
  0x60, 0x1C, 0x30, 0x0E, 0x18, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x01,
  0x83, 0x01, 0xC1, 0xFF, 0xC1, 0xFF, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30,
  0x60, 0x18, 0x38, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x00, 0xC1,
  0x80, 0x61, 0x80, 0x30, 0xC0, 0x1C, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0x06,
  0x01, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x80, 0x70, 0xFB, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x61, 0x80,
  0x0C, 0x30, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00,
  0x31, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00,
  0xC6, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03,
  0x18, 0x00, 0x63, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0xE0, 0xC0, 0x18,
  0x1C, 0x06, 0x01, 0xEF, 0x80, 0x1F, 0xE0, 0x00, 0xC0, 0x03, 0xE0, 0x01,
  0xB0, 0x01, 0xC8, 0x00, 0xC6, 0x00, 0xE3, 0x00, 0x61, 0x80, 0x70, 0xC0,
  0x30, 0x60, 0x38, 0x30, 0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x06, 0x0E, 0x03,
  0x06, 0x01, 0x87, 0x00, 0xC3, 0x00, 0x21, 0x80, 0x11, 0x80, 0x0C, 0xC0,
  0x06, 0xC0, 0x03, 0x60, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x18, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xD8,
  0x07, 0x80, 0x6C, 0x02, 0xC0, 0x66, 0x03, 0x60, 0x33, 0x01, 0xB0, 0x39,
  0x81, 0x98, 0x18, 0xC0, 0xCC, 0x0C, 0x60, 0xC6, 0x0C, 0x30, 0x63, 0x06,
  0x18, 0x61, 0x86, 0x0C, 0x30, 0xC3, 0x06, 0x10, 0x63, 0x03, 0x18, 0x31,
  0x81, 0x8C, 0x18, 0xC0, 0xCC, 0x0C, 0xC0, 0x66, 0x06, 0x60, 0x36, 0x03,
  0x60, 0x1B, 0x01, 0xB0, 0x0D, 0x00, 0xD0, 0x07, 0x80, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x30,
  0x30, 0x06, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0x81, 0x80, 0x0C, 0x30,
  0x00, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0xCC, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x19,
  0x80, 0x03, 0x18, 0x00, 0x61, 0x80, 0x06, 0x08, 0x00, 0xC0, 0xC0, 0x18,
  0x0C, 0x03, 0x80, 0xC0, 0x30, 0x06, 0x06, 0x00, 0x60, 0xE0, 0x06, 0x00,
  0xC0, 0x07, 0x80, 0x19, 0x80, 0x33, 0x00, 0xC6, 0x03, 0x0C, 0x06, 0x08,
  0x18, 0x18, 0x70, 0x30, 0xC0, 0x63, 0x00, 0xC6, 0x00, 0xD8, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0x03,
  0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x03,
  0xF8, 0x1F, 0x80, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x86, 0x31, 0x8C, 0x61, 0x0C, 0x63, 0x18, 0xC2, 0x10, 0xC6,
  0x31, 0x8C, 0x21, 0x8C, 0x63, 0x18, 0x03, 0xF8, 0x1F, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0x20, 0x03, 0x30, 0x06, 0x30, 0x06, 0x10, 0x0C,
  0x18, 0x0C, 0x18, 0x18, 0x0C, 0x30, 0x0C, 0x30, 0x04, 0x60, 0x06, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0x18, 0x63, 0x0C, 0x01, 0xE3, 0x07, 0xF3,
  0x0E, 0x1A, 0x1C, 0x0E, 0x18, 0x0E, 0x30, 0x0E, 0x30, 0x0E, 0x60, 0x0C,
  0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0xC0, 0x18, 0xC0, 0x18,
  0xE0, 0x38, 0x60, 0x78, 0x60, 0xD0, 0x7B, 0x90, 0x3F, 0x30, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x78, 0x33, 0xF8, 0x6C, 0x38, 0xF0, 0x31, 0xC0, 0x63, 0x00,
  0xCE, 0x01, 0x98, 0x03, 0x30, 0x06, 0x60, 0x0D, 0x80, 0x1B, 0x00, 0x76,
  0x00, 0xCC, 0x01, 0x98, 0x06, 0x70, 0x1C, 0xF0, 0x31, 0xB9, 0xC2, 0x3F,
  0x00, 0x01, 0xF8, 0x3F, 0xC3, 0x80, 0x38, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0xC6, 0x07, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x01, 0xE3, 0x01, 0xFC, 0xC0, 0xE1, 0xB0, 0x70, 0x28, 0x18,
  0x06, 0x0C, 0x01, 0x83, 0x00, 0x61, 0x80, 0x18, 0x60, 0x0C, 0x18, 0x03,
  0x06, 0x00, 0xC1, 0x80, 0x70, 0xC0, 0x18, 0x30, 0x06, 0x0E, 0x03, 0x81,
  0x81, 0xE0, 0x60, 0xD8, 0x1E, 0x64, 0x03, 0xF1, 0x00, 0x03, 0xE0, 0x7F,
  0x87, 0x0C, 0x70, 0x33, 0x01, 0xB0, 0x19, 0x80, 0xD8, 0x0C, 0xC3, 0xC7,
  0xF8, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0xCE, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x2E, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF1, 0x81, 0xFC, 0xC1, 0xC3, 0x61, 0xC0, 0xA0, 0xC0, 0x30, 0xC0, 0x18,
  0x60, 0x0C, 0x60, 0x06, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x01,
  0xC6, 0x00, 0xC3, 0x00, 0x61, 0xC0, 0x70, 0x60, 0x78, 0x30, 0x6C, 0x1E,
  0x64, 0x07, 0xE6, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x80, 0x60, 0x71, 0xE0, 0x1F, 0xE0, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x78, 0x33, 0xF8, 0x6C, 0x38, 0xF0, 0x31, 0xC0, 0x63, 0x00, 0xCE,
  0x01, 0x98, 0x06, 0x30, 0x0C, 0x60, 0x19, 0x80, 0x33, 0x00, 0x66, 0x01,
  0x8C, 0x03, 0x18, 0x06, 0x60, 0x0C, 0xC0, 0x31, 0x80, 0x63, 0x00, 0xC0,
  0x06, 0x1C, 0x10, 0x00, 0x00, 0x03, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x06,
  0x0C, 0x18, 0x60, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0xC0, 0x00, 0x18,
  0x01, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x13, 0x80, 0xF8, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x0E, 0x30, 0x18, 0x60,
  0x60, 0xC1, 0x81, 0x86, 0x02, 0x18, 0x0C, 0x60, 0x19, 0x80, 0x37, 0x00,
  0x7E, 0x01, 0xEC, 0x03, 0x8C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x30, 0x60,
  0x60, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0xC0, 0x06, 0x0C, 0x18, 0x30, 0xC1,
  0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x61, 0x83,
  0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x00, 0x08, 0xF0, 0x3C, 0x19, 0xF8,
  0xFE, 0x1B, 0x0D, 0x87, 0x1C, 0x0F, 0x03, 0x1C, 0x0E, 0x03, 0x18, 0x0E,
  0x03, 0x38, 0x0C, 0x03, 0x30, 0x0C, 0x06, 0x30, 0x0C, 0x06, 0x30, 0x18,
  0x06, 0x60, 0x18, 0x06, 0x60, 0x18, 0x04, 0x60, 0x18, 0x0C, 0x60, 0x30,
  0x0C, 0x60, 0x30, 0x0C, 0xC0, 0x30, 0x0C, 0xC0, 0x30, 0x18, 0xC0, 0x30,
  0x18, 0xC0, 0x60, 0x18, 0x08, 0xF8, 0x33, 0xF8, 0x6C, 0x38, 0xF0, 0x31,
  0xC0, 0x63, 0x00, 0xCE, 0x01, 0x98, 0x06, 0x30, 0x0C, 0x60, 0x19, 0x80,
  0x33, 0x00, 0x66, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x60, 0x0C, 0xC0, 0x31,
  0x80, 0x63, 0x00, 0xC0, 0x01, 0xF0, 0x0F, 0xF0, 0x38, 0x70, 0xE0, 0x61,
  0x80, 0x66, 0x00, 0xCC, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80,
  0x3E, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0x98, 0x06, 0x30, 0x1C, 0x70, 0x70,
  0x79, 0xC0, 0x7E, 0x00, 0x02, 0x1E, 0x03, 0x3F, 0x81, 0xB0, 0xE0, 0xF0,
  0x30, 0x70, 0x18, 0x30, 0x0C, 0x38, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x86,
  0x00, 0xC6, 0x00, 0x63, 0x00, 0x71, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x18,
  0x70, 0x1C, 0x34, 0x0C, 0x1B, 0x9C, 0x0C, 0xFC, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xE3, 0x07, 0xF3, 0x0E, 0x1B, 0x1C, 0x0A, 0x18, 0x06,
  0x30, 0x06, 0x30, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C,
  0x60, 0x0C, 0xC0, 0x18, 0xC0, 0x18, 0xE0, 0x38, 0x60, 0x78, 0x60, 0xD8,
  0x79, 0x90, 0x3F, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x08, 0xF1, 0x9F, 0x1B,
  0x01, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x00, 0x03, 0xE0, 0x7F, 0xC6, 0x04, 0x30, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x80, 0xC7, 0x9E, 0x3F, 0xC0, 0x04, 0x01, 0x00, 0xC0,
  0x30, 0x1F, 0xDF, 0xE1, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x19, 0x07,
  0xC0, 0x30, 0x06, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x00, 0xCC, 0x01,
  0x98, 0x06, 0x30, 0x0C, 0x60, 0x18, 0x80, 0x33, 0x00, 0x66, 0x01, 0x8C,
  0x03, 0x18, 0x0E, 0x30, 0x1C, 0x60, 0x70, 0xC1, 0xA1, 0xCE, 0xC1, 0xF9,
  0x80, 0xC0, 0x1E, 0x00, 0xF0, 0x0D, 0x80, 0x6C, 0x06, 0x60, 0x33, 0x03,
  0x18, 0x18, 0x41, 0x82, 0x0C, 0x18, 0xC0, 0xC6, 0x06, 0x60, 0x33, 0x01,
  0xB0, 0x0D, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xC0, 0x70, 0x1E, 0x03,
  0x80, 0xF0, 0x1C, 0x0D, 0x81, 0xE0, 0x6C, 0x0B, 0x06, 0x60, 0xD8, 0x33,
  0x04, 0xC3, 0x18, 0x66, 0x18, 0xC3, 0x31, 0x86, 0x31, 0x8C, 0x31, 0x8C,
  0x61, 0x98, 0x66, 0x0C, 0xC3, 0x30, 0x6C, 0x1B, 0x03, 0x60, 0xD8, 0x1A,
  0x06, 0x80, 0xF0, 0x3C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x0C, 0x03,
  0x0C, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x06, 0x18, 0x03, 0x30, 0x03, 0x70,
  0x03, 0x60, 0x01, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0,
  0x0C, 0x60, 0x18, 0x60, 0x38, 0x60, 0x30, 0x30, 0x60, 0x30, 0xC0, 0x18,
  0x03, 0x00, 0x70, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01,
  0x80, 0x10, 0x18, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x86, 0x00, 0x18,
  0x60, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x19, 0x80, 0x00,
  0xB0, 0x00, 0x0B, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x08, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xF0,
  0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x78, 0x07, 0x80, 0x60, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x0C, 0x03, 0xC0, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x1F, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0xE0, 0x07, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x01, 0xC0, 0x7C, 0x03, 0x00, 0x00, 0x7E, 0x03, 0xDF,
  0x0E, 0x07, 0xF0, 0x00, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 25, 8, 1, -25 },
  { 23, 8, 9, 12, 4, -25 },
  { 32, 19, 25, 19, 1, -25 },
  { 92, 15, 29, 17, 1, -27 },
  { 147, 21, 25, 25, 2, -25 },
  { 213, 18, 25, 20, 1, -25 },
  { 270, 3, 9, 6, 4, -25 },
  { 274, 10, 31, 9, 1, -25 },
  { 313, 10, 31, 9, -2, -25 },
  { 352, 13, 14, 16, 4, -27 },
  { 375, 15, 17, 18, 2, -21 },
  { 407, 6, 9, 7, -2, -4 },
  { 414, 8, 1, 10, 1, -10 },
  { 415, 3, 3, 7, 1, -3 },
  { 417, 16, 25, 11, -2, -25 },
  { 467, 14, 25, 17, 2, -25 },
  { 511, 9, 25, 17, 5, -25 },
  { 540, 16, 25, 17, 0, -25 },
  { 590, 16, 25, 17, 0, -25 },
  { 640, 16, 25, 17, 0, -25 },
  { 690, 16, 25, 17, 1, -25 },
  { 740, 15, 25, 17, 2, -25 },
  { 787, 15, 25, 17, 3, -25 },
  { 834, 16, 25, 17, 1, -25 },
  { 884, 15, 25, 17, 1, -25 },
  { 931, 6, 19, 7, 1, -19 },
  { 946, 9, 24, 7, -2, -19 },
  { 973, 15, 16, 18, 2, -21 },
  { 1003, 15, 9, 18, 2, -17 },
  { 1020, 15, 16, 18, 2, -21 },
  { 1050, 12, 25, 13, 2, -25 },
  { 1088, 24, 28, 26, 1, -25 },
  { 1172, 17, 25, 17, -2, -25 },
  { 1226, 17, 25, 18, 1, -25 },
  { 1280, 18, 25, 18, 2, -25 },
  { 1337, 19, 25, 21, 1, -25 },
  { 1397, 16, 25, 16, 1, -25 },
  { 1447, 16, 25, 15, 1, -25 },
  { 1497, 19, 25, 21, 2, -25 },
  { 1557, 20, 25, 21, 1, -25 },
  { 1620, 12, 25, 9, -1, -25 },
  { 1658, 13, 31, 8, -5, -25 },
  { 1709, 19, 25, 17, 1, -25 },
  { 1769, 11, 25, 15, 1, -25 },
  { 1804, 25, 25, 26, 1, -25 },
  { 1883, 21, 25, 22, 1, -25 },
  { 1949, 19, 25, 22, 2, -25 },
  { 2009, 17, 25, 17, 1, -25 },
  { 2063, 19, 31, 22, 2, -25 },
  { 2137, 17, 25, 18, 1, -25 },
  { 2191, 16, 25, 16, 0, -25 },
  { 2241, 15, 25, 15, 3, -25 },
  { 2288, 19, 25, 21, 2, -25 },
  { 2348, 17, 25, 17, 3, -25 },
  { 2402, 25, 25, 27, 4, -25 },
  { 2481, 20, 25, 16, -2, -25 },
  { 2544, 15, 25, 15, 3, -25 },
  { 2591, 19, 25, 16, -1, -25 },
  { 2651, 13, 31, 10, 0, -25 },
  { 2702, 5, 25, 12, 4, -25 },
  { 2718, 13, 31, 10, -2, -25 },
  { 2769, 16, 14, 18, 1, -25 },
  { 2797, 12, 2, 12, -3, 3 },
  { 2800, 5, 6, 9, 5, -27 },
  { 2804, 16, 19, 18, 1, -19 },
  { 2842, 15, 27, 18, 1, -27 },
  { 2893, 13, 19, 14, 1, -19 },
  { 2924, 18, 27, 18, 1, -27 },
  { 2985, 13, 19, 16, 2, -19 },
  { 3016, 18, 35, 9, -4, -27 },
  { 3095, 17, 27, 18, 0, -19 },
  { 3153, 15, 27, 17, 1, -27 },
  { 3204, 7, 25, 7, 1, -25 },
  { 3226, 13, 33, 7, -5, -25 },
  { 3280, 15, 27, 15, 1, -27 },
  { 3331, 7, 27, 7, 1, -27 },
  { 3355, 24, 19, 26, 1, -19 },
  { 3412, 15, 19, 17, 1, -19 },
  { 3448, 15, 19, 17, 1, -19 },
  { 3484, 17, 27, 18, -1, -19 },
  { 3542, 16, 27, 18, 1, -19 },
  { 3596, 12, 19, 12, 1, -19 },
  { 3625, 13, 19, 13, 0, -19 },
  { 3656, 10, 23, 10, 1, -23 },
  { 3685, 15, 19, 18, 2, -19 },
  { 3721, 13, 19, 14, 2, -19 },
  { 3752, 21, 19, 22, 2, -19 },
  { 3802, 16, 19, 14, -1, -19 },
  { 3840, 20, 27, 14, -4, -19 },
  { 3908, 14, 19, 13, -1, -19 },
  { 3942, 13, 31, 12, 1, -25 },
  { 3993, 2, 35, 17, 8, -27 },
  { 4002, 13, 31, 12, -2, -25 },
  { 4053, 15, 4, 18, 2, -14 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC35PT7B_H_
