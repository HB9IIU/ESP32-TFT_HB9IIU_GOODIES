#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC60PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x1C, 0x00, 0x40,
  0x00, 0x1E, 0x0E, 0x38, 0x1C, 0x70, 0x79, 0xE0, 0xF3, 0x81, 0xC7, 0x03,
  0x8E, 0x07, 0x1C, 0x0C, 0x30, 0x38, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0x86,
  0x03, 0x0C, 0x0E, 0x38, 0x1C, 0x70, 0x30, 0x00, 0x00, 0xC0, 0x1C, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x38, 0x03, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x38, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xE0, 0x1E, 0x1C, 0x18, 0x07, 0x83, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0,
  0x70, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x30, 0x00,
  0x0E, 0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1E, 0x30, 0x00, 0x01, 0xF6,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x3E, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x18, 0x3C, 0x00, 0x03, 0x03, 0x80, 0x00, 0x60, 0x70, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x0C, 0x07,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x78, 0x10, 0x0E, 0x1E, 0x03, 0x81,
  0x8F, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0x80, 0x7F, 0xC0, 0x00, 0xE0, 0x1E, 0x3C, 0x00, 0x1C, 0x07, 0x83,
  0x80, 0x07, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x38, 0x06, 0x00, 0x38, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0xE0, 0x07, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x18, 0x01,
  0xC1, 0xC0, 0x07, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0x1C,
  0x01, 0xC3, 0x83, 0xF3, 0x80, 0x70, 0xE1, 0xFF, 0x70, 0x0E, 0x1C, 0x7D,
  0xFE, 0x03, 0x87, 0x1E, 0x0F, 0xC0, 0x71, 0xC3, 0x81, 0xDC, 0x1C, 0x38,
  0xE0, 0x3B, 0xC7, 0x8E, 0x1C, 0x03, 0x3F, 0xE3, 0x87, 0x00, 0x63, 0xF0,
  0x70, 0xE0, 0x1C, 0x00, 0x1C, 0x18, 0x03, 0x80, 0x07, 0x07, 0x00, 0x70,
  0x00, 0xE0, 0xE0, 0x0E, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x0E, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0xE0, 0x06, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x1E, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0x07, 0x01, 0xC0,
  0x38, 0x00, 0xF0, 0x70, 0x0E, 0x00, 0x0E, 0x1E, 0x03, 0x80, 0x01, 0xFF,
  0x80, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7C,
  0xFC, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x03,
  0x80, 0x01, 0xC0, 0x0F, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0xC3, 0x80, 0x0E, 0x1F,
  0x07, 0x80, 0x1C, 0x78, 0x07, 0x80, 0x70, 0xF0, 0x0F, 0x00, 0xE3, 0xC0,
  0x0F, 0x03, 0xC7, 0x00, 0x0E, 0x07, 0x1E, 0x00, 0x1E, 0x1C, 0x38, 0x00,
  0x1C, 0x78, 0x70, 0x00, 0x3C, 0xE1, 0xE0, 0x00, 0x3B, 0xC3, 0xC0, 0x00,
  0x7F, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03,
  0xF0, 0x1C, 0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x3D, 0xE0, 0x7C, 0x01, 0xF1,
  0xC0, 0x7E, 0x1F, 0xC3, 0xC0, 0x7F, 0xFE, 0x03, 0xC0, 0x3F, 0xF0, 0x07,
  0x80, 0x0D, 0x00, 0x00, 0x00, 0x1E, 0x38, 0x71, 0xE3, 0x87, 0x0E, 0x1C,
  0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x04, 0x01, 0x80, 0x3C, 0x0E, 0x00, 0xFC,
  0x38, 0x00, 0xFC, 0xC0, 0x00, 0xFF, 0x07, 0xC0, 0x7F, 0xFF, 0x00, 0x7F,
  0xFC, 0x03, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0xE6, 0x00, 0x0F, 0x1C, 0x00,
  0x78, 0x30, 0x03, 0xC0, 0xE0, 0x1E, 0x03, 0x80, 0x30, 0x07, 0x00, 0x40,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03,
  0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x80,
  0x7B, 0xFF, 0xFF, 0x10, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0x81, 0xF0, 0x0F, 0x80,
  0x78, 0x07, 0x80, 0x1C, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x83, 0x80,
  0x01, 0xC3, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x38, 0xF0,
  0x00, 0x1C, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x3C, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xCE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B,
  0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x0F,
  0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x78, 0xE0, 0x00,
  0x3C, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x0F, 0x01, 0xC0, 0x07, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x0F, 0x80, 0x1F, 0x9F, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x7C, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0xC0, 0xFB, 0x87, 0xCF, 0x1F, 0x1E, 0xF8, 0x38, 0xE0, 0x70, 0x80, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xC0, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x04, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xE0, 0x01,
  0xE0, 0x04, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x80, 0x00, 0x7C, 0x0E,
  0x00, 0x0F, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x78, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0,
  0x78, 0x00, 0x1C, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x07, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0xE0, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xC0,
  0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x00,
  0x03, 0xC1, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x7B, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x80, 0x00, 0xF8, 0x0E, 0x00, 0x3F, 0x00, 0xFE, 0x1F, 0xE0, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xCF, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x03, 0xC3, 0xFE, 0x00,
  0xE3, 0xFF, 0xC0, 0x39, 0xE1, 0xF8, 0x1E, 0xE0, 0x1F, 0x07, 0x60, 0x03,
  0xC1, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x1C, 0x00,
  0x1E, 0x07, 0x00, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x07,
  0xC7, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xC0, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00,
  0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xE0,
  0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00,
  0x3C, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x87, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x07, 0x00,
  0xF0, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x0F, 0x1C,
  0x00, 0x03, 0xC7, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x3E,
  0x1E, 0x00, 0x0F, 0x83, 0x80, 0x07, 0xE0, 0xF0, 0x07, 0xF0, 0x1F, 0x07,
  0xDC, 0x07, 0xFF, 0xC7, 0x00, 0x7F, 0xE3, 0xC0, 0x07, 0xC0, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0xF1, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xE0,
  0x3C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0x80, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xE0, 0x1E, 0x08, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x0F, 0x00,
  0x0F, 0xE0, 0x0E, 0x0E, 0x00, 0x3F, 0xFC, 0x06, 0x1C, 0x00, 0xFF, 0xF8,
  0x07, 0x1C, 0x01, 0xE0, 0x38, 0x07, 0x38, 0x03, 0xC0, 0x38, 0x07, 0x38,
  0x03, 0x80, 0x38, 0x07, 0x38, 0x07, 0x00, 0x70, 0x07, 0x70, 0x0E, 0x00,
  0x70, 0x06, 0x70, 0x0E, 0x00, 0x70, 0x06, 0x70, 0x1C, 0x00, 0x70, 0x0E,
  0xE0, 0x1C, 0x00, 0xE0, 0x0E, 0xE0, 0x18, 0x00, 0xE0, 0x0E, 0xE0, 0x38,
  0x00, 0xE0, 0x0E, 0xE0, 0x38, 0x01, 0xE0, 0x1C, 0xE0, 0x38, 0x01, 0xC0,
  0x1C, 0xE0, 0x38, 0x01, 0xC0, 0x1C, 0xE0, 0x38, 0x03, 0xC0, 0x38, 0xE0,
  0x38, 0x03, 0xC0, 0x38, 0xE0, 0x38, 0x07, 0xC0, 0x70, 0xE0, 0x38, 0x07,
  0xC0, 0xF0, 0xE0, 0x38, 0x0D, 0xC1, 0xE0, 0xE0, 0x3C, 0x38, 0xE3, 0xC0,
  0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x78, 0x0F, 0x00, 0x03, 0x80, 0x78, 0x00, 0x3C, 0x01, 0xC0, 0x01,
  0xC0, 0x0E, 0x00, 0x1E, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x78, 0x0E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x70, 0x78, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xC0, 0x0F,
  0xC0, 0x0E, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xE0,
  0x3C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x38, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xE0,
  0x3C, 0x00, 0x3E, 0x01, 0xC0, 0x07, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xF8, 0x01, 0xC0, 0x01,
  0xE0, 0x0E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xF0,
  0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x1E, 0x0E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0,
  0x38, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0xF8, 0x0E, 0x00, 0x3F, 0x80, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xC0,
  0x0E, 0x00, 0x7C, 0x00, 0x08, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x02, 0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x7F, 0x00, 0x0E,
  0x00, 0x1F, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x07,
  0x87, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x0E, 0x00, 0x07, 0xC0, 0x1C, 0x00,
  0x3F, 0x00, 0x78, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0x02, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xF8,
  0xF0, 0x00, 0x7F, 0xF8, 0xF0, 0x00, 0x7F, 0xF8, 0xE0, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x01, 0xC0,
  0x3C, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0x07, 0x80,
  0x0F, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x80,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38,
  0x07, 0x80, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x01,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x38, 0x07, 0x80, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0xF0,
  0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x02,
  0x0F, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x0F, 0x00,
  0x01, 0xC0, 0x1F, 0x00, 0x01, 0xC0, 0x3E, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x03, 0xC0, 0xF8, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0x07, 0x3E, 0x00, 0x00, 0x0F, 0x7E, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xE7, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x07,
  0x70, 0x0E, 0xE0, 0x00, 0x01, 0xDE, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80,
  0x39, 0xC0, 0x00, 0x0E, 0x70, 0x07, 0x38, 0x00, 0x03, 0xCE, 0x01, 0xE7,
  0x00, 0x00, 0x73, 0xC0, 0x38, 0xE0, 0x00, 0x1E, 0x78, 0x07, 0x1C, 0x00,
  0x03, 0x8E, 0x00, 0xE3, 0x80, 0x00, 0xF1, 0xC0, 0x1C, 0x70, 0x00, 0x1C,
  0x38, 0x07, 0x8E, 0x00, 0x07, 0x8F, 0x00, 0xE1, 0xC0, 0x00, 0xE1, 0xE0,
  0x1C, 0x1C, 0x00, 0x3C, 0x38, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0xF0,
  0x70, 0x01, 0xC0, 0xE0, 0x1E, 0x0E, 0x00, 0x38, 0x3C, 0x03, 0x81, 0xC0,
  0x0E, 0x07, 0x80, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70,
  0x1C, 0x03, 0xC0, 0xE0, 0x1E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xF0,
  0x0E, 0x01, 0xC0, 0xF0, 0x1C, 0x01, 0xC0, 0x38, 0x1C, 0x03, 0x80, 0x38,
  0x07, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x3C, 0x03, 0xC0, 0x38, 0x03, 0x87, 0x00, 0x70, 0x07, 0x00, 0x71, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x38, 0x01, 0xC0, 0x3C, 0x01, 0xCE, 0x00, 0x78,
  0x07, 0x00, 0x1D, 0xC0, 0x0F, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xC0, 0x1C,
  0x00, 0x7E, 0x00, 0x38, 0x07, 0x80, 0x0F, 0x80, 0x07, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x1C,
  0x03, 0xE0, 0x00, 0x03, 0x80, 0x7C, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0x00,
  0x1C, 0x01, 0xF8, 0x00, 0x03, 0x80, 0x7F, 0x00, 0x00, 0x70, 0x0E, 0xF0,
  0x00, 0x0E, 0x01, 0xCE, 0x00, 0x03, 0xC0, 0x39, 0xC0, 0x00, 0x70, 0x07,
  0x3C, 0x00, 0x0E, 0x01, 0xE3, 0x80, 0x01, 0xC0, 0x38, 0x70, 0x00, 0x78,
  0x07, 0x0F, 0x00, 0x0F, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0x1C, 0x1C, 0x00,
  0x38, 0x07, 0x83, 0xC0, 0x07, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x1C, 0x07,
  0x00, 0x38, 0x03, 0x80, 0xF0, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x3C, 0x07, 0x80, 0x70, 0x07, 0x80, 0xE0,
  0x0E, 0x00, 0x70, 0x1C, 0x03, 0xC0, 0x0E, 0x03, 0x80, 0x70, 0x01, 0xE0,
  0xF0, 0x0E, 0x00, 0x1C, 0x1E, 0x01, 0xC0, 0x03, 0x83, 0x80, 0x38, 0x00,
  0x78, 0x70, 0x0F, 0x00, 0x07, 0x0E, 0x01, 0xC0, 0x00, 0xE3, 0xC0, 0x38,
  0x00, 0x1E, 0x78, 0x07, 0x00, 0x01, 0xCE, 0x00, 0xE0, 0x00, 0x39, 0xC0,
  0x3C, 0x00, 0x07, 0xB8, 0x07, 0x00, 0x00, 0x77, 0x00, 0xE0, 0x00, 0x0F,
  0xC0, 0x1C, 0x00, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x1C, 0x00, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0E,
  0x01, 0xFC, 0x00, 0xE0, 0x03, 0xE0, 0x0E, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x0F, 0x00,
  0x0F, 0x80, 0xF0, 0x03, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x7E, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0E, 0x01, 0xFC, 0x00, 0xE0, 0x03,
  0xE0, 0x0E, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x3C, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0,
  0x38, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x3F, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xE0,
  0x1C, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x1C, 0x00, 0xE0,
  0x01, 0xC0, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0x70, 0x03, 0x80, 0x07, 0x80, 0x38, 0x00, 0x78, 0x07, 0x80, 0x03,
  0x80, 0x78, 0x00, 0x38, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x0F,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x07, 0xC0, 0x0E, 0x00, 0xF8, 0x00, 0x20, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x80, 0x00, 0xF8, 0x0E, 0x00, 0x1F, 0x00, 0xFF, 0xBF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xE0,
  0x0F, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x3C, 0x07, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x78, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0xF0, 0x07, 0x00, 0x0E,
  0x00, 0x70, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x70, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x38, 0x3C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x78, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xEF, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xCF, 0x00, 0x03, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xCF, 0x00, 0x07, 0x70, 0x00,
  0x38, 0xF0, 0x00, 0x77, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x70, 0x00, 0x70,
  0x70, 0x00, 0xE7, 0x00, 0x0F, 0x07, 0x00, 0x0E, 0x70, 0x00, 0xE0, 0x70,
  0x01, 0xC7, 0x00, 0x1E, 0x07, 0x00, 0x1C, 0x70, 0x01, 0xC0, 0x70, 0x03,
  0x87, 0x00, 0x1C, 0x07, 0x00, 0x38, 0x70, 0x03, 0xC0, 0x70, 0x07, 0x87,
  0x00, 0x38, 0x07, 0x00, 0x70, 0x70, 0x07, 0x80, 0x70, 0x07, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x70, 0x0F, 0x00, 0x70, 0x0E, 0x07, 0x00, 0xE0,
  0x07, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0x70, 0x1C, 0x03, 0x01, 0xE0, 0x07,
  0x03, 0x80, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x03, 0x83, 0xC0, 0x07, 0x07,
  0x80, 0x38, 0x38, 0x00, 0x70, 0x70, 0x03, 0x87, 0x80, 0x07, 0x07, 0x00,
  0x38, 0x70, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x38,
  0xF0, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x39, 0xE0,
  0x00, 0x73, 0xC0, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x00,
  0x73, 0x80, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x00, 0x77,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xE0, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x38, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0xF0,
  0x03, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x0E, 0x00, 0x07,
  0x83, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x0F, 0x00,
  0x1C, 0x01, 0xC0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x07,
  0x80, 0xF0, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x0F, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x38,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xE0, 0x38, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0x70, 0x1C, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x38,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x1C, 0x00, 0x0F, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x1C, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0x38, 0x07, 0x00, 0x0E,
  0x03, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xF0, 0x70,
  0x78, 0x38, 0x1C, 0x1C, 0x0E, 0x06, 0x07, 0x00, 0x01, 0x00, 0x00, 0x03,
  0xFC, 0x1C, 0x01, 0xFF, 0xC3, 0x80, 0x7F, 0x7C, 0xE0, 0x1F, 0x01, 0xDC,
  0x07, 0x80, 0x1B, 0x81, 0xE0, 0x03, 0x70, 0x38, 0x00, 0x3E, 0x0F, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x78, 0x78, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x0F, 0x07, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x0E, 0x00, 0x0F, 0x81, 0xC0,
  0x03, 0xE0, 0x3C, 0x00, 0xFC, 0x07, 0x80, 0x3B, 0x80, 0x78, 0x0E, 0x70,
  0x0F, 0xCF, 0x8E, 0x00, 0xFF, 0xE1, 0x80, 0x0F, 0xF8, 0x70, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x7F, 0x80, 0x0E, 0x3F, 0xF8, 0x03, 0xCF, 0xBF, 0x80,
  0x73, 0x80, 0xF8, 0x0E, 0xE0, 0x0F, 0x01, 0xF8, 0x00, 0xE0, 0x3E, 0x00,
  0x1E, 0x0F, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x07,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00,
  0xF0, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x87, 0x80, 0x00, 0x70, 0xF0,
  0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E,
  0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0xF0, 0x76, 0x00, 0x3C, 0x0E, 0xC0, 0x0F, 0x81,
  0xDC, 0x03, 0xE0, 0x39, 0xF1, 0xF8, 0x06, 0x1F, 0xFC, 0x01, 0xC1, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xBE, 0x03, 0xE0, 0x08, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x04, 0x03, 0xF0, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x01, 0xFE, 0x0E, 0x00,
  0x1F, 0xFE, 0x38, 0x00, 0xFE, 0xF9, 0xE0, 0x07, 0xC0, 0x77, 0x00, 0x3C,
  0x00, 0xDC, 0x01, 0xE0, 0x01, 0xF0, 0x07, 0x00, 0x07, 0xC0, 0x3C, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x78, 0x0F, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x01,
  0xF0, 0x07, 0x00, 0x07, 0xC0, 0x1C, 0x00, 0x3F, 0x00, 0x78, 0x01, 0xDC,
  0x01, 0xE0, 0x0E, 0xE0, 0x03, 0xC0, 0x73, 0x80, 0x0F, 0xC7, 0x8E, 0x00,
  0x1F, 0xFC, 0x38, 0x00, 0x3F, 0xE0, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0x7E, 0x03,
  0xE0, 0x3C, 0x1E, 0x00, 0xF0, 0xF0, 0x01, 0xC3, 0x80, 0x07, 0x1E, 0x00,
  0x1C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0x8E, 0x00, 0x1E, 0x78, 0x00, 0xF1,
  0xC0, 0x07, 0xC7, 0x00, 0x7E, 0x3C, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF,
  0xC0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x03, 0x03, 0xF0,
  0x7C, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0x81, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xFF, 0x07, 0x00, 0x3F, 0xFC, 0x70, 0x07, 0xF7, 0xC7, 0x00, 0xF8, 0x0E,
  0x70, 0x1E, 0x00, 0x6E, 0x03, 0xC0, 0x03, 0xE0, 0x38, 0x00, 0x3E, 0x07,
  0x80, 0x03, 0xE0, 0x70, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x38, 0x3C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x78, 0x38, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x70, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x03, 0x80,
  0x03, 0xE0, 0x38, 0x00, 0x7E, 0x03, 0xC0, 0x0E, 0xE0, 0x3C, 0x01, 0xDC,
  0x01, 0xE0, 0x39, 0xC0, 0x1F, 0x8F, 0x1C, 0x00, 0xFF, 0xE1, 0xC0, 0x07,
  0xFC, 0x3C, 0x00, 0x04, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x80, 0x03,
  0xC0, 0x0C, 0x00, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x1F, 0xE0, 0x07, 0x1F, 0xFC, 0x03, 0xCF, 0xDF, 0x80,
  0xE7, 0x01, 0xF0, 0x3B, 0x80, 0x3C, 0x0F, 0xC0, 0x07, 0x03, 0xE0, 0x01,
  0xC1, 0xF0, 0x00, 0x70, 0x7C, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0xC1, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x83, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x1C,
  0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x38, 0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xE0, 0xE0,
  0x00, 0x78, 0x78, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x10,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x0E, 0x01, 0xE0, 0x03, 0x80, 0xF0, 0x01, 0xE0,
  0x78, 0x00, 0x70, 0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x7C, 0x00,
  0x03, 0xBF, 0x00, 0x01, 0xFD, 0xE0, 0x00, 0x7E, 0x38, 0x00, 0x1F, 0x0F,
  0x00, 0x07, 0x83, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xF0, 0x1E, 0x00, 0x38,
  0x07, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x01, 0xC0, 0x1C, 0x00, 0x78, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x03,
  0xC0, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x70, 0xFF, 0x00, 0x7F, 0x80, 0x18, 0x7F,
  0xE0, 0x7F, 0xF0, 0x0E, 0x3E, 0xFC, 0x3E, 0xFE, 0x03, 0x9C, 0x0F, 0x1C,
  0x07, 0x80, 0xEE, 0x01, 0xEE, 0x00, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0x38,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC1, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x78, 0x00, 0x38, 0x1E, 0x00, 0x1E,
  0x00, 0x0E, 0x07, 0x00, 0x07, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x00,
  0x0E, 0x07, 0x00, 0x07, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x70, 0x00, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x07, 0x00, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x00, 0x00, 0x30, 0x00, 0x70, 0x7F, 0x80,
  0x1C, 0x7F, 0xF8, 0x0E, 0x3F, 0xFE, 0x03, 0x9C, 0x07, 0xC0, 0xEE, 0x00,
  0xF0, 0x3F, 0x00, 0x1C, 0x0F, 0x80, 0x07, 0x07, 0xC0, 0x01, 0xC1, 0xF0,
  0x00, 0x70, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07,
  0x87, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00,
  0x0F, 0x07, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x70,
  0x78, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xE0, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01,
  0xFD, 0xFC, 0x03, 0xE0, 0x3E, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x0F, 0x0E,
  0x00, 0x0F, 0x1E, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x38,
  0x00, 0x07, 0x78, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x3C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x78, 0xF0,
  0x00, 0xF0, 0x78, 0x01, 0xE0, 0x7C, 0x03, 0xC0, 0x3F, 0x1F, 0x80, 0x1F,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x3F, 0xC0,
  0x00, 0xC3, 0xFF, 0x80, 0x07, 0x1F, 0x3F, 0x00, 0x1C, 0xF0, 0x3E, 0x00,
  0x77, 0x00, 0x78, 0x01, 0xF8, 0x00, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x3F,
  0x00, 0x0F, 0x00, 0xF8, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x70, 0x0F, 0x00,
  0x01, 0xC0, 0x3C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0xF0, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x70, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x78, 0x07, 0x80, 0x01, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0xFC, 0x00,
  0x78, 0x03, 0xB0, 0x03, 0xE0, 0x0E, 0xE0, 0x1F, 0x00, 0x39, 0xF1, 0xF8,
  0x00, 0xE3, 0xFF, 0xC0, 0x07, 0x87, 0xFC, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0xFC, 0x1C, 0x01, 0xFF, 0xE3, 0x80,
  0x7F, 0x7C, 0x70, 0x1F, 0x01, 0xCE, 0x07, 0x80, 0x1B, 0x81, 0xE0, 0x01,
  0xF0, 0x38, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC1, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F,
  0x0E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x07, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00,
  0x7C, 0x0E, 0x00, 0x0F, 0x81, 0xC0, 0x03, 0xF0, 0x3C, 0x00, 0xEE, 0x07,
  0x80, 0x3B, 0x80, 0x78, 0x0E, 0x70, 0x0F, 0xC7, 0x8E, 0x00, 0xFF, 0xE1,
  0xC0, 0x0F, 0xF8, 0x78, 0x00, 0x10, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC3, 0xF8, 0x0C, 0x3F, 0xC0, 0xE3, 0xFE,
  0x07, 0x3C, 0x00, 0x3B, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0xFE, 0x3F, 0x07, 0xC0, 0x18, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x80, 0x03, 0xC3,
  0x00, 0x1E, 0x0F, 0xC3, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x1F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x60, 0x7F, 0xE0, 0x3F, 0xE0, 0x02, 0x00, 0x07, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x83, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C,
  0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xE0, 0xF0, 0x00,
  0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07,
  0x83, 0x80, 0x03, 0xE0, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x7C, 0x0E, 0x00,
  0x37, 0x03, 0x80, 0x1D, 0xC0, 0xF0, 0x0E, 0x70, 0x1F, 0x1F, 0x38, 0x07,
  0xFF, 0x8E, 0x00, 0xFF, 0x83, 0x80, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xE7, 0x00, 0x07,
  0x8E, 0x00, 0x0F, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x70, 0x70, 0x01, 0xE0,
  0xE0, 0x03, 0x81, 0xC0, 0x0F, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x78, 0x0F,
  0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x1C, 0x07, 0x00, 0x38, 0x1E, 0x00, 0x70,
  0x38, 0x00, 0xE0, 0xF0, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x80, 0x07, 0x0E,
  0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x70, 0x00, 0x39, 0xE0, 0x00, 0x73, 0x80,
  0x00, 0x6F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x77, 0x00,
  0x0F, 0x00, 0x0F, 0x70, 0x00, 0xF0, 0x00, 0xE7, 0x00, 0x1F, 0x00, 0x0E,
  0x70, 0x01, 0xB0, 0x01, 0xE7, 0x00, 0x3B, 0x00, 0x1C, 0x70, 0x03, 0xB0,
  0x03, 0xC7, 0x00, 0x73, 0x00, 0x38, 0x70, 0x07, 0x38, 0x07, 0x87, 0x00,
  0xE3, 0x80, 0x70, 0x70, 0x0E, 0x38, 0x0F, 0x07, 0x01, 0xC3, 0x80, 0xE0,
  0x70, 0x1C, 0x38, 0x0E, 0x07, 0x01, 0xC3, 0x81, 0xE0, 0x70, 0x38, 0x38,
  0x1C, 0x07, 0x03, 0x83, 0x83, 0xC0, 0x70, 0x70, 0x38, 0x38, 0x07, 0x07,
  0x03, 0x87, 0x80, 0x70, 0xE0, 0x38, 0x70, 0x07, 0x0E, 0x03, 0x87, 0x00,
  0x71, 0xC0, 0x38, 0xE0, 0x07, 0x1C, 0x03, 0x8E, 0x00, 0x73, 0x80, 0x39,
  0xE0, 0x07, 0x38, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x07, 0x70,
  0x03, 0xB8, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x1E, 0x00,
  0x1E, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x07, 0x00, 0xF0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x38,
  0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x0F,
  0x00, 0x0F, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x78, 0x03,
  0x80, 0x03, 0x80, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x3C, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x38, 0x0F, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x19, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xE4, 0x00, 0x0F, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 13, 44, 14, 1, -43 },
  { 73, 15, 16, 20, 6, -43 },
  { 103, 32, 43, 33, 1, -43 },
  { 275, 27, 49, 29, 1, -46 },
  { 441, 35, 44, 42, 4, -43 },
  { 634, 31, 45, 34, 1, -44 },
  { 809, 7, 16, 11, 6, -43 },
  { 823, 18, 52, 16, 2, -43 },
  { 940, 18, 52, 16, -4, -43 },
  { 1057, 22, 24, 28, 7, -46 },
  { 1123, 25, 28, 31, 4, -35 },
  { 1211, 10, 15, 12, -3, -7 },
  { 1230, 14, 3, 18, 2, -18 },
  { 1236, 5, 6, 13, 1, -5 },
  { 1240, 27, 43, 19, -3, -43 },
  { 1386, 25, 45, 29, 3, -44 },
  { 1527, 15, 43, 29, 8, -43 },
  { 1608, 28, 43, 29, 0, -43 },
  { 1759, 28, 44, 29, 0, -43 },
  { 1913, 28, 43, 29, 0, -43 },
  { 2064, 28, 44, 29, 1, -43 },
  { 2218, 26, 45, 29, 3, -44 },
  { 2365, 26, 43, 29, 4, -43 },
  { 2505, 28, 44, 29, 1, -43 },
  { 2659, 26, 44, 29, 2, -43 },
  { 2802, 11, 33, 13, 1, -32 },
  { 2848, 15, 40, 13, -3, -32 },
  { 2923, 25, 27, 31, 4, -35 },
  { 3008, 25, 15, 31, 4, -29 },
  { 3055, 25, 27, 31, 4, -35 },
  { 3140, 20, 44, 22, 3, -43 },
  { 3250, 40, 48, 44, 3, -43 },
  { 3490, 29, 43, 29, -3, -43 },
  { 3646, 29, 43, 32, 2, -43 },
  { 3802, 30, 44, 30, 4, -43 },
  { 3967, 31, 43, 35, 2, -43 },
  { 4134, 28, 43, 28, 2, -43 },
  { 4285, 28, 43, 26, 2, -43 },
  { 4436, 32, 44, 36, 4, -43 },
  { 4612, 34, 43, 36, 2, -43 },
  { 4795, 21, 43, 16, -1, -43 },
  { 4908, 23, 54, 14, -9, -43 },
  { 5064, 32, 43, 29, 2, -43 },
  { 5236, 19, 43, 25, 2, -43 },
  { 5339, 43, 43, 45, 2, -43 },
  { 5571, 35, 43, 37, 2, -43 },
  { 5760, 32, 45, 38, 4, -44 },
  { 5940, 28, 43, 30, 2, -43 },
  { 6091, 32, 54, 38, 4, -44 },
  { 6307, 28, 43, 30, 2, -43 },
  { 6458, 28, 44, 27, 0, -43 },
  { 6612, 26, 43, 26, 5, -43 },
  { 6752, 33, 44, 36, 4, -43 },
  { 6934, 28, 43, 29, 6, -43 },
  { 7085, 44, 43, 46, 6, -43 },
  { 7322, 34, 43, 27, -3, -43 },
  { 7505, 26, 43, 26, 5, -43 },
  { 7645, 31, 43, 27, -1, -43 },
  { 7812, 23, 53, 17, -1, -43 },
  { 7965, 10, 43, 20, 6, -43 },
  { 8019, 22, 53, 17, -4, -43 },
  { 8165, 26, 25, 30, 2, -43 },
  { 8247, 21, 2, 21, -5, 6 },
  { 8253, 8, 10, 15, 9, -46 },
  { 8263, 27, 34, 30, 2, -33 },
  { 8378, 27, 47, 30, 1, -46 },
  { 8537, 22, 34, 24, 3, -33 },
  { 8631, 30, 47, 31, 2, -46 },
  { 8808, 22, 34, 27, 3, -33 },
  { 8902, 30, 60, 16, -7, -46 },
  { 9127, 28, 47, 31, 1, -33 },
  { 9292, 26, 46, 30, 1, -46 },
  { 9442, 13, 44, 13, 1, -44 },
  { 9514, 22, 58, 13, -8, -44 },
  { 9674, 26, 46, 25, 1, -46 },
  { 9824, 13, 46, 13, 1, -46 },
  { 9899, 42, 33, 45, 1, -33 },
  { 10073, 26, 33, 30, 1, -33 },
  { 10181, 24, 33, 30, 3, -32 },
  { 10280, 30, 46, 30, -2, -32 },
  { 10453, 27, 47, 31, 2, -33 },
  { 10612, 21, 32, 20, 1, -32 },
  { 10696, 22, 34, 23, 0, -33 },
  { 10790, 16, 40, 17, 2, -39 },
  { 10870, 26, 33, 30, 3, -32 },
  { 10978, 23, 32, 23, 3, -32 },
  { 11070, 36, 32, 37, 3, -32 },
  { 11214, 28, 32, 25, -2, -32 },
  { 11326, 33, 47, 24, -6, -32 },
  { 11520, 24, 32, 22, -1, -32 },
  { 11616, 22, 52, 20, 1, -43 },
  { 11759, 3, 60, 28, 14, -46 },
  { 11782, 22, 52, 20, -3, -43 },
  { 11925, 25, 6, 31, 4, -24 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC60PT7B_H_
