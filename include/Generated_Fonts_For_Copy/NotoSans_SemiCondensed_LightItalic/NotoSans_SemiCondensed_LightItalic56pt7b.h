#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC56PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x78, 0x0F, 0x80, 0xF8, 0x0F,
  0x00, 0x20, 0x00, 0x3C, 0x3C, 0xE0, 0xF3, 0x83, 0x8E, 0x0E, 0x38, 0x39,
  0xC0, 0xE7, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0x81, 0xC6, 0x06, 0x38, 0x18,
  0xE0, 0xE3, 0x03, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x30, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x07, 0x00,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x60,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x18, 0x07, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x01, 0xC0,
  0x30, 0x03, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x18, 0x07, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x70,
  0x0C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0xF1, 0x87, 0x80, 0xF0, 0xC0, 0x80, 0xF0, 0x60, 0x00, 0x70, 0x30, 0x00,
  0x70, 0x38, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x06, 0x00,
  0x07, 0x03, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xF1, 0x80, 0x00, 0x3C, 0xC0,
  0x00, 0x1F, 0x60, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x06, 0xF8, 0x00, 0x07, 0x1E, 0x00, 0x03,
  0x07, 0x00, 0x01, 0x83, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0x70, 0x00,
  0x70, 0x38, 0x00, 0x30, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x1E, 0x00,
  0x0E, 0x0E, 0x0E, 0x07, 0x1E, 0x07, 0xF3, 0x7E, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x01, 0xFF, 0x00, 0x07, 0x01, 0xE3,
  0xC0, 0x07, 0x01, 0xE0, 0xE0, 0x03, 0x80, 0xE0, 0x70, 0x03, 0x80, 0xE0,
  0x38, 0x03, 0x80, 0x70, 0x1C, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0xE0, 0x0C, 0x01, 0xC0, 0xE0, 0x06,
  0x00, 0xE0, 0xE0, 0x07, 0x00, 0x60, 0x70, 0x03, 0x80, 0x70, 0x70, 0x01,
  0xC0, 0x38, 0x30, 0x00, 0xE0, 0x1C, 0x38, 0x00, 0x70, 0x0C, 0x38, 0x7F,
  0x38, 0x0E, 0x18, 0x7F, 0xDC, 0x07, 0x1C, 0x70, 0xEE, 0x07, 0x1C, 0x70,
  0x37, 0x07, 0x0C, 0x30, 0x1D, 0xC7, 0x8E, 0x38, 0x0E, 0xFF, 0x8E, 0x18,
  0x07, 0x3F, 0x86, 0x1C, 0x03, 0x82, 0x07, 0x0E, 0x01, 0xC0, 0x07, 0x06,
  0x00, 0xE0, 0x03, 0x87, 0x00, 0x60, 0x03, 0x83, 0x80, 0x30, 0x03, 0x81,
  0xC0, 0x38, 0x01, 0xC0, 0xE0, 0x1C, 0x01, 0xC0, 0x60, 0x0E, 0x01, 0xC0,
  0x30, 0x06, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0xE0,
  0x06, 0x03, 0x80, 0x70, 0x03, 0x01, 0xC0, 0x70, 0x01, 0xC1, 0xC0, 0x70,
  0x00, 0xE1, 0xC0, 0x38, 0x00, 0x3F, 0xE0, 0x38, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x3C,
  0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xE0, 0x07,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x1F, 0x1C, 0x00, 0x01, 0xE0, 0xF0, 0x07, 0x1E, 0x03, 0x80, 0x70, 0xE0,
  0x1E, 0x03, 0x8E, 0x00, 0x70, 0x38, 0xF0, 0x03, 0xC1, 0xC7, 0x00, 0x0E,
  0x1C, 0x38, 0x00, 0x78, 0xE3, 0xC0, 0x01, 0xEE, 0x1C, 0x00, 0x07, 0xF0,
  0xE0, 0x00, 0x3F, 0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0xFC, 0x07, 0x00, 0x0F, 0xF0, 0x3C, 0x01, 0xF3, 0x80, 0xF8, 0x3F,
  0x0E, 0x03, 0xFF, 0xE0, 0x78, 0x0F, 0xFC, 0x01, 0xC0, 0x04, 0x00, 0x01,
  0x00, 0x3C, 0xE3, 0x8E, 0x39, 0xC7, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x00,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x20, 0x1C, 0x01, 0x80, 0xE0, 0x1F, 0x06, 0x00, 0x7E, 0x30, 0x00, 0x7D,
  0x80, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xFC, 0x00,
  0x0E, 0x60, 0x00, 0xE3, 0x80, 0x1E, 0x0C, 0x01, 0xE0, 0x70, 0x1E, 0x03,
  0x80, 0x20, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0x87, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0x70, 0x70,
  0x38, 0x38, 0x1C, 0x1C, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x73,
  0xFF, 0xFF, 0x10, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xC3,
  0xC0, 0x1E, 0x03, 0xC0, 0x78, 0x03, 0x80, 0xE0, 0x07, 0x83, 0xC0, 0x07,
  0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xE0, 0x00, 0x71,
  0xC0, 0x00, 0xE7, 0x80, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x78,
  0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xF7, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00,
  0x3D, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x07,
  0x9C, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1,
  0xC0, 0x03, 0x83, 0x80, 0x0F, 0x07, 0x80, 0x1C, 0x07, 0x00, 0x78, 0x0F,
  0x01, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x1F, 0x80, 0xFE, 0x0F, 0xB8, 0x7D,
  0xC3, 0xC7, 0x3E, 0x1C, 0xE0, 0x71, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xF8,
  0x7C, 0x00, 0xF0, 0x07, 0x80, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x07, 0x80, 0x30, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x80,
  0x00, 0xF0, 0x38, 0x00, 0x7C, 0x0F, 0xC0, 0xFE, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x3C, 0x00, 0x0F,
  0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x38, 0x00,
  0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00,
  0xE0, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x01, 0xC0,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x10, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x02, 0x00,
  0x07, 0x80, 0xC0, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0x83, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x1F, 0x00, 0x38, 0xFF,
  0xC0, 0x39, 0xFF, 0xE0, 0x73, 0x81, 0xF0, 0x76, 0x00, 0x70, 0x7C, 0x00,
  0x78, 0x78, 0x00, 0x38, 0xF8, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xF0, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0xF0, 0xE0, 0x00, 0xE0, 0x70, 0x01, 0xE0, 0x70, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0x3E, 0x1F, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x3C,
  0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00,
  0x1C, 0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0x80, 0x70, 0x01, 0xE0, 0x1C,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x3E, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0xF0,
  0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0x00,
  0x0E, 0x03, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1C,
  0x3C, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0x78, 0x00,
  0x78, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xF8, 0x01, 0xF8, 0x7C, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x1E,
  0x07, 0x80, 0x0E, 0x07, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x1E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07,
  0x3C, 0x00, 0x07, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F,
  0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x3E, 0x1E, 0x00, 0xEE,
  0x0F, 0x01, 0xDC, 0x07, 0xFF, 0x9C, 0x03, 0xFF, 0x1C, 0x00, 0xF8, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0xC0, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x81, 0xF0, 0x7C, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x83, 0xE0, 0xF0,
  0x3C, 0x04, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0x87, 0xC1,
  0x80, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x01, 0x81, 0xC0,
  0x03, 0xE0, 0x07, 0x0E, 0x00, 0x7F, 0xF0, 0x1C, 0x38, 0x03, 0xFF, 0xC0,
  0x71, 0xC0, 0x1E, 0x07, 0x01, 0xC7, 0x00, 0xE0, 0x1C, 0x07, 0x18, 0x07,
  0x00, 0x60, 0x1C, 0xE0, 0x1C, 0x03, 0x80, 0x73, 0x80, 0xE0, 0x0E, 0x01,
  0xCC, 0x07, 0x00, 0x38, 0x06, 0x70, 0x1C, 0x00, 0xC0, 0x19, 0xC0, 0x60,
  0x07, 0x00, 0xE7, 0x03, 0x80, 0x1C, 0x03, 0x98, 0x0E, 0x00, 0x70, 0x0E,
  0x60, 0x38, 0x03, 0x80, 0x31, 0x80, 0xE0, 0x0E, 0x01, 0xCE, 0x03, 0x80,
  0x38, 0x06, 0x38, 0x0E, 0x01, 0xE0, 0x38, 0xE0, 0x38, 0x07, 0x80, 0xC3,
  0x80, 0xE0, 0x36, 0x07, 0x0E, 0x03, 0xC1, 0x98, 0x38, 0x18, 0x07, 0xFC,
  0x7F, 0xC0, 0x70, 0x0F, 0xE0, 0xFE, 0x01, 0xC0, 0x1F, 0x01, 0xE0, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x06,
  0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x38, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0E,
  0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x01, 0xC0,
  0x03, 0x80, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xF0, 0x03, 0xE0, 0x1C, 0x00, 0x3C,
  0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x03, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0,
  0x78, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x3C, 0x07, 0x00, 0x1F, 0x01, 0xE0, 0x1F, 0x80, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0xE0, 0x3F, 0x80, 0x1C, 0x00, 0x78, 0x07, 0x80, 0x07,
  0x80, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E,
  0x0E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x0F, 0x00, 0x1F, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xE3, 0xF0,
  0x07, 0xC0, 0x04, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x20, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xC0, 0x1F, 0x80, 0x1C,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x78, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07,
  0x87, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1F, 0x03, 0x80, 0x01, 0xF0, 0x1C,
  0x00, 0x1F, 0x00, 0xE0, 0x03, 0xF0, 0x0F, 0x00, 0x7E, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x7C, 0x00, 0x38,
  0x03, 0xC0, 0x00, 0x20, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x03, 0xFF, 0x8E, 0x00, 0x1F, 0xFE, 0x38, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0x00,
  0x7C, 0x00, 0x38, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xE0,
  0x0E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x01, 0xC0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0x80,
  0x3C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x01, 0xC7, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0xE7, 0xC0, 0x00, 0x03, 0xBF, 0x00, 0x00, 0x0F, 0xDE, 0x00, 0x00, 0x3E,
  0x38, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x70, 0x1E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x38, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x78, 0x03, 0x80,
  0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x00, 0xEE, 0x03, 0xB8, 0x00, 0x01, 0xEE, 0x03, 0x98, 0x00, 0x01,
  0xDC, 0x03, 0x9C, 0x00, 0x03, 0x9C, 0x03, 0x9C, 0x00, 0x03, 0x9C, 0x03,
  0x9C, 0x00, 0x07, 0x1C, 0x07, 0x1C, 0x00, 0x07, 0x3C, 0x07, 0x1C, 0x00,
  0x0E, 0x38, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x07, 0x1C, 0x00, 0x1C, 0x38,
  0x07, 0x0C, 0x00, 0x1C, 0x38, 0x0E, 0x0C, 0x00, 0x38, 0x78, 0x0E, 0x0E,
  0x00, 0x78, 0x70, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x0E, 0x0E, 0x00, 0xF0,
  0x70, 0x0E, 0x0E, 0x00, 0xE0, 0x70, 0x1C, 0x0E, 0x01, 0xC0, 0xE0, 0x1C,
  0x0E, 0x01, 0xC0, 0xE0, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x06, 0x03,
  0x80, 0xE0, 0x3C, 0x06, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x07, 0x01, 0xC0,
  0x38, 0x07, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x1C, 0x01, 0xC0, 0x70, 0x07, 0x1C, 0x03, 0xC0, 0x70, 0x07, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x78, 0x03, 0x80, 0x70, 0x03, 0x70, 0x03, 0x80, 0x70,
  0x03, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01,
  0xC0, 0x3F, 0x00, 0x00, 0xE0, 0x1F, 0x80, 0x00, 0x70, 0x0F, 0xC0, 0x00,
  0x38, 0x07, 0xF0, 0x00, 0x3C, 0x07, 0x38, 0x00, 0x1C, 0x03, 0x9C, 0x00,
  0x0E, 0x01, 0xCE, 0x00, 0x07, 0x00, 0xE3, 0x80, 0x03, 0x80, 0x71, 0xC0,
  0x03, 0x80, 0x70, 0xE0, 0x01, 0xC0, 0x38, 0x38, 0x00, 0xE0, 0x1C, 0x1C,
  0x00, 0x70, 0x0E, 0x0E, 0x00, 0x38, 0x07, 0x03, 0x80, 0x38, 0x07, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x07, 0x81, 0xC0, 0x38,
  0x01, 0xC0, 0xE0, 0x1C, 0x00, 0xE0, 0x70, 0x0E, 0x00, 0x78, 0x70, 0x0F,
  0x00, 0x1C, 0x38, 0x07, 0x00, 0x0E, 0x1C, 0x03, 0x80, 0x07, 0x8E, 0x01,
  0xC0, 0x01, 0xC7, 0x00, 0xE0, 0x00, 0xE7, 0x00, 0xE0, 0x00, 0x7B, 0x80,
  0x70, 0x00, 0x1D, 0xC0, 0x38, 0x00, 0x0E, 0xE0, 0x1C, 0x00, 0x07, 0x70,
  0x0E, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0xF8, 0x07, 0x00, 0x00, 0x7C,
  0x03, 0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x1C, 0x78, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0x80, 0x7C,
  0x01, 0xC0, 0x07, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x0F, 0x00,
  0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E,
  0x00, 0x07, 0x07, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x38,
  0x1C, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0xE0, 0x01,
  0xE0, 0x38, 0x00, 0xF0, 0x0E, 0x01, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x1C, 0x78, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0x80, 0x7C, 0x01, 0xC0,
  0x07, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x03,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07,
  0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x1C, 0x00,
  0x1E, 0x07, 0x00, 0x07, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x03, 0xE0, 0x38,
  0x03, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x70, 0x1E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x03, 0xC0, 0x3C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1E, 0x01, 0xE0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x07,
  0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x78, 0x38, 0x00, 0x0E,
  0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0xF8, 0x01, 0x80,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x30, 0x00, 0xF8, 0x0F, 0xC1,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x70, 0x0F, 0x00, 0x03, 0xC0, 0x1C,
  0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00,
  0xF0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x3C, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x38,
  0x03, 0x80, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00,
  0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x06, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xB8,
  0x00, 0x0F, 0x00, 0x01, 0xDC, 0x00, 0x0F, 0x80, 0x01, 0xCE, 0x00, 0x07,
  0xC0, 0x00, 0xE7, 0x00, 0x07, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0xF0, 0x00,
  0x71, 0xC0, 0x01, 0xB8, 0x00, 0x78, 0xE0, 0x01, 0xDC, 0x00, 0x38, 0x70,
  0x00, 0xEE, 0x00, 0x1C, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0x1C, 0x00, 0x73,
  0x80, 0x0E, 0x0E, 0x00, 0x70, 0xC0, 0x0F, 0x07, 0x00, 0x38, 0x60, 0x07,
  0x03, 0x80, 0x38, 0x30, 0x07, 0x81, 0xC0, 0x1C, 0x18, 0x03, 0x80, 0xE0,
  0x0E, 0x0C, 0x01, 0xC0, 0x70, 0x0E, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x03,
  0x00, 0xE0, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0xC0, 0x70,
  0x07, 0x03, 0x80, 0x60, 0x78, 0x03, 0x81, 0xC0, 0x30, 0x38, 0x01, 0xC1,
  0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x0E, 0x1C, 0x00, 0x70, 0x70, 0x07,
  0x0E, 0x00, 0x38, 0x70, 0x03, 0x8E, 0x00, 0x1C, 0x38, 0x01, 0xC7, 0x00,
  0x0E, 0x38, 0x00, 0xE7, 0x80, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x01, 0x9C,
  0x00, 0x39, 0xC0, 0x00, 0xCE, 0x00, 0x1D, 0xC0, 0x00, 0x66, 0x00, 0x0E,
  0xE0, 0x00, 0x37, 0x00, 0x07, 0xE0, 0x00, 0x1B, 0x80, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x80,
  0x1C, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0E,
  0x70, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78,
  0x78, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0x38, 0x01, 0xC0,
  0x38, 0x03, 0xC0, 0x1C, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x1C, 0x0F, 0x00,
  0x1C, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x18, 0x0E,
  0x07, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1D,
  0x80, 0x00, 0x39, 0xC0, 0x00, 0x31, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x70, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x38, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x0E, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00,
  0x06, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0xE1, 0xC1, 0xC3, 0x83, 0x83, 0x07, 0x06, 0x00,
  0x3F, 0xC3, 0x80, 0x7F, 0xF1, 0xC0, 0x7F, 0x7C, 0xC0, 0x7C, 0x06, 0xE0,
  0x78, 0x03, 0xF0, 0x38, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x3C,
  0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x87, 0x00, 0x03,
  0xC7, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1E, 0x00,
  0x0F, 0x0E, 0x00, 0x07, 0x87, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0,
  0x03, 0xE0, 0x70, 0x03, 0xF0, 0x38, 0x03, 0xB8, 0x1E, 0x03, 0x98, 0x07,
  0xC7, 0x8C, 0x01, 0xFF, 0x8E, 0x00, 0x7F, 0x87, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x1F, 0xC0, 0x0E, 0x3F, 0xF0, 0x07,
  0x3E, 0xFC, 0x03, 0xB8, 0x0F, 0x01, 0xB8, 0x03, 0x81, 0xD8, 0x01, 0xE0,
  0xF8, 0x00, 0x70, 0x7C, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x0E,
  0x1E, 0x00, 0x07, 0x0F, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0xE3, 0xC0, 0x00, 0xF1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00,
  0x1C, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0F, 0x00,
  0x07, 0x87, 0x80, 0x03, 0x87, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xC1, 0xF8,
  0x03, 0xC0, 0xEC, 0x03, 0xC0, 0x67, 0x87, 0xE0, 0x71, 0xFF, 0xC0, 0x38,
  0x7F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0,
  0x7F, 0x3C, 0x07, 0xC0, 0x20, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x40, 0x3E, 0x0E, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x03, 0xFC, 0x38, 0x00, 0xFF, 0xE3, 0x80, 0x1F, 0xDF, 0x38,
  0x03, 0xE0, 0x33, 0x80, 0x78, 0x01, 0xF0, 0x07, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x78, 0x0E,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x01,
  0xF0, 0x07, 0x00, 0x3F, 0x00, 0x70, 0x07, 0x70, 0x07, 0x80, 0xE7, 0x00,
  0x3E, 0x3C, 0x60, 0x01, 0xFF, 0x86, 0x00, 0x0F, 0xF0, 0xE0, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x7E, 0x7C, 0x07, 0xC0,
  0xF0, 0x78, 0x03, 0x83, 0x80, 0x1C, 0x3C, 0x00, 0xE3, 0xC0, 0x07, 0x1C,
  0x00, 0x39, 0xE0, 0x03, 0xCE, 0x00, 0x3C, 0x70, 0x03, 0xC7, 0x80, 0x7C,
  0x38, 0x3F, 0xC1, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x20, 0x3E, 0x0F, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x78, 0x20, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x47, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x60, 0x07, 0xFF, 0x1C, 0x01, 0xFD, 0xF3, 0x80, 0x7C, 0x06,
  0x70, 0x1E, 0x00, 0x6C, 0x03, 0x80, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x3C,
  0x00, 0x1E, 0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x0E,
  0x07, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x07, 0x80, 0x01, 0xE0,
  0xF0, 0x00, 0x38, 0x1E, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xE0, 0x70, 0x00,
  0x7C, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x03, 0xE0, 0x1C, 0x00, 0xFC, 0x03,
  0x80, 0x3B, 0x80, 0x78, 0x0E, 0x70, 0x07, 0xC7, 0x9C, 0x00, 0x7F, 0xE3,
  0x80, 0x07, 0xF8, 0x70, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x06, 0x00,
  0x3C, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x83, 0xF8, 0x03, 0x8F, 0xFE, 0x03, 0x9F,
  0x3E, 0x03, 0xB8, 0x0F, 0x03, 0x70, 0x07, 0x07, 0xE0, 0x07, 0x07, 0xC0,
  0x07, 0x07, 0x80, 0x07, 0x07, 0x80, 0x07, 0x0F, 0x00, 0x07, 0x0F, 0x00,
  0x07, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1E, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x78, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x70, 0x70, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x00, 0x60,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x08, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0F, 0x03, 0x80, 0x0E,
  0x03, 0x80, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0,
  0x07, 0x01, 0xC0, 0x07, 0x03, 0xC0, 0x07, 0x07, 0x80, 0x0F, 0x0F, 0x00,
  0x0E, 0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0xF8, 0x00,
  0x1D, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x9C, 0x00, 0x1F, 0x1C, 0x00,
  0x1E, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x07, 0x00,
  0x38, 0x07, 0x00, 0x78, 0x07, 0x80, 0x70, 0x03, 0x80, 0x70, 0x03, 0x80,
  0x70, 0x03, 0xC0, 0x70, 0x01, 0xC0, 0xF0, 0x01, 0xC0, 0xE0, 0x01, 0xE0,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0x87, 0xF8, 0x07, 0xF0, 0x07, 0x1F,
  0xF8, 0x3F, 0xF0, 0x0E, 0x79, 0xF0, 0xFB, 0xF0, 0x19, 0xC0, 0xF3, 0x80,
  0xE0, 0x36, 0x00, 0xEE, 0x01, 0xE0, 0xFC, 0x01, 0xF8, 0x03, 0xC1, 0xF0,
  0x03, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x80, 0x07, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0x01, 0xC1, 0xC0, 0x03, 0x80,
  0x07, 0x87, 0x80, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0x01, 0xC1, 0xC0, 0x01, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x80, 0x07, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x38,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0x01, 0xC1,
  0xC0, 0x03, 0x80, 0x03, 0x83, 0x80, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0E,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0x83, 0xFC, 0x03,
  0x8F, 0xFE, 0x03, 0x9F, 0xFF, 0x03, 0x38, 0x0F, 0x07, 0x70, 0x07, 0x07,
  0xE0, 0x07, 0x07, 0xC0, 0x07, 0x07, 0x80, 0x07, 0x07, 0x80, 0x07, 0x0F,
  0x00, 0x07, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x1C,
  0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x38,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x78, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x78, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xE0,
  0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFD, 0xF8, 0x03,
  0xE0, 0x3C, 0x07, 0x80, 0x1C, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x1E,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x3C, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x38,
  0x00, 0x0F, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x78, 0x70,
  0x00, 0x70, 0x70, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3F,
  0x0F, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x70, 0x7F, 0x00, 0x07, 0x1F, 0xF8, 0x00, 0x73, 0xE7, 0xC0, 0x06, 0x70,
  0x1E, 0x00, 0x6E, 0x00, 0xE0, 0x0E, 0xC0, 0x0F, 0x00, 0xF8, 0x00, 0x70,
  0x0F, 0x80, 0x07, 0x00, 0xF0, 0x00, 0x70, 0x1E, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x70, 0x1E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38,
  0x00, 0x0E, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1C, 0x07, 0x80, 0x01,
  0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03, 0x80, 0x78, 0x00, 0x78, 0x0F,
  0x80, 0x0F, 0x00, 0xFC, 0x01, 0xE0, 0x0E, 0xC0, 0x3E, 0x00, 0xEF, 0x0F,
  0xC0, 0x1E, 0x7F, 0xF0, 0x01, 0xC3, 0xFE, 0x00, 0x1C, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0x80, 0x7F, 0xF1,
  0xC0, 0x7F, 0x7C, 0xE0, 0x7C, 0x06, 0x70, 0x78, 0x01, 0xB0, 0x38, 0x00,
  0xF8, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xE3, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x78,
  0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x87,
  0x00, 0x07, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x03, 0xE0, 0x70, 0x03, 0xF0,
  0x38, 0x03, 0xB8, 0x1E, 0x03, 0x9C, 0x07, 0xC7, 0x9C, 0x01, 0xFF, 0x8E,
  0x00, 0x7F, 0x87, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x83, 0xF0,
  0x38, 0xFE, 0x03, 0x9F, 0xE0, 0x33, 0x80, 0x03, 0x70, 0x00, 0x76, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0xFC, 0x7C, 0x0F, 0x00, 0x60, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x20, 0x03, 0xC1, 0xE0,
  0x7E, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x0F,
  0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xE1, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x80, 0x00, 0x07, 0x00,
  0x07, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x78, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C,
  0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81,
  0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x70,
  0x38, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x0F,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x03, 0xC1, 0xE0, 0x03,
  0xE0, 0xF0, 0x03, 0x70, 0x38, 0x03, 0xF0, 0x1C, 0x03, 0xB8, 0x0F, 0x87,
  0x9C, 0x03, 0xFF, 0x8E, 0x00, 0xFF, 0x06, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00,
  0xE3, 0x80, 0x03, 0x8F, 0x00, 0x1C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0x81,
  0xC0, 0x1E, 0x07, 0x00, 0x70, 0x1C, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x78, 0x07, 0x01, 0xC0, 0x1C, 0x0F, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xE0,
  0x03, 0x87, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0xE0, 0x00, 0xE7, 0x80, 0x03,
  0x9C, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0xEE, 0x00, 0x3E, 0x00, 0x3B, 0x80,
  0x0F, 0x80, 0x1C, 0xE0, 0x07, 0xE0, 0x07, 0x38, 0x01, 0xF8, 0x03, 0xCE,
  0x00, 0x6E, 0x00, 0xE3, 0x80, 0x3B, 0x80, 0x78, 0xE0, 0x0C, 0xE0, 0x1C,
  0x18, 0x07, 0x38, 0x07, 0x06, 0x01, 0x8E, 0x03, 0x81, 0x80, 0xE3, 0x80,
  0xE0, 0x70, 0x38, 0xE0, 0x70, 0x1C, 0x1C, 0x38, 0x1C, 0x07, 0x07, 0x06,
  0x0F, 0x01, 0xC3, 0x81, 0x83, 0x80, 0x70, 0xE0, 0x60, 0xE0, 0x1C, 0x70,
  0x18, 0x70, 0x07, 0x1C, 0x06, 0x1C, 0x01, 0xC6, 0x01, 0x8E, 0x00, 0x73,
  0x80, 0x63, 0x80, 0x1C, 0xC0, 0x1D, 0xC0, 0x07, 0x70, 0x07, 0x70, 0x01,
  0xDC, 0x01, 0xDC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x38, 0x00,
  0x78, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x07, 0x80, 0x0E, 0x00, 0xE0, 0x01,
  0xE0, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x38, 0x70,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x38, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x38, 0x07, 0x80, 0x07, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0xF0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x01, 0xE0, 0x00,
  0x70, 0x03, 0x80, 0x00, 0xE0, 0x0F, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01,
  0x80, 0x78, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0D, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x87,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x01, 0x3F, 0xF0, 0x01, 0x7F,
  0xFC, 0x03, 0xF0, 0x7F, 0xDF, 0xC0, 0x0F, 0xFE, 0x80, 0x03, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 12, 41, 13, 1, -40 },
  { 63, 14, 14, 19, 6, -40 },
  { 88, 30, 40, 30, 1, -40 },
  { 238, 25, 46, 27, 1, -43 },
  { 382, 33, 42, 39, 4, -41 },
  { 556, 29, 42, 32, 1, -41 },
  { 709, 6, 14, 10, 6, -40 },
  { 720, 16, 49, 15, 2, -40 },
  { 818, 17, 49, 15, -4, -40 },
  { 923, 21, 22, 26, 6, -43 },
  { 981, 24, 26, 29, 3, -33 },
  { 1059, 9, 13, 11, -2, -6 },
  { 1074, 13, 3, 16, 2, -17 },
  { 1079, 5, 6, 12, 1, -5 },
  { 1083, 26, 40, 18, -3, -40 },
  { 1213, 23, 42, 27, 3, -41 },
  { 1334, 14, 40, 27, 8, -40 },
  { 1404, 26, 41, 27, 0, -41 },
  { 1538, 26, 42, 27, 0, -41 },
  { 1675, 26, 40, 27, 0, -40 },
  { 1805, 26, 41, 27, 1, -40 },
  { 1939, 24, 42, 27, 3, -41 },
  { 2065, 24, 40, 27, 4, -40 },
  { 2185, 26, 42, 27, 1, -41 },
  { 2322, 24, 42, 27, 2, -41 },
  { 2448, 10, 31, 12, 1, -30 },
  { 2487, 14, 37, 12, -3, -30 },
  { 2552, 24, 26, 29, 3, -33 },
  { 2630, 24, 14, 29, 3, -27 },
  { 2672, 24, 26, 29, 3, -33 },
  { 2750, 19, 42, 20, 3, -41 },
  { 2850, 38, 45, 41, 2, -40 },
  { 3064, 27, 40, 27, -3, -40 },
  { 3199, 27, 40, 30, 2, -40 },
  { 3334, 27, 42, 28, 4, -41 },
  { 3476, 29, 40, 33, 2, -40 },
  { 3621, 26, 40, 26, 2, -40 },
  { 3751, 26, 40, 24, 2, -40 },
  { 3881, 30, 42, 34, 4, -41 },
  { 4039, 32, 40, 34, 2, -40 },
  { 4199, 19, 40, 15, -1, -40 },
  { 4294, 22, 50, 13, -9, -40 },
  { 4432, 30, 40, 27, 2, -40 },
  { 4582, 18, 40, 24, 2, -40 },
  { 4672, 40, 40, 42, 2, -40 },
  { 4872, 33, 40, 35, 2, -40 },
  { 5037, 30, 42, 35, 3, -41 },
  { 5195, 26, 40, 28, 2, -40 },
  { 5325, 30, 51, 35, 3, -41 },
  { 5517, 26, 40, 28, 2, -40 },
  { 5647, 26, 42, 25, 0, -41 },
  { 5784, 24, 40, 24, 5, -40 },
  { 5904, 30, 41, 33, 4, -40 },
  { 6058, 27, 40, 27, 5, -40 },
  { 6193, 41, 40, 43, 6, -40 },
  { 6398, 32, 40, 25, -3, -40 },
  { 6558, 24, 40, 24, 5, -40 },
  { 6678, 29, 40, 26, -1, -40 },
  { 6823, 21, 49, 16, -1, -40 },
  { 6952, 9, 40, 18, 6, -40 },
  { 6997, 21, 49, 16, -4, -40 },
  { 7126, 24, 23, 28, 2, -40 },
  { 7195, 20, 3, 19, -5, 5 },
  { 7203, 7, 9, 14, 8, -43 },
  { 7211, 25, 31, 28, 2, -30 },
  { 7308, 25, 44, 28, 1, -43 },
  { 7446, 21, 31, 22, 2, -30 },
  { 7528, 28, 44, 29, 2, -43 },
  { 7682, 21, 31, 25, 2, -30 },
  { 7764, 29, 56, 15, -7, -43 },
  { 7967, 27, 43, 29, 0, -30 },
  { 8113, 24, 43, 28, 1, -43 },
  { 8242, 12, 41, 12, 1, -41 },
  { 8304, 20, 54, 12, -7, -41 },
  { 8439, 24, 43, 23, 1, -43 },
  { 8568, 12, 43, 12, 1, -43 },
  { 8633, 39, 30, 42, 1, -30 },
  { 8780, 24, 30, 28, 1, -30 },
  { 8870, 24, 31, 28, 2, -30 },
  { 8963, 28, 43, 28, -2, -30 },
  { 9114, 25, 43, 29, 2, -30 },
  { 9249, 20, 30, 19, 1, -30 },
  { 9324, 21, 31, 21, 0, -30 },
  { 9406, 15, 38, 16, 2, -37 },
  { 9478, 25, 31, 28, 2, -30 },
  { 9575, 22, 30, 22, 3, -30 },
  { 9658, 34, 30, 35, 3, -30 },
  { 9786, 27, 30, 23, -2, -30 },
  { 9888, 31, 44, 22, -6, -30 },
  { 10059, 22, 30, 21, -1, -30 },
  { 10142, 21, 49, 19, 1, -40 },
  { 10271, 2, 57, 27, 13, -43 },
  { 10286, 20, 49, 19, -3, -40 },
  { 10409, 24, 6, 29, 3, -23 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC56PT7B_H_
