#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC18PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x13, 0x22, 0x22, 0x44, 0x04, 0xC0, 0x59, 0x99, 0xA0, 0x04,
  0x82, 0x20, 0x88, 0x24, 0x3F, 0xC4, 0x41, 0x20, 0x48, 0xFF, 0x89, 0x02,
  0x40, 0x90, 0x44, 0x00, 0x02, 0x04, 0x1F, 0x24, 0x24, 0x24, 0x38, 0x0C,
  0x0E, 0x0A, 0x12, 0x12, 0xFC, 0x10, 0x10, 0x38, 0x49, 0x11, 0x22, 0x44,
  0x88, 0xA1, 0x15, 0xA5, 0x4B, 0x51, 0x0A, 0x22, 0x44, 0x89, 0x11, 0x24,
  0x38, 0x0E, 0x04, 0x41, 0x10, 0x44, 0x12, 0x03, 0x01, 0x80, 0x91, 0x44,
  0xA0, 0xC8, 0x31, 0x0C, 0x7D, 0x80, 0x6A, 0x80, 0x08, 0x88, 0x84, 0x22,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x18, 0x10, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x84, 0x22, 0x11, 0x10, 0x10, 0x23, 0x41, 0xF3, 0x09, 0x32, 0x00, 0x10,
  0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x2D, 0x60, 0xF8, 0x70,
  0x01, 0x01, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40,
  0x80, 0x1C, 0x45, 0x8A, 0x14, 0x30, 0x60, 0xC1, 0x83, 0x0A, 0x14, 0x47,
  0x00, 0x09, 0xF4, 0x21, 0x08, 0x44, 0x21, 0x08, 0x44, 0x00, 0x1E, 0x31,
  0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFE, 0x1E,
  0x21, 0x01, 0x01, 0x01, 0x02, 0x1C, 0x02, 0x02, 0x02, 0x02, 0x06, 0xFC,
  0x01, 0x03, 0x05, 0x05, 0x0A, 0x12, 0x22, 0x42, 0x42, 0xFF, 0x04, 0x04,
  0x04, 0x1F, 0x88, 0x04, 0x04, 0x02, 0x01, 0xE0, 0x08, 0x04, 0x01, 0x01,
  0x00, 0x80, 0xCF, 0xC0, 0x0F, 0x10, 0x20, 0x40, 0x40, 0x7C, 0xC6, 0x82,
  0x82, 0x82, 0x84, 0x84, 0x78, 0x7F, 0x01, 0x02, 0x02, 0x04, 0x08, 0x08,
  0x10, 0x10, 0x20, 0x20, 0x40, 0xC0, 0x0F, 0x08, 0x88, 0x24, 0x21, 0x10,
  0xB0, 0x70, 0x44, 0x42, 0x20, 0xA0, 0x88, 0x47, 0xC0, 0x1C, 0x45, 0x0A,
  0x18, 0x30, 0x51, 0xBD, 0x04, 0x08, 0x20, 0x4F, 0x00, 0x24, 0x00, 0x00,
  0x58, 0x18, 0x80, 0x00, 0x00, 0x00, 0x22, 0x11, 0x00, 0x01, 0x02, 0x0C,
  0x70, 0x80, 0x60, 0x18, 0x06, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x04, 0x38, 0xC0, 0x80, 0x78, 0x10, 0x41, 0x08,
  0x63, 0x08, 0x41, 0x00, 0x20, 0xC0, 0x07, 0x81, 0x86, 0x20, 0x24, 0x01,
  0x47, 0x98, 0x91, 0x91, 0x19, 0x11, 0x91, 0x29, 0x32, 0x9D, 0xC8, 0x00,
  0x40, 0x06, 0x10, 0x1E, 0x00, 0x03, 0x01, 0x81, 0x40, 0xA0, 0x90, 0x48,
  0x44, 0x22, 0x3F, 0x10, 0x90, 0x28, 0x18, 0x08, 0x3E, 0x21, 0x21, 0x21,
  0x41, 0x42, 0x7C, 0x42, 0x82, 0x82, 0x82, 0x86, 0xF8, 0x0F, 0x88, 0x08,
  0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x08, 0x03, 0xE0,
  0x3E, 0x11, 0x88, 0x64, 0x14, 0x0A, 0x05, 0x02, 0x81, 0x81, 0x40, 0xA0,
  0x90, 0x8F, 0x80, 0x3F, 0x20, 0x20, 0x20, 0x40, 0x40, 0x7C, 0x40, 0x80,
  0x80, 0x80, 0x80, 0xF8, 0x3F, 0x20, 0x20, 0x20, 0x40, 0x40, 0x7C, 0x40,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x0F, 0x84, 0x12, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x7A, 0x02, 0x80, 0xA0, 0x4C, 0x11, 0x04, 0x3F, 0x00, 0x20, 0x48,
  0x12, 0x08, 0x82, 0x40, 0x90, 0x27, 0xF9, 0x04, 0x81, 0x20, 0x48, 0x12,
  0x04, 0x82, 0x00, 0x3C, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84, 0x10,
  0xE0, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40,
  0x82, 0x04, 0x70, 0x20, 0x90, 0x88, 0x84, 0x84, 0x82, 0x81, 0xC0, 0x90,
  0x88, 0x44, 0x21, 0x10, 0x88, 0x60, 0x21, 0x08, 0x44, 0x21, 0x08, 0x84,
  0x21, 0x0F, 0x80, 0x30, 0x19, 0x81, 0x8C, 0x0C, 0x60, 0xA5, 0x05, 0x28,
  0x51, 0x42, 0x89, 0x24, 0x89, 0x24, 0x51, 0x23, 0x11, 0x18, 0x88, 0x84,
  0x00, 0x20, 0x4C, 0x13, 0x05, 0x41, 0x48, 0x92, 0x24, 0x89, 0x12, 0x85,
  0x21, 0x48, 0x32, 0x0C, 0x83, 0x00, 0x0F, 0x04, 0x22, 0x0D, 0x01, 0x40,
  0x50, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x28, 0x11, 0x0C, 0x3C, 0x00, 0x3C,
  0x23, 0x21, 0x21, 0x41, 0x43, 0x46, 0x78, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x0F, 0x04, 0x22, 0x0D, 0x01, 0x40, 0x50, 0x18, 0x06, 0x02, 0x80, 0xA0,
  0x28, 0x11, 0x0C, 0x3C, 0x02, 0x00, 0x40, 0x18, 0x3E, 0x23, 0x21, 0x21,
  0x41, 0x42, 0x4E, 0x78, 0x88, 0x8C, 0x84, 0x84, 0x86, 0x1F, 0x31, 0x20,
  0x20, 0x20, 0x30, 0x08, 0x04, 0x02, 0x02, 0x02, 0x04, 0xF8, 0xFE, 0x20,
  0x41, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x00, 0x20, 0x48,
  0x12, 0x09, 0x02, 0x40, 0x90, 0x24, 0x09, 0x04, 0x81, 0x20, 0x48, 0x13,
  0x08, 0x7C, 0x00, 0x81, 0x82, 0x82, 0x84, 0x84, 0x88, 0x88, 0x90, 0x90,
  0xA0, 0xA0, 0xA0, 0x40, 0x82, 0x0C, 0x30, 0xA1, 0x85, 0x14, 0x28, 0xA2,
  0x45, 0x12, 0x49, 0x12, 0x48, 0xA2, 0x85, 0x14, 0x30, 0xA1, 0x86, 0x08,
  0x30, 0x00, 0x10, 0x44, 0x20, 0x88, 0x24, 0x0A, 0x01, 0x80, 0x40, 0x30,
  0x12, 0x0C, 0x82, 0x21, 0x08, 0x81, 0x00, 0x83, 0x0E, 0x14, 0x44, 0x8A,
  0x18, 0x30, 0x40, 0x81, 0x02, 0x08, 0x00, 0x3F, 0x80, 0x80, 0x40, 0x40,
  0x40, 0x20, 0x20, 0x20, 0x30, 0x10, 0x10, 0x10, 0x0F, 0xE0, 0x1C, 0x41,
  0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x38, 0x92, 0x48,
  0x92, 0x49, 0x12, 0x1C, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x41, 0x04,
  0x10, 0x42, 0x38, 0x08, 0x18, 0x14, 0x24, 0x44, 0x42, 0x82, 0x83, 0xFE,
  0xA4, 0x19, 0x26, 0x42, 0x82, 0x82, 0x82, 0x84, 0x84, 0x8C, 0xF4, 0x10,
  0x10, 0x10, 0x10, 0x26, 0x29, 0x31, 0x21, 0x21, 0x41, 0x41, 0x42, 0x42,
  0xBC, 0x1C, 0x94, 0x20, 0x82, 0x08, 0x20, 0x81, 0xE0, 0x00, 0x80, 0x80,
  0x40, 0x21, 0x91, 0x29, 0x09, 0x04, 0x82, 0x41, 0x21, 0x10, 0x88, 0xC7,
  0xA0, 0x1C, 0x49, 0x0C, 0x29, 0x9C, 0x20, 0x40, 0x80, 0xF0, 0x03, 0x83,
  0x01, 0x00, 0x81, 0xE0, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x80, 0x40, 0x20, 0x60, 0x00, 0x0C, 0x89, 0x48, 0x48, 0x24,
  0x12, 0x09, 0x08, 0x84, 0x46, 0x3D, 0x00, 0x80, 0x80, 0x47, 0xC0, 0x10,
  0x10, 0x10, 0x10, 0x26, 0x29, 0x31, 0x21, 0x21, 0x41, 0x42, 0x42, 0x42,
  0x82, 0x11, 0x02, 0x22, 0x22, 0x44, 0x44, 0x80, 0x04, 0x10, 0x02, 0x08,
  0x20, 0x82, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0xC0, 0x10, 0x10, 0x10,
  0x10, 0x21, 0x22, 0x24, 0x28, 0x50, 0x68, 0x48, 0x4C, 0x44, 0x84, 0x11,
  0x11, 0x22, 0x22, 0x24, 0x44, 0x48, 0x26, 0x71, 0xDC, 0xC8, 0x42, 0x42,
  0x12, 0x21, 0x21, 0x09, 0x08, 0x48, 0x42, 0x42, 0x14, 0x21, 0x00, 0x26,
  0x39, 0x21, 0x21, 0x21, 0x41, 0x42, 0x42, 0x42, 0x82, 0x1C, 0x4D, 0x0C,
  0x18, 0x30, 0x60, 0xC2, 0x84, 0xF0, 0x13, 0x0A, 0x46, 0x22, 0x11, 0x09,
  0x04, 0x82, 0x42, 0x21, 0x2F, 0x10, 0x08, 0x04, 0x06, 0x00, 0x19, 0x25,
  0x42, 0x82, 0x82, 0x82, 0x84, 0x84, 0x8C, 0xF4, 0x04, 0x08, 0x08, 0x08,
  0x26, 0x50, 0xC1, 0x02, 0x08, 0x10, 0x20, 0x41, 0x00, 0x1C, 0x45, 0x02,
  0x02, 0x03, 0x02, 0x02, 0x09, 0xF0, 0x21, 0x3E, 0x84, 0x22, 0x10, 0x84,
  0x21, 0xC0, 0x41, 0x42, 0x42, 0x42, 0x82, 0x84, 0x84, 0x84, 0x8C, 0xF4,
  0x83, 0x0A, 0x14, 0x48, 0x92, 0x24, 0x30, 0x60, 0x80, 0x84, 0x31, 0x8A,
  0x31, 0x4A, 0x49, 0x49, 0x29, 0x29, 0x45, 0x28, 0xC6, 0x18, 0xC0, 0x30,
  0x88, 0x84, 0x81, 0x80, 0xC0, 0x40, 0x50, 0x48, 0x64, 0x61, 0x00, 0x10,
  0x44, 0x21, 0x08, 0x44, 0x11, 0x02, 0x80, 0xA0, 0x30, 0x0C, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x38, 0x00, 0x3E, 0x0C, 0x10, 0x41, 0x02, 0x08, 0x20,
  0x81, 0xF0, 0x06, 0x10, 0x20, 0x81, 0x02, 0x04, 0x30, 0xE0, 0x40, 0x81,
  0x04, 0x08, 0x10, 0x18, 0xFF, 0xFF, 0xC0, 0x18, 0x08, 0x10, 0x20, 0x81,
  0x02, 0x07, 0x0C, 0x20, 0x40, 0x81, 0x04, 0x08, 0x60, 0xF9, 0x86,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 13, 4, 0, -13 },
  { 8, 4, 5, 6, 2, -13 },
  { 11, 10, 13, 10, 0, -13 },
  { 28, 8, 15, 9, 0, -14 },
  { 43, 11, 13, 13, 1, -13 },
  { 61, 10, 13, 10, 0, -13 },
  { 78, 2, 5, 3, 2, -13 },
  { 80, 5, 16, 5, 1, -13 },
  { 90, 5, 16, 5, -1, -13 },
  { 100, 7, 7, 8, 2, -14 },
  { 107, 8, 9, 9, 1, -11 },
  { 116, 3, 4, 4, -1, -2 },
  { 118, 5, 1, 5, 0, -5 },
  { 119, 2, 2, 4, 0, -2 },
  { 120, 8, 13, 6, -1, -13 },
  { 133, 7, 13, 9, 1, -13 },
  { 145, 5, 13, 9, 2, -13 },
  { 154, 8, 13, 9, 0, -13 },
  { 167, 8, 13, 9, 0, -13 },
  { 180, 8, 13, 9, 0, -13 },
  { 193, 9, 13, 9, 0, -13 },
  { 208, 8, 13, 9, 1, -13 },
  { 221, 8, 13, 9, 1, -13 },
  { 234, 9, 13, 9, 0, -13 },
  { 249, 7, 13, 9, 1, -13 },
  { 261, 3, 10, 4, 0, -10 },
  { 265, 5, 12, 4, -1, -10 },
  { 273, 8, 9, 9, 1, -11 },
  { 282, 8, 5, 9, 1, -9 },
  { 287, 8, 9, 9, 1, -11 },
  { 296, 6, 13, 7, 1, -13 },
  { 306, 12, 15, 13, 1, -13 },
  { 329, 9, 13, 9, -1, -13 },
  { 344, 8, 13, 9, 1, -13 },
  { 357, 9, 13, 9, 1, -13 },
  { 372, 9, 13, 11, 1, -13 },
  { 387, 8, 13, 8, 1, -13 },
  { 400, 8, 13, 8, 1, -13 },
  { 413, 10, 13, 11, 1, -13 },
  { 430, 10, 13, 11, 1, -13 },
  { 447, 6, 13, 5, 0, -13 },
  { 457, 7, 16, 4, -3, -13 },
  { 471, 9, 13, 9, 1, -13 },
  { 486, 5, 13, 8, 1, -13 },
  { 495, 13, 13, 13, 1, -13 },
  { 517, 10, 13, 11, 1, -13 },
  { 534, 10, 13, 11, 1, -13 },
  { 551, 8, 13, 9, 1, -13 },
  { 564, 10, 16, 11, 1, -13 },
  { 584, 8, 13, 9, 1, -13 },
  { 597, 8, 13, 8, 0, -13 },
  { 610, 7, 13, 8, 2, -13 },
  { 622, 10, 13, 11, 1, -13 },
  { 639, 8, 13, 9, 2, -13 },
  { 652, 13, 13, 14, 2, -13 },
  { 674, 10, 13, 8, -1, -13 },
  { 691, 7, 13, 8, 2, -13 },
  { 703, 9, 13, 8, 0, -13 },
  { 718, 6, 16, 5, 0, -13 },
  { 730, 3, 13, 6, 2, -13 },
  { 735, 6, 16, 5, -1, -13 },
  { 747, 8, 8, 9, 1, -13 },
  { 755, 7, 1, 6, -2, 2 },
  { 756, 2, 3, 4, 3, -14 },
  { 757, 8, 10, 9, 1, -10 },
  { 767, 8, 14, 9, 0, -14 },
  { 781, 6, 10, 7, 1, -10 },
  { 789, 9, 14, 9, 1, -14 },
  { 805, 7, 10, 8, 1, -10 },
  { 814, 9, 18, 5, -2, -14 },
  { 835, 9, 14, 9, 0, -10 },
  { 851, 8, 14, 9, 0, -14 },
  { 865, 4, 13, 4, 0, -13 },
  { 872, 6, 17, 4, -2, -13 },
  { 885, 8, 14, 7, 0, -14 },
  { 899, 4, 14, 4, 0, -14 },
  { 906, 13, 10, 14, 0, -10 },
  { 923, 8, 10, 9, 0, -10 },
  { 933, 7, 10, 9, 1, -10 },
  { 942, 9, 14, 9, -1, -10 },
  { 958, 8, 14, 9, 1, -10 },
  { 972, 7, 10, 6, 0, -10 },
  { 981, 7, 10, 7, 0, -10 },
  { 990, 5, 12, 5, 1, -12 },
  { 998, 8, 10, 9, 1, -10 },
  { 1008, 7, 10, 7, 1, -10 },
  { 1017, 11, 10, 11, 1, -10 },
  { 1031, 9, 10, 7, -1, -10 },
  { 1043, 10, 14, 7, -2, -10 },
  { 1061, 7, 10, 7, 0, -10 },
  { 1070, 7, 16, 6, 0, -13 },
  { 1084, 1, 18, 9, 4, -14 },
  { 1087, 7, 16, 6, -1, -13 },
  { 1101, 8, 2, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC18PT7B_H_
