#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC30PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC6, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x08, 0x21, 0x86,
  0x00, 0x00, 0x0C, 0x30, 0xC0, 0x63, 0x62, 0x66, 0x46, 0x44, 0xC4, 0xC4,
  0x01, 0x84, 0x01, 0x0C, 0x03, 0x08, 0x03, 0x08, 0x02, 0x18, 0x02, 0x18,
  0x3F, 0xFF, 0x04, 0x10, 0x04, 0x30, 0x0C, 0x20, 0x08, 0x20, 0x08, 0x60,
  0x18, 0x40, 0xFF, 0xFC, 0x10, 0x40, 0x10, 0xC0, 0x30, 0x80, 0x20, 0x80,
  0x21, 0x80, 0x61, 0x00, 0x41, 0x00, 0x00, 0x40, 0x06, 0x00, 0x20, 0x0F,
  0xE0, 0xC9, 0x8C, 0xC0, 0xC4, 0x06, 0x20, 0x31, 0x00, 0x88, 0x06, 0xC0,
  0x1C, 0x00, 0x38, 0x01, 0x60, 0x09, 0x80, 0xCC, 0x04, 0x20, 0x23, 0x01,
  0x19, 0x09, 0x8F, 0xF8, 0x0E, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x87, 0xC0, 0x43, 0x10, 0x21, 0x84, 0x18, 0x61, 0x04, 0x10, 0x42,
  0x0C, 0x11, 0x83, 0x0C, 0x40, 0xC3, 0x20, 0x30, 0x99, 0xEC, 0x64, 0xCB,
  0x13, 0x63, 0x7D, 0x90, 0xCC, 0x4C, 0x30, 0x33, 0x0C, 0x18, 0x82, 0x04,
  0x20, 0x83, 0x08, 0x61, 0x82, 0x18, 0x40, 0x84, 0x30, 0x22, 0x18, 0x0F,
  0x80, 0x01, 0xC0, 0x07, 0xE0, 0x18, 0xC0, 0x60, 0x80, 0xC1, 0x01, 0x82,
  0x03, 0x0C, 0x06, 0x30, 0x0C, 0xC0, 0x0F, 0x00, 0x18, 0x00, 0xF8, 0x03,
  0x10, 0x6C, 0x30, 0xF0, 0x23, 0x60, 0x66, 0x80, 0x79, 0x00, 0xE2, 0x01,
  0xC6, 0x07, 0x8E, 0x39, 0x8F, 0xE1, 0x80, 0x6D, 0xA5, 0xB0, 0x03, 0x81,
  0x01, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x08, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x00,
  0x80, 0x60, 0x10, 0x00, 0x06, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x03,
  0x01, 0x01, 0x80, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x00, 0x03, 0x00,
  0x30, 0x02, 0x04, 0x20, 0xF2, 0x01, 0xDF, 0x07, 0x80, 0xA0, 0x33, 0x06,
  0x10, 0x21, 0x80, 0x10, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x0F, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x33, 0x26, 0x4C, 0x80, 0xFF, 0xFC, 0xFC, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0x83, 0x8C,
  0x18, 0x31, 0x81, 0x88, 0x0C, 0xC0, 0x66, 0x03, 0x60, 0x1B, 0x00, 0xD8,
  0x06, 0xC0, 0x34, 0x01, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x66, 0x03,
  0x10, 0x30, 0xC1, 0x87, 0x38, 0x1F, 0x80, 0x07, 0x1E, 0x36, 0xE6, 0x46,
  0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30,
  0x30, 0x30, 0x20, 0x60, 0x01, 0xE0, 0x1F, 0xE0, 0xC1, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x01, 0xE0, 0x1F, 0xE0, 0xC1,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x01,
  0xC0, 0x7C, 0x01, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0xE1, 0xC1, 0xFE, 0x00, 0x00, 0x0C,
  0x00, 0x70, 0x03, 0x80, 0x0A, 0x00, 0x58, 0x03, 0x60, 0x19, 0x80, 0xC4,
  0x02, 0x10, 0x18, 0xC0, 0xC3, 0x06, 0x0C, 0x10, 0x20, 0x80, 0x86, 0x06,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x0F, 0xF8, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x31, 0x87, 0x0F, 0xF0, 0x00,
  0x00, 0x3C, 0x07, 0xE0, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x9F, 0x06, 0xC6, 0x1C, 0x0C, 0x60, 0x31, 0x80,
  0xC4, 0x03, 0x30, 0x0C, 0xC0, 0x31, 0x00, 0x84, 0x06, 0x18, 0x30, 0x31,
  0xC0, 0x7C, 0x00, 0x7F, 0xF8, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x01, 0xC0, 0x3F, 0x83, 0x06, 0x30, 0x31, 0x80, 0x8C, 0x04,
  0x60, 0x63, 0x03, 0x0C, 0x30, 0x67, 0x01, 0xE0, 0x1F, 0x03, 0x8C, 0x30,
  0x33, 0x00, 0x98, 0x04, 0x80, 0x34, 0x01, 0x30, 0x19, 0x80, 0xC6, 0x1C,
  0x1F, 0xC0, 0x01, 0xC0, 0x3F, 0x03, 0x0C, 0x30, 0x33, 0x01, 0x98, 0x0C,
  0x80, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xC8, 0x0C, 0x60, 0xA1, 0xFF, 0x07,
  0x98, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x08, 0x70,
  0x7E, 0x00, 0x19, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x43, 0x18,
  0x06, 0x1C, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x0C, 0x30, 0x60, 0x83, 0x04, 0x00, 0x00, 0x10, 0x03, 0x00, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x08, 0x00, 0x1E,
  0x1F, 0xE4, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x08, 0x06, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0xFF, 0x80, 0x18, 0x0C, 0x06, 0x00, 0x60, 0xC0,
  0x03, 0x08, 0x00, 0x31, 0x00, 0x01, 0x30, 0x7E, 0x12, 0x0C, 0x21, 0x61,
  0x86, 0x16, 0x30, 0x41, 0x43, 0x04, 0x14, 0x20, 0xC3, 0xC6, 0x0C, 0x3C,
  0x60, 0x82, 0xC6, 0x18, 0x6C, 0x61, 0x8C, 0xC3, 0xEF, 0x84, 0x1C, 0x70,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x40, 0x0F, 0xFC,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0xA0, 0x03, 0x40, 0x04,
  0x80, 0x19, 0x80, 0x23, 0x00, 0xC6, 0x01, 0x0C, 0x06, 0x18, 0x08, 0x30,
  0x30, 0x60, 0x7F, 0xC1, 0xFF, 0x82, 0x01, 0x0C, 0x02, 0x10, 0x04, 0x60,
  0x0C, 0x80, 0x1B, 0x00, 0x3C, 0x00, 0x60, 0x0F, 0xF8, 0x18, 0x38, 0x20,
  0x30, 0x40, 0x31, 0x80, 0x63, 0x00, 0x86, 0x03, 0x08, 0x06, 0x10, 0x38,
  0x7F, 0xC0, 0xFF, 0x81, 0x81, 0x82, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30,
  0x0C, 0x60, 0x18, 0x80, 0x63, 0x01, 0xC7, 0xFE, 0x0F, 0xF8, 0x00, 0x00,
  0x70, 0x07, 0xFC, 0x1C, 0x10, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x86, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0C, 0x1C, 0x08, 0x0E, 0x08,
  0x06, 0x18, 0x02, 0x18, 0x03, 0x18, 0x03, 0x10, 0x03, 0x10, 0x03, 0x30,
  0x03, 0x30, 0x02, 0x30, 0x06, 0x20, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x18, 0x40, 0x30, 0xC0, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F,
  0xFC, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0xFF, 0x83, 0xFE, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x0F, 0xFC, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0xFE, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x00, 0x78, 0x03, 0xFF, 0x07, 0x03, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x7E, 0xC0, 0xFC, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0xC0,
  0x08, 0x60, 0x18, 0x60, 0x18, 0x38, 0x38, 0x1F, 0xF0, 0x0C, 0x01, 0x86,
  0x00, 0xC2, 0x00, 0x61, 0x00, 0x21, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x0C,
  0x20, 0x06, 0x10, 0x02, 0x1F, 0xFF, 0x0F, 0xFF, 0x86, 0x00, 0xC2, 0x00,
  0x43, 0x00, 0x21, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x0C, 0x20, 0x04, 0x30,
  0x06, 0x18, 0x03, 0x0C, 0x01, 0x80, 0x07, 0xE0, 0x20, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x0F, 0xC0, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C,
  0x0F, 0x80, 0x0C, 0x07, 0x0C, 0x0C, 0x08, 0x18, 0x08, 0x30, 0x18, 0x70,
  0x18, 0xE0, 0x18, 0xC0, 0x11, 0x80, 0x13, 0x00, 0x37, 0x00, 0x3F, 0x00,
  0x31, 0x00, 0x21, 0x80, 0x61, 0x80, 0x60, 0x80, 0x60, 0xC0, 0x60, 0xC0,
  0x40, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80,
  0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0xFF, 0xFF, 0x80, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0xE0, 0xA0, 0x07, 0x82, 0x80, 0x1E, 0x1A, 0x00,
  0xD8, 0x68, 0x03, 0x41, 0xB0, 0x1B, 0x04, 0xC0, 0x4C, 0x13, 0x03, 0x30,
  0xCC, 0x08, 0xC3, 0x30, 0x62, 0x0C, 0x41, 0x18, 0x21, 0x0C, 0x61, 0x84,
  0x21, 0x86, 0x11, 0x84, 0x18, 0x64, 0x10, 0x41, 0xB0, 0xC1, 0x07, 0x83,
  0x0C, 0x1E, 0x0C, 0x30, 0x70, 0x20, 0xC0, 0x81, 0x80, 0x0E, 0x00, 0xC3,
  0x80, 0x20, 0xE0, 0x18, 0x28, 0x06, 0x1B, 0x01, 0x86, 0xC0, 0x41, 0x90,
  0x10, 0x46, 0x0C, 0x11, 0x83, 0x0C, 0x20, 0xC3, 0x0C, 0x20, 0xC3, 0x18,
  0x20, 0x46, 0x18, 0x19, 0x86, 0x06, 0x61, 0x80, 0x90, 0x40, 0x34, 0x10,
  0x0F, 0x0C, 0x01, 0xC3, 0x00, 0x60, 0xC0, 0x18, 0x00, 0x00, 0xE0, 0x03,
  0xFC, 0x0E, 0x0E, 0x1C, 0x06, 0x18, 0x03, 0x30, 0x03, 0x20, 0x03, 0x60,
  0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x60,
  0x30, 0x38, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x30, 0xE0, 0x80, 0xC2, 0x03,
  0x18, 0x0C, 0x60, 0x31, 0x80, 0xC4, 0x03, 0x10, 0x18, 0xC0, 0xE3, 0x0F,
  0x0F, 0xF0, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0xFC, 0x0E, 0x0E,
  0x1C, 0x06, 0x18, 0x03, 0x30, 0x03, 0x20, 0x03, 0x60, 0x03, 0x60, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x60, 0x30, 0x38, 0xE0,
  0x1F, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x0F, 0xF0, 0x30, 0xE0, 0x80, 0xC2, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80,
  0xC4, 0x03, 0x10, 0x18, 0xC0, 0xC3, 0xFE, 0x0F, 0xE0, 0x21, 0x81, 0x82,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0x41, 0x01, 0x8C, 0x06, 0x30, 0x18, 0xC0,
  0x30, 0x00, 0xE0, 0x1F, 0xF0, 0xE0, 0xC7, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0xE1, 0xC3, 0xFC, 0x00, 0xFF, 0xF0, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x00,
  0x18, 0x03, 0x18, 0x03, 0x10, 0x03, 0x30, 0x02, 0x30, 0x02, 0x30, 0x06,
  0x20, 0x06, 0x20, 0x06, 0x60, 0x04, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x0C,
  0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x10, 0xC0, 0x30,
  0xC0, 0x60, 0x70, 0xE0, 0x3F, 0x80, 0xC0, 0x0F, 0x00, 0x6C, 0x01, 0x30,
  0x0C, 0xC0, 0x23, 0x01, 0x8C, 0x04, 0x30, 0x30, 0xC0, 0x81, 0x06, 0x04,
  0x10, 0x10, 0xC0, 0x42, 0x01, 0x18, 0x06, 0x40, 0x1B, 0x00, 0x6C, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x30, 0x0F, 0x01, 0xC0,
  0x2C, 0x07, 0x01, 0xB0, 0x14, 0x04, 0xC0, 0xD0, 0x33, 0x02, 0x40, 0xCC,
  0x19, 0x06, 0x30, 0x44, 0x18, 0xC3, 0x10, 0x43, 0x0C, 0x43, 0x0C, 0x61,
  0x08, 0x31, 0x84, 0x60, 0xC4, 0x11, 0x83, 0x30, 0x4C, 0x0C, 0x81, 0x30,
  0x36, 0x04, 0x80, 0xD0, 0x16, 0x01, 0xC0, 0x50, 0x07, 0x01, 0xC0, 0x18,
  0x06, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0xC0, 0xC0, 0xC0, 0x30, 0x30,
  0x04, 0x18, 0x01, 0x0C, 0x00, 0x62, 0x00, 0x19, 0x80, 0x02, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0x60, 0x00, 0x88,
  0x00, 0x63, 0x00, 0x30, 0xC0, 0x18, 0x30, 0x06, 0x04, 0x03, 0x01, 0x81,
  0x80, 0x60, 0xE0, 0x08, 0x00, 0xC0, 0x3E, 0x01, 0x30, 0x18, 0x81, 0x84,
  0x0C, 0x30, 0xC1, 0x8C, 0x0C, 0x60, 0x26, 0x01, 0x20, 0x0F, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x07, 0xE0,
  0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFC, 0x1F, 0x00, 0xC6, 0x10,
  0x84, 0x31, 0x8C, 0x61, 0x08, 0x43, 0x18, 0xC2, 0x10, 0x86, 0x31, 0x80,
  0x07, 0xE0, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0xFC, 0x1F, 0x80,
  0x01, 0x00, 0x0C, 0x00, 0xE0, 0x0D, 0x80, 0x6C, 0x06, 0x20, 0x21, 0x83,
  0x04, 0x10, 0x21, 0x81, 0x98, 0x04, 0xC0, 0x3C, 0x01, 0x80, 0xFF, 0xE0,
  0xC6, 0x23, 0x10, 0x07, 0xC8, 0x63, 0x46, 0x0E, 0x60, 0x72, 0x01, 0xB0,
  0x19, 0x80, 0xC8, 0x06, 0xC0, 0x36, 0x01, 0x30, 0x19, 0x80, 0xCC, 0x0E,
  0x20, 0xF1, 0x8D, 0x07, 0xC8, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x7C, 0x16, 0x31, 0xE0, 0xCE, 0x06, 0x60,
  0x33, 0x01, 0x90, 0x0D, 0x80, 0x6C, 0x03, 0x60, 0x13, 0x01, 0x90, 0x0D,
  0xC0, 0xCE, 0x0C, 0x58, 0xE2, 0x7C, 0x00, 0x07, 0xE1, 0x84, 0x60, 0x18,
  0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x1C, 0x21, 0xFC, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x03, 0xE6, 0x0C, 0x68, 0x30, 0x50,
  0xC0, 0x61, 0x00, 0xC6, 0x01, 0x0C, 0x02, 0x10, 0x0C, 0x60, 0x18, 0xC0,
  0x31, 0x80, 0xC3, 0x01, 0x86, 0x07, 0x04, 0x1E, 0x0C, 0x6C, 0x0F, 0x90,
  0x00, 0x07, 0xC0, 0xC6, 0x18, 0x23, 0x03, 0x20, 0x26, 0x06, 0x61, 0xC7,
  0xF8, 0xF0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x83,
  0xF8, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x03, 0xF8, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x98, 0x00, 0xF0,
  0x00, 0x03, 0xE6, 0x0C, 0x68, 0x30, 0x50, 0xC0, 0x61, 0x00, 0xC6, 0x01,
  0x0C, 0x02, 0x10, 0x0C, 0x60, 0x18, 0xC0, 0x31, 0x80, 0xC3, 0x01, 0x86,
  0x07, 0x04, 0x1E, 0x0C, 0x6C, 0x0F, 0x90, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x18, 0x70, 0x1F, 0xC0, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x7C, 0x16, 0x31,
  0xE0, 0x8E, 0x06, 0x60, 0x23, 0x01, 0x10, 0x19, 0x80, 0xCC, 0x06, 0x60,
  0x22, 0x01, 0x10, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x22, 0x03, 0x00, 0x0C,
  0x30, 0x80, 0x00, 0x01, 0x84, 0x30, 0xC3, 0x08, 0x21, 0x86, 0x18, 0x41,
  0x0C, 0x30, 0xC2, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x60, 0x5C, 0x0F, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x07, 0x10, 0x61, 0x86,
  0x0C, 0x60, 0x66, 0x02, 0x20, 0x13, 0x01, 0xB8, 0x0E, 0xC0, 0x62, 0x02,
  0x18, 0x10, 0xC1, 0x82, 0x0C, 0x18, 0x60, 0xC2, 0x03, 0x00, 0x0C, 0x30,
  0xC2, 0x08, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x20, 0x86, 0x18, 0x61, 0x04,
  0x30, 0xC3, 0x08, 0x00, 0x13, 0xE3, 0xE1, 0x67, 0x63, 0x3C, 0x3C, 0x33,
  0x83, 0x81, 0x30, 0x30, 0x33, 0x03, 0x03, 0x20, 0x30, 0x36, 0x02, 0x03,
  0x60, 0x60, 0x26, 0x06, 0x06, 0x40, 0x60, 0x64, 0x04, 0x06, 0xC0, 0x40,
  0x6C, 0x0C, 0x04, 0xC0, 0xC0, 0xC8, 0x0C, 0x0C, 0x13, 0xF0, 0xB1, 0x8F,
  0x06, 0x70, 0x33, 0x01, 0x18, 0x08, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x01,
  0x10, 0x08, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x01, 0x10, 0x18, 0x07, 0xE0,
  0x63, 0x86, 0x0C, 0x60, 0x22, 0x01, 0xB0, 0x0D, 0x80, 0x68, 0x03, 0xC0,
  0x16, 0x01, 0xB0, 0x0D, 0x80, 0x4C, 0x06, 0x30, 0x61, 0xC6, 0x07, 0xE0,
  0x04, 0xF8, 0x0B, 0x18, 0x3C, 0x18, 0x70, 0x30, 0xC0, 0x61, 0x80, 0xC2,
  0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x08, 0x60, 0x30, 0x80, 0x63, 0x81,
  0x87, 0x06, 0x0F, 0x1C, 0x13, 0xE0, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x07, 0xCC, 0x31, 0xA1,
  0x82, 0x8C, 0x06, 0x20, 0x19, 0x80, 0x46, 0x01, 0x10, 0x0C, 0xC0, 0x33,
  0x00, 0xCC, 0x06, 0x30, 0x18, 0xC0, 0xE1, 0x07, 0x86, 0x36, 0x0F, 0x90,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x13, 0xC5, 0x93, 0xC0, 0xE0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60,
  0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x0F, 0xE3, 0x0C,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06,
  0x00, 0x40, 0x18, 0x03, 0x30, 0xC7, 0xF0, 0x08, 0x08, 0x18, 0x18, 0x7F,
  0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0,
  0xC0, 0xC0, 0x78, 0x10, 0x08, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x01, 0x10,
  0x19, 0x80, 0xCC, 0x06, 0x60, 0x32, 0x01, 0x10, 0x19, 0x80, 0xCC, 0x0E,
  0x60, 0xE1, 0x8D, 0x0F, 0xC8, 0x80, 0x70, 0x0A, 0x03, 0x40, 0x4C, 0x19,
  0x82, 0x30, 0xC6, 0x10, 0xC6, 0x18, 0x81, 0x30, 0x24, 0x05, 0x80, 0xA0,
  0x1C, 0x03, 0x00, 0x80, 0xC0, 0xE0, 0x70, 0x68, 0x1C, 0x1A, 0x0F, 0x04,
  0x82, 0xC3, 0x21, 0xB0, 0x88, 0x4C, 0x63, 0x33, 0x10, 0xC8, 0xCC, 0x32,
  0x13, 0x0D, 0x85, 0x83, 0x41, 0x60, 0xF0, 0x50, 0x38, 0x1C, 0x0E, 0x06,
  0x03, 0x01, 0x80, 0x18, 0x0C, 0x30, 0x60, 0xC3, 0x01, 0x08, 0x06, 0x60,
  0x1B, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1E, 0x00, 0xD8, 0x06, 0x20,
  0x10, 0xC0, 0xC3, 0x06, 0x04, 0x30, 0x18, 0x04, 0x03, 0x06, 0x03, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x0C, 0x06, 0x0C, 0x06, 0x18, 0x02, 0x10, 0x02,
  0x30, 0x02, 0x20, 0x02, 0x60, 0x02, 0x40, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x03, 0x00, 0x20, 0x06, 0x00,
  0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30,
  0x02, 0x00, 0x60, 0x0F, 0xFC, 0x01, 0xE0, 0x60, 0x18, 0x03, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x38, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x06, 0x03, 0x80, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x18, 0x03, 0x00, 0xC0, 0x78, 0x18, 0x00, 0x7C, 0x0E, 0x7D,
  0xE0, 0x78,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 21, 7, 1, -21 },
  { 17, 8, 7, 10, 3, -21 },
  { 24, 16, 21, 16, 1, -21 },
  { 66, 13, 25, 14, 1, -23 },
  { 107, 18, 22, 21, 2, -22 },
  { 157, 15, 22, 17, 1, -22 },
  { 199, 3, 7, 6, 3, -21 },
  { 202, 9, 26, 8, 1, -21 },
  { 232, 9, 26, 8, -2, -21 },
  { 262, 12, 12, 14, 3, -23 },
  { 280, 12, 14, 15, 2, -18 },
  { 301, 4, 7, 6, -1, -3 },
  { 305, 7, 2, 9, 1, -9 },
  { 307, 2, 3, 6, 1, -3 },
  { 308, 13, 21, 10, -1, -21 },
  { 343, 13, 22, 14, 1, -22 },
  { 379, 8, 21, 14, 4, -21 },
  { 400, 14, 22, 14, 0, -22 },
  { 439, 14, 22, 14, 0, -22 },
  { 478, 14, 22, 14, 0, -22 },
  { 517, 13, 21, 14, 1, -21 },
  { 552, 14, 22, 14, 1, -22 },
  { 591, 13, 21, 14, 2, -21 },
  { 626, 13, 22, 14, 1, -22 },
  { 662, 13, 22, 14, 1, -22 },
  { 698, 5, 16, 6, 1, -16 },
  { 708, 7, 20, 6, -1, -16 },
  { 726, 12, 14, 15, 2, -18 },
  { 747, 12, 7, 15, 2, -14 },
  { 758, 12, 14, 15, 2, -18 },
  { 779, 10, 22, 11, 2, -22 },
  { 807, 20, 24, 22, 1, -21 },
  { 867, 15, 21, 15, -2, -21 },
  { 907, 15, 21, 16, 1, -21 },
  { 947, 15, 22, 15, 2, -22 },
  { 989, 16, 21, 18, 1, -21 },
  { 1031, 14, 21, 14, 1, -21 },
  { 1068, 14, 21, 13, 1, -21 },
  { 1105, 16, 22, 18, 2, -22 },
  { 1149, 17, 21, 18, 1, -21 },
  { 1194, 11, 21, 8, -1, -21 },
  { 1223, 12, 26, 7, -5, -21 },
  { 1262, 16, 21, 15, 1, -21 },
  { 1304, 10, 21, 13, 1, -21 },
  { 1331, 22, 21, 22, 1, -21 },
  { 1389, 18, 21, 18, 1, -21 },
  { 1437, 16, 22, 19, 2, -22 },
  { 1481, 14, 21, 15, 1, -21 },
  { 1518, 16, 27, 19, 2, -22 },
  { 1572, 14, 21, 15, 1, -21 },
  { 1609, 14, 22, 13, 0, -22 },
  { 1648, 12, 21, 13, 3, -21 },
  { 1680, 16, 21, 18, 2, -21 },
  { 1722, 14, 21, 14, 3, -21 },
  { 1759, 22, 21, 23, 3, -21 },
  { 1817, 18, 21, 13, -2, -21 },
  { 1865, 13, 21, 13, 3, -21 },
  { 1900, 16, 21, 14, -1, -21 },
  { 1942, 11, 26, 9, 0, -21 },
  { 1978, 5, 21, 10, 3, -21 },
  { 1992, 11, 26, 9, -2, -21 },
  { 2028, 13, 13, 15, 1, -22 },
  { 2050, 11, 1, 10, -3, 3 },
  { 2052, 4, 5, 7, 4, -23 },
  { 2055, 13, 16, 15, 1, -16 },
  { 2081, 13, 23, 15, 1, -23 },
  { 2119, 11, 16, 12, 1, -16 },
  { 2141, 15, 23, 15, 1, -23 },
  { 2185, 12, 16, 13, 1, -16 },
  { 2209, 16, 30, 8, -4, -23 },
  { 2269, 15, 23, 15, 0, -16 },
  { 2313, 13, 23, 15, 1, -23 },
  { 2351, 6, 22, 6, 1, -22 },
  { 2368, 11, 29, 6, -4, -22 },
  { 2408, 13, 23, 12, 1, -23 },
  { 2446, 6, 23, 6, 1, -23 },
  { 2464, 20, 16, 23, 1, -16 },
  { 2504, 13, 16, 15, 1, -16 },
  { 2530, 13, 16, 15, 1, -16 },
  { 2556, 15, 23, 15, -1, -16 },
  { 2600, 14, 23, 15, 1, -16 },
  { 2641, 10, 16, 10, 1, -16 },
  { 2661, 11, 16, 11, 0, -16 },
  { 2683, 8, 20, 8, 1, -20 },
  { 2703, 13, 16, 15, 1, -16 },
  { 2729, 11, 16, 12, 2, -16 },
  { 2751, 18, 16, 19, 2, -16 },
  { 2787, 14, 16, 12, -1, -16 },
  { 2815, 16, 23, 12, -3, -16 },
  { 2861, 12, 16, 11, -1, -16 },
  { 2885, 11, 26, 10, 1, -21 },
  { 2921, 1, 30, 14, 7, -23 },
  { 2925, 11, 26, 10, -2, -21 },
  { 2961, 13, 3, 15, 2, -12 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC30PT7B_H_
