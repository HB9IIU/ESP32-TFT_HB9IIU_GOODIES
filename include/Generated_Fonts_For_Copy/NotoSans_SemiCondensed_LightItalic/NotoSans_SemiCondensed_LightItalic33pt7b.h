#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC33PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0x83,
  0x06, 0x0C, 0x10, 0x20, 0xC0, 0x00, 0x00, 0x18, 0x30, 0x60, 0x31, 0x98,
  0x88, 0xCC, 0x66, 0x33, 0x11, 0x08, 0x84, 0xC6, 0x00, 0x00, 0xC3, 0x00,
  0x41, 0x80, 0x20, 0x80, 0x30, 0xC0, 0x10, 0x60, 0x08, 0x20, 0x0C, 0x30,
  0x7F, 0xFF, 0x3F, 0xFF, 0x83, 0x04, 0x01, 0x86, 0x00, 0x83, 0x00, 0x41,
  0x00, 0x61, 0x80, 0x20, 0xC1, 0xFF, 0xFC, 0xFF, 0xFE, 0x0C, 0x30, 0x04,
  0x10, 0x06, 0x08, 0x03, 0x0C, 0x01, 0x06, 0x00, 0x82, 0x00, 0xC3, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x1F, 0xF0, 0xE5, 0xC3, 0x98, 0x06,
  0x20, 0x08, 0x40, 0x10, 0x80, 0x31, 0x00, 0x66, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x38, 0x00, 0xF8, 0x01, 0x98, 0x02, 0x30, 0x04, 0x20, 0x08, 0xC0,
  0x31, 0x80, 0x67, 0x18, 0x9C, 0x3F, 0xE0, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x0F, 0x00, 0x61, 0xF8, 0x0C, 0x31, 0x80, 0x83, 0x08,
  0x18, 0x60, 0x83, 0x06, 0x08, 0x20, 0x41, 0x86, 0x04, 0x18, 0xC0, 0xC1,
  0x88, 0x0C, 0x11, 0x80, 0xC3, 0x33, 0xEC, 0x32, 0x66, 0x46, 0x6C, 0x37,
  0xCC, 0xC3, 0x38, 0x88, 0x30, 0x19, 0x83, 0x03, 0x18, 0x20, 0x21, 0x82,
  0x06, 0x10, 0x60, 0xC1, 0x06, 0x08, 0x10, 0x41, 0x81, 0x0C, 0x30, 0x19,
  0x86, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xFC, 0x01, 0x87, 0x00, 0xC1, 0x80,
  0x40, 0xC0, 0x60, 0x60, 0x30, 0x60, 0x18, 0x30, 0x06, 0x30, 0x03, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xD8, 0x01, 0xCC, 0x0D, 0xC3, 0x0C, 0xC1,
  0x86, 0xC0, 0x66, 0x60, 0x3B, 0x30, 0x0F, 0x18, 0x03, 0x0C, 0x03, 0x86,
  0x03, 0x61, 0xCF, 0x30, 0x7E, 0x0C, 0x33, 0x26, 0x66, 0x44, 0xC0, 0x00,
  0xC0, 0x60, 0x30, 0x18, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x30, 0x00,
  0x02, 0x01, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x60,
  0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x00, 0x03, 0x00, 0x30,
  0x02, 0x0C, 0x20, 0xE6, 0x03, 0xC7, 0x07, 0xF0, 0xA0, 0x1A, 0x07, 0x30,
  0xE1, 0x04, 0x18, 0x01, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x19, 0xCC, 0x66, 0x33,
  0x10, 0xFF, 0xFE, 0xDF, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x01,
  0xE0, 0x1F, 0xC0, 0xC1, 0x86, 0x06, 0x18, 0x18, 0xC0, 0x23, 0x00, 0xD8,
  0x03, 0x60, 0x09, 0x80, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x6C,
  0x01, 0xA0, 0x0C, 0x80, 0x32, 0x00, 0xC8, 0x06, 0x20, 0x18, 0xC0, 0xC3,
  0x06, 0x07, 0x38, 0x0F, 0x80, 0x03, 0x07, 0x1E, 0x36, 0xE6, 0xC6, 0x04,
  0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30,
  0x30, 0x20, 0x60, 0x60, 0x60, 0x00, 0xF0, 0x07, 0xF8, 0x38, 0x38, 0x20,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFC,
  0x7F, 0xF8, 0x00, 0xF0, 0x0F, 0xF8, 0x38, 0x38, 0x40, 0x30, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x3F,
  0x00, 0x7E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x90, 0x0E, 0x3C, 0x78, 0x3F, 0xC0, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xB0, 0x03, 0x40, 0x0D, 0x80, 0x33,
  0x00, 0x46, 0x01, 0x8C, 0x06, 0x10, 0x18, 0x60, 0x60, 0xC0, 0xC1, 0x83,
  0x03, 0x0C, 0x04, 0x30, 0x18, 0x40, 0x31, 0xFF, 0xFC, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x07, 0xFE, 0x0F, 0xFC,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0xFF, 0x00, 0xC7, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x07, 0x10,
  0x1C, 0x38, 0xF0, 0x7F, 0x80, 0x00, 0x7C, 0x07, 0xF0, 0x70, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x84, 0x06, 0xFE,
  0x36, 0x1C, 0xE0, 0x33, 0x80, 0xCC, 0x01, 0x30, 0x04, 0xC0, 0x32, 0x00,
  0xC8, 0x03, 0x30, 0x18, 0xC0, 0x63, 0x03, 0x07, 0x38, 0x0F, 0xC0, 0x3F,
  0xFE, 0x7F, 0xFC, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x0F, 0xF0,
  0x38, 0x30, 0x60, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x06, 0x0C,
  0x0C, 0x18, 0x70, 0x1D, 0x80, 0x1E, 0x00, 0xEC, 0x03, 0x0C, 0x1C, 0x0C,
  0x30, 0x18, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x03, 0x1C,
  0x0E, 0x1C, 0x38, 0x1F, 0xC0, 0x01, 0xE0, 0x1F, 0xE0, 0xC1, 0x86, 0x03,
  0x18, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x20, 0x0C, 0x80, 0x33, 0x00,
  0xCC, 0x07, 0x30, 0x3C, 0x7F, 0xA0, 0xF9, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x08, 0x70, 0x3F, 0x80, 0x18,
  0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0xC6, 0x00, 0x03,
  0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x18, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x00, 0x0C, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x03, 0x00, 0x08, 0x00, 0x00, 0x1F, 0x0F, 0xF8, 0x83, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x38, 0x06, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFF, 0x80, 0x1E, 0x07,
  0x00, 0xC0, 0x06, 0x06, 0x00, 0x08, 0x30, 0x00, 0x30, 0x80, 0x00, 0x46,
  0x07, 0xC1, 0x30, 0x73, 0x84, 0xC3, 0x06, 0x12, 0x08, 0x10, 0x58, 0x60,
  0xC1, 0x61, 0x03, 0x05, 0x0C, 0x08, 0x34, 0x30, 0x20, 0xF0, 0xC1, 0x82,
  0xC3, 0x06, 0x1B, 0x0C, 0x38, 0x4C, 0x31, 0xA3, 0x10, 0x7C, 0xF8, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x02,
  0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x34, 0x00, 0x34, 0x00, 0x66, 0x00, 0x66, 0x00, 0xC6, 0x00,
  0xC6, 0x01, 0x86, 0x01, 0x86, 0x03, 0x06, 0x03, 0x06, 0x06, 0x06, 0x07,
  0xFE, 0x0F, 0xFE, 0x0C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x30, 0x03, 0x30,
  0x03, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x03, 0x07, 0xE0, 0x07, 0xFC, 0x0C,
  0x0E, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x18, 0x03, 0x18,
  0x06, 0x18, 0x0E, 0x18, 0x1C, 0x1F, 0xF0, 0x30, 0xF8, 0x30, 0x1C, 0x30,
  0x0C, 0x30, 0x0C, 0x20, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x18, 0xC0, 0x38, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xC1,
  0xE0, 0x41, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xF9, 0xC0, 0x1F, 0xE0, 0x07, 0xE0,
  0x03, 0xFE, 0x03, 0x03, 0x81, 0x80, 0x60, 0xC0, 0x38, 0x60, 0x0C, 0x30,
  0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x62, 0x00, 0x33,
  0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x06, 0x20, 0x03, 0x30, 0x03,
  0x18, 0x03, 0x8C, 0x01, 0x86, 0x03, 0x86, 0x03, 0x83, 0xFF, 0x81, 0xFE,
  0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xC3,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE,
  0x0F, 0xFC, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x43, 0xFF, 0x07, 0xFE,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF0,
  0x78, 0x08, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F,
  0x30, 0x1F, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x06, 0x30, 0x01, 0x8C,
  0x00, 0x61, 0x80, 0x18, 0x60, 0x04, 0x0C, 0x03, 0x03, 0xE3, 0xC0, 0x3F,
  0xE0, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x10, 0x01, 0x86, 0x00, 0x20, 0xC0,
  0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x01, 0x83, 0x00,
  0x30, 0x60, 0x06, 0x0F, 0xFF, 0xC3, 0x00, 0x10, 0x60, 0x06, 0x0C, 0x00,
  0xC1, 0x80, 0x18, 0x20, 0x03, 0x0C, 0x00, 0x41, 0x80, 0x18, 0x30, 0x03,
  0x06, 0x00, 0x60, 0x80, 0x0C, 0x30, 0x03, 0x06, 0x00, 0x60, 0x07, 0xF0,
  0x7F, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x0F, 0xE0, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x1C, 0x0F, 0xC0, 0x7C, 0x00, 0x06,
  0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x03, 0x06,
  0x00, 0xC3, 0x00, 0x61, 0x80, 0x18, 0xC0, 0x06, 0x60, 0x01, 0xB0, 0x00,
  0x5E, 0x00, 0x3D, 0x80, 0x0E, 0x60, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x20,
  0xC0, 0x18, 0x18, 0x06, 0x06, 0x01, 0x81, 0x80, 0x60, 0x30, 0x30, 0x0C,
  0x0C, 0x01, 0x83, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x3F,
  0xFF, 0xFE, 0x07, 0x00, 0x07, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x36, 0x09, 0x00, 0x36, 0x19,
  0x00, 0x64, 0x19, 0x00, 0x6C, 0x19, 0x80, 0xCC, 0x19, 0x80, 0x8C, 0x11,
  0x81, 0x8C, 0x31, 0x81, 0x18, 0x31, 0x83, 0x18, 0x31, 0x86, 0x18, 0x30,
  0x86, 0x18, 0x20, 0x8C, 0x18, 0x60, 0x8C, 0x30, 0x60, 0xD8, 0x30, 0x60,
  0xD8, 0x30, 0x40, 0xF0, 0x30, 0xC0, 0xF0, 0x20, 0xC0, 0xE0, 0x60, 0xC0,
  0xC0, 0x60, 0x06, 0x00, 0x30, 0x60, 0x02, 0x0F, 0x00, 0x60, 0xF0, 0x06,
  0x0F, 0x00, 0x60, 0xD8, 0x04, 0x09, 0x80, 0xC1, 0x98, 0x0C, 0x18, 0xC0,
  0xC1, 0x8C, 0x0C, 0x18, 0xC0, 0x81, 0x04, 0x18, 0x30, 0x61, 0x83, 0x06,
  0x18, 0x30, 0x21, 0x83, 0x03, 0x10, 0x20, 0x33, 0x06, 0x01, 0x30, 0x60,
  0x1B, 0x06, 0x01, 0xB0, 0x40, 0x1A, 0x0C, 0x00, 0xE0, 0xC0, 0x0E, 0x0C,
  0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x70, 0x70, 0x30, 0x06, 0x18,
  0x01, 0x86, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x03, 0x60, 0x00, 0xD8, 0x00,
  0x36, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B,
  0x00, 0x06, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x63, 0x80, 0x18, 0x60,
  0x0C, 0x1C, 0x06, 0x03, 0xCF, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x07, 0xF8,
  0x0C, 0x1E, 0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x03, 0x0C, 0x03, 0x18, 0x06,
  0x18, 0x06, 0x18, 0x06, 0x18, 0x0C, 0x10, 0x1C, 0x30, 0x78, 0x3F, 0xE0,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0xFF,
  0x80, 0x70, 0x70, 0x30, 0x06, 0x18, 0x01, 0x86, 0x00, 0x63, 0x00, 0x0C,
  0xC0, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03, 0x30, 0x00,
  0xCC, 0x00, 0x63, 0x80, 0x18, 0x60, 0x0C, 0x1C, 0x06, 0x03, 0xCF, 0x00,
  0x7F, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x0C, 0x1E, 0x0C, 0x06,
  0x0C, 0x06, 0x0C, 0x03, 0x0C, 0x03, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06,
  0x18, 0x0C, 0x10, 0x18, 0x3F, 0xF0, 0x3F, 0xC0, 0x30, 0xC0, 0x30, 0xC0,
  0x20, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x30, 0x60, 0x30, 0xC0, 0x30,
  0xC0, 0x38, 0xC0, 0x18, 0x00, 0xF8, 0x07, 0xFC, 0x18, 0x08, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x10, 0x0E, 0x3C, 0xF8, 0x3F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xC6, 0x00, 0x31,
  0x80, 0x0C, 0x60, 0x02, 0x18, 0x01, 0x86, 0x00, 0x63, 0x00, 0x18, 0xC0,
  0x06, 0x30, 0x01, 0x0C, 0x00, 0xC2, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03,
  0x18, 0x01, 0x86, 0x00, 0x61, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x0C,
  0x00, 0xC3, 0x00, 0x30, 0xC0, 0x18, 0x18, 0x0E, 0x07, 0x8F, 0x00, 0x7F,
  0x00, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x18, 0x40, 0x18, 0x40, 0x30, 0x40, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60,
  0xC0, 0x60, 0xC0, 0x61, 0x80, 0x61, 0x80, 0x63, 0x00, 0x63, 0x00, 0x66,
  0x00, 0x66, 0x00, 0x2C, 0x00, 0x2C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30,
  0x00, 0xC0, 0x08, 0x01, 0xE0, 0x0C, 0x01, 0x90, 0x07, 0x00, 0xC8, 0x07,
  0x80, 0xC4, 0x03, 0xC0, 0x62, 0x03, 0x60, 0x21, 0x01, 0xB0, 0x30, 0x80,
  0x98, 0x18, 0x40, 0xCC, 0x18, 0x20, 0x46, 0x0C, 0x10, 0x63, 0x0C, 0x08,
  0x31, 0x86, 0x04, 0x30, 0xC2, 0x02, 0x18, 0x63, 0x01, 0x98, 0x31, 0x80,
  0xCC, 0x19, 0x80, 0x64, 0x0C, 0xC0, 0x36, 0x06, 0xC0, 0x1A, 0x03, 0x60,
  0x0F, 0x01, 0xA0, 0x07, 0x80, 0xF0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38,
  0x00, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0x60, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0x80, 0xC0, 0x18, 0x30, 0x03, 0x06, 0x00, 0x21, 0x80, 0x06, 0x60, 0x00,
  0xD8, 0x00, 0x1B, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x6C, 0x00, 0x19, 0x80, 0x06, 0x10, 0x00, 0xC3, 0x00, 0x30,
  0x60, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x18, 0x03, 0x07, 0x00,
  0x30, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0x90, 0x0C, 0x60, 0x31, 0x81, 0x86,
  0x0C, 0x18, 0x30, 0x31, 0x80, 0xC4, 0x03, 0x30, 0x0D, 0x80, 0x16, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xE0,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x07, 0xFF, 0x83, 0xFF,
  0xE0, 0x03, 0xF0, 0x7F, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFC, 0x00, 0xC1, 0x04, 0x18,
  0x61, 0x86, 0x18, 0x20, 0x83, 0x0C, 0x30, 0xC1, 0x04, 0x18, 0x61, 0x86,
  0x18, 0x20, 0x83, 0x03, 0xF0, 0x7F, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0xFC, 0x00, 0x00,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x1B, 0x00, 0x26, 0x00, 0xC4, 0x03, 0x0C,
  0x06, 0x18, 0x18, 0x10, 0x30, 0x30, 0xC0, 0x21, 0x00, 0x66, 0x00, 0xD8,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xC6, 0x62, 0x10, 0x03, 0xC6, 0x0F, 0xCC,
  0x30, 0x50, 0xC0, 0xE3, 0x00, 0xC6, 0x01, 0x98, 0x03, 0x30, 0x0C, 0x60,
  0x18, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x03, 0x18, 0x06, 0x10, 0x1C,
  0x30, 0x58, 0x73, 0xA0, 0x7C, 0x40, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x3C, 0x1B, 0xF8, 0x78, 0x71,
  0x40, 0xC6, 0x03, 0x38, 0x04, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x60, 0x0D,
  0x80, 0x36, 0x00, 0x98, 0x06, 0x60, 0x1B, 0x80, 0xCF, 0x06, 0x36, 0x38,
  0x8F, 0x80, 0x01, 0xF8, 0x3F, 0x83, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x38, 0xC0, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x07,
  0x8C, 0x07, 0xF6, 0x06, 0x0B, 0x06, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC3,
  0x00, 0x61, 0x80, 0x30, 0xC0, 0x10, 0x60, 0x18, 0x60, 0x0C, 0x30, 0x06,
  0x18, 0x07, 0x0C, 0x03, 0x02, 0x03, 0x81, 0x83, 0xC0, 0xE7, 0x60, 0x3E,
  0x20, 0x00, 0x01, 0xE0, 0x3F, 0x83, 0x06, 0x30, 0x33, 0x01, 0x98, 0x0D,
  0x80, 0xCC, 0x1C, 0x7F, 0xC3, 0xF0, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x0C, 0x00, 0x38, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x0E,
  0x80, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xF8, 0x03, 0xFC, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE1, 0x03, 0xFB, 0x06,
  0x0B, 0x0C, 0x06, 0x18, 0x06, 0x18, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30,
  0x04, 0x30, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0x20,
  0x38, 0x30, 0x78, 0x39, 0xD8, 0x1F, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x80, 0xC0, 0xFF, 0x80, 0x3F, 0x00, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x3C, 0x1B, 0xF8, 0x78, 0x31, 0x40, 0xC6, 0x03, 0x38, 0x0C, 0xC0, 0x33,
  0x00, 0x8C, 0x06, 0x60, 0x19, 0x80, 0x66, 0x01, 0x98, 0x04, 0x40, 0x33,
  0x00, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x60, 0x04, 0x1C, 0x30, 0x00, 0x00,
  0x06, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x82,
  0x0C, 0x18, 0x30, 0x60, 0x00, 0x30, 0x07, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0xF0, 0x0E, 0x00, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x03, 0x18, 0x18, 0x60, 0xC1, 0x86, 0x04,
  0x30, 0x31, 0x80, 0xCC, 0x03, 0x60, 0x0B, 0x80, 0x7B, 0x01, 0xCC, 0x06,
  0x30, 0x18, 0x60, 0x41, 0x83, 0x03, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0x60,
  0x06, 0x08, 0x30, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x60, 0x83, 0x06,
  0x0C, 0x10, 0x60, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x60, 0xC0, 0x18, 0xF0,
  0x70, 0x6F, 0xE7, 0xF1, 0xE1, 0xB0, 0xC5, 0x07, 0x83, 0x18, 0x1C, 0x04,
  0xE0, 0x70, 0x33, 0x01, 0x80, 0xCC, 0x06, 0x03, 0x30, 0x18, 0x0D, 0x80,
  0x40, 0x26, 0x03, 0x01, 0x98, 0x0C, 0x06, 0x60, 0x30, 0x19, 0x00, 0xC0,
  0x6C, 0x06, 0x01, 0x30, 0x18, 0x0C, 0xC0, 0x60, 0x33, 0x01, 0x80, 0xC0,
  0x18, 0xF0, 0x6F, 0xE1, 0xE1, 0xC5, 0x03, 0x38, 0x0C, 0xE0, 0x33, 0x00,
  0xCC, 0x02, 0x30, 0x19, 0x80, 0x66, 0x01, 0x98, 0x06, 0x60, 0x31, 0x00,
  0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x01, 0x80, 0x01, 0xE0, 0x1F, 0xC0,
  0xC1, 0x86, 0x03, 0x30, 0x0C, 0xC0, 0x36, 0x00, 0xD8, 0x03, 0x60, 0x0D,
  0x00, 0x3C, 0x00, 0xF0, 0x06, 0xC0, 0x1B, 0x00, 0xC6, 0x03, 0x18, 0x18,
  0x39, 0xC0, 0x7E, 0x00, 0x06, 0x3C, 0x06, 0x7E, 0x07, 0x87, 0x05, 0x03,
  0x06, 0x03, 0x0E, 0x01, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x18, 0x03,
  0x18, 0x03, 0x18, 0x02, 0x18, 0x06, 0x18, 0x06, 0x38, 0x0C, 0x3C, 0x18,
  0x36, 0x38, 0x33, 0xE0, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xC2, 0x0F, 0xEC,
  0x30, 0x58, 0xC0, 0xE3, 0x00, 0xC6, 0x01, 0x98, 0x03, 0x30, 0x06, 0x60,
  0x08, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x03, 0x98, 0x06, 0x10, 0x1C,
  0x30, 0x78, 0x73, 0xB0, 0x7C, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x18, 0xE3, 0x7C,
  0x78, 0x0A, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x07, 0xC0,
  0xFF, 0x18, 0x13, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC8, 0x0C, 0xE3, 0x8F,
  0xF0, 0x04, 0x06, 0x03, 0x01, 0x01, 0xFB, 0xFC, 0x60, 0x30, 0x30, 0x18,
  0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x06,
  0x43, 0xE0, 0x18, 0x06, 0x30, 0x08, 0x60, 0x30, 0x80, 0x63, 0x00, 0xC6,
  0x01, 0x8C, 0x02, 0x18, 0x0C, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x01,
  0x84, 0x03, 0x18, 0x0E, 0x30, 0x1C, 0x30, 0x58, 0x73, 0x20, 0x7C, 0xC0,
  0xC0, 0x3C, 0x03, 0xC0, 0x6C, 0x06, 0xC0, 0xCC, 0x0C, 0xC1, 0x8C, 0x18,
  0xC3, 0x04, 0x30, 0x46, 0x04, 0x60, 0x6C, 0x06, 0xC0, 0x78, 0x07, 0x80,
  0x70, 0x07, 0x00, 0xC0, 0x60, 0x3C, 0x0E, 0x06, 0xC0, 0xE0, 0x6C, 0x1E,
  0x0C, 0xC1, 0xE0, 0xCC, 0x16, 0x08, 0xC3, 0x61, 0x8C, 0x26, 0x18, 0xC6,
  0x23, 0x0C, 0x42, 0x30, 0xCC, 0x26, 0x0C, 0x82, 0x60, 0xD8, 0x24, 0x0D,
  0x82, 0xC0, 0xF0, 0x28, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00,
  0x0C, 0x06, 0x18, 0x0C, 0x30, 0x30, 0x30, 0xC0, 0x63, 0x00, 0xC6, 0x00,
  0xD8, 0x01, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x36, 0x00, 0xCC,
  0x03, 0x08, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x31, 0x80, 0x60, 0x06, 0x00,
  0xC1, 0x80, 0x60, 0x60, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80,
  0x20, 0x60, 0x08, 0x30, 0x02, 0x0C, 0x00, 0xC6, 0x00, 0x31, 0x00, 0x0C,
  0xC0, 0x03, 0x20, 0x00, 0xD8, 0x00, 0x34, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFC, 0x3F,
  0xE0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x30, 0x1F, 0x03, 0x80, 0x30, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08,
  0x03, 0x80, 0xF0, 0x0F, 0x00, 0x30, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x80, 0x1C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00,
  0x3C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x70, 0x0F, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x07, 0x80, 0xF0, 0x00, 0x7E, 0x07, 0x1F, 0x78, 0x0F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 24, 8, 1, -24 },
  { 22, 9, 9, 11, 3, -24 },
  { 33, 17, 24, 18, 1, -24 },
  { 84, 15, 27, 16, 1, -25 },
  { 135, 20, 24, 23, 2, -24 },
  { 195, 17, 24, 19, 1, -24 },
  { 246, 4, 9, 6, 3, -24 },
  { 251, 10, 29, 9, 1, -24 },
  { 288, 9, 29, 9, -2, -24 },
  { 321, 12, 13, 15, 4, -25 },
  { 341, 14, 15, 17, 2, -19 },
  { 368, 5, 8, 7, -1, -4 },
  { 373, 8, 2, 10, 1, -10 },
  { 375, 3, 3, 7, 1, -3 },
  { 377, 14, 24, 11, -1, -24 },
  { 419, 14, 24, 16, 2, -24 },
  { 461, 8, 24, 16, 5, -24 },
  { 485, 15, 24, 16, 0, -24 },
  { 530, 15, 24, 16, 0, -24 },
  { 575, 15, 24, 16, 0, -24 },
  { 620, 15, 24, 16, 1, -24 },
  { 665, 14, 24, 16, 2, -24 },
  { 707, 15, 24, 16, 2, -24 },
  { 752, 15, 24, 16, 1, -24 },
  { 797, 14, 24, 16, 1, -24 },
  { 839, 5, 18, 7, 1, -18 },
  { 851, 8, 22, 7, -2, -18 },
  { 873, 14, 15, 17, 2, -19 },
  { 900, 14, 9, 17, 2, -16 },
  { 916, 14, 15, 17, 2, -19 },
  { 943, 11, 24, 12, 2, -24 },
  { 976, 22, 27, 24, 1, -24 },
  { 1051, 16, 24, 16, -2, -24 },
  { 1099, 16, 24, 17, 1, -24 },
  { 1147, 17, 24, 17, 2, -24 },
  { 1198, 17, 24, 19, 1, -24 },
  { 1249, 15, 24, 15, 1, -24 },
  { 1294, 15, 24, 14, 1, -24 },
  { 1339, 18, 24, 20, 2, -24 },
  { 1393, 19, 24, 20, 1, -24 },
  { 1450, 12, 24, 9, -1, -24 },
  { 1486, 13, 30, 7, -5, -24 },
  { 1535, 18, 24, 16, 1, -24 },
  { 1589, 11, 24, 14, 1, -24 },
  { 1622, 24, 24, 25, 1, -24 },
  { 1694, 20, 24, 20, 1, -24 },
  { 1754, 18, 24, 21, 2, -24 },
  { 1808, 16, 24, 16, 1, -24 },
  { 1856, 18, 30, 21, 2, -24 },
  { 1924, 16, 24, 17, 1, -24 },
  { 1972, 15, 24, 15, 0, -24 },
  { 2017, 14, 24, 14, 3, -24 },
  { 2059, 18, 24, 20, 2, -24 },
  { 2113, 16, 24, 16, 3, -24 },
  { 2161, 25, 24, 25, 3, -24 },
  { 2236, 19, 24, 15, -2, -24 },
  { 2293, 14, 24, 14, 3, -24 },
  { 2335, 18, 24, 15, -1, -24 },
  { 2389, 12, 29, 10, 0, -24 },
  { 2433, 6, 24, 11, 3, -24 },
  { 2451, 12, 29, 10, -2, -24 },
  { 2495, 15, 14, 17, 1, -24 },
  { 2522, 12, 2, 11, -3, 3 },
  { 2525, 4, 5, 8, 5, -25 },
  { 2528, 15, 18, 17, 1, -18 },
  { 2562, 14, 25, 17, 1, -25 },
  { 2606, 13, 18, 13, 1, -18 },
  { 2636, 17, 25, 17, 1, -25 },
  { 2690, 13, 18, 15, 1, -18 },
  { 2720, 17, 33, 9, -4, -25 },
  { 2791, 16, 26, 17, 0, -18 },
  { 2843, 14, 25, 16, 1, -25 },
  { 2887, 7, 24, 7, 1, -24 },
  { 2908, 12, 32, 7, -4, -24 },
  { 2956, 14, 25, 14, 1, -25 },
  { 3000, 7, 25, 7, 1, -25 },
  { 3022, 22, 18, 25, 1, -18 },
  { 3072, 14, 18, 16, 1, -18 },
  { 3104, 14, 18, 16, 1, -18 },
  { 3136, 16, 26, 17, -1, -18 },
  { 3188, 15, 26, 17, 1, -18 },
  { 3237, 11, 18, 11, 1, -18 },
  { 3262, 12, 18, 13, 0, -18 },
  { 3289, 9, 22, 9, 1, -22 },
  { 3314, 15, 18, 17, 1, -18 },
  { 3348, 12, 18, 13, 2, -18 },
  { 3375, 20, 18, 20, 2, -18 },
  { 3420, 15, 18, 14, -1, -18 },
  { 3454, 18, 26, 13, -3, -18 },
  { 3513, 14, 18, 12, -1, -18 },
  { 3545, 12, 29, 11, 1, -24 },
  { 3589, 2, 33, 16, 7, -25 },
  { 3598, 12, 29, 11, -2, -24 },
  { 3642, 14, 3, 17, 2, -13 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC33PT7B_H_
