#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC15PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x12, 0x22, 0x24, 0x44, 0x00, 0xC0, 0xB6, 0xD0, 0x09, 0x0A, 0x12,
  0x7F, 0x12, 0x24, 0x24, 0xFE, 0x28, 0x48, 0x48, 0x08, 0x3C, 0xA1, 0x42,
  0x83, 0x05, 0x0A, 0x15, 0xF0, 0x81, 0x00, 0x31, 0x28, 0xA4, 0x92, 0x89,
  0x55, 0x55, 0xD2, 0x29, 0x24, 0xA2, 0x91, 0xC0, 0x0C, 0x12, 0x22, 0x24,
  0x18, 0x30, 0x49, 0x4A, 0x86, 0x86, 0x7A, 0xF0, 0x08, 0x88, 0x44, 0x21,
  0x10, 0x84, 0x20, 0x84, 0x00, 0x11, 0x11, 0x11, 0x11, 0x12, 0x24, 0xC0,
  0x25, 0x1E, 0xC9, 0x00, 0x10, 0x41, 0x3F, 0x10, 0x41, 0x00, 0x29, 0x40,
  0xF0, 0xC0, 0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x83, 0x00,
  0x19, 0x94, 0x61, 0x86, 0x18, 0x62, 0x8A, 0x4F, 0x00, 0x17, 0xA2, 0x22,
  0x24, 0x44, 0x40, 0x1C, 0x44, 0x08, 0x10, 0x40, 0x82, 0x08, 0x20, 0x83,
  0xF0, 0x1C, 0x44, 0x08, 0x10, 0x47, 0x01, 0x02, 0x04, 0x0B, 0xE0, 0x02,
  0x0C, 0x28, 0xA1, 0x44, 0x91, 0x42, 0x7A, 0x10, 0x20, 0x1E, 0x40, 0x81,
  0x03, 0x09, 0x81, 0x02, 0x04, 0x0B, 0xE0, 0x1C, 0x84, 0x10, 0xB3, 0x28,
  0x61, 0x8A, 0x27, 0x00, 0x7E, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x40,
  0x82, 0x00, 0x1C, 0x44, 0x89, 0x12, 0x43, 0x19, 0x22, 0x85, 0x09, 0xE0,
  0x1C, 0x45, 0x0A, 0x14, 0x28, 0xCE, 0x82, 0x04, 0x13, 0xC0, 0x20, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x24, 0x48, 0x04, 0x66, 0x20, 0x60, 0x60, 0x40,
  0xFC, 0x00, 0x3F, 0x81, 0x81, 0x81, 0x19, 0x88, 0x00, 0xF0, 0x42, 0x11,
  0x11, 0x10, 0x00, 0x20, 0x0F, 0x0C, 0x24, 0x09, 0x39, 0x92, 0x68, 0x9A,
  0x2A, 0x92, 0xAF, 0x24, 0x08, 0x01, 0xF0, 0x06, 0x0C, 0x28, 0x51, 0x22,
  0x4F, 0x91, 0x42, 0x86, 0x08, 0x1C, 0x23, 0x21, 0x21, 0x22, 0x3C, 0x42,
  0x42, 0x42, 0x44, 0xF8, 0x1E, 0x41, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x01, 0xE0, 0x1C, 0x23, 0x21, 0x21, 0x21, 0x21, 0x41, 0x41, 0x42, 0x44,
  0xF8, 0x1E, 0x40, 0x81, 0x02, 0x07, 0x90, 0x20, 0x40, 0x83, 0xE0, 0x1E,
  0x40, 0x81, 0x02, 0x07, 0x90, 0x20, 0x40, 0x82, 0x00, 0x1E, 0x21, 0x40,
  0x40, 0x80, 0x8C, 0x82, 0x82, 0x82, 0x82, 0x7C, 0x10, 0x90, 0x48, 0x24,
  0x22, 0x11, 0xF9, 0x04, 0x82, 0x42, 0x21, 0x20, 0x80, 0x38, 0x88, 0x42,
  0x10, 0x88, 0x42, 0x38, 0x04, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x42,
  0x08, 0x23, 0x00, 0x11, 0x91, 0x09, 0x84, 0x82, 0x81, 0x81, 0x20, 0x90,
  0x44, 0x22, 0x21, 0x00, 0x11, 0x08, 0x42, 0x11, 0x08, 0x42, 0x3E, 0x10,
  0x26, 0x0C, 0xC1, 0x98, 0x53, 0x0C, 0x92, 0x92, 0x52, 0x52, 0x4A, 0x49,
  0x92, 0x22, 0x00, 0x10, 0x98, 0x4C, 0x25, 0x12, 0x8A, 0x49, 0x14, 0x8A,
  0x45, 0x21, 0x20, 0x80, 0x1C, 0x22, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82,
  0x82, 0x84, 0x78, 0x1C, 0x22, 0x21, 0x21, 0x22, 0x26, 0x78, 0x40, 0x40,
  0x40, 0x80, 0x1C, 0x22, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84,
  0x78, 0x10, 0x08, 0x04, 0x1C, 0x22, 0x21, 0x21, 0x22, 0x24, 0x58, 0x48,
  0x44, 0x44, 0x84, 0x1E, 0x41, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x0B,
  0xE0, 0xFE, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x00, 0x41,
  0x41, 0x41, 0x41, 0x42, 0x82, 0x82, 0x82, 0x84, 0x84, 0x78, 0x83, 0x06,
  0x12, 0x24, 0x89, 0x14, 0x28, 0x60, 0xC1, 0x00, 0x84, 0x31, 0x8A, 0x31,
  0x4A, 0x49, 0x49, 0x4A, 0x29, 0x46, 0x28, 0xC6, 0x10, 0xC2, 0x10, 0x00,
  0x10, 0x88, 0x84, 0x81, 0x40, 0xC0, 0x40, 0x50, 0x28, 0x24, 0x22, 0x20,
  0x80, 0x82, 0x89, 0x22, 0x45, 0x0A, 0x08, 0x10, 0x40, 0x81, 0x00, 0x3F,
  0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0xFC, 0x19, 0x08,
  0x42, 0x21, 0x08, 0x42, 0x21, 0x0E, 0x00, 0xAA, 0xA9, 0x54, 0x1C, 0x20,
  0x82, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08, 0xE0, 0x10, 0xC2, 0x92, 0x4A,
  0x10, 0xF8, 0xD0, 0x3D, 0x18, 0x61, 0x8A, 0x29, 0xBA, 0x30, 0x40, 0x81,
  0xE2, 0x2C, 0x50, 0xA1, 0x44, 0x8A, 0xE0, 0x3A, 0x21, 0x08, 0x42, 0x1E,
  0x02, 0x04, 0x11, 0xE4, 0x50, 0xA1, 0x44, 0x89, 0x33, 0xA0, 0x3A, 0x63,
  0xE8, 0x42, 0x1E, 0x07, 0x08, 0x08, 0x1C, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0xC0, 0x1E, 0x45, 0x0A, 0x14, 0x48, 0x93,
  0x3A, 0x04, 0x12, 0x63, 0x00, 0x30, 0x40, 0x81, 0xE2, 0x28, 0x50, 0xA2,
  0x44, 0x8A, 0x10, 0x20, 0x12, 0x92, 0x4A, 0x00, 0x08, 0x00, 0x10, 0x88,
  0x42, 0x10, 0x88, 0x42, 0x13, 0x00, 0x30, 0x40, 0x81, 0x32, 0x8A, 0x14,
  0x38, 0x48, 0x92, 0x20, 0x32, 0x22, 0x24, 0x44, 0x44, 0x80, 0x3D, 0xC4,
  0x45, 0x08, 0xA2, 0x24, 0x44, 0x88, 0x91, 0x14, 0x42, 0x3C, 0x45, 0x0A,
  0x14, 0x48, 0x91, 0x42, 0x39, 0x18, 0x61, 0x86, 0x28, 0xBC, 0x3C, 0x45,
  0x8A, 0x14, 0x28, 0x91, 0x5C, 0x81, 0x02, 0x04, 0x00, 0x3D, 0x18, 0x61,
  0x8A, 0x29, 0xBA, 0x08, 0x41, 0x04, 0x3C, 0x84, 0x10, 0x41, 0x04, 0x20,
  0x3D, 0x04, 0x08, 0x10, 0x20, 0xBC, 0x44, 0xF4, 0x88, 0x88, 0x8C, 0x45,
  0x18, 0x62, 0x8A, 0x29, 0xBA, 0x8E, 0x29, 0x24, 0xA2, 0x8C, 0x30, 0x88,
  0xCC, 0xA6, 0x55, 0x4A, 0xA6, 0x53, 0x31, 0x18, 0x23, 0x14, 0x14, 0x18,
  0x18, 0x28, 0x24, 0xC4, 0x11, 0x88, 0x84, 0x82, 0x41, 0x40, 0xA0, 0x60,
  0x10, 0x10, 0x08, 0x08, 0x18, 0x00, 0x7C, 0x21, 0x04, 0x21, 0x08, 0x3C,
  0x0C, 0x41, 0x04, 0x20, 0x8C, 0x10, 0x21, 0x04, 0x10, 0x60, 0xFF, 0xFE,
  0x10, 0x20, 0x82, 0x08, 0x40, 0xC4, 0x10, 0x42, 0x08, 0xE0, 0xF4, 0x20,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 3, 0, -11 },
  { 7, 3, 4, 5, 2, -11 },
  { 9, 8, 11, 8, 0, -11 },
  { 20, 7, 12, 7, 0, -11 },
  { 31, 9, 11, 11, 1, -11 },
  { 44, 8, 11, 9, 0, -11 },
  { 55, 1, 4, 3, 2, -11 },
  { 56, 5, 13, 4, 0, -11 },
  { 65, 4, 13, 4, -1, -11 },
  { 72, 5, 5, 7, 2, -11 },
  { 76, 6, 7, 8, 1, -9 },
  { 82, 3, 4, 3, -1, -2 },
  { 84, 4, 1, 4, 0, -5 },
  { 85, 2, 1, 3, 0, -1 },
  { 86, 7, 11, 5, -1, -11 },
  { 96, 6, 11, 7, 1, -11 },
  { 105, 4, 11, 7, 2, -11 },
  { 111, 7, 11, 7, 0, -11 },
  { 121, 7, 11, 7, 0, -11 },
  { 131, 7, 11, 7, 0, -11 },
  { 141, 7, 11, 7, 0, -11 },
  { 151, 6, 11, 7, 1, -11 },
  { 160, 7, 11, 7, 1, -11 },
  { 170, 7, 11, 7, 0, -11 },
  { 180, 7, 11, 7, 0, -11 },
  { 190, 3, 8, 3, 0, -8 },
  { 193, 4, 10, 3, -1, -8 },
  { 198, 6, 7, 8, 1, -9 },
  { 204, 6, 4, 8, 1, -7 },
  { 207, 6, 7, 8, 1, -9 },
  { 213, 5, 11, 5, 1, -11 },
  { 220, 10, 12, 11, 1, -11 },
  { 235, 7, 11, 7, -1, -11 },
  { 245, 8, 11, 8, 0, -11 },
  { 256, 7, 11, 8, 1, -11 },
  { 266, 8, 11, 9, 0, -11 },
  { 277, 7, 11, 7, 0, -11 },
  { 287, 7, 11, 6, 0, -11 },
  { 297, 8, 11, 9, 1, -11 },
  { 308, 9, 11, 9, 0, -11 },
  { 321, 5, 11, 4, 0, -11 },
  { 328, 6, 14, 3, -2, -11 },
  { 339, 9, 11, 7, 0, -11 },
  { 352, 5, 11, 6, 0, -11 },
  { 359, 11, 11, 11, 0, -11 },
  { 375, 9, 11, 9, 0, -11 },
  { 388, 8, 11, 9, 1, -11 },
  { 399, 8, 11, 7, 0, -11 },
  { 410, 8, 14, 9, 1, -11 },
  { 424, 8, 11, 8, 0, -11 },
  { 435, 7, 11, 7, 0, -11 },
  { 445, 7, 11, 6, 1, -11 },
  { 455, 8, 11, 9, 1, -11 },
  { 466, 7, 11, 7, 1, -11 },
  { 476, 11, 11, 11, 2, -11 },
  { 492, 9, 11, 7, -1, -11 },
  { 505, 7, 11, 7, 1, -11 },
  { 515, 8, 11, 7, 0, -11 },
  { 526, 5, 13, 4, 0, -11 },
  { 535, 2, 11, 5, 2, -11 },
  { 538, 6, 13, 4, -1, -11 },
  { 548, 6, 6, 8, 1, -11 },
  { 553, 5, 1, 5, -1, 1 },
  { 554, 2, 2, 4, 2, -11 },
  { 555, 6, 8, 8, 1, -8 },
  { 561, 7, 11, 8, 0, -11 },
  { 571, 5, 8, 6, 1, -8 },
  { 576, 7, 11, 8, 1, -11 },
  { 586, 5, 8, 7, 1, -8 },
  { 591, 8, 15, 4, -2, -11 },
  { 606, 7, 12, 8, 0, -8 },
  { 617, 7, 11, 7, 0, -11 },
  { 627, 3, 11, 3, 0, -11 },
  { 632, 5, 15, 3, -2, -11 },
  { 642, 7, 11, 6, 0, -11 },
  { 652, 4, 11, 3, 0, -11 },
  { 658, 11, 8, 11, 0, -8 },
  { 669, 7, 8, 7, 0, -8 },
  { 676, 6, 8, 7, 1, -8 },
  { 682, 7, 12, 8, 0, -8 },
  { 693, 6, 12, 8, 1, -8 },
  { 702, 6, 8, 5, 0, -8 },
  { 708, 6, 8, 6, 0, -8 },
  { 714, 4, 10, 4, 1, -10 },
  { 719, 6, 8, 8, 1, -8 },
  { 725, 6, 8, 6, 1, -8 },
  { 731, 9, 8, 9, 1, -8 },
  { 740, 8, 8, 6, -1, -8 },
  { 748, 9, 12, 6, -2, -8 },
  { 762, 6, 8, 6, 0, -8 },
  { 768, 6, 13, 5, 0, -11 },
  { 778, 1, 15, 7, 3, -11 },
  { 780, 6, 13, 5, -1, -11 },
  { 790, 6, 2, 8, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC15PT7B_H_
