#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC22PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x46, 0x31, 0x08, 0x46, 0x21, 0x08, 0x40, 0x01, 0x18, 0x6D,
  0x34, 0x92, 0x4A, 0x20, 0x02, 0x20, 0x22, 0x04, 0x20, 0x44, 0x04, 0x43,
  0xFF, 0x08, 0x80, 0x88, 0x08, 0x81, 0x10, 0x7F, 0xE9, 0x10, 0x21, 0x02,
  0x20, 0x22, 0x06, 0x20, 0x02, 0x01, 0x03, 0xC6, 0x92, 0x43, 0x21, 0x90,
  0x50, 0x18, 0x07, 0x02, 0x81, 0x21, 0x10, 0x9A, 0x59, 0xF8, 0x10, 0x10,
  0x00, 0x38, 0x34, 0x82, 0xCC, 0x48, 0x8C, 0x88, 0x88, 0x90, 0x89, 0x29,
  0xAD, 0x94, 0x9E, 0x51, 0x09, 0x11, 0x11, 0x11, 0x12, 0x31, 0x41, 0x2C,
  0x1C, 0x07, 0x80, 0xCC, 0x08, 0x40, 0x84, 0x08, 0x80, 0x98, 0x0B, 0x00,
  0xC0, 0x1E, 0x02, 0x23, 0x43, 0x24, 0x16, 0xC1, 0xC4, 0x08, 0x43, 0x43,
  0xE6, 0x69, 0x25, 0x00, 0x04, 0x21, 0x04, 0x21, 0x84, 0x10, 0xC2, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x04, 0x00, 0x04, 0x08, 0x10, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x18, 0x20, 0x41, 0x82, 0x0C, 0x10, 0x43, 0x80,
  0x04, 0x02, 0x12, 0x1D, 0x01, 0xF8, 0xC0, 0x90, 0x88, 0x02, 0x00, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x3F, 0xF0, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x32, 0x44, 0x80, 0xFF, 0xC0, 0x70, 0x00, 0x40, 0x20, 0x18, 0x04, 0x03,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04,
  0x03, 0x00, 0x0F, 0x0C, 0xCC, 0x24, 0x16, 0x0A, 0x05, 0x03, 0x81, 0xC0,
  0xC0, 0xE0, 0x50, 0x28, 0x34, 0x11, 0x10, 0xF0, 0x08, 0xDB, 0x91, 0x88,
  0x42, 0x11, 0x88, 0x42, 0x31, 0x08, 0x07, 0x86, 0x30, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x03, 0xFC, 0x07, 0x86, 0x30, 0x04, 0x01, 0x00, 0x40, 0x30, 0x18, 0x7C,
  0x03, 0x00, 0x60, 0x08, 0x02, 0x00, 0x80, 0x48, 0x33, 0xF8, 0x00, 0x40,
  0x30, 0x14, 0x0B, 0x06, 0x81, 0x20, 0x88, 0x46, 0x31, 0x08, 0x44, 0x13,
  0xFF, 0x03, 0x00, 0x80, 0x20, 0x08, 0x0F, 0xE1, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0xF8, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x03, 0x20, 0xC7, 0xF0, 0x03, 0xC3, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04,
  0xE1, 0xCC, 0xC1, 0x30, 0x68, 0x1A, 0x04, 0x81, 0x30, 0xC4, 0x21, 0xF0,
  0x7F, 0xC0, 0x40, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x08, 0x04,
  0x04, 0x02, 0x02, 0x03, 0x01, 0x00, 0x0F, 0x04, 0x62, 0x08, 0x83, 0x20,
  0x88, 0x21, 0x30, 0x30, 0x36, 0x10, 0xC8, 0x12, 0x04, 0x81, 0x20, 0x4C,
  0x21, 0xF0, 0x0E, 0x08, 0x88, 0x2C, 0x14, 0x0A, 0x05, 0x02, 0x83, 0x62,
  0x9E, 0x80, 0x40, 0x60, 0x20, 0x30, 0x31, 0xE0, 0x13, 0x00, 0x00, 0x00,
  0x00, 0x4C, 0x08, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x08, 0xC4, 0x22, 0x00,
  0x00, 0x40, 0x60, 0x60, 0x60, 0x60, 0x30, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x30, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x70, 0x70, 0x70, 0x70, 0x30, 0x00, 0x3C, 0x66,
  0x03, 0x03, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x00, 0x00,
  0xC0, 0xC0, 0x01, 0xE0, 0x0C, 0x30, 0x20, 0x30, 0x80, 0x22, 0x00, 0x48,
  0x7C, 0x51, 0x08, 0xA2, 0x21, 0x88, 0x45, 0x10, 0x8A, 0x23, 0x14, 0x46,
  0x48, 0x95, 0x90, 0xC4, 0x30, 0x00, 0x20, 0x00, 0x30, 0x40, 0x3F, 0x00,
  0x00, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x81, 0x30, 0x4C, 0x21, 0x08, 0x47,
  0xF1, 0xFC, 0x81, 0x60, 0x50, 0x1C, 0x06, 0x01, 0x1F, 0x04, 0x73, 0x04,
  0xC1, 0x20, 0x48, 0x12, 0x09, 0xFC, 0x43, 0x10, 0x24, 0x09, 0x02, 0xC0,
  0xA0, 0x68, 0x33, 0xF0, 0x03, 0xE1, 0x84, 0x60, 0x18, 0x02, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18,
  0x01, 0xF8, 0x1F, 0x02, 0x38, 0xC1, 0x18, 0x12, 0x02, 0x40, 0x48, 0x0B,
  0x01, 0x40, 0x28, 0x0D, 0x01, 0x20, 0x2C, 0x09, 0x03, 0x21, 0xC7, 0xE0,
  0x1F, 0xC4, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0xFC, 0x40, 0x10,
  0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x03, 0xF8, 0x1F, 0xC4, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x7F, 0x10, 0x04, 0x01, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x00, 0x03, 0xE0, 0xC3, 0x18, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x41, 0xEC, 0x02, 0xC0, 0x6C, 0x04, 0x40, 0x44,
  0x04, 0x20, 0x41, 0xF8, 0x10, 0x11, 0x01, 0x10, 0x13, 0x03, 0x20, 0x22,
  0x02, 0x20, 0x27, 0xFE, 0x40, 0x64, 0x04, 0x40, 0x44, 0x04, 0xC0, 0x48,
  0x0C, 0x80, 0x88, 0x08, 0x0F, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08,
  0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0xF8, 0x01, 0x01, 0x01, 0x03,
  0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08,
  0x08, 0x18, 0x30, 0xE0, 0x10, 0x31, 0x04, 0x30, 0xC3, 0x18, 0x23, 0x02,
  0x60, 0x2C, 0x07, 0x80, 0x7C, 0x04, 0x40, 0x44, 0x04, 0x60, 0xC2, 0x08,
  0x30, 0x81, 0x08, 0x10, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x30, 0x40,
  0x81, 0x02, 0x0C, 0x10, 0x20, 0x7F, 0x18, 0x03, 0x18, 0x06, 0x38, 0x0E,
  0x28, 0x0A, 0x28, 0x1E, 0x28, 0x14, 0x28, 0x34, 0x6C, 0x24, 0x44, 0x64,
  0x44, 0x4C, 0x44, 0x88, 0x44, 0x88, 0xC5, 0x08, 0x85, 0x08, 0x86, 0x18,
  0x86, 0x10, 0x10, 0x18, 0xC0, 0x8E, 0x04, 0x50, 0x22, 0xC1, 0x12, 0x18,
  0x90, 0x8C, 0xC4, 0x42, 0x22, 0x11, 0x10, 0xD8, 0x82, 0x8C, 0x14, 0x40,
  0xE2, 0x03, 0x10, 0x10, 0x07, 0xC0, 0xC6, 0x10, 0x33, 0x01, 0x20, 0x16,
  0x01, 0x40, 0x14, 0x01, 0x40, 0x1C, 0x03, 0xC0, 0x2C, 0x02, 0x40, 0x64,
  0x0C, 0x61, 0x83, 0xF0, 0x1F, 0x04, 0x63, 0x0C, 0xC1, 0x20, 0x48, 0x12,
  0x0D, 0x86, 0x7F, 0x1E, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00,
  0x07, 0xC0, 0xC6, 0x10, 0x33, 0x01, 0x20, 0x16, 0x01, 0x40, 0x14, 0x01,
  0x40, 0x1C, 0x03, 0xC0, 0x2C, 0x02, 0x40, 0x64, 0x0C, 0x61, 0x83, 0xF0,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x1F, 0x04, 0x63, 0x0C, 0xC1, 0x20,
  0x48, 0x12, 0x09, 0x86, 0x7E, 0x11, 0x04, 0x61, 0x08, 0xC2, 0x20, 0xC8,
  0x12, 0x04, 0x07, 0x86, 0x11, 0x00, 0xC0, 0x20, 0x0C, 0x01, 0x00, 0x30,
  0x06, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x00, 0x48, 0x33, 0xF0, 0xFF, 0x84,
  0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02,
  0x03, 0x01, 0x00, 0x80, 0x10, 0x11, 0x01, 0x30, 0x12, 0x03, 0x20, 0x32,
  0x02, 0x20, 0x26, 0x02, 0x40, 0x64, 0x04, 0x40, 0x4C, 0x04, 0xC0, 0xC4,
  0x08, 0x61, 0x83, 0xE0, 0x80, 0x60, 0x38, 0x0B, 0x06, 0xC1, 0x30, 0x44,
  0x21, 0x08, 0x44, 0x11, 0x04, 0x81, 0x20, 0x50, 0x14, 0x06, 0x01, 0x80,
  0xC0, 0x81, 0xC1, 0x81, 0xC1, 0x82, 0xC2, 0x82, 0xC2, 0x86, 0xC6, 0x84,
  0xC4, 0x8C, 0xC4, 0x88, 0xC8, 0x88, 0x48, 0x90, 0x50, 0x90, 0x50, 0xB0,
  0x70, 0xA0, 0x60, 0xA0, 0x60, 0xC0, 0x40, 0xC0, 0x18, 0x10, 0x83, 0x08,
  0x20, 0xC4, 0x04, 0x80, 0x58, 0x05, 0x00, 0x20, 0x06, 0x00, 0xF0, 0x09,
  0x01, 0x10, 0x31, 0x02, 0x18, 0x40, 0x88, 0x08, 0x80, 0xE0, 0x6C, 0x11,
  0x08, 0x42, 0x11, 0x06, 0xC0, 0xA0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20,
  0x18, 0x04, 0x01, 0x00, 0x1F, 0xE0, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x06,
  0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30,
  0x07, 0xF8, 0x0F, 0x08, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20,
  0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0xF0, 0xF0, 0x8C, 0x44,
  0x44, 0x44, 0x22, 0x22, 0x22, 0x31, 0x0F, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x18, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x10,
  0x08, 0x04, 0x1E, 0x1F, 0x00, 0x04, 0x06, 0x02, 0x82, 0x41, 0x31, 0x09,
  0x84, 0x81, 0x80, 0x80, 0xFF, 0xC9, 0x90, 0x0E, 0x4C, 0x62, 0x19, 0x06,
  0x41, 0xB0, 0x48, 0x12, 0x04, 0x83, 0x20, 0xCC, 0x61, 0xE8, 0x08, 0x02,
  0x00, 0x80, 0x60, 0x10, 0x04, 0xE1, 0xCC, 0xE1, 0x30, 0x48, 0x12, 0x04,
  0x81, 0x60, 0xD8, 0x26, 0x19, 0x84, 0xDE, 0x00, 0x0F, 0x31, 0x20, 0x40,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x7C, 0x00, 0x20, 0x0C, 0x01,
  0x00, 0x20, 0x04, 0x1D, 0x8C, 0x61, 0x0C, 0x40, 0x88, 0x13, 0x06, 0x40,
  0x88, 0x11, 0x06, 0x20, 0xC6, 0x38, 0x7A, 0x00, 0x0E, 0x31, 0x21, 0x41,
  0x43, 0xDE, 0xF0, 0x80, 0x80, 0x80, 0xC2, 0x7E, 0x00, 0xF0, 0x18, 0x01,
  0x00, 0x10, 0x03, 0x00, 0xFC, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x10, 0x0E, 0x00, 0x07, 0x23, 0x18, 0x43, 0x10, 0x22, 0x04,
  0xC1, 0x90, 0x22, 0x04, 0x41, 0x88, 0x31, 0x8E, 0x1E, 0x80, 0x10, 0x02,
  0x00, 0xC4, 0x30, 0xFC, 0x00, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04,
  0xE1, 0xCC, 0xE1, 0x30, 0x48, 0x32, 0x0C, 0x82, 0x60, 0x90, 0x24, 0x19,
  0x04, 0xC1, 0x00, 0x08, 0xC0, 0x01, 0x08, 0xC4, 0x21, 0x08, 0xC4, 0x21,
  0x18, 0x01, 0x03, 0x00, 0x00, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04,
  0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x30, 0xE0, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x31, 0x18, 0xCC, 0x22, 0x09, 0x02, 0x80,
  0xD0, 0x64, 0x11, 0x84, 0x21, 0x08, 0xC3, 0x00, 0x08, 0x42, 0x31, 0x08,
  0x46, 0x21, 0x08, 0x46, 0x21, 0x08, 0xC0, 0x13, 0x9E, 0x1C, 0xB2, 0x30,
  0xC3, 0x30, 0xC3, 0x20, 0x82, 0x20, 0x82, 0x20, 0x82, 0x61, 0x86, 0x41,
  0x06, 0x41, 0x04, 0x41, 0x04, 0xC3, 0x04, 0x13, 0x87, 0x33, 0x84, 0xC1,
  0x20, 0xC8, 0x32, 0x09, 0x82, 0x40, 0x90, 0x64, 0x13, 0x04, 0x0E, 0x18,
  0x98, 0x68, 0x14, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x41, 0xB1, 0x8F, 0x80,
  0x09, 0xC1, 0xCC, 0x70, 0x8C, 0x11, 0x02, 0x20, 0x44, 0x09, 0x83, 0x30,
  0x46, 0x18, 0xC2, 0x17, 0x86, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x00,
  0x0E, 0x4C, 0x62, 0x19, 0x02, 0x40, 0xB0, 0x68, 0x12, 0x04, 0x83, 0x20,
  0xCC, 0x71, 0xE8, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x00, 0x13, 0x1C,
  0x38, 0x30, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x1E, 0x31,
  0x20, 0x60, 0x20, 0x10, 0x0C, 0x06, 0x02, 0x06, 0x84, 0xFC, 0x30, 0x8F,
  0xC8, 0x61, 0x04, 0x10, 0x43, 0x08, 0x20, 0x83, 0xC0, 0x20, 0x90, 0x58,
  0x28, 0x14, 0x1A, 0x0B, 0x05, 0x02, 0x83, 0x41, 0xA1, 0x8F, 0x40, 0x81,
  0xC0, 0xB0, 0xD8, 0x44, 0x42, 0x21, 0x20, 0x90, 0x50, 0x28, 0x18, 0x0C,
  0x00, 0x82, 0x0C, 0x18, 0x71, 0x45, 0x8A, 0x2C, 0x93, 0x64, 0x93, 0x44,
  0x9A, 0x28, 0x71, 0x43, 0x0C, 0x18, 0x60, 0x83, 0x00, 0x10, 0x62, 0x18,
  0x22, 0x04, 0x80, 0xA0, 0x0C, 0x03, 0x00, 0x50, 0x12, 0x04, 0x41, 0x84,
  0x60, 0x80, 0x18, 0x31, 0x82, 0x08, 0x60, 0x84, 0x08, 0xC0, 0x88, 0x09,
  0x80, 0x90, 0x0B, 0x00, 0xA0, 0x0E, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x10,
  0x03, 0x00, 0xE0, 0x00, 0x3F, 0x01, 0x02, 0x06, 0x04, 0x08, 0x10, 0x30,
  0x20, 0x40, 0x80, 0xFC, 0x01, 0x83, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x30, 0x10, 0x30, 0x28, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x0E, 0x00, 0xFF, 0xFF, 0xFC, 0x08, 0x06, 0x02, 0x02, 0x06, 0x04, 0x04,
  0x04, 0x04, 0x07, 0x06, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x30, 0xE0,
  0x78, 0x63, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 16, 5, 0, -16 },
  { 11, 6, 6, 7, 2, -16 },
  { 16, 12, 16, 12, 0, -16 },
  { 40, 9, 18, 11, 1, -17 },
  { 61, 12, 16, 15, 2, -16 },
  { 85, 12, 16, 12, 0, -16 },
  { 109, 3, 6, 4, 2, -16 },
  { 112, 6, 19, 6, 1, -16 },
  { 127, 7, 19, 6, -2, -16 },
  { 144, 9, 9, 10, 2, -17 },
  { 155, 10, 10, 11, 1, -13 },
  { 168, 4, 5, 5, -1, -2 },
  { 171, 5, 2, 6, 1, -7 },
  { 173, 2, 2, 5, 0, -2 },
  { 174, 10, 16, 7, -1, -16 },
  { 194, 9, 16, 11, 1, -16 },
  { 212, 5, 16, 11, 3, -16 },
  { 222, 10, 16, 11, 0, -16 },
  { 242, 10, 16, 11, 0, -16 },
  { 262, 10, 16, 11, 0, -16 },
  { 282, 11, 16, 11, 0, -16 },
  { 304, 10, 16, 11, 1, -16 },
  { 324, 9, 16, 11, 2, -16 },
  { 342, 10, 16, 11, 1, -16 },
  { 362, 9, 16, 11, 1, -16 },
  { 380, 4, 12, 5, 0, -12 },
  { 386, 5, 15, 5, -1, -12 },
  { 396, 10, 10, 11, 1, -13 },
  { 409, 10, 6, 11, 1, -11 },
  { 417, 10, 10, 11, 1, -13 },
  { 430, 8, 16, 8, 1, -16 },
  { 446, 15, 18, 16, 1, -16 },
  { 480, 10, 16, 11, -1, -16 },
  { 500, 10, 16, 12, 1, -16 },
  { 520, 11, 16, 11, 1, -16 },
  { 542, 11, 16, 13, 1, -16 },
  { 564, 10, 16, 10, 1, -16 },
  { 584, 10, 16, 9, 1, -16 },
  { 604, 12, 16, 13, 1, -16 },
  { 628, 12, 16, 13, 1, -16 },
  { 652, 8, 16, 6, -1, -16 },
  { 668, 8, 20, 5, -3, -16 },
  { 688, 12, 16, 11, 1, -16 },
  { 712, 7, 16, 9, 1, -16 },
  { 726, 16, 16, 16, 1, -16 },
  { 758, 13, 16, 14, 1, -16 },
  { 784, 12, 16, 14, 1, -16 },
  { 808, 10, 16, 11, 1, -16 },
  { 828, 12, 20, 14, 1, -16 },
  { 858, 10, 16, 11, 1, -16 },
  { 878, 10, 16, 10, 0, -16 },
  { 898, 9, 16, 9, 2, -16 },
  { 916, 12, 16, 13, 1, -16 },
  { 940, 10, 16, 11, 2, -16 },
  { 960, 16, 16, 17, 2, -16 },
  { 992, 12, 16, 10, -1, -16 },
  { 1016, 10, 16, 10, 2, -16 },
  { 1036, 11, 16, 10, 0, -16 },
  { 1058, 8, 20, 6, 0, -16 },
  { 1078, 4, 16, 7, 2, -16 },
  { 1086, 9, 20, 6, -2, -16 },
  { 1109, 9, 9, 11, 1, -16 },
  { 1120, 8, 1, 8, -2, 2 },
  { 1121, 3, 4, 5, 3, -17 },
  { 1123, 10, 12, 11, 1, -12 },
  { 1138, 10, 17, 11, 0, -17 },
  { 1160, 8, 12, 9, 1, -12 },
  { 1172, 11, 17, 11, 1, -17 },
  { 1196, 8, 12, 10, 1, -12 },
  { 1208, 12, 22, 6, -3, -17 },
  { 1241, 11, 17, 11, 0, -12 },
  { 1265, 10, 17, 11, 0, -17 },
  { 1287, 5, 16, 5, 0, -16 },
  { 1297, 8, 21, 5, -3, -16 },
  { 1318, 10, 17, 9, 0, -17 },
  { 1340, 5, 17, 5, 0, -17 },
  { 1351, 16, 12, 17, 0, -12 },
  { 1375, 10, 12, 11, 0, -12 },
  { 1390, 9, 12, 11, 1, -12 },
  { 1404, 11, 17, 11, -1, -12 },
  { 1428, 10, 17, 11, 1, -12 },
  { 1450, 8, 12, 7, 0, -12 },
  { 1462, 8, 12, 8, 0, -12 },
  { 1474, 6, 14, 6, 1, -14 },
  { 1485, 9, 12, 11, 1, -12 },
  { 1499, 9, 12, 9, 1, -12 },
  { 1513, 13, 12, 14, 1, -12 },
  { 1533, 11, 12, 9, -1, -12 },
  { 1550, 12, 17, 9, -2, -12 },
  { 1576, 8, 12, 8, 0, -12 },
  { 1588, 9, 19, 7, 0, -16 },
  { 1610, 1, 22, 10, 5, -17 },
  { 1613, 8, 19, 7, -1, -16 },
  { 1632, 10, 2, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC22PT7B_H_
