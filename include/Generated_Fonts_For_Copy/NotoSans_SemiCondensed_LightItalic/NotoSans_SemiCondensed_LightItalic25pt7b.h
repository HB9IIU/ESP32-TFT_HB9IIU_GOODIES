#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC25PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC4, 0x21, 0x18, 0xC4, 0x21, 0x18, 0x84, 0x00, 0x00, 0xC4,
  0x00, 0x4F, 0x3C, 0xA2, 0x8A, 0x69, 0x00, 0x02, 0x30, 0x11, 0x01, 0x08,
  0x08, 0x40, 0x44, 0x3F, 0xFD, 0xFF, 0xE1, 0x18, 0x18, 0x80, 0x84, 0x04,
  0x21, 0xFF, 0xC2, 0x10, 0x10, 0x80, 0x8C, 0x0C, 0x40, 0x42, 0x02, 0x30,
  0x00, 0x01, 0x00, 0x20, 0x1F, 0x0F, 0x73, 0x20, 0x44, 0x08, 0x81, 0x20,
  0x34, 0x03, 0x80, 0x1C, 0x02, 0xC0, 0x88, 0x11, 0x02, 0x20, 0x4C, 0xFF,
  0x0F, 0x80, 0x40, 0x08, 0x00, 0x3C, 0x0D, 0x90, 0x64, 0x61, 0x31, 0x88,
  0x84, 0x62, 0x11, 0x08, 0x48, 0x23, 0x66, 0x89, 0x66, 0x69, 0x17, 0x6C,
  0x41, 0x21, 0x08, 0x84, 0x22, 0x11, 0x08, 0xCC, 0x22, 0x20, 0x99, 0x03,
  0xC0, 0x07, 0x80, 0xCC, 0x18, 0x41, 0x84, 0x10, 0x41, 0x88, 0x19, 0x80,
  0xE0, 0x0C, 0x03, 0x40, 0x66, 0x1C, 0x33, 0x81, 0x28, 0x1E, 0x80, 0xC8,
  0x1C, 0xC3, 0x47, 0xC6, 0x5E, 0xA8, 0x02, 0x08, 0x20, 0xC1, 0x04, 0x08,
  0x30, 0x41, 0x83, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x06, 0x04,
  0x0C, 0x00, 0x04, 0x06, 0x02, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x02, 0x02, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x60, 0xC0,
  0x04, 0x06, 0x22, 0x1D, 0x03, 0xF8, 0xC0, 0x91, 0xC8, 0x46, 0x02, 0x00,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x32, 0x26, 0x48, 0xFC, 0xE0, 0x00, 0x20,
  0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x00, 0x07,
  0x81, 0x98, 0x61, 0x18, 0x32, 0x06, 0xC0, 0xD8, 0x1A, 0x03, 0x40, 0x58,
  0x0B, 0x01, 0x60, 0x6C, 0x0D, 0x81, 0x30, 0x66, 0x18, 0x66, 0x07, 0x80,
  0x06, 0x38, 0xD7, 0x24, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x40, 0x81, 0x06,
  0x0C, 0x10, 0x20, 0xC0, 0x07, 0xC1, 0xC6, 0x08, 0x20, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x0F, 0xF8, 0x07, 0xC1, 0xC6, 0x10, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x0F, 0x00, 0x38, 0x00, 0xC0,
  0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x81, 0x8F, 0xE0, 0x00, 0x30,
  0x06, 0x00, 0xA0, 0x1A, 0x03, 0x60, 0x24, 0x04, 0x40, 0xC4, 0x18, 0xC1,
  0x0C, 0x20, 0x84, 0x08, 0xFF, 0xEF, 0xFE, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x30, 0x07, 0xF0, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01,
  0xF0, 0x3B, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x08, 0x83, 0x87, 0xE0, 0x03, 0xE0, 0xC0, 0x20, 0x08, 0x03, 0x00, 0x40,
  0x18, 0x03, 0x78, 0x51, 0x8C, 0x1B, 0x03, 0x60, 0x6C, 0x0D, 0x81, 0xB0,
  0x22, 0x0C, 0x63, 0x07, 0xC0, 0x7F, 0xE0, 0x08, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x40, 0x18, 0x00, 0x0F, 0x83, 0x18, 0x41, 0x98, 0x13,
  0x06, 0x60, 0xC4, 0x30, 0xCC, 0x0E, 0x07, 0x61, 0x86, 0x60, 0x48, 0x09,
  0x01, 0x20, 0x24, 0x0C, 0xC3, 0x0F, 0xC0, 0x0F, 0x83, 0x18, 0xC1, 0x10,
  0x26, 0x06, 0xC0, 0xD0, 0x1A, 0x02, 0x60, 0xC4, 0x28, 0xFB, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x40, 0x10, 0x0C, 0x1F, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x08, 0x61, 0x04, 0x20, 0x00, 0x20, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x10, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x80, 0x40, 0x00,
  0x7E, 0x11, 0x80, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x04, 0x02, 0x02, 0x00, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0xF8, 0x01,
  0xC7, 0x03, 0x00, 0xC3, 0x00, 0x21, 0x00, 0x11, 0x07, 0xCD, 0x84, 0x42,
  0x84, 0x21, 0x44, 0x11, 0xE2, 0x18, 0xE3, 0x08, 0x51, 0x84, 0x28, 0xC6,
  0x24, 0x63, 0x32, 0x1E, 0xF1, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x08, 0x01, 0xFC, 0x00, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x14, 0x03, 0x60,
  0x26, 0x06, 0x60, 0x42, 0x0C, 0x20, 0x82, 0x1F, 0xE1, 0xFE, 0x30, 0x22,
  0x02, 0x60, 0x24, 0x03, 0xC0, 0x38, 0x03, 0x1F, 0x81, 0x8E, 0x10, 0x31,
  0x03, 0x10, 0x33, 0x03, 0x30, 0x22, 0x0C, 0x3F, 0x82, 0x1C, 0x60, 0x46,
  0x06, 0x40, 0x64, 0x06, 0xC0, 0x4C, 0x0C, 0x83, 0x8F, 0xE0, 0x03, 0xF0,
  0xE3, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x83,
  0xF8, 0x1F, 0x80, 0xCF, 0x04, 0x0C, 0x20, 0x21, 0x01, 0x98, 0x0C, 0xC0,
  0x64, 0x03, 0x20, 0x19, 0x00, 0xD8, 0x04, 0xC0, 0x24, 0x03, 0x20, 0x33,
  0x01, 0x98, 0x38, 0x87, 0x07, 0xE0, 0x00, 0x1F, 0xE3, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x3F, 0x84, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x1F, 0xE0, 0x1F, 0xE3, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x07, 0xF1, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x00, 0x03, 0xF0, 0x70,
  0xC6, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x0F, 0xA0, 0x0D, 0x00, 0x48, 0x02, 0x40, 0x32, 0x01, 0x98, 0x08, 0x60,
  0xC1, 0xFE, 0x00, 0x18, 0x04, 0x60, 0x31, 0x00, 0xC4, 0x02, 0x10, 0x08,
  0xC0, 0x23, 0x01, 0x88, 0x06, 0x3F, 0xF0, 0x80, 0x46, 0x01, 0x18, 0x0C,
  0x40, 0x31, 0x00, 0x8C, 0x02, 0x30, 0x18, 0x80, 0x62, 0x01, 0x00, 0x0F,
  0x81, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01,
  0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x7E, 0x00, 0x00, 0xC0, 0x30, 0x08,
  0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02,
  0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x3E, 0x04,
  0x00, 0x18, 0x18, 0xC1, 0x84, 0x18, 0x21, 0x81, 0x18, 0x19, 0x80, 0xC8,
  0x04, 0x80, 0x2C, 0x01, 0xB0, 0x19, 0x80, 0xC4, 0x04, 0x30, 0x20, 0x83,
  0x04, 0x18, 0x30, 0x80, 0x84, 0x06, 0x00, 0x18, 0x18, 0x10, 0x10, 0x10,
  0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0x80,
  0xFF, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x38, 0x50, 0x0A, 0x14, 0x06,
  0x8D, 0x01, 0x63, 0x40, 0xD8, 0x90, 0x24, 0x24, 0x19, 0x09, 0x84, 0xC6,
  0x63, 0x31, 0x18, 0x88, 0x42, 0x42, 0x10, 0x90, 0x8C, 0x28, 0x63, 0x0E,
  0x18, 0x83, 0x04, 0x20, 0xC1, 0x00, 0x18, 0x06, 0x30, 0x08, 0x70, 0x10,
  0xA0, 0x61, 0x40, 0xC6, 0xC1, 0x0C, 0x82, 0x11, 0x04, 0x23, 0x18, 0x42,
  0x31, 0x84, 0x42, 0x0C, 0x84, 0x09, 0x08, 0x16, 0x30, 0x3C, 0x60, 0x70,
  0x80, 0x61, 0x00, 0xC0, 0x07, 0xC0, 0x63, 0x84, 0x04, 0x40, 0x36, 0x01,
  0xA0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x05, 0x00, 0x28,
  0x03, 0x40, 0x12, 0x01, 0x98, 0x18, 0x61, 0x81, 0xF8, 0x00, 0x1F, 0x81,
  0x9E, 0x10, 0x61, 0x02, 0x10, 0x33, 0x02, 0x30, 0x22, 0x06, 0x20, 0xC3,
  0xF8, 0x7C, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08,
  0x00, 0x07, 0xC0, 0x63, 0x84, 0x04, 0x40, 0x36, 0x01, 0xA0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x05, 0x00, 0x28, 0x03, 0x40, 0x12,
  0x01, 0x98, 0x18, 0x61, 0x81, 0xF8, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x1F, 0x81, 0x9E, 0x10, 0x21, 0x02, 0x10, 0x33, 0x02, 0x30, 0x22,
  0x06, 0x20, 0xC3, 0xF8, 0x62, 0x06, 0x30, 0x43, 0x04, 0x10, 0xC1, 0x8C,
  0x18, 0x80, 0x88, 0x0C, 0x07, 0xF0, 0xC2, 0x18, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x18, 0x83, 0x8F, 0xE0, 0xFF, 0xE0, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x09, 0x00, 0x48,
  0x06, 0x40, 0x36, 0x01, 0x30, 0x09, 0x00, 0xC8, 0x06, 0x40, 0x26, 0x01,
  0x30, 0x09, 0x00, 0xC8, 0x06, 0x40, 0x22, 0x03, 0x10, 0x10, 0xC3, 0x83,
  0xF0, 0x00, 0xC0, 0x3C, 0x02, 0x40, 0x64, 0x04, 0x40, 0xC4, 0x08, 0x41,
  0x84, 0x10, 0x43, 0x04, 0x20, 0x42, 0x06, 0x40, 0x64, 0x06, 0x80, 0x68,
  0x07, 0x00, 0x30, 0x02, 0x00, 0x80, 0x80, 0xE0, 0x30, 0x28, 0x1C, 0x1A,
  0x07, 0x06, 0x82, 0xC1, 0x20, 0xB0, 0xC8, 0x6C, 0x22, 0x13, 0x18, 0x8C,
  0xC4, 0x22, 0x33, 0x09, 0x8C, 0x82, 0x41, 0x20, 0x90, 0x58, 0x2C, 0x14,
  0x0A, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x00, 0x08, 0x0C,
  0x30, 0x20, 0x41, 0x01, 0x0C, 0x04, 0x60, 0x19, 0x00, 0x2C, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x50, 0x03, 0x60, 0x18, 0x80, 0x42, 0x03, 0x0C,
  0x18, 0x30, 0x40, 0x42, 0x01, 0x80, 0xC0, 0x68, 0x09, 0x03, 0x20, 0xC6,
  0x10, 0xC6, 0x08, 0x81, 0x20, 0x2C, 0x07, 0x00, 0xC0, 0x08, 0x03, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x00, 0x0F, 0xFC, 0x00, 0x20, 0x01,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x03, 0xFF, 0x00, 0x0F, 0x84, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20,
  0x10, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30,
  0x18, 0x08, 0x07, 0xC0, 0x88, 0x88, 0xCC, 0x44, 0x44, 0x46, 0x62, 0x22,
  0x23, 0x07, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00,
  0xC0, 0x20, 0x08, 0x3E, 0x00, 0x02, 0x00, 0xC0, 0x34, 0x04, 0x81, 0x98,
  0x21, 0x08, 0x21, 0x06, 0x40, 0x58, 0x0C, 0xFF, 0xFF, 0xC0, 0x99, 0x10,
  0x02, 0x03, 0xE4, 0xC3, 0x90, 0x66, 0x04, 0x80, 0xB0, 0x36, 0x06, 0xC0,
  0x90, 0x12, 0x06, 0x61, 0xC4, 0x78, 0xF2, 0x00, 0x0C, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x88, 0x1B, 0xE1, 0x42, 0x18, 0x31, 0x03, 0x30,
  0x33, 0x03, 0x20, 0x22, 0x02, 0x60, 0x66, 0x04, 0x60, 0xC5, 0x18, 0xDF,
  0x00, 0x02, 0x0F, 0xCC, 0x04, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40,
  0x30, 0x18, 0x06, 0x21, 0xF0, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x22, 0x1F, 0xA3, 0x0E, 0x20, 0x66, 0x04, 0x40, 0x4C, 0x04, 0xC0,
  0xCC, 0x0C, 0x80, 0x88, 0x18, 0xC2, 0x84, 0x78, 0x7D, 0x00, 0x02, 0x0F,
  0xCC, 0x24, 0x16, 0x0A, 0x0F, 0x3D, 0xF0, 0xC0, 0x60, 0x30, 0x18, 0x06,
  0x11, 0xF8, 0x00, 0x78, 0x06, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x3F, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0xE0, 0x00, 0x01, 0x00, 0xFD, 0x18, 0x51,
  0x03, 0x30, 0x22, 0x02, 0x60, 0x26, 0x06, 0x60, 0x64, 0x04, 0x40, 0xC6,
  0x14, 0x63, 0xC3, 0xE8, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0xC7, 0x07,
  0xC0, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x31, 0x04, 0xF8, 0xA1,
  0x18, 0x22, 0x04, 0xC0, 0x90, 0x32, 0x06, 0x40, 0x98, 0x13, 0x02, 0x40,
  0xC8, 0x1B, 0x02, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x04, 0x10, 0xC2,
  0x08, 0x21, 0x86, 0x10, 0x43, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x10,
  0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC1, 0xC0, 0x0C, 0x01, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x18, 0x86, 0x11, 0x82, 0x60, 0xD8,
  0x16, 0x03, 0xE0, 0x6C, 0x18, 0x83, 0x18, 0x41, 0x08, 0x23, 0x06, 0x00,
  0x0C, 0x30, 0x82, 0x08, 0x61, 0x84, 0x10, 0x43, 0x08, 0x20, 0x86, 0x18,
  0x41, 0x0C, 0x00, 0x00, 0x82, 0x05, 0xF3, 0xE1, 0x47, 0x0C, 0x61, 0xC3,
  0x10, 0x60, 0xCC, 0x18, 0x22, 0x04, 0x08, 0x81, 0x02, 0x20, 0x41, 0x98,
  0x30, 0x66, 0x0C, 0x11, 0x02, 0x04, 0x40, 0x81, 0x30, 0x60, 0xC0, 0x00,
  0x82, 0x7C, 0x50, 0x8C, 0x13, 0x02, 0x60, 0x4C, 0x19, 0x03, 0x20, 0x4C,
  0x09, 0x81, 0x20, 0x64, 0x0D, 0x81, 0x00, 0x02, 0x07, 0xE3, 0x0C, 0x81,
  0x60, 0x50, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x3C, 0x0B, 0x06, 0x63, 0x0F,
  0x80, 0x00, 0x40, 0x4F, 0x82, 0x84, 0x18, 0x30, 0x81, 0x8C, 0x0C, 0x60,
  0x62, 0x02, 0x10, 0x11, 0x81, 0x8C, 0x08, 0x60, 0xC2, 0x8C, 0x17, 0xC1,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x00, 0x02, 0x03,
  0xF4, 0xC2, 0x90, 0x36, 0x04, 0x80, 0xB0, 0x16, 0x06, 0xC0, 0xD0, 0x12,
  0x06, 0x61, 0x44, 0x78, 0xFA, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x00, 0x89, 0xC5, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20,
  0x30, 0x18, 0x08, 0x04, 0x06, 0x00, 0x04, 0x0F, 0xCC, 0x04, 0x02, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x68, 0x67, 0xE0, 0x10, 0x20,
  0xC7, 0xF2, 0x04, 0x18, 0x30, 0x40, 0x81, 0x06, 0x0C, 0x10, 0x30, 0x38,
  0x30, 0x64, 0x0C, 0x81, 0x30, 0x26, 0x0C, 0x81, 0x90, 0x22, 0x04, 0xC1,
  0x98, 0x33, 0x0E, 0x63, 0x87, 0x90, 0xC0, 0xF0, 0x24, 0x19, 0x04, 0x42,
  0x11, 0x84, 0x41, 0x30, 0x48, 0x16, 0x07, 0x01, 0xC0, 0x60, 0x00, 0xC1,
  0x82, 0x87, 0x0D, 0x0A, 0x12, 0x34, 0x64, 0x48, 0x88, 0x93, 0x12, 0x24,
  0x24, 0x48, 0x50, 0xB0, 0xA1, 0x41, 0xC3, 0x83, 0x06, 0x06, 0x0C, 0x00,
  0x18, 0x30, 0x86, 0x08, 0xC0, 0xD8, 0x05, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0B, 0x01, 0x10, 0x31, 0x06, 0x18, 0xC0, 0x80, 0x0C, 0x0C, 0x10, 0x20,
  0x41, 0x81, 0x04, 0x04, 0x30, 0x10, 0x80, 0x46, 0x01, 0x90, 0x06, 0xC0,
  0x0A, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x08, 0x00, 0x60, 0x0F, 0x00, 0x00, 0x1F, 0xE0, 0x18, 0x02, 0x00, 0x80,
  0x30, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0F, 0xF0,
  0x03, 0x83, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x18, 0x38,
  0x18, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x06, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x20, 0x10,
  0x08, 0x0C, 0x06, 0x03, 0x00, 0xE0, 0x70, 0x40, 0x60, 0x20, 0x10, 0x18,
  0x0C, 0x04, 0x02, 0x07, 0x06, 0x00, 0x7C, 0x38, 0xFC, 0x02, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 18, 6, 1, -18 },
  { 13, 6, 7, 8, 3, -18 },
  { 19, 13, 18, 14, 1, -18 },
  { 49, 11, 20, 12, 1, -19 },
  { 77, 14, 18, 18, 2, -18 },
  { 109, 12, 18, 14, 1, -18 },
  { 136, 2, 7, 5, 3, -18 },
  { 138, 7, 22, 7, 1, -18 },
  { 158, 8, 22, 7, -2, -18 },
  { 180, 9, 10, 12, 3, -19 },
  { 192, 11, 12, 13, 1, -15 },
  { 209, 4, 6, 5, -1, -3 },
  { 212, 6, 1, 7, 1, -7 },
  { 213, 2, 2, 5, 1, -2 },
  { 214, 11, 18, 8, -1, -18 },
  { 239, 11, 18, 12, 1, -18 },
  { 264, 7, 18, 12, 3, -18 },
  { 280, 12, 18, 12, 0, -18 },
  { 307, 12, 18, 12, 0, -18 },
  { 334, 12, 18, 12, 0, -18 },
  { 361, 12, 18, 12, 0, -18 },
  { 388, 11, 18, 12, 1, -18 },
  { 413, 11, 18, 12, 2, -18 },
  { 438, 11, 18, 12, 1, -18 },
  { 463, 11, 18, 12, 1, -18 },
  { 488, 5, 13, 5, 0, -13 },
  { 497, 6, 16, 5, -1, -13 },
  { 509, 11, 12, 13, 1, -15 },
  { 526, 11, 6, 13, 1, -12 },
  { 535, 11, 12, 13, 1, -15 },
  { 552, 9, 18, 9, 1, -18 },
  { 573, 17, 20, 18, 1, -18 },
  { 616, 12, 18, 12, -1, -18 },
  { 643, 12, 18, 13, 1, -18 },
  { 670, 12, 18, 13, 2, -18 },
  { 697, 13, 18, 15, 1, -18 },
  { 727, 11, 18, 12, 1, -18 },
  { 752, 11, 18, 11, 1, -18 },
  { 777, 13, 18, 15, 2, -18 },
  { 807, 14, 18, 15, 1, -18 },
  { 839, 9, 18, 7, -1, -18 },
  { 860, 10, 23, 6, -4, -18 },
  { 889, 13, 18, 12, 1, -18 },
  { 919, 8, 18, 11, 1, -18 },
  { 937, 18, 18, 19, 1, -18 },
  { 978, 15, 18, 15, 1, -18 },
  { 1012, 13, 18, 16, 2, -18 },
  { 1042, 12, 18, 12, 1, -18 },
  { 1069, 13, 22, 16, 2, -18 },
  { 1105, 12, 18, 13, 1, -18 },
  { 1132, 12, 18, 11, 0, -18 },
  { 1159, 11, 18, 11, 2, -18 },
  { 1184, 13, 18, 15, 2, -18 },
  { 1214, 12, 18, 12, 2, -18 },
  { 1241, 18, 18, 19, 3, -18 },
  { 1282, 14, 18, 11, -1, -18 },
  { 1314, 11, 18, 11, 2, -18 },
  { 1339, 14, 18, 11, -1, -18 },
  { 1371, 9, 22, 7, 0, -18 },
  { 1396, 4, 18, 8, 3, -18 },
  { 1405, 10, 22, 7, -2, -18 },
  { 1433, 11, 10, 13, 1, -18 },
  { 1447, 9, 2, 9, -2, 2 },
  { 1450, 3, 4, 6, 4, -19 },
  { 1452, 11, 14, 13, 1, -14 },
  { 1472, 12, 19, 13, 0, -19 },
  { 1501, 9, 14, 10, 1, -14 },
  { 1517, 12, 19, 13, 1, -19 },
  { 1546, 9, 14, 11, 1, -14 },
  { 1562, 13, 25, 7, -3, -19 },
  { 1603, 12, 20, 13, 0, -14 },
  { 1633, 11, 19, 12, 0, -19 },
  { 1660, 6, 18, 5, 0, -18 },
  { 1674, 9, 24, 5, -3, -18 },
  { 1701, 11, 19, 10, 0, -19 },
  { 1728, 6, 19, 5, 0, -19 },
  { 1743, 18, 14, 19, 0, -14 },
  { 1775, 11, 14, 12, 0, -14 },
  { 1795, 10, 14, 12, 1, -14 },
  { 1813, 13, 20, 13, -1, -14 },
  { 1846, 11, 20, 13, 1, -14 },
  { 1874, 9, 14, 8, 0, -14 },
  { 1890, 9, 14, 9, 0, -14 },
  { 1906, 7, 16, 7, 1, -16 },
  { 1920, 11, 13, 13, 1, -13 },
  { 1938, 10, 13, 10, 1, -13 },
  { 1955, 15, 13, 15, 1, -13 },
  { 1980, 12, 13, 10, -1, -13 },
  { 2000, 14, 19, 10, -3, -13 },
  { 2034, 11, 13, 9, -1, -13 },
  { 2052, 9, 22, 8, 1, -18 },
  { 2077, 1, 25, 12, 6, -19 },
  { 2081, 9, 22, 8, -1, -18 },
  { 2106, 11, 3, 13, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC25PT7B_H_
