#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC49PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x00, 0x38, 0x73, 0x87, 0x38, 0x73, 0x07, 0x30, 0x67, 0x06, 0x70,
  0xE6, 0x0E, 0x60, 0xC6, 0x0C, 0xE0, 0xCC, 0x0C, 0xC1, 0x80, 0x00, 0x0E,
  0x03, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00,
  0x1C, 0x0E, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x30, 0x1C, 0x00, 0x0C, 0x06, 0x01, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xC0, 0x18, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x03,
  0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x70, 0x18, 0x00, 0x18, 0x0E, 0x00,
  0x06, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0x70, 0x0F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0x07, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x38, 0x0C, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x01, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x70, 0x38, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF0, 0x1F, 0x67, 0xC0,
  0xE1, 0x82, 0x07, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x83,
  0x00, 0x0E, 0x0C, 0x00, 0x38, 0x30, 0x00, 0x70, 0xC0, 0x01, 0xC6, 0x00,
  0x03, 0x98, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xDE, 0x00, 0x03, 0x3C, 0x00, 0x0C, 0x70, 0x00, 0x60,
  0xE0, 0x01, 0x83, 0x80, 0x06, 0x0E, 0x00, 0x18, 0x38, 0x00, 0x60, 0xC0,
  0x03, 0x07, 0x00, 0x0C, 0x38, 0x38, 0x31, 0xE0, 0xFF, 0xFF, 0x01, 0xFF,
  0xF0, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x60, 0x3F, 0xC0,
  0x07, 0x03, 0x86, 0x00, 0x70, 0x38, 0x38, 0x03, 0x01, 0x81, 0xC0, 0x38,
  0x1C, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x81, 0xC0, 0x70,
  0x1C, 0x1C, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x06, 0x0E, 0x00, 0xC0, 0x30,
  0xE0, 0x06, 0x03, 0x86, 0x00, 0x70, 0x18, 0x70, 0x03, 0x80, 0xC3, 0x1F,
  0x9C, 0x0E, 0x31, 0xFE, 0xE0, 0x63, 0x9C, 0x3B, 0x07, 0x18, 0xC0, 0xDC,
  0x71, 0x8E, 0x06, 0xFF, 0x1C, 0x60, 0x33, 0xF0, 0xC7, 0x01, 0x80, 0x0C,
  0x30, 0x0C, 0x00, 0xE1, 0x80, 0x60, 0x06, 0x0C, 0x07, 0x00, 0x60, 0xE0,
  0x38, 0x07, 0x07, 0x01, 0x80, 0x30, 0x30, 0x0C, 0x03, 0x81, 0x80, 0x60,
  0x38, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x30, 0x1C, 0x03, 0x03, 0x81, 0xC0,
  0x18, 0x18, 0x0C, 0x00, 0xE1, 0xC0, 0xE0, 0x03, 0xFC, 0x0E, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0,
  0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C,
  0x00, 0x70, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x06, 0x1E,
  0x00, 0x03, 0x9E, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0xE1, 0xC0, 0x38, 0xE0,
  0x70, 0x1C, 0xE0, 0x38, 0x0C, 0xE0, 0x0E, 0x0E, 0x70, 0x07, 0x86, 0x30,
  0x01, 0xC7, 0x38, 0x00, 0x77, 0x1C, 0x00, 0x3F, 0x0E, 0x00, 0x0F, 0x87,
  0x00, 0x07, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x03, 0xE0, 0x70, 0x07, 0xB8,
  0x3C, 0x0F, 0x8E, 0x0F, 0xFF, 0x07, 0x03, 0xFF, 0x01, 0xC0, 0x39, 0xCE,
  0x63, 0x39, 0xCC, 0x63, 0x19, 0x8C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x80, 0xC0, 0x38, 0x30, 0x0F, 0x8C, 0x00, 0xFB, 0x01, 0x0F, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3C, 0x00, 0x1F, 0x00, 0x0E, 0x60, 0x07, 0x18, 0x03, 0x83,
  0x01, 0xC0, 0xC0, 0x20, 0x38, 0x00, 0x07, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0F,
  0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x30, 0x70, 0x60, 0xE0, 0x7F, 0xF7,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xF8, 0x03, 0xC1, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x18, 0x1C, 0x00,
  0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x60, 0x01, 0xC7, 0x00, 0x0E, 0x38,
  0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE6, 0x00, 0x07,
  0x70, 0x00, 0x3B, 0x80, 0x01, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE6, 0x00,
  0x07, 0x30, 0x00, 0x3B, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7,
  0x00, 0x06, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x01,
  0xC1, 0x80, 0x1C, 0x0E, 0x01, 0xE0, 0x70, 0x1E, 0x01, 0xE1, 0xE0, 0x07,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x70, 0x1F, 0x03, 0xE0, 0x76, 0x1E,
  0xE3, 0xCE, 0xF0, 0xEE, 0x0C, 0x41, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x00, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xC1, 0xE0, 0x0E, 0x00, 0xE0, 0x10, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0xC0, 0xF0,
  0x0C, 0x00, 0xE0, 0x10, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x40, 0x01, 0xE0, 0xF0,
  0x0F, 0x81, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x0F, 0xC0, 0x00,
  0x3B, 0x80, 0x00, 0xE6, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x38, 0x00, 0x1C,
  0x70, 0x00, 0x70, 0xC0, 0x01, 0xC1, 0x80, 0x03, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x38, 0x1C, 0x00, 0xE0, 0x30, 0x01, 0x80, 0x60, 0x06, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x70, 0x07, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x38, 0x0E,
  0x00, 0x70, 0x38, 0x00, 0xE0, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0E, 0x0F, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x20, 0x01, 0xE0, 0xE0, 0x1F, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F,
  0x01, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x83, 0xC0, 0x0E, 0x3F, 0xC0, 0x3B, 0xFF,
  0xC0, 0xDC, 0x07, 0x07, 0xC0, 0x0E, 0x1E, 0x00, 0x38, 0x78, 0x00, 0xE1,
  0xC0, 0x01, 0x87, 0x00, 0x06, 0x1C, 0x00, 0x18, 0xE0, 0x00, 0xE3, 0x80,
  0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0x60, 0x01, 0xC1, 0x80, 0x07,
  0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xF0, 0x78, 0x01,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFC, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0x07, 0x80, 0x70, 0x07,
  0x03, 0x80, 0x1C, 0x0E, 0x00, 0x30, 0x30, 0x00, 0xC1, 0xC0, 0x03, 0x07,
  0x00, 0x0C, 0x1C, 0x00, 0x70, 0x30, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0x80,
  0x70, 0x07, 0x03, 0x80, 0x0E, 0x3C, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF8, 0x00, 0x3C, 0x70, 0x03, 0xC0, 0xE0, 0x1C, 0x01, 0xC0, 0xE0,
  0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x60, 0x00, 0x63, 0x80, 0x01,
  0xCE, 0x00, 0x07, 0x38, 0x00, 0x18, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x87,
  0x00, 0x1C, 0x1E, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0x7F, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x1E, 0x0F, 0x00, 0xF0,
  0x1E, 0x07, 0x80, 0x38, 0x1C, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x07,
  0x0C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C,
  0x00, 0x1C, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1E, 0x1C, 0x00,
  0x78, 0x38, 0x03, 0xE0, 0xF0, 0x3B, 0x81, 0xFF, 0xCC, 0x03, 0xFE, 0x70,
  0x03, 0xC1, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x80, 0x78, 0x03, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0x0F, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0xF0, 0xF0, 0xE0, 0x00, 0xE0, 0x0F, 0x01, 0xE0, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xFC, 0x3C, 0x1E, 0x20, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x01, 0x83, 0x00, 0x3F, 0xC0, 0xE3, 0x80,
  0x7F, 0xF0, 0x71, 0x80, 0x70, 0x30, 0x39, 0xC0, 0x70, 0x18, 0x0C, 0xC0,
  0x70, 0x1C, 0x0E, 0x60, 0x30, 0x0C, 0x07, 0x70, 0x38, 0x06, 0x03, 0xB0,
  0x18, 0x03, 0x01, 0x98, 0x1C, 0x03, 0x80, 0xCC, 0x0C, 0x01, 0x80, 0x6E,
  0x06, 0x00, 0xC0, 0x77, 0x07, 0x00, 0xE0, 0x33, 0x83, 0x80, 0x70, 0x19,
  0xC1, 0xC0, 0x38, 0x1C, 0xE0, 0xE0, 0x38, 0x0C, 0x70, 0x70, 0x3C, 0x0E,
  0x38, 0x18, 0x3B, 0x0E, 0x1C, 0x0F, 0x79, 0xDE, 0x0E, 0x03, 0xF8, 0xFE,
  0x03, 0x00, 0x70, 0x08, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xDC,
  0x00, 0x01, 0x9C, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x1C, 0x00, 0x07, 0x1C,
  0x00, 0x06, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x0C,
  0x00, 0x18, 0x0C, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x0E,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xC1, 0xFE,
  0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x07, 0x01, 0x80, 0x07, 0x03, 0x80, 0x03,
  0x03, 0x80, 0x03, 0x03, 0x80, 0x03, 0x03, 0x80, 0x07, 0x03, 0x00, 0x07,
  0x07, 0x00, 0x07, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x78,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0E, 0x00, 0xF0,
  0x0E, 0x00, 0x78, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x30, 0x00, 0x78, 0x70, 0x00, 0xF0,
  0x70, 0x01, 0xE0, 0x70, 0x3F, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x7C, 0x07, 0x00, 0xF0, 0x01,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x01, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x1C, 0x3F, 0xC0, 0x07, 0x00, 0x7C, 0x01, 0xC0,
  0x0F, 0x00, 0x60, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x07,
  0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x18, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x30,
  0x00, 0x06, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x78,
  0x70, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01,
  0xE0, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x0C, 0x00, 0x3C, 0x07, 0x00,
  0x1E, 0x01, 0xC0, 0x1F, 0x00, 0x70, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0x00,
  0x78, 0x00, 0x60, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x7F, 0xE3, 0x80, 0x0F, 0xFC, 0x70, 0x01, 0xFF, 0x8E, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x0E, 0x1C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x01, 0xE0, 0x01,
  0xC0, 0x1F, 0x80, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x01, 0x80, 0x70, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x0E, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x01, 0x80, 0x70, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0xE0, 0x18, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x30, 0x0E, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0xE0, 0x38, 0x00, 0x06, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00,
  0x00, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x78, 0x07, 0x00, 0x1E, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x01, 0xE0, 0x03, 0x00, 0x78, 0x00, 0xE0, 0x1E, 0x00,
  0x1C, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x0C, 0x0E,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x0E, 0xF8, 0x00, 0x01, 0xFB, 0x80,
  0x00, 0x3E, 0x70, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x38,
  0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x18, 0x07, 0x00,
  0x07, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x07, 0x00,
  0x70, 0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0x3E, 0x01, 0xB0, 0x00, 0x07, 0xE0, 0x1B, 0x00, 0x00, 0x7E,
  0x03, 0xB0, 0x00, 0x0E, 0xE0, 0x3B, 0x80, 0x00, 0xCC, 0x03, 0xB8, 0x00,
  0x1D, 0xC0, 0x33, 0x80, 0x01, 0x9C, 0x03, 0x38, 0x00, 0x39, 0xC0, 0x73,
  0x80, 0x03, 0x1C, 0x07, 0x18, 0x00, 0x71, 0x80, 0x71, 0x80, 0x0E, 0x38,
  0x06, 0x18, 0x00, 0xE3, 0x80, 0x61, 0x80, 0x1C, 0x38, 0x0E, 0x1C, 0x01,
  0xC3, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xC1,
  0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x06, 0x07, 0x01, 0xC0, 0xC0, 0xE0, 0x60,
  0x1C, 0x0C, 0x0C, 0x0E, 0x01, 0xC0, 0xC1, 0xC0, 0xE0, 0x18, 0x0C, 0x18,
  0x0E, 0x03, 0x80, 0xE3, 0x80, 0xE0, 0x38, 0x0E, 0x30, 0x0C, 0x03, 0x80,
  0xE7, 0x01, 0xC0, 0x30, 0x0E, 0xE0, 0x1C, 0x03, 0x00, 0x6E, 0x01, 0xC0,
  0x70, 0x07, 0xC0, 0x1C, 0x07, 0x00, 0x7C, 0x01, 0x80, 0x70, 0x07, 0x80,
  0x38, 0x06, 0x00, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0, 0x1F, 0x00, 0x03, 0x80, 0x7C,
  0x00, 0x0E, 0x01, 0xF0, 0x00, 0x38, 0x06, 0xE0, 0x00, 0xC0, 0x3B, 0x80,
  0x07, 0x00, 0xEE, 0x00, 0x1C, 0x03, 0x98, 0x00, 0x70, 0x0C, 0x70, 0x01,
  0xC0, 0x31, 0xC0, 0x06, 0x01, 0xC3, 0x00, 0x38, 0x07, 0x0E, 0x00, 0xE0,
  0x1C, 0x38, 0x03, 0x80, 0x60, 0x60, 0x0C, 0x01, 0x81, 0xC0, 0x30, 0x0E,
  0x07, 0x01, 0xC0, 0x38, 0x0C, 0x07, 0x00, 0xE0, 0x38, 0x1C, 0x03, 0x00,
  0xE0, 0x60, 0x1C, 0x01, 0x83, 0x80, 0x70, 0x07, 0x0E, 0x01, 0xC0, 0x1C,
  0x38, 0x07, 0x00, 0x30, 0xE0, 0x18, 0x00, 0xE3, 0x00, 0xE0, 0x03, 0x9C,
  0x03, 0x80, 0x0E, 0x70, 0x0E, 0x00, 0x1D, 0xC0, 0x30, 0x00, 0x76, 0x00,
  0xC0, 0x01, 0xD8, 0x07, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x0F, 0x80, 0x70,
  0x00, 0x3E, 0x01, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xE0, 0x7C,
  0x01, 0xE0, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x3C, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x07,
  0x07, 0x00, 0x03, 0x80, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x07, 0xC0,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x01, 0xC3, 0xFC, 0x01, 0xC0, 0x3C, 0x01, 0xC0, 0x0E, 0x01,
  0x80, 0x0E, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03,
  0x80, 0x07, 0x03, 0x00, 0x06, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07,
  0x00, 0x0E, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x3C, 0x0E, 0x00, 0x78, 0x0E,
  0x01, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x07, 0x00, 0xF0, 0x00,
  0xE0, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0,
  0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x38,
  0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x01,
  0xC0, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xC3,
  0xFC, 0x01, 0xC0, 0x3C, 0x01, 0xC0, 0x0E, 0x01, 0x80, 0x0E, 0x03, 0x80,
  0x0E, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x06, 0x03, 0x00,
  0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x1C, 0x07, 0x00,
  0x1C, 0x06, 0x00, 0x38, 0x0E, 0x00, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x1C, 0x06, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07,
  0x00, 0x1C, 0x07, 0x00, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x01, 0x80, 0x38, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0x70, 0x01,
  0xC0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xE0, 0x00,
  0x70, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0x70, 0x1E, 0x00,
  0x20, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x40, 0x03, 0xC0, 0xF0, 0x1F, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03,
  0x03, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x70, 0x70, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x30, 0x00,
  0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x06, 0x07,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x07, 0x03, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x1C, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x03, 0xC0,
  0x0E, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3B, 0x00, 0x00, 0xE7, 0x00, 0x01,
  0xCE, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70,
  0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x06,
  0x00, 0x70, 0x0C, 0x00, 0xE0, 0x18, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60,
  0x0C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x60, 0x03, 0x81, 0xC0, 0x07, 0x03,
  0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x70, 0x00, 0x70, 0xC0,
  0x00, 0x63, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x9C, 0x00, 0x03, 0x30, 0x00,
  0x06, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x7E, 0x00,
  0x0E, 0x00, 0x06, 0xE0, 0x00, 0xF0, 0x00, 0xEE, 0x00, 0x1F, 0x00, 0x0E,
  0xE0, 0x01, 0xF0, 0x01, 0xCE, 0x00, 0x3F, 0x00, 0x1C, 0xE0, 0x03, 0x70,
  0x03, 0x8E, 0x00, 0x77, 0x00, 0x38, 0xE0, 0x07, 0x70, 0x03, 0x0E, 0x00,
  0x67, 0x00, 0x70, 0xE0, 0x0E, 0x70, 0x07, 0x0E, 0x00, 0xC7, 0x00, 0xE0,
  0xE0, 0x1C, 0x70, 0x0E, 0x0E, 0x01, 0x87, 0x01, 0xC0, 0xE0, 0x38, 0x70,
  0x1C, 0x0E, 0x03, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x70, 0x38, 0x06, 0x07,
  0x07, 0x03, 0x00, 0x60, 0x60, 0x70, 0x70, 0x06, 0x0E, 0x03, 0x07, 0x00,
  0x60, 0xC0, 0x30, 0xE0, 0x06, 0x1C, 0x03, 0x0E, 0x00, 0x61, 0x80, 0x30,
  0xC0, 0x06, 0x38, 0x03, 0x1C, 0x00, 0x63, 0x80, 0x31, 0x80, 0x06, 0x70,
  0x03, 0x38, 0x00, 0x67, 0x00, 0x33, 0x80, 0x06, 0x60, 0x03, 0x70, 0x00,
  0x6E, 0x00, 0x37, 0x00, 0x06, 0xC0, 0x03, 0x60, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x78,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x03,
  0x80, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x38, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x3C,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x1C,
  0x00, 0x38, 0x70, 0x00, 0xE0, 0xC0, 0x07, 0x03, 0x80, 0x38, 0x0E, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0xE0, 0x07, 0x07, 0x00,
  0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0xC7, 0x00, 0x03, 0x1C, 0x00, 0x0E,
  0xE0, 0x00, 0x3B, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0x00, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x70,
  0x70, 0x70, 0x30, 0x30, 0x30, 0x30, 0x38, 0x38, 0x38, 0x18, 0x18, 0x18,
  0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x06, 0x06,
  0x06, 0x07, 0x07, 0x07, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xFC, 0x00, 0x06, 0x60, 0x00, 0x73, 0x00, 0x03, 0x1C, 0x00,
  0x38, 0x60, 0x03, 0x83, 0x80, 0x18, 0x0C, 0x01, 0xC0, 0x60, 0x0C, 0x03,
  0x80, 0xE0, 0x0C, 0x06, 0x00, 0x70, 0x70, 0x03, 0x87, 0x00, 0x0C, 0x38,
  0x00, 0x73, 0x80, 0x01, 0x98, 0x00, 0x0D, 0xC0, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0xC1, 0xC1, 0x83, 0x83, 0x80, 0x00, 0x08,
  0x00, 0x03, 0xFC, 0x70, 0x1F, 0xF9, 0x81, 0xF0, 0x66, 0x07, 0x00, 0xF8,
  0x38, 0x03, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0,
  0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x18, 0x70, 0x00, 0xE1, 0x80, 0x03,
  0x8E, 0x00, 0x0E, 0x38, 0x00, 0x30, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0x83, 0x80, 0x1E, 0x0E, 0x00,
  0xD8, 0x1C, 0x06, 0xE0, 0x78, 0x33, 0x80, 0xFF, 0x8C, 0x01, 0xFC, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x10, 0x01, 0xC3, 0xF8, 0x07, 0x3F,
  0xF0, 0x1D, 0xC1, 0xE0, 0x6E, 0x03, 0x81, 0xF0, 0x06, 0x0F, 0x80, 0x1C,
  0x3C, 0x00, 0x70, 0xF0, 0x01, 0xC3, 0x80, 0x07, 0x1E, 0x00, 0x1C, 0x70,
  0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x06, 0x18, 0x00, 0x38, 0xE0, 0x00,
  0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC7,
  0x80, 0x0E, 0x1E, 0x00, 0x38, 0x68, 0x01, 0xC1, 0xB0, 0x0E, 0x06, 0xE0,
  0xF0, 0x39, 0xFF, 0x80, 0xC3, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xF0,
  0x1F, 0xFC, 0x1F, 0x02, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x0C, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x08, 0x1C, 0x00, 0xFF, 0x1C, 0x03, 0xFF, 0x9C, 0x07,
  0xC1, 0xD8, 0x07, 0x00, 0xD8, 0x0E, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x1C,
  0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70,
  0x00, 0x70, 0x70, 0x00, 0x60, 0x60, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0,
  0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0,
  0x03, 0xC0, 0xE0, 0x07, 0xC0, 0xE0, 0x07, 0xC0, 0xE0, 0x0D, 0x80, 0x70,
  0x1D, 0x80, 0x78, 0x39, 0x80, 0x3F, 0xF3, 0x80, 0x1F, 0xC3, 0x00, 0x00,
  0x1C, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0x07, 0x07, 0x01, 0xC3, 0x80,
  0x31, 0xC0, 0x0C, 0x70, 0x03, 0x38, 0x01, 0xCE, 0x00, 0x77, 0x00, 0x39,
  0xC0, 0x3C, 0x70, 0xFE, 0x1F, 0xFE, 0x0F, 0xF8, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x0E, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x3F, 0xC3, 0x00, 0xFF, 0xE7, 0x01, 0xF0, 0x76, 0x01, 0xC0,
  0x36, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x1C, 0x0E, 0x00,
  0x1C, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x18, 0x18, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x78, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x38, 0x01,
  0xF0, 0x38, 0x01, 0xF0, 0x38, 0x03, 0x60, 0x1C, 0x07, 0xE0, 0x1E, 0x0E,
  0xE0, 0x0F, 0xFC, 0xE0, 0x07, 0xF0, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0xC0, 0x1E, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x40,
  0x0E, 0x3F, 0xC0, 0x73, 0xFF, 0x03, 0xB8, 0x3C, 0x1B, 0x00, 0xE0, 0xF0,
  0x07, 0x0F, 0x80, 0x38, 0x78, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x71,
  0xC0, 0x03, 0x8E, 0x00, 0x18, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x18, 0x00,
  0x71, 0xC0, 0x03, 0x8E, 0x00, 0x18, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x18,
  0x00, 0x71, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0x70, 0x01, 0xC3, 0x00, 0x0E,
  0x18, 0x00, 0x71, 0xC0, 0x03, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x80, 0x70,
  0x1C, 0x07, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01,
  0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x3F,
  0xC0, 0x0F, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0xF0, 0x70, 0x07, 0x03, 0x80, 0x70, 0x18, 0x07, 0x00, 0xC0, 0x70,
  0x0E, 0x07, 0x00, 0x70, 0x70, 0x03, 0x87, 0x00, 0x18, 0x70, 0x01, 0xC7,
  0x00, 0x0E, 0x70, 0x00, 0x77, 0x80, 0x03, 0x7E, 0x00, 0x1F, 0x70, 0x01,
  0xF3, 0x80, 0x0F, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x01, 0x80, 0x18, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x00, 0x70, 0x18,
  0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x00, 0x00,
  0x02, 0x00, 0x08, 0x01, 0xC7, 0xF0, 0x3F, 0xC0, 0x63, 0xFE, 0x1F, 0xF8,
  0x19, 0xC3, 0xCE, 0x0E, 0x06, 0xC0, 0x76, 0x01, 0xC1, 0xE0, 0x1F, 0x00,
  0x70, 0xF0, 0x03, 0xC0, 0x1C, 0x3C, 0x01, 0xE0, 0x07, 0x0E, 0x00, 0x78,
  0x01, 0xC3, 0x80, 0x1C, 0x00, 0x61, 0xC0, 0x07, 0x00, 0x38, 0x70, 0x01,
  0x80, 0x0E, 0x1C, 0x00, 0x60, 0x03, 0x87, 0x00, 0x38, 0x00, 0xE1, 0x80,
  0x0E, 0x00, 0x30, 0xE0, 0x03, 0x80, 0x1C, 0x38, 0x00, 0xC0, 0x07, 0x0E,
  0x00, 0x70, 0x01, 0xC3, 0x80, 0x1C, 0x00, 0x60, 0xC0, 0x07, 0x00, 0x18,
  0x70, 0x01, 0xC0, 0x0E, 0x1C, 0x00, 0x60, 0x03, 0x87, 0x00, 0x38, 0x00,
  0xE1, 0x80, 0x0E, 0x00, 0x30, 0x60, 0x03, 0x80, 0x1C, 0x38, 0x00, 0xC0,
  0x07, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x38, 0xFF, 0x01,
  0xCF, 0xFC, 0x0C, 0xE0, 0xF0, 0x6C, 0x03, 0x87, 0xC0, 0x1C, 0x3E, 0x00,
  0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x00, 0x0E, 0x38,
  0x00, 0x61, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x60, 0x01, 0xC7, 0x00, 0x0E,
  0x38, 0x00, 0x61, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x60, 0x01, 0xC7, 0x00,
  0x0C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0xC7,
  0x00, 0x0C, 0x38, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0x7C, 0x1E, 0x07, 0x00, 0xE0, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0,
  0x07, 0x38, 0x00, 0x73, 0x80, 0x03, 0x70, 0x00, 0x37, 0x00, 0x07, 0x70,
  0x00, 0x76, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x6E,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x38,
  0x70, 0x07, 0x87, 0x00, 0xF0, 0x3C, 0x1E, 0x01, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x40, 0x01, 0xC3, 0xF8, 0x01, 0x8F, 0xFC, 0x01, 0x9C,
  0x1E, 0x01, 0xB8, 0x0E, 0x01, 0xF0, 0x06, 0x03, 0xE0, 0x07, 0x03, 0xC0,
  0x07, 0x03, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x07, 0x80, 0x07, 0x07, 0x00,
  0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x1C, 0x0E, 0x00,
  0x1C, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0x70, 0x1B, 0x00,
  0xE0, 0x1B, 0x83, 0xC0, 0x39, 0xFF, 0x80, 0x38, 0xFF, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFC,
  0x30, 0x1F, 0xF9, 0xC1, 0xF0, 0x76, 0x07, 0x00, 0xD8, 0x38, 0x01, 0xE1,
  0xC0, 0x07, 0x87, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x00,
  0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x61, 0x80, 0x03, 0x8E, 0x00, 0x0E,
  0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38,
  0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x1F, 0x0E, 0x00, 0xD8, 0x1C, 0x07,
  0xE0, 0x78, 0x3B, 0x80, 0xFF, 0xCE, 0x01, 0xFC, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x02, 0x03, 0x8F, 0xC1,
  0x8F, 0xE0, 0xCE, 0x00, 0x6E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xE0, 0x7F, 0xFC,
  0x3C, 0x06, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE2, 0x00, 0x70, 0xE0,
  0x3C, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x01, 0xFF, 0xEF, 0xFF, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xFC, 0x0F, 0xE0, 0x0E, 0x00,
  0x38, 0x70, 0x01, 0xC3, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x0E,
  0x00, 0x38, 0x70, 0x01, 0xC3, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03,
  0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x00, 0x0E, 0x38, 0x00, 0x61, 0xC0,
  0x07, 0x0E, 0x00, 0x38, 0x60, 0x01, 0xC3, 0x00, 0x1E, 0x38, 0x00, 0xE1,
  0xC0, 0x0F, 0x0E, 0x00, 0x78, 0x70, 0x07, 0xC3, 0x80, 0x6E, 0x0E, 0x0E,
  0x60, 0x7F, 0xE3, 0x01, 0xFE, 0x18, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xE3, 0x80,
  0x38, 0xE0, 0x1C, 0x38, 0x07, 0x06, 0x03, 0x81, 0x80, 0xE0, 0x60, 0x70,
  0x18, 0x18, 0x06, 0x0E, 0x01, 0xC3, 0x00, 0x71, 0xC0, 0x1C, 0x60, 0x07,
  0x38, 0x01, 0xCC, 0x00, 0x77, 0x00, 0x1D, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x78,
  0x01, 0xF8, 0x03, 0xC0, 0x1D, 0xC0, 0x3E, 0x00, 0xEE, 0x01, 0xB0, 0x0E,
  0x70, 0x0D, 0x80, 0x73, 0x80, 0xEC, 0x03, 0x1C, 0x06, 0x60, 0x38, 0xE0,
  0x73, 0x01, 0x87, 0x03, 0x18, 0x1C, 0x38, 0x38, 0xC0, 0xE1, 0xC1, 0x86,
  0x0E, 0x0E, 0x1C, 0x30, 0x70, 0x70, 0xC1, 0xC3, 0x03, 0x8E, 0x0E, 0x38,
  0x1C, 0x60, 0x71, 0x80, 0xE7, 0x03, 0x9C, 0x07, 0x38, 0x1C, 0xC0, 0x39,
  0x80, 0xEE, 0x01, 0xDC, 0x07, 0x70, 0x0E, 0xC0, 0x3B, 0x00, 0x7E, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x03, 0x00, 0x38, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x70, 0x00, 0x30, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xEE, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x77, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x8C, 0x00, 0x0E, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x70, 0x07, 0x00, 0xE0, 0x1C,
  0x00, 0xE0, 0x70, 0x01, 0xC1, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xE0,
  0x1C, 0x00, 0x38, 0x03, 0x80, 0x06, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0x0E, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x70, 0x00,
  0x60, 0x0C, 0x00, 0x0C, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C,
  0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xC0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x0E, 0x00,
  0x00, 0x1F, 0x00, 0x0B, 0xFF, 0x00, 0xFC, 0xFE, 0x0F, 0x80, 0xFF, 0xE8,
  0x01, 0xFE, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 35, 11, 1, -35 },
  { 50, 12, 13, 16, 5, -35 },
  { 70, 26, 35, 27, 1, -35 },
  { 184, 22, 40, 24, 1, -37 },
  { 294, 29, 36, 34, 3, -35 },
  { 425, 25, 36, 28, 1, -36 },
  { 538, 5, 13, 9, 5, -35 },
  { 547, 14, 43, 13, 2, -35 },
  { 623, 14, 43, 13, -3, -35 },
  { 699, 18, 19, 23, 6, -37 },
  { 742, 21, 23, 25, 3, -29 },
  { 803, 8, 11, 10, -2, -5 },
  { 814, 12, 3, 14, 1, -15 },
  { 819, 4, 4, 10, 1, -4 },
  { 821, 22, 35, 16, -2, -35 },
  { 918, 21, 36, 24, 2, -36 },
  { 1013, 12, 35, 24, 7, -35 },
  { 1066, 23, 35, 24, 0, -35 },
  { 1167, 23, 35, 24, 0, -35 },
  { 1268, 23, 35, 24, 0, -35 },
  { 1369, 22, 35, 24, 1, -35 },
  { 1466, 22, 36, 24, 2, -36 },
  { 1565, 21, 35, 24, 4, -35 },
  { 1657, 22, 35, 24, 1, -35 },
  { 1754, 22, 35, 24, 1, -35 },
  { 1851, 8, 26, 10, 1, -26 },
  { 1877, 12, 32, 10, -2, -26 },
  { 1925, 21, 23, 25, 3, -29 },
  { 1986, 21, 12, 25, 3, -23 },
  { 2018, 21, 23, 25, 3, -29 },
  { 2079, 16, 35, 18, 3, -35 },
  { 2149, 33, 39, 36, 2, -35 },
  { 2310, 24, 35, 24, -3, -35 },
  { 2415, 24, 35, 26, 1, -35 },
  { 2520, 24, 35, 25, 3, -35 },
  { 2625, 26, 35, 29, 1, -35 },
  { 2739, 23, 35, 23, 1, -35 },
  { 2840, 23, 35, 21, 1, -35 },
  { 2941, 27, 35, 30, 3, -35 },
  { 3060, 29, 35, 29, 1, -35 },
  { 3187, 17, 35, 13, -1, -35 },
  { 3262, 20, 44, 11, -8, -35 },
  { 3372, 27, 35, 24, 1, -35 },
  { 3491, 16, 35, 21, 1, -35 },
  { 3561, 36, 35, 37, 1, -35 },
  { 3719, 30, 35, 30, 1, -35 },
  { 3851, 26, 36, 31, 3, -36 },
  { 3968, 24, 35, 24, 1, -35 },
  { 4073, 26, 44, 31, 3, -36 },
  { 4216, 24, 35, 25, 1, -35 },
  { 4321, 23, 35, 22, 0, -35 },
  { 4422, 21, 35, 21, 4, -35 },
  { 4514, 27, 35, 29, 3, -35 },
  { 4633, 23, 35, 24, 5, -35 },
  { 4734, 36, 35, 37, 5, -35 },
  { 4892, 29, 35, 22, -3, -35 },
  { 5019, 22, 35, 21, 4, -35 },
  { 5116, 26, 35, 22, -1, -35 },
  { 5230, 19, 43, 14, -1, -35 },
  { 5333, 8, 35, 16, 5, -35 },
  { 5368, 18, 43, 14, -3, -35 },
  { 5465, 21, 20, 25, 2, -35 },
  { 5518, 17, 2, 17, -4, 5 },
  { 5523, 7, 7, 12, 7, -37 },
  { 5530, 22, 27, 25, 2, -27 },
  { 5605, 22, 37, 25, 1, -37 },
  { 5707, 18, 27, 19, 2, -27 },
  { 5768, 24, 37, 25, 2, -37 },
  { 5879, 18, 27, 22, 2, -27 },
  { 5940, 25, 49, 13, -6, -37 },
  { 6094, 24, 39, 25, 0, -27 },
  { 6211, 21, 37, 24, 1, -37 },
  { 6309, 10, 36, 10, 1, -36 },
  { 6354, 18, 48, 10, -7, -36 },
  { 6462, 21, 37, 20, 1, -37 },
  { 6560, 11, 37, 10, 1, -37 },
  { 6611, 34, 27, 37, 1, -27 },
  { 6726, 21, 27, 24, 1, -27 },
  { 6797, 20, 27, 24, 2, -27 },
  { 6865, 24, 38, 25, -1, -27 },
  { 6979, 22, 39, 25, 2, -27 },
  { 7087, 17, 27, 17, 1, -27 },
  { 7145, 18, 27, 19, 0, -27 },
  { 7206, 13, 32, 14, 2, -32 },
  { 7258, 21, 26, 25, 2, -26 },
  { 7327, 18, 26, 19, 3, -26 },
  { 7386, 29, 26, 30, 3, -26 },
  { 7481, 23, 26, 20, -2, -26 },
  { 7556, 27, 38, 19, -5, -26 },
  { 7685, 20, 26, 18, -1, -26 },
  { 7750, 18, 43, 16, 1, -35 },
  { 7847, 2, 49, 23, 11, -37 },
  { 7860, 18, 43, 16, -3, -35 },
  { 7957, 21, 5, 25, 3, -20 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC49PT7B_H_
