#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC23PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x21, 0x86, 0x10, 0x41, 0x0C, 0x20, 0x82, 0x08, 0x00, 0x04,
  0x30, 0x65, 0x34, 0x92, 0x4A, 0x20, 0x02, 0x30, 0x11, 0x00, 0x88, 0x08,
  0x43, 0xFF, 0x9F, 0xFC, 0x21, 0x01, 0x10, 0x08, 0x80, 0x84, 0x3F, 0xF8,
  0x22, 0x01, 0x10, 0x10, 0x80, 0x88, 0x04, 0x40, 0x02, 0x00, 0x81, 0xFC,
  0x90, 0x24, 0x09, 0x02, 0x40, 0xD0, 0x1C, 0x03, 0x80, 0x90, 0x24, 0x09,
  0x04, 0x49, 0x63, 0xF0, 0x10, 0x08, 0x00, 0x18, 0x03, 0x60, 0x91, 0x09,
  0x08, 0x88, 0x44, 0x42, 0x42, 0x24, 0x11, 0x2E, 0x9A, 0xCC, 0xA4, 0x59,
  0x62, 0x12, 0x11, 0x90, 0x88, 0x8C, 0x84, 0x4C, 0x26, 0xC1, 0xE0, 0x03,
  0x80, 0x6C, 0x0C, 0x40, 0x84, 0x08, 0x40, 0x8C, 0x09, 0x80, 0x60, 0x0C,
  0x01, 0x21, 0x23, 0x14, 0x12, 0x41, 0xAC, 0x0C, 0x40, 0xC6, 0x34, 0x3E,
  0x20, 0x69, 0x25, 0x00, 0x0E, 0x10, 0x41, 0x82, 0x0C, 0x10, 0x20, 0xC1,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x01, 0x02, 0x00, 0x04, 0x0C,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x18, 0x20, 0x41, 0x82, 0x0C,
  0x10, 0x41, 0x86, 0x00, 0x08, 0x08, 0xC8, 0x3F, 0x10, 0x28, 0xC8, 0x84,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x3F, 0xF0, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x32, 0x24, 0x48, 0xF8, 0x70, 0x00, 0x40, 0x20, 0x18, 0x04,
  0x03, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x18,
  0x04, 0x03, 0x00, 0x07, 0x03, 0x61, 0x08, 0xC3, 0x20, 0x58, 0x14, 0x0D,
  0x03, 0xC0, 0xF0, 0x28, 0x0A, 0x06, 0x81, 0x20, 0x4C, 0x21, 0x18, 0x7C,
  0x00, 0x1C, 0xE4, 0xA2, 0x08, 0x61, 0x04, 0x10, 0xC3, 0x08, 0x20, 0x86,
  0x10, 0x03, 0x01, 0xB8, 0x41, 0x00, 0x30, 0x06, 0x00, 0x80, 0x10, 0x04,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0xFF,
  0x80, 0x03, 0x03, 0xB8, 0x41, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x0C,
  0x1E, 0x00, 0x30, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x64, 0x18, 0xFE,
  0x00, 0x00, 0x60, 0x18, 0x03, 0x00, 0xA0, 0x24, 0x0D, 0x83, 0x20, 0x44,
  0x10, 0x84, 0x11, 0x86, 0x20, 0x8F, 0xFE, 0x02, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0x0F, 0xE1, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x0F, 0xC1, 0x0C,
  0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x20, 0xC3, 0xF0, 0x01,
  0xC1, 0x90, 0x80, 0x40, 0x20, 0x08, 0x06, 0x01, 0x7C, 0x61, 0xB0, 0x2C,
  0x0B, 0x02, 0x80, 0xA0, 0x6C, 0x11, 0x08, 0x3C, 0x00, 0xFF, 0xC0, 0x20,
  0x10, 0x04, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0,
  0x20, 0x10, 0x04, 0x02, 0x00, 0x07, 0x07, 0x63, 0x0C, 0x81, 0x20, 0x48,
  0x33, 0x18, 0x6C, 0x0C, 0x0C, 0x84, 0x12, 0x06, 0x81, 0xA0, 0x68, 0x13,
  0x0C, 0x7E, 0x00, 0x06, 0x06, 0xE3, 0x08, 0x83, 0x60, 0xD0, 0x34, 0x0D,
  0x02, 0x41, 0x88, 0xA1, 0xC8, 0x04, 0x01, 0x00, 0x80, 0x60, 0x30, 0xF8,
  0x00, 0x13, 0x00, 0x00, 0x00, 0x00, 0x4C, 0x08, 0x40, 0x00, 0x00, 0x00,
  0x01, 0x88, 0xC4, 0x22, 0x00, 0x00, 0xC0, 0xE0, 0xC0, 0xC0, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x01, 0xC0, 0x10, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x60, 0x60, 0x60,
  0x60, 0x20, 0x00, 0x1C, 0x7E, 0x03, 0x01, 0x01, 0x03, 0x02, 0x0C, 0x18,
  0x10, 0x20, 0x20, 0x40, 0x00, 0x00, 0xC0, 0xC0, 0x03, 0xF8, 0x18, 0x08,
  0x60, 0x19, 0x80, 0x12, 0x1F, 0x28, 0x44, 0x51, 0x08, 0xE2, 0x11, 0x88,
  0x63, 0x10, 0x86, 0x21, 0x14, 0x46, 0x28, 0xD7, 0x90, 0x40, 0x10, 0x00,
  0x20, 0x00, 0x30, 0x40, 0x3F, 0x80, 0x00, 0xC0, 0x38, 0x05, 0x01, 0x20,
  0x24, 0x08, 0x83, 0x10, 0x42, 0x18, 0x43, 0xF8, 0xC1, 0x10, 0x26, 0x06,
  0x80, 0xF0, 0x1C, 0x01, 0x1F, 0xC2, 0x0C, 0x40, 0x98, 0x12, 0x06, 0x40,
  0x88, 0x63, 0xF0, 0x61, 0x88, 0x19, 0x03, 0x20, 0x6C, 0x0D, 0x03, 0x20,
  0xC7, 0xF0, 0x01, 0xC0, 0x7F, 0x0C, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60,
  0x03, 0x08, 0x1F, 0x80, 0x1F, 0xC1, 0x06, 0x10, 0x23, 0x03, 0x20, 0x32,
  0x03, 0x20, 0x36, 0x03, 0x60, 0x24, 0x02, 0x40, 0x64, 0x04, 0xC0, 0xC8,
  0x18, 0x87, 0x0F, 0xC0, 0x1F, 0xC4, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02,
  0x09, 0xFC, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x03, 0xF8,
  0x1F, 0xC4, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x7F, 0x10,
  0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x01, 0xC0, 0x3F, 0xC3,
  0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x0F,
  0xB0, 0x09, 0x80, 0x44, 0x02, 0x20, 0x31, 0x81, 0x06, 0x08, 0x1F, 0xC0,
  0x10, 0x18, 0x80, 0xC4, 0x04, 0x60, 0x22, 0x01, 0x10, 0x18, 0x80, 0x8F,
  0xFC, 0x60, 0x22, 0x01, 0x10, 0x18, 0x80, 0x8C, 0x04, 0x60, 0x22, 0x03,
  0x10, 0x18, 0x0F, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x18,
  0x18, 0x10, 0x10, 0x10, 0x30, 0xF8, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10,
  0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08,
  0x04, 0x06, 0x02, 0x1E, 0x00, 0x10, 0x31, 0x04, 0x10, 0x83, 0x10, 0x23,
  0x02, 0x60, 0x2C, 0x07, 0xC0, 0x64, 0x04, 0x40, 0x46, 0x04, 0x20, 0xC3,
  0x08, 0x10, 0x81, 0x08, 0x18, 0x10, 0x20, 0x41, 0x82, 0x04, 0x08, 0x30,
  0x60, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x7F, 0x18, 0x03, 0x18, 0x07, 0x18,
  0x07, 0x38, 0x0F, 0x2C, 0x0A, 0x2C, 0x12, 0x24, 0x12, 0x64, 0x26, 0x44,
  0x24, 0x44, 0x44, 0x44, 0x44, 0x44, 0x84, 0xC5, 0x8C, 0x87, 0x08, 0x87,
  0x08, 0x82, 0x08, 0x18, 0x08, 0xC0, 0x46, 0x06, 0x78, 0x22, 0x41, 0x12,
  0x08, 0x98, 0x4C, 0x46, 0x42, 0x22, 0x19, 0x10, 0x48, 0x82, 0x4C, 0x1E,
  0x40, 0x62, 0x03, 0x10, 0x18, 0x01, 0x80, 0x7F, 0x06, 0x0C, 0x20, 0x22,
  0x01, 0x90, 0x0D, 0x80, 0x68, 0x03, 0x40, 0x1A, 0x00, 0xB0, 0x05, 0x80,
  0x6C, 0x02, 0x20, 0x31, 0x01, 0x04, 0x38, 0x1F, 0x00, 0x1F, 0x82, 0x18,
  0x41, 0x18, 0x32, 0x04, 0x40, 0x88, 0x33, 0x0C, 0x7F, 0x08, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x01, 0x80, 0x7F, 0x06, 0x0C,
  0x20, 0x22, 0x01, 0x90, 0x0D, 0x80, 0x68, 0x03, 0x40, 0x1A, 0x00, 0xB0,
  0x05, 0x80, 0x6C, 0x02, 0x20, 0x31, 0x01, 0x04, 0x30, 0x1F, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x1F, 0x82, 0x08, 0x41, 0x18, 0x32,
  0x04, 0x40, 0x88, 0x33, 0x0C, 0x7E, 0x08, 0xC1, 0x08, 0x21, 0x0C, 0x31,
  0x82, 0x20, 0x44, 0x0C, 0x03, 0x81, 0xFC, 0x60, 0x18, 0x03, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x03, 0x00,
  0x64, 0x18, 0xFE, 0x00, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00,
  0x10, 0x08, 0x80, 0xCC, 0x04, 0x40, 0x22, 0x01, 0x10, 0x18, 0x80, 0xCC,
  0x04, 0x40, 0x22, 0x01, 0x10, 0x18, 0x80, 0x8C, 0x04, 0x20, 0x61, 0x86,
  0x07, 0xE0, 0x80, 0x78, 0x0B, 0x03, 0x60, 0x44, 0x18, 0x82, 0x10, 0xC2,
  0x10, 0x46, 0x08, 0x81, 0x30, 0x24, 0x05, 0x80, 0xA0, 0x1C, 0x03, 0x00,
  0xC0, 0xC0, 0xE0, 0xE0, 0xB0, 0x70, 0x48, 0x78, 0x64, 0x2C, 0x22, 0x16,
  0x31, 0x11, 0x10, 0x88, 0x88, 0x48, 0x48, 0x24, 0x24, 0x16, 0x16, 0x0A,
  0x0A, 0x05, 0x07, 0x03, 0x03, 0x01, 0x81, 0x80, 0x80, 0x80, 0x08, 0x18,
  0x41, 0x83, 0x08, 0x08, 0x80, 0x48, 0x03, 0xC0, 0x0C, 0x00, 0x40, 0x07,
  0x00, 0x68, 0x02, 0x40, 0x22, 0x03, 0x18, 0x30, 0x41, 0x02, 0x10, 0x18,
  0xC0, 0xF0, 0x64, 0x11, 0x0C, 0x42, 0x19, 0x02, 0xC0, 0xA0, 0x30, 0x0C,
  0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x1F, 0xF0, 0x06, 0x00,
  0x40, 0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10,
  0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x8F, 0xF0, 0x0F, 0x08, 0x18, 0x10,
  0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40,
  0xC0, 0x80, 0x80, 0xF0, 0xC4, 0x44, 0x44, 0x62, 0x22, 0x22, 0x31, 0x11,
  0x0F, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x1F, 0x00, 0x06,
  0x02, 0x80, 0xA0, 0x44, 0x31, 0x08, 0x46, 0x09, 0x02, 0x80, 0xC0, 0xFF,
  0xC9, 0x90, 0x1F, 0x4C, 0x56, 0x09, 0x02, 0x40, 0xB0, 0x28, 0x1A, 0x04,
  0x81, 0x20, 0xCC, 0x51, 0xEC, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00,
  0x2F, 0x86, 0x11, 0x83, 0x30, 0x64, 0x0C, 0x81, 0x90, 0x26, 0x04, 0xC1,
  0x98, 0x23, 0x08, 0xDE, 0x00, 0x1F, 0x30, 0x60, 0x40, 0xC0, 0xC0, 0x80,
  0x80, 0x80, 0xC0, 0x42, 0x7C, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04,
  0x3E, 0x8C, 0x53, 0x06, 0x40, 0x88, 0x13, 0x02, 0x40, 0xC8, 0x19, 0x02,
  0x20, 0xC6, 0x28, 0x79, 0x00, 0x1F, 0x18, 0xD8, 0x68, 0x24, 0x37, 0xE2,
  0x01, 0x00, 0x80, 0x60, 0x10, 0x8F, 0xC0, 0x00, 0x60, 0x0F, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x30, 0x0F, 0xC0, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x10, 0x01, 0x00, 0xF0, 0x04, 0x00, 0x0F, 0xA3, 0x14, 0xC1, 0x90,
  0x22, 0x04, 0xC0, 0x90, 0x32, 0x06, 0x40, 0x88, 0x31, 0x8A, 0x1E, 0xC0,
  0x10, 0x02, 0x00, 0x40, 0x10, 0xFE, 0x02, 0x00, 0x08, 0x02, 0x00, 0x80,
  0x60, 0x10, 0x05, 0xF1, 0x84, 0xC1, 0x30, 0x48, 0x12, 0x04, 0x83, 0x60,
  0x90, 0x24, 0x09, 0x02, 0xC1, 0x80, 0x08, 0x40, 0x00, 0x08, 0x46, 0x31,
  0x08, 0x46, 0x21, 0x08, 0xC0, 0x01, 0x01, 0x00, 0x00, 0x00, 0x02, 0x02,
  0x02, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10,
  0x10, 0x10, 0xE0, 0x40, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x31,
  0x18, 0xCC, 0x36, 0x09, 0x02, 0xC0, 0xD0, 0x66, 0x10, 0x84, 0x21, 0x0C,
  0xC1, 0x00, 0x08, 0x42, 0x31, 0x08, 0x46, 0x31, 0x08, 0x46, 0x21, 0x08,
  0xC0, 0x17, 0x9F, 0x18, 0x61, 0x30, 0x61, 0x30, 0x41, 0x20, 0xC1, 0x20,
  0x83, 0x20, 0x83, 0x60, 0x82, 0x40, 0x82, 0x41, 0x82, 0x41, 0x06, 0xC1,
  0x04, 0x17, 0xC6, 0x13, 0x04, 0xC1, 0x20, 0x48, 0x12, 0x0D, 0x82, 0x40,
  0x90, 0x24, 0x1B, 0x06, 0x1F, 0x18, 0x58, 0x28, 0x1C, 0x0E, 0x06, 0x03,
  0x01, 0x81, 0xC0, 0x90, 0x8F, 0x80, 0x0B, 0xE0, 0xC2, 0x1C, 0x31, 0x83,
  0x10, 0x31, 0x03, 0x10, 0x23, 0x02, 0x30, 0x63, 0x04, 0x30, 0x82, 0xF0,
  0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x00, 0x1F, 0x4C, 0x56, 0x0D,
  0x02, 0x40, 0xB0, 0x28, 0x1A, 0x06, 0x81, 0x20, 0xCC, 0x51, 0xEC, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x06, 0x00, 0x17, 0x8C, 0x0C, 0x06, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x00, 0x1F, 0x20, 0x20, 0x20,
  0x30, 0x18, 0x0C, 0x06, 0x02, 0x02, 0x86, 0xFC, 0x10, 0xC2, 0x3F, 0x21,
  0x84, 0x10, 0x41, 0x0C, 0x20, 0x82, 0x0F, 0x00, 0x20, 0x48, 0x36, 0x09,
  0x02, 0x40, 0x90, 0x64, 0x1B, 0x04, 0x83, 0x20, 0xCC, 0x51, 0xE8, 0xC1,
  0xE0, 0xB0, 0xC8, 0x44, 0x62, 0x21, 0x30, 0x90, 0x58, 0x28, 0x1C, 0x0C,
  0x00, 0xC3, 0x07, 0x0C, 0x2C, 0x50, 0xB1, 0x44, 0xCD, 0x13, 0x24, 0xC5,
  0x92, 0x14, 0x58, 0x51, 0x41, 0x85, 0x06, 0x18, 0x10, 0x60, 0x10, 0x63,
  0x18, 0x22, 0x04, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x50, 0x12, 0x04, 0x21,
  0x84, 0x60, 0xC0, 0x18, 0x30, 0x82, 0x08, 0x60, 0x84, 0x08, 0xC0, 0x88,
  0x09, 0x80, 0x90, 0x0B, 0x00, 0xA0, 0x0E, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x00, 0xE0, 0x0C, 0x00, 0x1F, 0xC0, 0x20, 0x10, 0x0C, 0x06,
  0x01, 0x00, 0x80, 0x60, 0x10, 0x08, 0x06, 0x03, 0xFC, 0x03, 0x82, 0x01,
  0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x10, 0x30, 0x2C, 0x02, 0x01, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0x0E,
  0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x03, 0x04, 0x08, 0x08,
  0x08, 0x18, 0x10, 0x10, 0x30, 0x60, 0x80, 0x7C, 0x61, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 16, 5, 0, -16 },
  { 13, 6, 6, 8, 2, -16 },
  { 18, 13, 16, 13, 0, -16 },
  { 44, 10, 18, 11, 1, -17 },
  { 67, 13, 17, 16, 2, -17 },
  { 95, 12, 17, 13, 0, -17 },
  { 121, 3, 6, 4, 2, -16 },
  { 124, 7, 20, 6, 1, -16 },
  { 142, 7, 20, 6, -2, -16 },
  { 160, 8, 8, 11, 3, -17 },
  { 168, 10, 11, 12, 1, -14 },
  { 182, 4, 6, 5, -1, -3 },
  { 185, 5, 1, 7, 1, -7 },
  { 186, 2, 2, 5, 0, -2 },
  { 187, 10, 16, 7, -1, -16 },
  { 207, 10, 17, 11, 1, -17 },
  { 229, 6, 16, 11, 3, -16 },
  { 241, 11, 17, 11, 0, -17 },
  { 265, 11, 17, 11, 0, -17 },
  { 289, 11, 17, 11, 0, -17 },
  { 313, 11, 16, 11, 0, -16 },
  { 335, 10, 17, 11, 1, -17 },
  { 357, 10, 16, 11, 2, -16 },
  { 377, 10, 17, 11, 1, -17 },
  { 399, 10, 17, 11, 1, -17 },
  { 421, 4, 12, 5, 0, -12 },
  { 427, 5, 15, 5, -1, -12 },
  { 437, 10, 10, 12, 1, -13 },
  { 450, 10, 6, 12, 1, -11 },
  { 458, 10, 10, 12, 1, -13 },
  { 471, 8, 17, 8, 1, -17 },
  { 488, 15, 18, 17, 1, -16 },
  { 522, 11, 16, 11, -1, -16 },
  { 544, 11, 16, 12, 1, -16 },
  { 566, 12, 17, 12, 1, -17 },
  { 592, 12, 16, 13, 1, -16 },
  { 616, 10, 16, 11, 1, -16 },
  { 636, 10, 16, 10, 1, -16 },
  { 656, 13, 17, 14, 1, -17 },
  { 684, 13, 16, 14, 1, -16 },
  { 710, 8, 16, 6, -1, -16 },
  { 726, 9, 20, 5, -4, -16 },
  { 749, 12, 16, 11, 1, -16 },
  { 773, 7, 16, 10, 1, -16 },
  { 787, 16, 16, 17, 1, -16 },
  { 819, 13, 16, 14, 1, -16 },
  { 845, 13, 17, 14, 1, -17 },
  { 873, 11, 16, 11, 1, -16 },
  { 895, 13, 21, 14, 1, -17 },
  { 930, 11, 16, 12, 1, -16 },
  { 952, 11, 17, 10, 0, -17 },
  { 976, 10, 16, 10, 2, -16 },
  { 996, 13, 16, 14, 1, -16 },
  { 1022, 11, 16, 11, 2, -16 },
  { 1044, 17, 16, 18, 2, -16 },
  { 1078, 13, 16, 10, -1, -16 },
  { 1104, 10, 16, 10, 2, -16 },
  { 1124, 12, 16, 10, 0, -16 },
  { 1148, 8, 20, 7, 0, -16 },
  { 1168, 4, 16, 8, 2, -16 },
  { 1176, 9, 20, 7, -2, -16 },
  { 1199, 10, 9, 12, 1, -16 },
  { 1211, 8, 1, 8, -2, 2 },
  { 1212, 3, 4, 6, 3, -18 },
  { 1214, 10, 12, 12, 1, -12 },
  { 1229, 11, 17, 12, 0, -17 },
  { 1253, 8, 12, 9, 1, -12 },
  { 1265, 11, 17, 12, 1, -17 },
  { 1289, 9, 12, 10, 1, -12 },
  { 1303, 12, 24, 6, -3, -18 },
  { 1339, 11, 18, 12, 0, -12 },
  { 1364, 10, 17, 11, 0, -17 },
  { 1386, 5, 17, 5, 0, -17 },
  { 1397, 8, 23, 5, -3, -17 },
  { 1420, 10, 17, 10, 0, -17 },
  { 1442, 5, 17, 5, 0, -17 },
  { 1453, 16, 12, 17, 0, -12 },
  { 1477, 10, 12, 11, 0, -12 },
  { 1492, 9, 12, 11, 1, -12 },
  { 1506, 12, 17, 12, -1, -12 },
  { 1532, 10, 17, 12, 1, -12 },
  { 1554, 9, 12, 8, 0, -12 },
  { 1568, 8, 12, 9, 0, -12 },
  { 1580, 6, 15, 6, 1, -15 },
  { 1592, 10, 12, 12, 1, -12 },
  { 1607, 9, 12, 9, 1, -12 },
  { 1621, 14, 12, 14, 1, -12 },
  { 1642, 11, 12, 9, -1, -12 },
  { 1659, 12, 18, 9, -2, -12 },
  { 1686, 10, 12, 9, -1, -12 },
  { 1701, 9, 20, 8, 0, -16 },
  { 1724, 1, 24, 11, 5, -18 },
  { 1727, 8, 20, 8, -1, -16 },
  { 1747, 10, 2, 12, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC23PT7B_H_
