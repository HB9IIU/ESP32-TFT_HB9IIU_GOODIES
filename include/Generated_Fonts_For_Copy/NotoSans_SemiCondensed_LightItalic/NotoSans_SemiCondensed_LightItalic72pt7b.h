#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC72PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x03, 0x00, 0x00, 0x1E, 0x07, 0xCF, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E,
  0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0E, 0x1E,
  0x03, 0x87, 0x01, 0xE1, 0xC0, 0x78, 0x70, 0x1C, 0x3C, 0x07, 0x0E, 0x01,
  0xC3, 0x80, 0x70, 0xE0, 0x38, 0x30, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x78, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0x1C, 0x3E, 0x00, 0xFC, 0x1C, 0x06, 0x00,
  0xF0, 0x38, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03,
  0xC0, 0x60, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x00,
  0xF8, 0xE0, 0x00, 0x00, 0xFC, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x9F, 0x80, 0x00,
  0x03, 0x8F, 0xC0, 0x00, 0x03, 0x87, 0xC0, 0x00, 0x03, 0x03, 0xE0, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x06, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0E, 0x07, 0xC0, 0x80,
  0x1C, 0x0F, 0x80, 0xC0, 0x1C, 0x1F, 0x00, 0xFC, 0x1C, 0x7E, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0x80, 0x1F, 0xFC, 0x00, 0x01, 0xE0, 0x0F,
  0x0F, 0x80, 0x00, 0xF0, 0x07, 0x81, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x38,
  0x00, 0x1E, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x03,
  0x80, 0x1C, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x03, 0x80, 0x07, 0x80, 0x0E, 0x01,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0x70, 0x01, 0xE0, 0x38, 0x00,
  0x3C, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC0,
  0x0F, 0x03, 0x80, 0x00, 0xF0, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x00, 0xE0,
  0xF0, 0x7F, 0x8E, 0x00, 0x78, 0x38, 0x3F, 0xF3, 0x80, 0x1E, 0x1E, 0x1F,
  0xFE, 0xF0, 0x07, 0x0F, 0x0F, 0x87, 0xFC, 0x03, 0xC3, 0xC7, 0x80, 0xFF,
  0x01, 0xE1, 0xE1, 0xE0, 0x3D, 0xC0, 0xF8, 0x70, 0xF0, 0x07, 0x78, 0x7C,
  0x3C, 0x38, 0x01, 0xCF, 0xFE, 0x1E, 0x1E, 0x00, 0x73, 0xFF, 0x07, 0x07,
  0x80, 0x1C, 0x3F, 0x03, 0xC1, 0xC0, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x01,
  0xC0, 0x00, 0x70, 0x3C, 0x00, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x00,
  0x1E, 0x03, 0x80, 0x0F, 0x00, 0x07, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x78, 0x00, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x3C, 0x01, 0xE0,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x00, 0x1C,
  0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x07, 0x00, 0x01, 0xE0, 0x78,
  0x03, 0xC0, 0x00, 0x3E, 0xFC, 0x01, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00,
  0x07, 0xBF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x07,
  0x83, 0xE0, 0x7C, 0x00, 0x78, 0x3E, 0x01, 0xE0, 0x03, 0xC3, 0xE0, 0x0F,
  0x80, 0x1E, 0x3E, 0x00, 0x3C, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0x0F, 0x1E,
  0x00, 0x07, 0x80, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x8F, 0x00, 0x00, 0xF8,
  0x78, 0x78, 0x00, 0x03, 0xC7, 0x83, 0xC0, 0x00, 0x1F, 0x7C, 0x1E, 0x00,
  0x00, 0x7B, 0xC0, 0xF0, 0x00, 0x03, 0xFC, 0x07, 0x80, 0x00, 0x0F, 0xE0,
  0x3C, 0x00, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00,
  0x3F, 0x80, 0x7C, 0x00, 0x03, 0xFE, 0x03, 0xE0, 0x00, 0x7E, 0xF0, 0x0F,
  0x80, 0x07, 0xC7, 0xC0, 0x7F, 0x00, 0xFC, 0x1E, 0x01, 0xFF, 0xFF, 0xC0,
  0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x7C, 0xF1, 0xE3, 0xC7, 0x8E, 0x3C, 0x78,
  0xF1, 0xC3, 0x87, 0x1E, 0x38, 0x70, 0xE1, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x38, 0x00, 0x78, 0x07, 0x00,
  0x1F, 0xC0, 0xE0, 0x01, 0xFC, 0x18, 0x00, 0x0F, 0xE3, 0x00, 0x00, 0x3F,
  0xE1, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x03, 0x80, 0x0F, 0x80, 0x78, 0x01,
  0xF0, 0x0F, 0x00, 0x1C, 0x00, 0xF0, 0x01, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70,
  0x1E, 0x03, 0x80, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7B, 0xFF, 0xFE, 0xFB, 0xE6, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0x3F, 0x80, 0x03, 0xF0,
  0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x7C, 0x78, 0x00,
  0x00, 0xF1, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF8, 0x07, 0x80, 0x01, 0xE0,
  0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0xFD, 0xE0, 0xFC, 0xF0,
  0x7E, 0x3C, 0x3F, 0x0F, 0x3F, 0x03, 0xCF, 0x81, 0xE1, 0x80, 0x78, 0x40,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xE7,
  0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x03, 0x00,
  0x00, 0xF8, 0x00, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x08,
  0x00, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1C, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x01, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x04, 0x00,
  0x00, 0x7C, 0x03, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0xE0, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x7F,
  0x00, 0x07, 0x83, 0xFF, 0xC0, 0x0F, 0x1F, 0xFF, 0xC0, 0x1E, 0x7F, 0xFF,
  0xC0, 0x79, 0xE0, 0x0F, 0xC0, 0xF7, 0x00, 0x0F, 0x81, 0xFC, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1E, 0x1F, 0x80, 0x00, 0x3C,
  0x3E, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF8, 0x78,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF0, 0x0F, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3C, 0x03, 0xF0,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFE, 0x3E, 0x00, 0x03, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x80,
  0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x0F, 0x87, 0x80, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x03,
  0xF8, 0x1E, 0x00, 0x0F, 0xF0, 0x3E, 0x00, 0x3D, 0xE0, 0x3F, 0x01, 0xF3,
  0x80, 0x3F, 0xFF, 0xCF, 0x00, 0x3F, 0xFF, 0x1E, 0x00, 0x3F, 0xF8, 0x3C,
  0x00, 0x02, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0xC0, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01,
  0xE0, 0x04, 0x00, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F,
  0x00, 0x7E, 0x08, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0x07, 0x80, 0x03, 0xFF,
  0xF0, 0x07, 0x07, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0x0F, 0x00, 0x1F, 0x80,
  0xF0, 0x07, 0x0E, 0x00, 0x3E, 0x00, 0xE0, 0x07, 0x1E, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x1C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x3C, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0x38, 0x01, 0xE0, 0x01,
  0xC0, 0x07, 0x38, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x78, 0x03, 0xC0, 0x03,
  0xC0, 0x0F, 0x78, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x78, 0x07, 0x80, 0x03,
  0x80, 0x0E, 0x70, 0x07, 0x00, 0x07, 0x80, 0x1E, 0x70, 0x07, 0x00, 0x07,
  0x80, 0x1E, 0xF0, 0x07, 0x00, 0x07, 0x00, 0x1C, 0xF0, 0x0F, 0x00, 0x0F,
  0x00, 0x1C, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0xF0, 0x0F, 0x00, 0x1F,
  0x00, 0x38, 0xF0, 0x0F, 0x00, 0x1F, 0x00, 0x78, 0xF0, 0x0F, 0x00, 0x3E,
  0x00, 0x70, 0xF0, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0x77,
  0x01, 0xE0, 0xF0, 0x07, 0x80, 0xE7, 0x03, 0xC0, 0xF0, 0x07, 0xC1, 0xC7,
  0x87, 0x80, 0xF0, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x70, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x70, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x1F,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0xF1, 0xF0, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00,
  0x7F, 0xC0, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x1E, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x3C, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1F,
  0x80, 0xF0, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0x00, 0x1C, 0x00, 0x3F, 0x00, 0x00, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x04, 0x00, 0x0F, 0xF0,
  0x07, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0x00, 0x7F, 0xE0, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0x00, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x07, 0xF0, 0x01, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0x80,
  0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFE, 0x3C, 0x00, 0x03,
  0xFF, 0xF8, 0xF0, 0x00, 0x0F, 0xFF, 0xC3, 0xC0, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0xF0, 0x00, 0x0F,
  0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x00, 0x0F, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x3F, 0x00, 0x00, 0x00,
  0x78, 0xFC, 0x00, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x01, 0xE7, 0xF0,
  0x00, 0x00, 0x03, 0xDF, 0xE0, 0x00, 0x00, 0x0F, 0xFB, 0xC0, 0x00, 0x00,
  0x1F, 0xE3, 0xC0, 0x00, 0x00, 0x3F, 0x87, 0x80, 0x00, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x03, 0xB8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7B, 0x80, 0x00,
  0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0x7B, 0xC0, 0x07, 0xBC, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x73,
  0xC0, 0x00, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0xF3, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x0F, 0x1C, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0xF1, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x0E, 0x1C, 0x00, 0x00, 0x3C,
  0x78, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x00,
  0xF0, 0xF8, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x01, 0xE0, 0xF0, 0x01, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x0E, 0x00, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x1E, 0x00,
  0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E,
  0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0,
  0x3C, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x70,
  0x0F, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x00, 0xF0, 0x07, 0x80, 0x0E, 0x00,
  0x78, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x87, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x38, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0x8F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x39, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xDE,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x03,
  0xF8, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x07, 0x80,
  0x03, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xE0, 0x03,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x80, 0x1F, 0xE0,
  0x00, 0x01, 0xE0, 0x03, 0xDE, 0x00, 0x00, 0x3C, 0x00, 0x7B, 0xC0, 0x00,
  0x07, 0x80, 0x0F, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xC7, 0x80, 0x00, 0x1E,
  0x00, 0x78, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0x1E, 0x00, 0x00, 0xF0, 0x01,
  0xE1, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC0, 0x07, 0x87,
  0x80, 0x00, 0x70, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0x0F, 0x00,
  0x03, 0xC0, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x0F,
  0x00, 0x1C, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00,
  0x78, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x01, 0xE0,
  0x00, 0x78, 0x1E, 0x00, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0xF0, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC3,
  0xC0, 0x07, 0x80, 0x00, 0x3C, 0x78, 0x00, 0xE0, 0x00, 0x07, 0x8E, 0x00,
  0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x78, 0x00, 0xF0,
  0x00, 0x01, 0xEF, 0x00, 0x1E, 0x00, 0x00, 0x3D, 0xE0, 0x07, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x3E,
  0x00, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x00, 0xF3, 0xE0, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0x0F, 0x9E, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0xF8, 0x00, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x07, 0xF8,
  0x00, 0x3C, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0xF8, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x1E, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x01,
  0xF0, 0x03, 0xC0, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x00, 0xF3, 0xE0, 0x00,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x0F, 0x9E, 0x00,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x00,
  0x79, 0xF0, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x03, 0xC7, 0xC0,
  0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x07,
  0xFC, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x1E,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x07, 0xE0, 0x0F, 0x00,
  0x03, 0xF0, 0x03, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x40, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x08, 0x00, 0x00, 0xFC, 0x03, 0x80, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x3E, 0x07, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0xF8, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x77, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E,
  0x70, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x3C, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC7, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x78, 0x70, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x87, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0xE0, 0x70, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x07, 0x00,
  0x0F, 0x00, 0xF0, 0x01, 0xC0, 0x70, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x07,
  0x00, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x0F,
  0x00, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00,
  0x0F, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E,
  0x00, 0x0F, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x78,
  0x3C, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xE0,
  0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xB8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x7D, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF8,
  0x3C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x80,
  0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03,
  0x80, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x38, 0x03, 0xC0,
  0x00, 0x78, 0x01, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x0E, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78,
  0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0x00, 0x3F, 0xFF, 0x0E, 0x00,
  0x7F, 0xFF, 0x8E, 0x00, 0xFC, 0x03, 0x9E, 0x01, 0xF0, 0x01, 0xDE, 0x03,
  0xE0, 0x01, 0xDC, 0x07, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0xFC, 0x0F,
  0x80, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF8, 0x3C,
  0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x0F, 0xC0, 0xF0,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3B, 0x80, 0x78, 0x00, 0x3F, 0x80, 0x78,
  0x00, 0x77, 0x80, 0x7C, 0x01, 0xE7, 0x00, 0x3E, 0x03, 0xC7, 0x00, 0x3F,
  0xFF, 0x87, 0x00, 0x1F, 0xFF, 0x07, 0x00, 0x07, 0xFC, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x0F,
  0xC0, 0x00, 0x78, 0x3F, 0xF8, 0x00, 0x3C, 0x3F, 0xFE, 0x00, 0x1E, 0x3F,
  0xFF, 0x80, 0x0F, 0x3C, 0x07, 0xE0, 0x07, 0x38, 0x00, 0xF0, 0x07, 0xB8,
  0x00, 0x7C, 0x03, 0xF8, 0x00, 0x1E, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0xFC,
  0x00, 0x07, 0x80, 0xFC, 0x00, 0x03, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C,
  0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x03, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x3B, 0x00, 0x03,
  0xE0, 0x1D, 0xC0, 0x03, 0xE0, 0x1E, 0xF0, 0x03, 0xE0, 0x0F, 0x3C, 0x07,
  0xE0, 0x07, 0x0F, 0xFF, 0xE0, 0x03, 0x83, 0xFF, 0xE0, 0x03, 0xC0, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x80, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x80,
  0x7E, 0x01, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0x00, 0x00, 0xFF, 0xE0,
  0xF0, 0x00, 0x3F, 0xFF, 0x0F, 0x00, 0x07, 0xFF, 0xF8, 0xE0, 0x00, 0xFC,
  0x03, 0xDE, 0x00, 0x1F, 0x00, 0x1D, 0xE0, 0x03, 0xE0, 0x00, 0xFE, 0x00,
  0x7C, 0x00, 0x0F, 0xE0, 0x07, 0x80, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x0F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1E, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00,
  0x0F, 0xC0, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x0F,
  0x80, 0x03, 0xFC, 0x00, 0x78, 0x00, 0x3B, 0x80, 0x07, 0x80, 0x07, 0x38,
  0x00, 0x7C, 0x01, 0xE7, 0x80, 0x03, 0xE0, 0x3C, 0x78, 0x00, 0x3F, 0xFF,
  0x87, 0x00, 0x01, 0xFF, 0xF0, 0x70, 0x00, 0x07, 0xFC, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x07,
  0xC0, 0xF8, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE1, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x3C,
  0x7C, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0x7C, 0x00,
  0x7E, 0x0F, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x30, 0x0F, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x02, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x08, 0x3E, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x70, 0x00, 0xFF, 0xFC, 0x3C, 0x00, 0x7F, 0xFF, 0x8E, 0x00, 0x3F, 0x00,
  0xF3, 0x80, 0x1F, 0x00, 0x1C, 0xE0, 0x0F, 0x80, 0x03, 0xF8, 0x07, 0xC0,
  0x00, 0xFE, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3C,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78,
  0x1F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0xF0,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0xFC, 0x03,
  0xC0, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x1E, 0xE0,
  0x07, 0x80, 0x0F, 0x78, 0x01, 0xF0, 0x07, 0x9E, 0x00, 0x3E, 0x03, 0xC7,
  0x80, 0x0F, 0xFF, 0xE1, 0xC0, 0x01, 0xFF, 0xF0, 0xF0, 0x00, 0x1F, 0xF0,
  0x3C, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x08, 0x00, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0x00, 0xF0,
  0x7F, 0xF0, 0x00, 0xF0, 0xFF, 0xFC, 0x00, 0xF1, 0xFF, 0xFC, 0x00, 0xF3,
  0xC0, 0x3E, 0x00, 0xE7, 0x00, 0x1E, 0x01, 0xEE, 0x00, 0x1E, 0x01, 0xFC,
  0x00, 0x1E, 0x01, 0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x03, 0xC0, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x18, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x01, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0xE0, 0x03, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x07,
  0x87, 0xC0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x07, 0x9F, 0x80, 0x00, 0x07,
  0xBF, 0x80, 0x00, 0x07, 0x7F, 0xC0, 0x00, 0x0F, 0x7B, 0xC0, 0x00, 0x0F,
  0xE3, 0xC0, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3C, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x0F, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0x8F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x00, 0xE7, 0x80, 0xF8, 0x78, 0x0F, 0x80, 0x3B, 0xC0, 0x1F,
  0x38, 0x01, 0xF0, 0x1E, 0xE0, 0x03, 0xDC, 0x00, 0x3C, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x7F,
  0xF8, 0x00, 0xF0, 0xFF, 0xFC, 0x00, 0xE3, 0xFF, 0xFC, 0x00, 0xE7, 0xC0,
  0x7E, 0x01, 0xE7, 0x00, 0x1E, 0x01, 0xEE, 0x00, 0x1E, 0x01, 0xFC, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFC, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0x7C, 0x1E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x7C,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x7F, 0xE0, 0x00, 0x1E, 0x1F, 0xFF,
  0x00, 0x01, 0xC3, 0xF7, 0xF8, 0x00, 0x1C, 0x78, 0x0F, 0xC0, 0x01, 0xCF,
  0x00, 0x3C, 0x00, 0x3D, 0xC0, 0x03, 0xE0, 0x03, 0xFC, 0x00, 0x1E, 0x00,
  0x3F, 0x80, 0x01, 0xE0, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x77, 0x00, 0x0F, 0x80, 0x0F, 0x78, 0x01, 0xF0,
  0x00, 0xF3, 0xC0, 0x7E, 0x00, 0x0F, 0x1F, 0xFF, 0xC0, 0x00, 0xF0, 0xFF,
  0xF8, 0x00, 0x0F, 0x07, 0xFE, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x07, 0x00, 0x3F, 0xFF, 0x0F, 0x00,
  0x7F, 0xFF, 0x8E, 0x00, 0xFC, 0x03, 0xCE, 0x01, 0xF0, 0x01, 0xCE, 0x03,
  0xE0, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1E,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0xF8,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x0F, 0xC0, 0xF0,
  0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0x3B, 0x80, 0x78,
  0x00, 0x77, 0x80, 0x7C, 0x01, 0xE7, 0x80, 0x3E, 0x03, 0xC7, 0x80, 0x3F,
  0xFF, 0x87, 0x00, 0x1F, 0xFF, 0x0F, 0x00, 0x07, 0xFC, 0x0F, 0x00, 0x00,
  0xE0, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x3C,
  0x1F, 0xE0, 0x0E, 0x0F, 0xF8, 0x03, 0x8F, 0xFE, 0x00, 0xE7, 0xC0, 0x00,
  0x39, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0x9F, 0xE0, 0x1F, 0x00, 0x1C, 0x07, 0xC0, 0x01, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x03, 0x00, 0x03, 0xE0,
  0x7C, 0x01, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x08, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x7C, 0x0F,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x0F, 0xE0, 0x78,
  0x00, 0x3B, 0xC0, 0xF8, 0x00, 0xF7, 0x00, 0xF0, 0x03, 0xCE, 0x01, 0xF0,
  0x1F, 0x3C, 0x01, 0xFF, 0xFC, 0x78, 0x03, 0xFF, 0xF0, 0xE0, 0x01, 0xFF,
  0x81, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF0, 0x70,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x07,
  0x80, 0x78, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x03,
  0xC0, 0x03, 0x80, 0x78, 0x00, 0x38, 0x07, 0x80, 0x03, 0x80, 0xF0, 0x00,
  0x3C, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x1D,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x78, 0x00, 0x1F, 0x80, 0x01, 0xEF, 0x00, 0x07, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xEE, 0x00, 0x0F, 0x3C, 0x00, 0x1D, 0xC0, 0x03, 0xC7, 0x80, 0x07,
  0xB8, 0x00, 0x78, 0xF0, 0x00, 0xE7, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0xE0,
  0x03, 0xC3, 0xC0, 0x07, 0x1C, 0x00, 0x78, 0x38, 0x01, 0xE3, 0x80, 0x1E,
  0x07, 0x00, 0x38, 0x70, 0x03, 0xC0, 0xE0, 0x0F, 0x0E, 0x00, 0xF0, 0x1C,
  0x01, 0xC1, 0xC0, 0x1E, 0x03, 0x80, 0x78, 0x3C, 0x07, 0x80, 0x70, 0x0F,
  0x07, 0x80, 0xF0, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x01, 0xC0, 0x78, 0x1E,
  0x07, 0x80, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x07, 0x03, 0xC0, 0x78, 0x3C,
  0x00, 0xF0, 0x70, 0x0F, 0x07, 0x80, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x03,
  0xC3, 0x80, 0x3C, 0x3C, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x0F, 0x1C,
  0x00, 0xF1, 0xE0, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x00, 0x3C, 0xF0, 0x03,
  0xCF, 0x00, 0x07, 0xBC, 0x00, 0x39, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0x78,
  0x00, 0x1E, 0xE0, 0x00, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x1D, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xE0, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x07, 0xC0,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x04, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x02,
  0x7F, 0xFC, 0x00, 0x0D, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x81, 0xFF,
  0x00, 0x7F, 0xFF, 0xD8, 0x00, 0x1F, 0xFF, 0x20, 0x00, 0x0F, 0xF8, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 15, 52, 16, 2, -51 },
  { 99, 18, 18, 24, 8, -51 },
  { 140, 38, 51, 39, 2, -51 },
  { 383, 32, 59, 35, 2, -55 },
  { 619, 42, 53, 50, 5, -52 },
  { 898, 37, 53, 41, 2, -52 },
  { 1144, 7, 18, 13, 8, -51 },
  { 1160, 22, 62, 19, 2, -51 },
  { 1331, 21, 62, 19, -5, -51 },
  { 1494, 27, 28, 34, 8, -55 },
  { 1589, 31, 34, 37, 4, -42 },
  { 1721, 11, 17, 15, -3, -8 },
  { 1745, 17, 3, 21, 2, -21 },
  { 1752, 6, 7, 15, 2, -6 },
  { 1758, 32, 51, 23, -3, -51 },
  { 1962, 31, 53, 35, 3, -52 },
  { 2168, 18, 51, 35, 10, -51 },
  { 2283, 34, 52, 35, -1, -52 },
  { 2504, 34, 53, 35, 0, -52 },
  { 2730, 33, 52, 35, 0, -52 },
  { 2945, 33, 52, 35, 1, -51 },
  { 3160, 31, 53, 35, 4, -52 },
  { 3366, 31, 51, 35, 5, -51 },
  { 3564, 32, 53, 35, 2, -52 },
  { 3776, 31, 53, 35, 2, -52 },
  { 3982, 13, 40, 15, 1, -39 },
  { 4047, 17, 48, 15, -3, -39 },
  { 4149, 31, 33, 37, 4, -42 },
  { 4277, 31, 18, 37, 4, -34 },
  { 4347, 31, 33, 37, 4, -42 },
  { 4475, 24, 53, 26, 4, -52 },
  { 4634, 48, 57, 53, 3, -51 },
  { 4976, 35, 52, 35, -4, -52 },
  { 5204, 35, 51, 38, 2, -51 },
  { 5428, 35, 53, 37, 5, -52 },
  { 5660, 38, 51, 42, 2, -51 },
  { 5903, 34, 51, 33, 2, -51 },
  { 6120, 34, 51, 31, 2, -51 },
  { 6337, 38, 53, 44, 5, -52 },
  { 6589, 42, 51, 43, 2, -51 },
  { 6857, 25, 51, 19, -2, -51 },
  { 7017, 28, 64, 16, -11, -51 },
  { 7241, 39, 51, 35, 2, -51 },
  { 7490, 23, 51, 31, 2, -51 },
  { 7637, 52, 51, 54, 2, -51 },
  { 7969, 43, 51, 44, 2, -51 },
  { 8244, 39, 53, 45, 4, -52 },
  { 8503, 34, 51, 36, 2, -51 },
  { 8720, 39, 64, 45, 4, -52 },
  { 9032, 34, 51, 36, 2, -51 },
  { 9249, 34, 53, 32, 0, -52 },
  { 9475, 31, 51, 31, 6, -51 },
  { 9673, 39, 52, 43, 5, -51 },
  { 9927, 34, 51, 35, 7, -51 },
  { 10144, 52, 51, 55, 8, -51 },
  { 10476, 42, 51, 32, -4, -51 },
  { 10744, 32, 51, 31, 6, -51 },
  { 10948, 38, 51, 33, -2, -51 },
  { 11191, 27, 62, 21, -1, -51 },
  { 11401, 12, 51, 24, 7, -51 },
  { 11478, 27, 62, 21, -5, -51 },
  { 11688, 32, 30, 36, 2, -52 },
  { 11808, 25, 3, 25, -6, 7 },
  { 11818, 9, 11, 18, 11, -55 },
  { 11831, 32, 40, 36, 3, -39 },
  { 11991, 33, 56, 37, 1, -55 },
  { 12222, 26, 40, 28, 3, -39 },
  { 12352, 36, 56, 37, 3, -55 },
  { 12604, 27, 40, 32, 3, -39 },
  { 12739, 37, 72, 19, -9, -55 },
  { 13072, 34, 56, 37, 1, -39 },
  { 13310, 32, 55, 36, 1, -55 },
  { 13530, 16, 52, 15, 1, -52 },
  { 13634, 27, 69, 15, -10, -52 },
  { 13867, 32, 55, 30, 1, -55 },
  { 14087, 16, 55, 15, 1, -55 },
  { 14197, 50, 39, 54, 1, -39 },
  { 14441, 32, 39, 36, 1, -39 },
  { 14597, 30, 40, 36, 3, -39 },
  { 14747, 36, 56, 37, -2, -39 },
  { 14999, 32, 56, 37, 3, -39 },
  { 15223, 26, 39, 24, 1, -39 },
  { 15350, 27, 40, 27, 0, -39 },
  { 15485, 19, 48, 20, 3, -47 },
  { 15599, 31, 39, 36, 3, -38 },
  { 15751, 28, 38, 28, 4, -38 },
  { 15884, 43, 38, 45, 4, -38 },
  { 16089, 35, 38, 30, -3, -38 },
  { 16256, 39, 55, 28, -7, -38 },
  { 16525, 30, 38, 27, -2, -38 },
  { 16668, 26, 62, 24, 2, -51 },
  { 16870, 4, 72, 34, 16, -55 },
  { 16906, 26, 62, 24, -4, -51 },
  { 17108, 31, 7, 37, 4, -29 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC72PT7B_H_
