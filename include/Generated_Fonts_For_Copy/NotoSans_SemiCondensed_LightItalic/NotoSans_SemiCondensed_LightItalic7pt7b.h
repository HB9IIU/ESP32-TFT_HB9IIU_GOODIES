#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC7PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0x80, 0xC0, 0x57, 0x6E, 0xA0, 0x79, 0x3C, 0x55, 0x2E, 0xD7,
  0x00, 0x66, 0x4B, 0xE0, 0xC0, 0x5A, 0xA0, 0x55, 0xA0, 0xF0, 0x5D, 0x00,
  0xC0, 0xC0, 0x80, 0x29, 0x48, 0x76, 0xDE, 0xDA, 0x80, 0x64, 0xAE, 0x65,
  0x1E, 0x2D, 0xF2, 0x68, 0x9E, 0x6A, 0xDE, 0xE9, 0x48, 0x6D, 0x5E, 0x77,
  0x9C, 0x90, 0x98, 0x38, 0x80, 0xE0, 0xC7, 0x00, 0xE5, 0x48, 0x7B, 0xF7,
  0xBA, 0x30, 0x2D, 0xDA, 0x75, 0x69, 0xE0, 0x74, 0x88, 0x60, 0x75, 0x99,
  0xE0, 0x69, 0xCE, 0x69, 0xC8, 0x74, 0xB9, 0x70, 0x55, 0x79, 0x90, 0x56,
  0x80, 0x25, 0x25, 0x80, 0x56, 0x4A, 0xA0, 0x5A, 0xC0, 0x4A, 0x77, 0x5A,
  0x80, 0x55, 0xBB, 0x90, 0x79, 0x99, 0xE0, 0x75, 0xE8, 0x80, 0x79, 0x99,
  0xE2, 0x75, 0xEA, 0xA0, 0x71, 0x1E, 0xF2, 0x48, 0x55, 0x99, 0xE0, 0xBB,
  0x48, 0xAF, 0x6D, 0x4A, 0x00, 0x56, 0x4A, 0xA0, 0xBA, 0x48, 0x72, 0x48,
  0xE0, 0x6A, 0x49, 0x00, 0xF8, 0x55, 0xA0, 0x4E, 0x80, 0xE0, 0x80, 0x76,
  0xF0, 0x4E, 0xDE, 0x72, 0x60, 0x16, 0xAA, 0xE0, 0x77, 0x70, 0x36, 0x44,
  0x44, 0x80, 0x76, 0xF3, 0x80, 0x4E, 0xDA, 0x5A, 0x80, 0x25, 0x24, 0xA0,
  0x4F, 0x6A, 0x5A, 0x80, 0x7D, 0x6B, 0x50, 0x76, 0xD0, 0x76, 0xF0, 0x76,
  0xF9, 0x00, 0x76, 0xF2, 0x40, 0x72, 0x40, 0x71, 0x60, 0x7A, 0x80, 0x76,
  0xF0, 0xB7, 0x40, 0xAD, 0xBD, 0x40, 0xA9, 0x60, 0x55, 0x64, 0x48, 0x6A,
  0x60, 0x69, 0x49, 0x00, 0xFE, 0x55, 0xA0, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 1, 2, 2, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 3, 5, 3, 0, -5 },
  { 9, 5, 5, 5, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 1, 1, -5 },
  { 17, 2, 6, 2, 0, -5 },
  { 19, 2, 6, 2, 0, -5 },
  { 21, 2, 2, 3, 1, -5 },
  { 22, 3, 3, 4, 0, -4 },
  { 24, 1, 2, 1, 0, -1 },
  { 25, 2, 1, 2, 0, -2 },
  { 26, 1, 1, 1, 0, -1 },
  { 27, 3, 5, 2, 0, -5 },
  { 29, 3, 5, 3, 0, -5 },
  { 31, 2, 5, 3, 1, -5 },
  { 33, 3, 5, 3, 0, -5 },
  { 35, 3, 5, 3, 0, -5 },
  { 37, 3, 5, 3, 0, -5 },
  { 39, 3, 5, 3, 0, -5 },
  { 41, 3, 5, 3, 0, -5 },
  { 43, 3, 5, 3, 1, -5 },
  { 45, 3, 5, 3, 0, -5 },
  { 47, 3, 5, 3, 0, -5 },
  { 49, 1, 4, 1, 0, -4 },
  { 50, 1, 5, 2, 0, -4 },
  { 51, 3, 3, 4, 0, -4 },
  { 53, 3, 1, 4, 0, -3 },
  { 54, 3, 3, 4, 0, -4 },
  { 56, 3, 5, 3, 0, -5 },
  { 58, 5, 6, 5, 0, -5 },
  { 62, 3, 5, 3, 0, -5 },
  { 64, 4, 5, 4, 0, -5 },
  { 67, 4, 5, 4, 0, -5 },
  { 70, 4, 5, 4, 0, -5 },
  { 73, 3, 5, 3, 0, -5 },
  { 75, 3, 5, 3, 0, -5 },
  { 77, 4, 5, 4, 0, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 2, 5, 2, 0, -5 },
  { 85, 3, 6, 2, -1, -5 },
  { 88, 4, 5, 3, 0, -5 },
  { 91, 2, 5, 3, 0, -5 },
  { 93, 5, 5, 5, 0, -5 },
  { 97, 4, 5, 4, 0, -5 },
  { 100, 4, 5, 4, 0, -5 },
  { 103, 4, 5, 3, 0, -5 },
  { 106, 4, 6, 4, 0, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 3, 5, 3, 0, -5 },
  { 114, 3, 5, 3, 1, -5 },
  { 116, 4, 5, 4, 0, -5 },
  { 119, 3, 5, 3, 1, -5 },
  { 121, 5, 5, 5, 1, -5 },
  { 125, 4, 5, 3, 0, -5 },
  { 128, 3, 5, 3, 1, -5 },
  { 130, 4, 5, 3, 0, -5 },
  { 133, 3, 6, 2, 0, -5 },
  { 136, 1, 5, 2, 1, -5 },
  { 137, 2, 6, 2, 0, -5 },
  { 139, 3, 3, 4, 0, -5 },
  { 141, 3, 1, 2, -1, 0 },
  { 142, 1, 1, 2, 1, -5 },
  { 143, 3, 4, 4, 0, -4 },
  { 145, 3, 5, 4, 0, -5 },
  { 147, 3, 4, 3, 0, -4 },
  { 149, 4, 5, 4, 0, -5 },
  { 152, 3, 4, 3, 0, -4 },
  { 154, 4, 7, 2, -1, -5 },
  { 158, 3, 6, 4, 0, -4 },
  { 161, 3, 5, 4, 0, -5 },
  { 163, 2, 5, 1, 0, -5 },
  { 165, 3, 7, 1, -1, -5 },
  { 168, 3, 5, 3, 0, -5 },
  { 170, 2, 5, 1, 0, -5 },
  { 172, 5, 4, 5, 0, -4 },
  { 175, 3, 4, 4, 0, -4 },
  { 177, 3, 4, 3, 0, -4 },
  { 179, 3, 6, 4, 0, -4 },
  { 182, 3, 6, 4, 0, -4 },
  { 185, 3, 4, 2, 0, -4 },
  { 187, 3, 4, 3, 0, -4 },
  { 189, 2, 5, 2, 0, -5 },
  { 191, 3, 4, 4, 0, -4 },
  { 193, 3, 4, 3, 0, -4 },
  { 195, 5, 4, 4, 0, -4 },
  { 198, 3, 4, 3, 0, -4 },
  { 200, 4, 6, 3, -1, -4 },
  { 203, 3, 4, 3, 0, -4 },
  { 205, 3, 6, 2, 0, -5 },
  { 208, 1, 7, 3, 1, -5 },
  { 209, 2, 6, 2, 0, -5 },
  { 211, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC7PT7B_H_
