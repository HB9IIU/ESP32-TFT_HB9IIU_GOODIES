#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC43PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03,
  0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01,
  0x81, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0F, 0x07, 0x03, 0x80,
  0x70, 0xDC, 0x36, 0x1D, 0x87, 0x61, 0x98, 0x6C, 0x1B, 0x0C, 0xC3, 0x30,
  0xC8, 0x30, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x01,
  0x81, 0x80, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x30, 0x00, 0xC0, 0xE0, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x06, 0x06,
  0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80,
  0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x30, 0x30, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C,
  0x0C, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81,
  0x80, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xE6,
  0x38, 0x38, 0xC0, 0x0E, 0x18, 0x01, 0x83, 0x00, 0x30, 0x40, 0x06, 0x18,
  0x00, 0xC3, 0x00, 0x1C, 0x60, 0x01, 0xC8, 0x00, 0x3D, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x2F, 0x00, 0x0C, 0x70, 0x01, 0x86,
  0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0x83, 0x00, 0x30, 0x60, 0x06, 0x1C,
  0x40, 0xC7, 0x0F, 0x1B, 0xC1, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x07, 0xC0,
  0x07, 0x07, 0xF0, 0x03, 0x07, 0x18, 0x03, 0x07, 0x0E, 0x03, 0x83, 0x03,
  0x01, 0x83, 0x81, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0xC0, 0xE0, 0xC0, 0x60,
  0x60, 0xC0, 0x70, 0x30, 0x60, 0x30, 0x18, 0x60, 0x18, 0x0C, 0x60, 0x0C,
  0x0C, 0x31, 0xE6, 0x06, 0x31, 0xFB, 0x03, 0x31, 0xCF, 0x83, 0x19, 0x83,
  0xE3, 0x98, 0xC1, 0xBF, 0x9C, 0xC0, 0xCF, 0x0C, 0x60, 0x60, 0x0C, 0x70,
  0x30, 0x0E, 0x30, 0x18, 0x06, 0x18, 0x0C, 0x06, 0x0C, 0x06, 0x07, 0x06,
  0x06, 0x03, 0x03, 0x03, 0x03, 0x01, 0x81, 0x83, 0x80, 0xC1, 0x81, 0x80,
  0x60, 0xC1, 0x80, 0x30, 0xC1, 0xC0, 0x1D, 0xE1, 0xC0, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xFE, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0x30, 0x03, 0x80,
  0xC0, 0x0E, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x01, 0xC0,
  0x0E, 0x0E, 0x00, 0x38, 0x70, 0x00, 0x63, 0x80, 0x01, 0xDC, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x70, 0x00, 0x70, 0xC0,
  0x33, 0x83, 0x81, 0xDC, 0x07, 0x06, 0x60, 0x1C, 0x3B, 0x80, 0x38, 0xCE,
  0x00, 0x66, 0x30, 0x01, 0xF8, 0xC0, 0x03, 0xC3, 0x00, 0x0E, 0x0E, 0x00,
  0x7C, 0x38, 0x03, 0xF0, 0x70, 0x1C, 0xE0, 0xFF, 0xE1, 0x81, 0xFE, 0x07,
  0x00, 0x77, 0x66, 0x66, 0xCC, 0xCC, 0x80, 0x00, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x80, 0x80, 0xE1, 0x80, 0xF9,
  0x80, 0x1F, 0x8F, 0x07, 0xFF, 0x03, 0x80, 0x06, 0x80, 0x0C, 0xC0, 0x38,
  0xC0, 0x70, 0x60, 0x60, 0x60, 0x20, 0x70, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0E, 0x1C, 0x30, 0xE1, 0x87, 0x0C,
  0x18, 0x60, 0xC3, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x6F, 0xEE, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3C, 0x38, 0x1C, 0x06, 0x06, 0x01, 0xC3,
  0x80, 0x31, 0xC0, 0x0C, 0x70, 0x03, 0x18, 0x00, 0xCE, 0x00, 0x33, 0x00,
  0x0C, 0xC0, 0x03, 0x70, 0x00, 0xDC, 0x00, 0x76, 0x00, 0x1D, 0x80, 0x07,
  0xE0, 0x01, 0xB8, 0x00, 0x6E, 0x00, 0x3B, 0x80, 0x0E, 0xC0, 0x03, 0x30,
  0x00, 0xCC, 0x00, 0x73, 0x00, 0x18, 0xC0, 0x0E, 0x38, 0x03, 0x0E, 0x01,
  0xC1, 0x80, 0xE0, 0x70, 0x70, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xE0,
  0x38, 0x1F, 0x07, 0x63, 0xDC, 0xF3, 0x38, 0x62, 0x0C, 0x03, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0x80, 0x60, 0x0C, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x03, 0xC1,
  0xE0, 0x30, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x1F, 0xFC, 0x07, 0xC1, 0xE0, 0x30, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x02, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0xC0, 0x1E, 0x0F,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0x60, 0x00, 0x66, 0x00, 0x0E, 0xE0, 0x01,
  0xCC, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x61, 0xC0, 0x0E, 0x1C, 0x01,
  0xC1, 0x80, 0x18, 0x18, 0x03, 0x01, 0x80, 0x70, 0x38, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x18, 0x03, 0x03, 0x00, 0x30, 0x70, 0x07, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x40, 0x01, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x08, 0x00, 0xE0, 0xC0, 0x3C, 0x0F,
  0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x1F, 0x80,
  0x67, 0xFC, 0x1D, 0x83, 0xC3, 0x60, 0x38, 0x78, 0x03, 0x0E, 0x00, 0x73,
  0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xC7,
  0x00, 0x18, 0xE0, 0x07, 0x1C, 0x00, 0xC1, 0x80, 0x38, 0x38, 0x0E, 0x07,
  0x83, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x0F, 0xFC, 0x03, 0xC1, 0xE0, 0x38, 0x0E, 0x07, 0x00, 0x60, 0x60, 0x07,
  0x06, 0x00, 0x70, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x0E, 0x07, 0x00,
  0xC0, 0x30, 0x18, 0x03, 0x87, 0x00, 0x1D, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x07, 0x9C, 0x01, 0xE0, 0xE0, 0x38, 0x07, 0x07, 0x00, 0x30, 0x60,
  0x03, 0x8E, 0x00, 0x38, 0xE0, 0x01, 0x8E, 0x00, 0x18, 0xE0, 0x03, 0x8E,
  0x00, 0x38, 0xE0, 0x03, 0x07, 0x00, 0x70, 0x78, 0x0E, 0x03, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0x0E, 0x03, 0x80,
  0xE0, 0xE0, 0x0C, 0x1C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x03, 0x18, 0x00,
  0x63, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x03,
  0xC6, 0x00, 0x70, 0xE0, 0x1E, 0x1E, 0x0E, 0xC1, 0xFF, 0xB8, 0x1F, 0xC6,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x0F, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x0E, 0x1C, 0x38, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0E, 0x1C,
  0x38, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x30,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0xF0, 0x60, 0xF0,
  0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0x83, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x30, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x30, 0xC0, 0x1F, 0xC1, 0x86, 0x03, 0xFE, 0x0E, 0x60, 0x38, 0x30,
  0x33, 0x03, 0x01, 0x81, 0xB0, 0x38, 0x18, 0x1D, 0x81, 0x80, 0xC0, 0xCC,
  0x18, 0x06, 0x06, 0xE0, 0xC0, 0x30, 0x36, 0x06, 0x03, 0x01, 0xB0, 0x60,
  0x18, 0x1D, 0x83, 0x00, 0xC0, 0xCC, 0x18, 0x0E, 0x06, 0x60, 0xC0, 0x70,
  0x63, 0x06, 0x07, 0x83, 0x18, 0x38, 0x6C, 0x30, 0xC0, 0xFE, 0x7F, 0x06,
  0x03, 0xE1, 0xF0, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x36, 0x00, 0x03, 0xB0, 0x00, 0x19, 0x80, 0x01, 0xCC, 0x00, 0x0C, 0x70,
  0x00, 0xE3, 0x80, 0x06, 0x1C, 0x00, 0x70, 0x60, 0x03, 0x03, 0x00, 0x38,
  0x18, 0x01, 0x80, 0xC0, 0x1C, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80,
  0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x30, 0x03, 0x83, 0x80, 0x1C, 0x18, 0x00,
  0xE1, 0xC0, 0x07, 0x0C, 0x00, 0x18, 0xE0, 0x00, 0xC6, 0x00, 0x06, 0x70,
  0x00, 0x33, 0x00, 0x01, 0xB8, 0x00, 0x0F, 0x80, 0x00, 0x60, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0xE0, 0xFC, 0x07, 0x00, 0xF0, 0x30, 0x03, 0x81,
  0x80, 0x0C, 0x1C, 0x00, 0x60, 0xE0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x01,
  0xC1, 0x80, 0x0E, 0x1C, 0x00, 0xE0, 0xE0, 0x0E, 0x06, 0x01, 0xE0, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x0E, 0x06, 0x00, 0x38,
  0x30, 0x01, 0xC3, 0x80, 0x06, 0x1C, 0x00, 0x30, 0xE0, 0x03, 0x86, 0x00,
  0x1C, 0x30, 0x00, 0xE3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xC0, 0x0F, 0x06,
  0x01, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0xC0, 0x7C, 0x0E, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x20,
  0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x0E, 0x1F, 0xC0, 0x1C, 0x03, 0xC0, 0x30, 0x03, 0x80, 0x60, 0x03, 0x81,
  0xC0, 0x03, 0x03, 0x80, 0x07, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x18,
  0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0x80, 0x01, 0xC3, 0x00,
  0x03, 0x86, 0x00, 0x07, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x60, 0x00,
  0x70, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x1C,
  0x18, 0x00, 0x38, 0x30, 0x00, 0xE0, 0xE0, 0x03, 0x81, 0xC0, 0x0E, 0x03,
  0x00, 0x78, 0x06, 0x07, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0x70, 0x1E, 0x00, 0x20,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x07, 0xFC, 0xC0, 0x0F,
  0xF9, 0x80, 0x1F, 0xE3, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x8C, 0x00, 0x07,
  0x18, 0x00, 0x0E, 0x30, 0x00, 0x18, 0x70, 0x00, 0x30, 0xE0, 0x00, 0xE1,
  0xC0, 0x01, 0xC1, 0xC0, 0x03, 0x03, 0xC0, 0x06, 0x03, 0xC0, 0x1C, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x01,
  0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00,
  0x18, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1C, 0x00, 0x1C, 0x0E,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x03, 0x81,
  0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06,
  0x03, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x0C, 0x78,
  0x07, 0xF8, 0x01, 0xF0, 0x00, 0x01, 0x80, 0x0F, 0x03, 0x80, 0x1C, 0x03,
  0x80, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x03, 0x00, 0xE0, 0x07,
  0x01, 0xC0, 0x07, 0x03, 0x80, 0x06, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x06,
  0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x0D,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x30, 0x00, 0x1E, 0x30, 0x00, 0x1C,
  0x38, 0x00, 0x18, 0x18, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x80, 0x60, 0x03, 0x80, 0xE0,
  0x01, 0x80, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x6C, 0x00, 0x0D, 0x81, 0xD8, 0x00, 0x3B,
  0x03, 0xB0, 0x00, 0x6E, 0x06, 0x60, 0x01, 0xDC, 0x0C, 0xC0, 0x03, 0x30,
  0x19, 0x80, 0x0E, 0x60, 0x73, 0x00, 0x18, 0xC0, 0xC6, 0x00, 0x73, 0x81,
  0x8E, 0x00, 0xC7, 0x03, 0x0C, 0x03, 0x0C, 0x06, 0x18, 0x06, 0x18, 0x1C,
  0x30, 0x18, 0x30, 0x30, 0x60, 0x70, 0xE0, 0x60, 0xC0, 0xC1, 0xC0, 0xC1,
  0x83, 0x83, 0x03, 0x83, 0x06, 0x06, 0x07, 0x06, 0x1C, 0x0C, 0x0C, 0x0E,
  0x30, 0x38, 0x18, 0x0C, 0xE0, 0x70, 0x30, 0x19, 0x80, 0xC0, 0xE0, 0x37,
  0x01, 0x81, 0xC0, 0x6C, 0x07, 0x03, 0x00, 0xF8, 0x0E, 0x06, 0x01, 0xE0,
  0x18, 0x0C, 0x03, 0x80, 0x30, 0x38, 0x07, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0xF0, 0x00, 0x70, 0x3C, 0x00, 0x18, 0x0F, 0x00, 0x06, 0x03,
  0xE0, 0x01, 0x80, 0xD8, 0x00, 0xE0, 0x76, 0x00, 0x30, 0x19, 0xC0, 0x0C,
  0x06, 0x30, 0x03, 0x01, 0x8C, 0x01, 0xC0, 0x63, 0x80, 0x70, 0x38, 0xE0,
  0x18, 0x0C, 0x18, 0x06, 0x03, 0x07, 0x01, 0x80, 0xC1, 0xC0, 0xE0, 0x30,
  0x30, 0x38, 0x1C, 0x0C, 0x0C, 0x06, 0x03, 0x83, 0x01, 0x80, 0x60, 0xC0,
  0x60, 0x18, 0x70, 0x38, 0x07, 0x18, 0x0E, 0x00, 0xC6, 0x03, 0x00, 0x31,
  0x80, 0xC0, 0x0E, 0x60, 0x30, 0x01, 0xB8, 0x1C, 0x00, 0x6C, 0x07, 0x00,
  0x1F, 0x01, 0x80, 0x03, 0xC0, 0x60, 0x00, 0xF0, 0x18, 0x00, 0x3C, 0x0E,
  0x00, 0x06, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0x83, 0xC0,
  0x1C, 0x01, 0xC0, 0x70, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x03, 0x0C,
  0x00, 0x06, 0x38, 0x00, 0x0E, 0x60, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80,
  0x00, 0x76, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0x70, 0x00,
  0x06, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x76, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x98, 0x00, 0x07, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x38,
  0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC1, 0xC0, 0x07, 0x03, 0x80, 0x1C, 0x03,
  0xC0, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xE3, 0xF8, 0x07, 0x01, 0xE0, 0x30, 0x07, 0x01, 0x80,
  0x18, 0x1C, 0x00, 0xC0, 0xE0, 0x07, 0x06, 0x00, 0x38, 0x30, 0x01, 0x81,
  0x80, 0x0C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x06, 0x00, 0x70, 0x30, 0x07,
  0x01, 0x80, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0xC0, 0x07, 0x83, 0xC0, 0x1C, 0x01, 0xC0, 0x70, 0x01, 0xC1, 0xC0, 0x03,
  0x87, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x60, 0x00, 0x1D,
  0xC0, 0x00, 0x3B, 0x80, 0x00, 0x76, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x3B, 0x00,
  0x00, 0x76, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x98, 0x00, 0x07, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x61, 0xC0, 0x01, 0xC1, 0xC0, 0x07,
  0x03, 0x80, 0x1C, 0x03, 0xC0, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0xE3, 0xF8, 0x07, 0x01, 0xE0, 0x30, 0x07, 0x01, 0x80,
  0x18, 0x1C, 0x00, 0xC0, 0xE0, 0x07, 0x06, 0x00, 0x38, 0x30, 0x01, 0x81,
  0x80, 0x0C, 0x1C, 0x00, 0xE0, 0xE0, 0x06, 0x06, 0x00, 0x70, 0x30, 0x07,
  0x01, 0x81, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x06, 0x06, 0x00, 0x30,
  0x38, 0x03, 0x80, 0xC0, 0x1C, 0x06, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0,
  0x30, 0x06, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xC0, 0x06, 0x06, 0x00,
  0x30, 0x30, 0x01, 0xC3, 0x80, 0x0E, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF,
  0x03, 0xE0, 0xF0, 0x38, 0x01, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0xC0, 0x3E, 0x0F, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x06, 0x1C, 0x00, 0x0C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x70, 0xC0,
  0x00, 0xC3, 0x80, 0x01, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x30, 0xE0, 0x00, 0x61, 0xC0, 0x01, 0xC3, 0x00, 0x03,
  0x86, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x60, 0x00, 0x70,
  0xC0, 0x00, 0xE1, 0x80, 0x01, 0x87, 0x00, 0x03, 0x0E, 0x00, 0x0E, 0x18,
  0x00, 0x1C, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x01, 0xC1, 0x80,
  0x03, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x38, 0x07, 0x80, 0xE0, 0x07, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xCE, 0x00, 0x1C, 0x60, 0x01, 0x86, 0x00,
  0x38, 0x60, 0x03, 0x06, 0x00, 0x70, 0x60, 0x06, 0x06, 0x00, 0xE0, 0x60,
  0x0C, 0x06, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0x70, 0x30, 0x07,
  0x07, 0x00, 0x70, 0x60, 0x07, 0x0E, 0x00, 0x30, 0xC0, 0x03, 0x1C, 0x00,
  0x31, 0x80, 0x03, 0x38, 0x00, 0x33, 0x00, 0x03, 0x70, 0x00, 0x36, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x0F, 0x80, 0x06, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x36, 0x00,
  0x3C, 0x00, 0xEC, 0x00, 0xD8, 0x01, 0x98, 0x01, 0xB0, 0x07, 0x30, 0x07,
  0x60, 0x0C, 0x60, 0x0C, 0xC0, 0x38, 0xC0, 0x39, 0x80, 0x61, 0x80, 0x63,
  0x00, 0xC3, 0x00, 0xC6, 0x03, 0x86, 0x03, 0x0C, 0x06, 0x0C, 0x06, 0x18,
  0x1C, 0x18, 0x1C, 0x30, 0x30, 0x30, 0x30, 0x60, 0xE0, 0x60, 0xE0, 0xC1,
  0x80, 0xC1, 0x81, 0x83, 0x01, 0x87, 0x03, 0x0E, 0x03, 0x0C, 0x06, 0x18,
  0x06, 0x18, 0x0C, 0x70, 0x0C, 0x60, 0x18, 0xC0, 0x18, 0xC0, 0x33, 0x80,
  0x33, 0x80, 0x66, 0x00, 0x66, 0x00, 0xCC, 0x00, 0xDC, 0x01, 0xB0, 0x01,
  0xB0, 0x03, 0x60, 0x03, 0x60, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x03, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x0E, 0x00, 0xC0, 0x1C,
  0x00, 0xE0, 0x18, 0x00, 0xE0, 0x38, 0x00, 0x60, 0x70, 0x00, 0x60, 0x60,
  0x00, 0x70, 0xE0, 0x00, 0x31, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x33, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xC6, 0x00,
  0x01, 0xC6, 0x00, 0x03, 0x87, 0x00, 0x03, 0x03, 0x00, 0x07, 0x03, 0x00,
  0x0E, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x18, 0x01, 0x80, 0x38, 0x01, 0x80,
  0x70, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0xE0, 0x00, 0xC0, 0xC0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x39, 0x80, 0x0C, 0x60, 0x07, 0x18, 0x01, 0x87, 0x00,
  0xE1, 0xC0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x03, 0x07, 0x00, 0xE1, 0x80,
  0x38, 0xE0, 0x06, 0x30, 0x01, 0x98, 0x00, 0x6E, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x07, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xE0, 0xC1,
  0x83, 0x06, 0x0C, 0x1C, 0x38, 0x30, 0x60, 0xC1, 0x80, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x36, 0x00, 0x0E,
  0xC0, 0x01, 0x98, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x03, 0x07, 0x00, 0xE0,
  0x60, 0x18, 0x0C, 0x07, 0x00, 0xC0, 0xC0, 0x18, 0x30, 0x03, 0x86, 0x00,
  0x31, 0x80, 0x06, 0x70, 0x00, 0xFC, 0x00, 0x0C, 0x7F, 0xFF, 0xFF, 0xFE,
  0xE1, 0x87, 0x0C, 0x18, 0x60, 0xC0, 0x01, 0xF8, 0x60, 0xFF, 0x98, 0x3C,
  0x1B, 0x07, 0x01, 0x61, 0xC0, 0x3C, 0x70, 0x07, 0x8C, 0x00, 0x63, 0x80,
  0x1C, 0x70, 0x03, 0x8C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0x8E, 0x00,
  0x31, 0x80, 0x0E, 0x30, 0x01, 0xC6, 0x00, 0x30, 0xC0, 0x0E, 0x18, 0x03,
  0xC3, 0x80, 0x78, 0x70, 0x1F, 0x07, 0x06, 0xC0, 0xFF, 0x98, 0x0F, 0xE3,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0xFC, 0x07, 0x3F, 0xC0, 0xEC, 0x1C, 0x1B, 0x01, 0xC3, 0xC0,
  0x38, 0x70, 0x07, 0x1E, 0x00, 0x63, 0x80, 0x0C, 0x70, 0x01, 0x8C, 0x00,
  0x73, 0x80, 0x0E, 0x70, 0x01, 0xCC, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01,
  0xCE, 0x00, 0x31, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x70, 0xF0, 0x1C,
  0x33, 0x07, 0x86, 0x7F, 0xC0, 0xC7, 0xF0, 0x00, 0x01, 0xFF, 0x03, 0xFE,
  0x0F, 0x02, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x10, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x7E, 0x18, 0x0F,
  0xFD, 0xC0, 0xF0, 0x6C, 0x07, 0x01, 0xE0, 0x70, 0x0F, 0x07, 0x00, 0x38,
  0x30, 0x01, 0xC3, 0x80, 0x0C, 0x1C, 0x00, 0x60, 0xC0, 0x03, 0x0E, 0x00,
  0x38, 0x70, 0x01, 0xC3, 0x80, 0x0C, 0x18, 0x00, 0xE0, 0xC0, 0x07, 0x06,
  0x00, 0x38, 0x30, 0x03, 0x81, 0x80, 0x3C, 0x0C, 0x01, 0xE0, 0x70, 0x1B,
  0x01, 0xC1, 0x98, 0x0F, 0xF9, 0x80, 0x3F, 0x8C, 0x00, 0x01, 0xFC, 0x03,
  0xFE, 0x07, 0x07, 0x0E, 0x07, 0x1C, 0x03, 0x38, 0x03, 0x30, 0x07, 0x70,
  0x06, 0x60, 0x0E, 0x60, 0x3C, 0xFF, 0xF0, 0xFF, 0xC0, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x08, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x38, 0x80, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x18, 0x0F, 0xFC, 0xC0,
  0xF0, 0x6C, 0x07, 0x01, 0xE0, 0x70, 0x0F, 0x07, 0x00, 0x38, 0x30, 0x01,
  0xC3, 0x80, 0x0C, 0x1C, 0x00, 0x60, 0xC0, 0x03, 0x0E, 0x00, 0x38, 0x70,
  0x01, 0xC3, 0x80, 0x0C, 0x18, 0x00, 0xE0, 0xC0, 0x07, 0x06, 0x00, 0x38,
  0x30, 0x03, 0x81, 0x80, 0x3C, 0x0E, 0x01, 0xE0, 0x70, 0x1B, 0x01, 0xC1,
  0xB8, 0x0F, 0xF9, 0x80, 0x3F, 0x8C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x03, 0x00, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x63, 0xF0, 0x39, 0xFF,
  0x0C, 0xC1, 0xC3, 0x60, 0x30, 0xF0, 0x0C, 0x38, 0x03, 0x1C, 0x00, 0xC7,
  0x00, 0x31, 0xC0, 0x0C, 0x60, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x63, 0x00,
  0x18, 0xC0, 0x0E, 0x30, 0x03, 0x9C, 0x00, 0xC7, 0x00, 0x31, 0x80, 0x0C,
  0x60, 0x07, 0x18, 0x01, 0xCE, 0x00, 0x63, 0x80, 0x18, 0xC0, 0x0E, 0x00,
  0x03, 0x81, 0xC0, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x06, 0x07, 0x03,
  0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01,
  0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x1C, 0x38, 0x0E,
  0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x60, 0x1C, 0x38, 0x06,
  0x1C, 0x01, 0x8E, 0x00, 0x67, 0x00, 0x3B, 0xC0, 0x0F, 0xF0, 0x03, 0xEE,
  0x00, 0xE3, 0x80, 0x30, 0x60, 0x1C, 0x1C, 0x07, 0x07, 0x01, 0x80, 0xC0,
  0x60, 0x38, 0x18, 0x06, 0x0E, 0x01, 0x83, 0x80, 0x70, 0xC0, 0x0C, 0x00,
  0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01,
  0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81,
  0xC0, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0,
  0xC0, 0x00, 0x06, 0x3F, 0x07, 0xF0, 0x67, 0xFC, 0x7F, 0xC3, 0x70, 0xE6,
  0x0E, 0x1A, 0x03, 0x60, 0x30, 0xF0, 0x1E, 0x01, 0x87, 0x00, 0xF0, 0x0C,
  0x70, 0x07, 0x00, 0x63, 0x80, 0x38, 0x03, 0x1C, 0x01, 0x80, 0x18, 0xC0,
  0x0C, 0x01, 0xC6, 0x00, 0xE0, 0x0E, 0x70, 0x07, 0x00, 0x63, 0x00, 0x30,
  0x03, 0x18, 0x01, 0x80, 0x18, 0xC0, 0x0C, 0x01, 0xCE, 0x00, 0xE0, 0x0C,
  0x70, 0x06, 0x00, 0x63, 0x00, 0x30, 0x03, 0x18, 0x01, 0x80, 0x38, 0xC0,
  0x1C, 0x01, 0xCE, 0x00, 0xE0, 0x0C, 0x70, 0x06, 0x00, 0x63, 0x00, 0x30,
  0x03, 0x00, 0x06, 0x3F, 0x83, 0x1F, 0xF0, 0xCC, 0x1C, 0x36, 0x03, 0x0F,
  0x00, 0xC3, 0x80, 0x31, 0xC0, 0x0C, 0x70, 0x03, 0x1C, 0x01, 0xC6, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xE3, 0x00, 0x39,
  0xC0, 0x0C, 0x70, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x71, 0x80, 0x1C, 0xE0,
  0x06, 0x38, 0x01, 0x8C, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0xF0,
  0x70, 0x38, 0x0E, 0x1C, 0x01, 0x8E, 0x00, 0x63, 0x00, 0x1D, 0xC0, 0x07,
  0x60, 0x01, 0xD8, 0x00, 0x7E, 0x00, 0x1B, 0x80, 0x06, 0xC0, 0x01, 0xB0,
  0x00, 0xEC, 0x00, 0x3B, 0x00, 0x0C, 0xC0, 0x07, 0x30, 0x01, 0x8E, 0x00,
  0xE1, 0x80, 0x70, 0x70, 0x38, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0x8F,
  0xC0, 0x18, 0xFF, 0x00, 0xCC, 0x1C, 0x06, 0xC0, 0x70, 0x3C, 0x03, 0x81,
  0xC0, 0x1C, 0x1E, 0x00, 0x60, 0xE0, 0x03, 0x07, 0x00, 0x18, 0x30, 0x01,
  0xC1, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30,
  0x01, 0xC3, 0x80, 0x0C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x70,
  0x3C, 0x07, 0x03, 0xB0, 0x78, 0x1D, 0xFF, 0x80, 0xC7, 0xF0, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x60, 0xFF, 0xCC, 0x3C, 0x1B, 0x07, 0x01, 0xE1, 0xC0,
  0x3C, 0x70, 0x03, 0x8C, 0x00, 0x73, 0x80, 0x0C, 0x70, 0x01, 0x8C, 0x00,
  0x33, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x31, 0x80, 0x0E, 0x30, 0x01,
  0xC6, 0x00, 0x38, 0xC0, 0x0E, 0x18, 0x01, 0xC3, 0x00, 0x78, 0x70, 0x1B,
  0x07, 0x06, 0xE0, 0xFF, 0x98, 0x0F, 0xE3, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x3E, 0x18, 0xFC,
  0x33, 0x00, 0x6C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x0E, 0x02, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0xC0, 0x70, 0xFF, 0xF0,
  0x7F, 0xC0, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0xFF, 0xFF, 0xF8,
  0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0xF8, 0x3F, 0x00, 0x1C, 0x00, 0xC7, 0x00, 0x31, 0x80, 0x0C,
  0x60, 0x07, 0x18, 0x01, 0xCE, 0x00, 0x63, 0x80, 0x18, 0xC0, 0x06, 0x30,
  0x03, 0x9C, 0x00, 0xC7, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x07, 0x18, 0x01,
  0xCE, 0x00, 0x63, 0x80, 0x38, 0xC0, 0x0E, 0x30, 0x07, 0x8C, 0x01, 0xE3,
  0x80, 0xF0, 0xE0, 0xEC, 0x1F, 0xF3, 0x03, 0xF0, 0xC0, 0xE0, 0x03, 0xF0,
  0x01, 0xB8, 0x01, 0xCC, 0x00, 0xC6, 0x00, 0xE3, 0x00, 0x61, 0x80, 0x70,
  0xC0, 0x30, 0x60, 0x38, 0x30, 0x38, 0x18, 0x1C, 0x0E, 0x1C, 0x07, 0x0C,
  0x03, 0x8E, 0x00, 0xC6, 0x00, 0x67, 0x00, 0x33, 0x00, 0x1B, 0x80, 0x0D,
  0x80, 0x06, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x0E,
  0x00, 0xD8, 0x07, 0x80, 0x76, 0x01, 0xE0, 0x19, 0x80, 0x78, 0x0E, 0x60,
  0x36, 0x03, 0x18, 0x0D, 0x81, 0xC6, 0x06, 0x60, 0x61, 0x81, 0x98, 0x18,
  0x60, 0xC6, 0x0E, 0x18, 0x31, 0x83, 0x06, 0x1C, 0x61, 0xC1, 0x86, 0x18,
  0x60, 0x63, 0x86, 0x38, 0x18, 0xC1, 0x8C, 0x06, 0x30, 0x63, 0x01, 0x98,
  0x19, 0x80, 0x66, 0x06, 0x60, 0x1B, 0x01, 0xB8, 0x06, 0xC0, 0x6C, 0x01,
  0xE0, 0x1B, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x38, 0x18, 0x03, 0x80, 0xE0, 0x38, 0x03, 0x01, 0x80,
  0x18, 0x18, 0x00, 0xE1, 0xC0, 0x03, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0x6C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x6C, 0x00, 0x06, 0x60, 0x00, 0x73, 0x80, 0x07, 0x0C, 0x00, 0x30, 0x60,
  0x03, 0x03, 0x80, 0x38, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x03, 0x83, 0x80,
  0x0C, 0x00, 0x03, 0x80, 0x0E, 0x03, 0x00, 0x18, 0x06, 0x00, 0x70, 0x0C,
  0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0x60, 0x1C, 0x00, 0xE0,
  0x30, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0x80, 0x03, 0x07, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x38, 0x00, 0x18, 0x60, 0x00, 0x31, 0xC0, 0x00, 0x63, 0x00,
  0x00, 0xCE, 0x00, 0x01, 0x98, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xC3,
  0xFF, 0xE0, 0x00, 0x07, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x01, 0xE0,
  0x0F, 0x80, 0x1C, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xC0, 0x1F, 0xFE, 0x0E,
  0x03, 0xFE, 0x80, 0x3F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 31, 10, 1, -31 },
  { 36, 10, 11, 14, 5, -31 },
  { 50, 23, 31, 23, 1, -31 },
  { 140, 19, 36, 21, 1, -33 },
  { 226, 25, 31, 30, 3, -31 },
  { 323, 22, 31, 24, 1, -31 },
  { 409, 4, 11, 8, 5, -31 },
  { 415, 13, 38, 11, 1, -31 },
  { 477, 13, 38, 11, -3, -31 },
  { 539, 16, 17, 20, 5, -33 },
  { 573, 18, 20, 22, 3, -25 },
  { 618, 7, 11, 9, -2, -5 },
  { 628, 10, 3, 13, 1, -13 },
  { 632, 4, 4, 9, 1, -4 },
  { 634, 19, 31, 14, -2, -31 },
  { 708, 18, 31, 21, 2, -31 },
  { 778, 11, 31, 21, 6, -31 },
  { 821, 20, 31, 21, 0, -31 },
  { 899, 20, 31, 21, 0, -31 },
  { 977, 20, 31, 21, 0, -31 },
  { 1055, 20, 31, 21, 1, -31 },
  { 1133, 19, 31, 21, 2, -31 },
  { 1207, 19, 31, 21, 3, -31 },
  { 1281, 20, 31, 21, 1, -31 },
  { 1359, 19, 31, 21, 1, -31 },
  { 1433, 7, 23, 9, 1, -23 },
  { 1454, 10, 29, 9, -2, -23 },
  { 1491, 18, 19, 22, 3, -25 },
  { 1534, 18, 11, 22, 3, -21 },
  { 1559, 18, 19, 22, 3, -25 },
  { 1602, 15, 31, 16, 2, -31 },
  { 1661, 29, 35, 32, 2, -31 },
  { 1788, 21, 31, 21, -3, -31 },
  { 1870, 21, 31, 23, 1, -31 },
  { 1952, 21, 31, 22, 3, -31 },
  { 2034, 23, 31, 25, 1, -31 },
  { 2124, 20, 31, 20, 1, -31 },
  { 2202, 20, 31, 18, 1, -31 },
  { 2280, 23, 31, 26, 3, -31 },
  { 2370, 25, 31, 26, 1, -31 },
  { 2467, 15, 31, 12, -1, -31 },
  { 2526, 17, 39, 10, -7, -31 },
  { 2609, 24, 31, 21, 1, -31 },
  { 2702, 14, 31, 18, 1, -31 },
  { 2757, 31, 31, 32, 1, -31 },
  { 2878, 26, 31, 26, 1, -31 },
  { 2979, 23, 31, 27, 3, -31 },
  { 3069, 21, 31, 21, 1, -31 },
  { 3151, 23, 38, 27, 3, -31 },
  { 3261, 21, 31, 22, 1, -31 },
  { 3343, 20, 31, 19, 0, -31 },
  { 3421, 18, 31, 18, 4, -31 },
  { 3491, 23, 31, 26, 3, -31 },
  { 3581, 20, 31, 21, 4, -31 },
  { 3659, 31, 31, 33, 5, -31 },
  { 3780, 24, 31, 19, -2, -31 },
  { 3873, 18, 31, 19, 4, -31 },
  { 3943, 23, 31, 20, -1, -31 },
  { 4033, 16, 38, 12, -1, -31 },
  { 4109, 7, 31, 14, 4, -31 },
  { 4137, 16, 38, 12, -3, -31 },
  { 4213, 19, 18, 22, 1, -31 },
  { 4256, 16, 2, 15, -4, 4 },
  { 4260, 6, 7, 10, 6, -33 },
  { 4266, 19, 23, 22, 2, -23 },
  { 4321, 19, 33, 22, 1, -33 },
  { 4400, 16, 23, 17, 2, -23 },
  { 4446, 21, 33, 22, 2, -33 },
  { 4533, 16, 23, 19, 2, -23 },
  { 4579, 22, 43, 11, -5, -33 },
  { 4698, 21, 33, 22, 0, -23 },
  { 4785, 18, 33, 21, 1, -33 },
  { 4860, 9, 31, 9, 1, -31 },
  { 4895, 16, 41, 9, -6, -31 },
  { 4977, 18, 33, 18, 1, -33 },
  { 5052, 9, 33, 9, 1, -33 },
  { 5090, 29, 23, 33, 1, -23 },
  { 5174, 18, 23, 21, 1, -23 },
  { 5226, 18, 23, 21, 2, -23 },
  { 5278, 21, 33, 22, -1, -23 },
  { 5365, 19, 33, 22, 2, -23 },
  { 5444, 15, 23, 14, 1, -23 },
  { 5488, 16, 23, 16, 0, -23 },
  { 5534, 11, 28, 12, 2, -28 },
  { 5573, 18, 23, 22, 2, -23 },
  { 5625, 17, 23, 17, 2, -23 },
  { 5674, 26, 23, 27, 2, -23 },
  { 5749, 21, 23, 18, -2, -23 },
  { 5810, 23, 33, 17, -4, -23 },
  { 5905, 17, 23, 16, -1, -23 },
  { 5954, 16, 38, 14, 1, -31 },
  { 6030, 2, 43, 20, 10, -33 },
  { 6041, 15, 38, 14, -2, -31 },
  { 6113, 18, 5, 22, 3, -18 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC43PT7B_H_
