#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC19PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x21, 0x10, 0x84, 0x22, 0x00, 0x04, 0x60, 0x4A, 0xA5,
  0x29, 0x00, 0x04, 0x40, 0x90, 0x12, 0x04, 0x43, 0xFE, 0x12, 0x04, 0x40,
  0x88, 0x12, 0x1F, 0xF0, 0x88, 0x12, 0x02, 0x40, 0x88, 0x00, 0x02, 0x07,
  0x85, 0x24, 0x82, 0x41, 0x20, 0x60, 0x18, 0x0A, 0x04, 0x82, 0x52, 0x4F,
  0xC0, 0x80, 0x40, 0x18, 0x25, 0x09, 0x12, 0x24, 0x48, 0x91, 0x12, 0x22,
  0xBC, 0xA9, 0x65, 0x21, 0x24, 0x48, 0x89, 0x12, 0x24, 0x83, 0x80, 0x06,
  0x02, 0x41, 0x18, 0x44, 0x11, 0x06, 0x80, 0xC0, 0xF0, 0x64, 0x50, 0xAC,
  0x2A, 0x04, 0x43, 0x1F, 0x20, 0x5A, 0x80, 0x08, 0x8C, 0x44, 0x23, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x40, 0x10, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x21, 0x10, 0x88, 0x80, 0x09, 0x21, 0xC0, 0xF2, 0x89, 0x03, 0x00,
  0x08, 0x08, 0x08, 0x08, 0xFF, 0x08, 0x08, 0x08, 0x08, 0x2D, 0x60, 0xF0,
  0x70, 0x00, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08,
  0x08, 0x04, 0x04, 0x04, 0x00, 0x0C, 0x12, 0x21, 0x41, 0x41, 0x41, 0x81,
  0x83, 0x82, 0x82, 0x82, 0x84, 0x8C, 0x78, 0x13, 0xD9, 0x22, 0x22, 0x24,
  0x44, 0x4C, 0x0E, 0x08, 0x80, 0x20, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x04, 0x07, 0xF0, 0x0E, 0x18, 0xC0, 0x20, 0x10, 0x08,
  0x08, 0x78, 0x0C, 0x03, 0x00, 0x80, 0x40, 0x48, 0x27, 0xE0, 0x01, 0x80,
  0xC0, 0xC0, 0xA0, 0x90, 0x48, 0x4C, 0x44, 0x42, 0x61, 0x3F, 0xE0, 0x80,
  0x40, 0x20, 0x0F, 0x88, 0x04, 0x02, 0x02, 0x01, 0x00, 0xF8, 0x06, 0x01,
  0x00, 0x80, 0x40, 0x68, 0x67, 0xE0, 0x07, 0x18, 0x30, 0x20, 0x40, 0x40,
  0x7E, 0xC2, 0x82, 0x82, 0x82, 0x82, 0xC4, 0x78, 0x7F, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x20, 0x10, 0x10, 0x18, 0x08, 0x08, 0x04, 0x04, 0x06, 0x00,
  0x06, 0x0C, 0xC4, 0x26, 0x11, 0x08, 0x88, 0x38, 0x3C, 0x62, 0x20, 0x90,
  0x58, 0x24, 0x21, 0xE0, 0x1C, 0x22, 0x41, 0x41, 0x41, 0xC1, 0x43, 0x46,
  0x3A, 0x02, 0x04, 0x04, 0x08, 0xF0, 0x32, 0x00, 0x00, 0x00, 0x4C, 0x18,
  0x80, 0x00, 0x00, 0x00, 0x23, 0x11, 0x80, 0x01, 0x06, 0x18, 0x60, 0xC0,
  0x30, 0x0C, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x18, 0x06,
  0x03, 0x0C, 0x30, 0xC0, 0x39, 0x10, 0x41, 0x04, 0x21, 0x08, 0x41, 0x00,
  0x00, 0x83, 0x00, 0x03, 0x80, 0x63, 0x04, 0x04, 0x40, 0x24, 0x39, 0x22,
  0x46, 0x22, 0x32, 0x12, 0x91, 0x14, 0x88, 0xA4, 0xC9, 0x19, 0x88, 0x00,
  0x20, 0x00, 0x84, 0x03, 0xC0, 0x01, 0x01, 0x80, 0xC0, 0xA0, 0x50, 0x48,
  0x26, 0x21, 0x1F, 0x90, 0x48, 0x28, 0x14, 0x0C, 0x04, 0x3C, 0x11, 0x88,
  0x24, 0x12, 0x0A, 0x09, 0xF8, 0x8C, 0x41, 0x20, 0xA0, 0x50, 0x68, 0x67,
  0xE0, 0x07, 0x86, 0x33, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x0F, 0x80, 0x3C, 0x08, 0xC2, 0x08, 0x82,
  0x20, 0xD0, 0x34, 0x0D, 0x02, 0x40, 0x90, 0x28, 0x12, 0x0C, 0x86, 0x3E,
  0x00, 0x3F, 0x20, 0x20, 0x20, 0x20, 0x40, 0x7E, 0x40, 0x40, 0x40, 0x80,
  0x80, 0x80, 0xFC, 0x3F, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x7E, 0x40,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x07, 0x86, 0x13, 0x00, 0x80, 0x40, 0x10,
  0x04, 0x02, 0x0F, 0x80, 0xA0, 0x28, 0x09, 0x02, 0x41, 0x0F, 0xC0, 0x30,
  0x64, 0x08, 0x81, 0x10, 0x22, 0x04, 0x81, 0x1F, 0xE2, 0x04, 0x40, 0x88,
  0x12, 0x04, 0x40, 0x88, 0x11, 0x02, 0x00, 0x3C, 0x21, 0x04, 0x10, 0x43,
  0x08, 0x20, 0x82, 0x10, 0x43, 0x80, 0x03, 0x02, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0xF0, 0x30,
  0x48, 0x22, 0x10, 0x88, 0x24, 0x12, 0x05, 0x01, 0xA0, 0x48, 0x12, 0x08,
  0x42, 0x10, 0x86, 0x20, 0x80, 0x30, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41,
  0x08, 0x20, 0x83, 0xF0, 0x30, 0x09, 0x80, 0xCC, 0x06, 0x60, 0x53, 0x03,
  0x28, 0x29, 0x22, 0x49, 0x12, 0x49, 0x12, 0x49, 0x22, 0x89, 0x14, 0x48,
  0xC2, 0x46, 0x30, 0x30, 0x26, 0x04, 0xC1, 0x1C, 0x22, 0x84, 0x90, 0x93,
  0x12, 0x24, 0x44, 0x88, 0x92, 0x0A, 0x41, 0x88, 0x31, 0x02, 0x00, 0x07,
  0x06, 0x23, 0x04, 0x81, 0x40, 0x50, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38,
  0x0B, 0x06, 0x43, 0x0F, 0x80, 0x3C, 0x11, 0x88, 0x44, 0x32, 0x12, 0x09,
  0x0C, 0xFC, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x00, 0x07, 0x06, 0x23,
  0x04, 0x81, 0x40, 0x50, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0B, 0x06,
  0x43, 0x0F, 0x80, 0x40, 0x10, 0x02, 0x00, 0x3C, 0x11, 0x88, 0x44, 0x32,
  0x12, 0x09, 0x0C, 0xF8, 0x48, 0x22, 0x21, 0x10, 0x88, 0x64, 0x10, 0x0F,
  0x0C, 0x48, 0x04, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x80,
  0x48, 0x67, 0xE0, 0xFF, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x40, 0xC0, 0x20, 0x24, 0x08, 0x81, 0x10, 0x26, 0x04,
  0x81, 0x90, 0x22, 0x04, 0x40, 0x90, 0x12, 0x04, 0x40, 0x84, 0x20, 0xF8,
  0x00, 0x80, 0xC0, 0xA0, 0x50, 0x48, 0x24, 0x22, 0x11, 0x10, 0x88, 0x48,
  0x14, 0x0C, 0x06, 0x02, 0x00, 0x82, 0x06, 0x0C, 0x28, 0x50, 0xA1, 0x46,
  0x85, 0x12, 0x24, 0x48, 0x92, 0x24, 0x48, 0x91, 0x42, 0x85, 0x0A, 0x14,
  0x28, 0x60, 0xC1, 0x83, 0x04, 0x00, 0x10, 0x23, 0x08, 0x22, 0x04, 0x40,
  0x90, 0x0C, 0x01, 0x80, 0x20, 0x0A, 0x02, 0x40, 0xC8, 0x11, 0x84, 0x11,
  0x02, 0x00, 0x81, 0x82, 0x86, 0x84, 0x48, 0x48, 0x50, 0x60, 0x60, 0x40,
  0x40, 0x40, 0x40, 0xC0, 0x1F, 0xC8, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00,
  0xC0, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x3F, 0x80, 0x1E, 0x20,
  0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40,
  0xF0, 0x92, 0x44, 0x92, 0x49, 0x12, 0x40, 0x1E, 0x04, 0x10, 0x20, 0x40,
  0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0xE0, 0x08, 0x08,
  0x14, 0x24, 0x22, 0x42, 0x42, 0x81, 0xFE, 0xA4, 0x3D, 0x63, 0x43, 0x82,
  0x82, 0x82, 0x82, 0x86, 0x8C, 0x74, 0x10, 0x08, 0x04, 0x02, 0x02, 0xF1,
  0x84, 0x82, 0x41, 0x20, 0xA0, 0xD0, 0x48, 0x26, 0x25, 0xE0, 0x3E, 0xC1,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0xF0, 0x00, 0x80, 0x40, 0x20, 0x23,
  0xD3, 0x19, 0x0D, 0x04, 0x82, 0x41, 0x20, 0x90, 0xC8, 0xC3, 0xA0, 0x3E,
  0xC5, 0x0C, 0x2F, 0x90, 0x20, 0x40, 0x80, 0xF8, 0x01, 0x01, 0x41, 0x00,
  0x80, 0x40, 0xF8, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x60, 0x20, 0x10, 0x38, 0x10, 0x00, 0x1E, 0x98, 0xC8, 0x68, 0x24,
  0x12, 0x09, 0x04, 0x86, 0x46, 0x1D, 0x00, 0x80, 0x40, 0x46, 0x60, 0xC0,
  0x10, 0x08, 0x04, 0x02, 0x02, 0xF1, 0x8C, 0x82, 0x42, 0x21, 0x20, 0x90,
  0x48, 0x64, 0x26, 0x10, 0x11, 0x00, 0x32, 0x22, 0x24, 0x44, 0x4C, 0x02,
  0x04, 0x00, 0x00, 0x60, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04,
  0x08, 0x11, 0x41, 0x00, 0x10, 0x08, 0x04, 0x02, 0x12, 0x11, 0x10, 0x90,
  0x50, 0x38, 0x34, 0x13, 0x08, 0x84, 0x46, 0x30, 0x11, 0x11, 0x22, 0x22,
  0x24, 0x44, 0x4C, 0x2F, 0x79, 0x8C, 0x48, 0x62, 0x42, 0x12, 0x10, 0xA0,
  0x85, 0x08, 0x28, 0x42, 0x42, 0x16, 0x10, 0x80, 0x2F, 0x18, 0xC8, 0x64,
  0x22, 0x12, 0x09, 0x04, 0x86, 0x42, 0x61, 0x00, 0x3E, 0x62, 0x41, 0x81,
  0x83, 0x82, 0x82, 0x82, 0x84, 0x78, 0x17, 0x86, 0x11, 0x84, 0x41, 0x10,
  0x48, 0x32, 0x08, 0x82, 0x31, 0x1F, 0x84, 0x01, 0x00, 0x40, 0x30, 0x00,
  0x3D, 0x63, 0x43, 0x82, 0x82, 0x82, 0x82, 0x86, 0x8C, 0x74, 0x04, 0x04,
  0x04, 0x08, 0x2E, 0x60, 0x81, 0x02, 0x08, 0x10, 0x20, 0x41, 0x80, 0x3E,
  0xC1, 0x03, 0x03, 0x01, 0x01, 0x02, 0x0D, 0xF0, 0x21, 0x09, 0xF4, 0x21,
  0x08, 0x84, 0x21, 0x0E, 0x00, 0x41, 0x41, 0x42, 0x42, 0x82, 0x82, 0x86,
  0x84, 0x8C, 0xF4, 0x83, 0x0A, 0x14, 0x48, 0x92, 0x14, 0x30, 0x60, 0x80,
  0x84, 0x38, 0xC2, 0x8C, 0x48, 0xA4, 0x92, 0x89, 0x28, 0xA2, 0x8A, 0x30,
  0xC3, 0x0C, 0x20, 0x10, 0x88, 0x86, 0x81, 0xC0, 0xC0, 0x60, 0x50, 0x48,
  0x62, 0x61, 0x00, 0x10, 0x44, 0x31, 0x08, 0x46, 0x09, 0x02, 0xC0, 0xA0,
  0x38, 0x0C, 0x02, 0x00, 0x80, 0x40, 0x10, 0x28, 0x0C, 0x00, 0x3E, 0x0C,
  0x10, 0x41, 0x06, 0x08, 0x20, 0x81, 0xF0, 0x02, 0x18, 0x20, 0x41, 0x02,
  0x04, 0x08, 0xE0, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x30, 0xFF, 0xFF,
  0xE0, 0x10, 0x18, 0x10, 0x20, 0x41, 0x02, 0x04, 0x06, 0x10, 0x40, 0x81,
  0x02, 0x04, 0x10, 0xC0, 0x71, 0x8F,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 14, 4, 0, -14 },
  { 10, 5, 5, 6, 2, -14 },
  { 14, 11, 14, 10, 0, -14 },
  { 34, 9, 15, 9, 0, -14 },
  { 51, 11, 14, 13, 1, -14 },
  { 71, 10, 14, 11, 0, -14 },
  { 89, 2, 5, 4, 2, -14 },
  { 91, 5, 17, 5, 1, -14 },
  { 102, 5, 17, 5, -1, -14 },
  { 113, 7, 7, 9, 2, -14 },
  { 120, 8, 9, 10, 1, -11 },
  { 129, 3, 4, 4, -1, -2 },
  { 131, 4, 1, 6, 1, -6 },
  { 132, 2, 2, 4, 0, -2 },
  { 133, 9, 14, 6, -1, -14 },
  { 149, 8, 14, 9, 1, -14 },
  { 163, 4, 14, 9, 3, -14 },
  { 170, 9, 14, 9, 0, -14 },
  { 186, 9, 14, 9, 0, -14 },
  { 202, 9, 14, 9, 0, -14 },
  { 218, 9, 14, 9, 0, -14 },
  { 234, 8, 14, 9, 1, -14 },
  { 248, 9, 14, 9, 1, -14 },
  { 264, 9, 14, 9, 0, -14 },
  { 280, 8, 14, 9, 1, -14 },
  { 294, 4, 10, 4, 0, -10 },
  { 299, 5, 12, 4, -1, -10 },
  { 307, 8, 8, 10, 1, -11 },
  { 315, 8, 5, 10, 1, -9 },
  { 320, 8, 8, 10, 1, -11 },
  { 328, 6, 14, 7, 1, -14 },
  { 339, 13, 16, 14, 1, -14 },
  { 365, 9, 14, 9, -1, -14 },
  { 381, 9, 14, 10, 1, -14 },
  { 397, 10, 14, 10, 1, -14 },
  { 415, 10, 14, 11, 1, -14 },
  { 433, 8, 14, 9, 1, -14 },
  { 447, 8, 14, 8, 1, -14 },
  { 461, 10, 14, 12, 1, -14 },
  { 479, 11, 14, 11, 1, -14 },
  { 499, 6, 14, 5, 0, -14 },
  { 510, 8, 17, 4, -3, -14 },
  { 527, 10, 14, 9, 1, -14 },
  { 545, 6, 14, 8, 1, -14 },
  { 556, 13, 14, 14, 1, -14 },
  { 579, 11, 14, 12, 1, -14 },
  { 599, 10, 14, 12, 1, -14 },
  { 617, 9, 14, 9, 1, -14 },
  { 633, 10, 17, 12, 1, -14 },
  { 655, 9, 14, 10, 1, -14 },
  { 671, 9, 14, 9, 0, -14 },
  { 687, 8, 14, 8, 2, -14 },
  { 701, 11, 14, 11, 1, -14 },
  { 721, 9, 14, 9, 2, -14 },
  { 737, 14, 14, 14, 2, -14 },
  { 762, 11, 14, 8, -1, -14 },
  { 782, 8, 14, 8, 2, -14 },
  { 796, 10, 14, 9, 0, -14 },
  { 814, 7, 17, 6, 0, -14 },
  { 829, 3, 14, 6, 2, -14 },
  { 835, 7, 17, 6, -1, -14 },
  { 850, 8, 8, 10, 1, -14 },
  { 858, 7, 1, 7, -2, 2 },
  { 859, 2, 3, 5, 3, -15 },
  { 860, 8, 10, 10, 1, -10 },
  { 870, 9, 14, 10, 0, -14 },
  { 886, 7, 10, 7, 1, -10 },
  { 895, 9, 14, 10, 1, -14 },
  { 911, 7, 10, 8, 1, -10 },
  { 920, 9, 20, 5, -2, -15 },
  { 943, 9, 15, 10, 0, -10 },
  { 960, 9, 14, 9, 0, -14 },
  { 976, 4, 14, 4, 0, -14 },
  { 983, 7, 19, 4, -3, -14 },
  { 1000, 9, 14, 8, 0, -14 },
  { 1016, 4, 14, 4, 0, -14 },
  { 1023, 13, 10, 14, 0, -10 },
  { 1040, 9, 10, 9, 0, -10 },
  { 1052, 8, 10, 9, 1, -10 },
  { 1062, 10, 14, 10, -1, -10 },
  { 1080, 8, 14, 10, 1, -10 },
  { 1094, 7, 10, 6, 0, -10 },
  { 1103, 7, 10, 7, 0, -10 },
  { 1112, 5, 13, 5, 1, -13 },
  { 1121, 8, 10, 10, 1, -10 },
  { 1131, 7, 10, 7, 1, -10 },
  { 1140, 12, 10, 12, 1, -10 },
  { 1155, 9, 10, 8, -1, -10 },
  { 1167, 10, 15, 7, -2, -10 },
  { 1186, 7, 10, 7, 0, -10 },
  { 1195, 7, 17, 6, 0, -14 },
  { 1210, 1, 19, 9, 4, -14 },
  { 1213, 7, 17, 6, -1, -14 },
  { 1228, 8, 2, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC19PT7B_H_
