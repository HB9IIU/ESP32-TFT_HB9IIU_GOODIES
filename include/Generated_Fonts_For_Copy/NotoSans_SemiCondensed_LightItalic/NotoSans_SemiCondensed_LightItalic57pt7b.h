#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC57PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x01, 0x00, 0x00, 0x3C, 0x1C,
  0xF0, 0x73, 0x83, 0xCE, 0x0E, 0x38, 0x38, 0xE0, 0xE7, 0x03, 0x9C, 0x0C,
  0x70, 0x71, 0xC1, 0xC6, 0x07, 0x18, 0x18, 0xE0, 0x63, 0x81, 0x8C, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x18, 0x07, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x80,
  0x1C, 0x03, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x03, 0x80, 0x60, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0x03, 0x80, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x18, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x03, 0xF3, 0x3E, 0x01, 0xE1, 0xC1, 0x80, 0x70, 0x60,
  0x00, 0x38, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0,
  0xE0, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x07, 0xD8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0x3E, 0x00, 0x00, 0xC7, 0x80, 0x00, 0x70, 0xF0, 0x00,
  0x18, 0x1C, 0x00, 0x06, 0x07, 0x00, 0x01, 0x81, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x38, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03, 0x82, 0x00, 0xC1,
  0xC0, 0xE0, 0x71, 0xF0, 0x3F, 0xDF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x0E, 0x03, 0xFE, 0x00, 0x07, 0x01, 0xC7, 0x80, 0x07, 0x01, 0xC1,
  0xC0, 0x07, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x30, 0x03, 0x80, 0xE0,
  0x1C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0xC0, 0x70, 0x06, 0x01, 0xC0, 0x38,
  0x03, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0xE0, 0x0C, 0x01, 0xC0, 0xE0, 0x06,
  0x00, 0xE0, 0x60, 0x07, 0x00, 0x70, 0x70, 0x03, 0x80, 0x30, 0x70, 0x01,
  0xC0, 0x38, 0x38, 0x00, 0xE0, 0x1C, 0x38, 0x3C, 0x70, 0x0C, 0x38, 0x7F,
  0xB8, 0x0E, 0x1C, 0x7F, 0xDC, 0x07, 0x1C, 0x70, 0x7E, 0x07, 0x1C, 0x70,
  0x3F, 0x07, 0x8E, 0x38, 0x0D, 0xE7, 0x8E, 0x38, 0x06, 0xFF, 0x8E, 0x1C,
  0x03, 0x1F, 0x07, 0x0C, 0x01, 0x80, 0x07, 0x0E, 0x00, 0xC0, 0x07, 0x07,
  0x00, 0xE0, 0x03, 0x83, 0x80, 0x70, 0x03, 0x81, 0x80, 0x38, 0x03, 0x81,
  0xC0, 0x1C, 0x01, 0xC0, 0xE0, 0x0C, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x60,
  0x07, 0x01, 0xC0, 0x70, 0x03, 0x81, 0xC0, 0x70, 0x01, 0xC0, 0xE0, 0x30,
  0x00, 0x70, 0xE0, 0x38, 0x00, 0x3F, 0xE0, 0x38, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x01,
  0xC0, 0x1E, 0x00, 0x07, 0x00, 0x78, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0xE0,
  0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x03,
  0x80, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3B, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xBC, 0x00, 0x00, 0x78, 0x78, 0x01, 0xC3, 0xC0, 0xE0, 0x0E, 0x1E, 0x03,
  0xC0, 0x38, 0xF0, 0x07, 0x01, 0xC3, 0x80, 0x1E, 0x07, 0x1E, 0x00, 0x38,
  0x38, 0x70, 0x00, 0xF0, 0xE1, 0xC0, 0x01, 0xC7, 0x0F, 0x00, 0x07, 0xBC,
  0x38, 0x00, 0x0F, 0xE0, 0xE0, 0x00, 0x1F, 0x03, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0xF7, 0x01, 0xF0,
  0x07, 0x9E, 0x03, 0xE0, 0xFC, 0x3C, 0x07, 0xFF, 0xC0, 0x70, 0x0F, 0xFE,
  0x01, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x1C, 0xF3, 0x8E, 0x38, 0xE7, 0x1C,
  0x71, 0xC6, 0x18, 0xE3, 0x8C, 0x00, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x01, 0x80, 0x60, 0x07, 0x81, 0x80, 0x3F,
  0x8E, 0x00, 0x1F, 0x30, 0x00, 0x1F, 0xC7, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0xD8, 0x00, 0x0F, 0x60, 0x00, 0x79, 0xC0, 0x03, 0xC3, 0x00,
  0x1E, 0x0E, 0x00, 0xF0, 0x38, 0x03, 0x80, 0x70, 0x04, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x08, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x83, 0x83, 0xC1, 0xC1, 0xE0,
  0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7B, 0xFF, 0xFF, 0x10, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x0E, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0E,
  0x00, 0x07, 0x1E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x3C,
  0x00, 0x0F, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0,
  0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x3C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x78, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0,
  0x01, 0xE0, 0xE0, 0x01, 0xC0, 0xF0, 0x03, 0xC0, 0x70, 0x07, 0x80, 0x78,
  0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xF8, 0x3E,
  0xE3, 0xE3, 0x9F, 0x1C, 0xF0, 0x71, 0x81, 0xC4, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x03, 0xE0, 0x1E, 0x00, 0xE0, 0x03, 0xC0, 0x10, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0xFC, 0x03, 0xC0, 0x0E, 0x00, 0x3C, 0x01, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x08, 0x00, 0x07, 0x81, 0xC0, 0x03, 0xE0,
  0x3F, 0x03, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x79, 0xC0, 0x00,
  0x1C, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0x81, 0xC0,
  0x01, 0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x03,
  0x80, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x01, 0xC0, 0x3C, 0x00, 0xF0, 0x0E, 0x00, 0x38, 0x07,
  0x00, 0x0E, 0x03, 0x80, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1E, 0x07, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x80, 0x01, 0xF0, 0x30, 0x00, 0xF8, 0x0F, 0x81, 0xFC, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x3F, 0x80, 0x1C, 0x7F, 0xF0, 0x1E, 0xFD, 0xFC, 0x0E, 0xE0, 0x1F, 0x07,
  0x60, 0x07, 0x83, 0xE0, 0x01, 0xC1, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x78,
  0xF0, 0x00, 0x1C, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03,
  0x8E, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x0E, 0x00,
  0x3C, 0x07, 0x80, 0x1C, 0x03, 0xC0, 0x3E, 0x00, 0xF8, 0x7E, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x78,
  0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0,
  0xF0, 0x00, 0x70, 0x3C, 0x00, 0x1C, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x03,
  0x80, 0x70, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x78, 0x00, 0x70,
  0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x3E, 0x01, 0xE0,
  0x1E, 0x00, 0x38, 0x0F, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xC1, 0xE0, 0x00,
  0x78, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x38, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x01, 0xF8, 0x3E,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xF0, 0x3E, 0x03,
  0xC0, 0x0E, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x1C,
  0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x1F, 0x1C, 0x00, 0x1F, 0x1E,
  0x00, 0x3E, 0x0F, 0x00, 0xEE, 0x0F, 0xC3, 0xCE, 0x07, 0xFF, 0x9E, 0x03,
  0xFF, 0x1C, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x14, 0x00, 0x00, 0x01, 0x80, 0xF0, 0x7C, 0x1F, 0x07, 0x80,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x03, 0xE0, 0xF8, 0x3C, 0x0F, 0x01, 0x00, 0x00, 0x18, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x0E, 0x01, 0xE1, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x70, 0x01, 0xFF, 0x00, 0xC1, 0xC0, 0x0F, 0xFF, 0x01,
  0x83, 0x80, 0x3C, 0x1E, 0x03, 0x0E, 0x00, 0xE0, 0x18, 0x07, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x70, 0x0E, 0x00, 0xE0, 0x18, 0xE0, 0x1C, 0x01, 0xC0,
  0x31, 0xC0, 0x70, 0x03, 0x00, 0x63, 0x00, 0xC0, 0x0E, 0x01, 0xCE, 0x03,
  0x80, 0x1C, 0x03, 0x9C, 0x07, 0x00, 0x38, 0x07, 0x38, 0x0C, 0x00, 0xE0,
  0x0C, 0x70, 0x38, 0x01, 0xC0, 0x38, 0xC0, 0x70, 0x03, 0x80, 0x71, 0x80,
  0xE0, 0x0F, 0x00, 0xC7, 0x01, 0xC0, 0x1C, 0x03, 0x8E, 0x03, 0x80, 0x78,
  0x07, 0x1C, 0x07, 0x00, 0xF0, 0x1C, 0x38, 0x0E, 0x03, 0x60, 0x70, 0x30,
  0x0E, 0x0E, 0xE1, 0xE0, 0x60, 0x1F, 0xF8, 0xFF, 0x80, 0xE0, 0x1F, 0xE1,
  0xFC, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xF0,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01,
  0xC0, 0x70, 0x00, 0x70, 0x0F, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0xE0,
  0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x78, 0x78, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0xFC, 0x01, 0xE0,
  0x03, 0xE0, 0x1C, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x38,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x80, 0x70, 0x01, 0xF0, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xE0, 0x07,
  0xC0, 0x0E, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x78, 0x3C, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x78, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70,
  0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x07, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x06, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x01, 0x00, 0x1F, 0xE3, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x38,
  0x07, 0xF0, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x1C, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x0F, 0x81, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xE0, 0x1C, 0x00,
  0x1F, 0x00, 0x70, 0x01, 0xF8, 0x03, 0xC0, 0x1F, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0x08, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xF3, 0x80, 0x03, 0xFF, 0x8E,
  0x00, 0x0F, 0xFE, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x78,
  0x1E, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x07, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x01, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x78, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x07,
  0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x70, 0x03,
  0x80, 0x01, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x01, 0xE0, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xC0,
  0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x0E, 0x7C, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x73, 0xE0, 0x00, 0x00, 0xEF, 0xE0, 0x00,
  0x01, 0xF9, 0xC0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F, 0x83, 0x80, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xB8, 0x07, 0x60,
  0x00, 0x01, 0xDC, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x01, 0xDC, 0x00, 0x00,
  0xEE, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80,
  0x73, 0x80, 0x00, 0x73, 0xC0, 0x39, 0xC0, 0x00, 0x79, 0xC0, 0x3C, 0xE0,
  0x00, 0x38, 0xE0, 0x1C, 0x70, 0x00, 0x3C, 0x70, 0x0E, 0x18, 0x00, 0x1C,
  0x38, 0x07, 0x0E, 0x00, 0x1E, 0x3C, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x03,
  0x83, 0x80, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0xE0, 0xE0,
  0x07, 0x03, 0x80, 0x70, 0x70, 0x03, 0x83, 0xC0, 0x38, 0x38, 0x03, 0x81,
  0xC0, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x1C, 0x06, 0x01, 0xC0, 0x70, 0x0E,
  0x03, 0x80, 0xE0, 0x78, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x07, 0x80, 0xE0,
  0xF0, 0x1C, 0x03, 0x80, 0x70, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x78, 0x07,
  0x00, 0xE0, 0x1C, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x1C, 0x01, 0xC0, 0x38, 0x01, 0x9C, 0x00, 0xE0, 0x1C, 0x00, 0xEE,
  0x00, 0x70, 0x0E, 0x00, 0x7E, 0x00, 0x78, 0x07, 0x00, 0x3F, 0x00, 0x38,
  0x07, 0x00, 0x1F, 0x00, 0x1C, 0x03, 0x80, 0x0F, 0x80, 0x0E, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x38, 0x03,
  0xE0, 0x00, 0x0E, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x7E, 0x00, 0x01, 0xC0,
  0x1F, 0xC0, 0x00, 0x70, 0x07, 0x70, 0x00, 0x1C, 0x01, 0x9C, 0x00, 0x07,
  0x00, 0xE7, 0x80, 0x03, 0xC0, 0x38, 0xE0, 0x00, 0xE0, 0x0E, 0x38, 0x00,
  0x38, 0x03, 0x8F, 0x00, 0x0E, 0x01, 0xE1, 0xC0, 0x03, 0x80, 0x70, 0x70,
  0x01, 0xE0, 0x1C, 0x1E, 0x00, 0x70, 0x07, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0xE0, 0x07, 0x00, 0xF0, 0x3C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x03, 0x80,
  0x70, 0x03, 0x81, 0xE0, 0x1C, 0x00, 0xE0, 0x70, 0x07, 0x00, 0x1C, 0x1C,
  0x01, 0xC0, 0x07, 0x07, 0x00, 0xF0, 0x01, 0xC1, 0xC0, 0x38, 0x00, 0x38,
  0xF0, 0x0E, 0x00, 0x0E, 0x38, 0x03, 0x80, 0x03, 0x8E, 0x00, 0xE0, 0x00,
  0xF3, 0x80, 0x78, 0x00, 0x1C, 0xE0, 0x1C, 0x00, 0x07, 0x70, 0x07, 0x00,
  0x01, 0xFC, 0x01, 0xC0, 0x00, 0x3F, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x38,
  0x00, 0x03, 0xF0, 0x0E, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF0,
  0x0F, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x1E, 0x38, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x70, 0x1F, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0x80, 0x07, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0,
  0x01, 0xC0, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xF0,
  0x38, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00,
  0x1E, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x07,
  0x00, 0x0F, 0x00, 0xE0, 0x07, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x01,
  0xC0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x3C,
  0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x70, 0x1F, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0x80, 0x07, 0x80, 0x70,
  0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C,
  0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x0F, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0x00, 0x1F, 0x00, 0xE0, 0x1F,
  0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0F, 0x00, 0x1E, 0x00, 0xE0,
  0x03, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xC0,
  0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x70, 0x38, 0x00,
  0x0E, 0x07, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xE0, 0x1F,
  0x00, 0x04, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x08, 0x00,
  0x0F, 0x01, 0xC0, 0x07, 0xE0, 0x3F, 0x87, 0xF8, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x70, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x1E,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x0F, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x70, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x07, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x80, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x01, 0xE0,
  0x03, 0x80, 0x38, 0x00, 0x70, 0x0F, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0,
  0x78, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xE0, 0x70, 0x00,
  0x1C, 0x1E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xEE, 0x00,
  0x03, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xF8, 0x00, 0x1C, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0x38, 0x00, 0x1F, 0x80, 0x03, 0xCE, 0x00, 0x06, 0xE0, 0x00,
  0xE3, 0x80, 0x03, 0xB8, 0x00, 0x78, 0xE0, 0x00, 0xEE, 0x00, 0x1C, 0x38,
  0x00, 0x73, 0x80, 0x0F, 0x0E, 0x00, 0x1C, 0xE0, 0x03, 0x83, 0x80, 0x0E,
  0x38, 0x00, 0xE0, 0xE0, 0x03, 0x8E, 0x00, 0x70, 0x38, 0x01, 0xC3, 0x80,
  0x1C, 0x0E, 0x00, 0x70, 0xE0, 0x0F, 0x03, 0x80, 0x1C, 0x38, 0x03, 0x80,
  0xE0, 0x0E, 0x0E, 0x01, 0xE0, 0x38, 0x03, 0x83, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x38, 0x0E, 0x00, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x0E, 0x07, 0x00, 0xE0, 0x70,
  0x03, 0x81, 0xC0, 0x38, 0x3C, 0x00, 0xE0, 0x70, 0x0E, 0x0E, 0x00, 0x1C,
  0x38, 0x03, 0x83, 0x80, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x01, 0xC7, 0x00,
  0x38, 0x70, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x00, 0x1C, 0xE0, 0x03, 0x8E,
  0x00, 0x07, 0x38, 0x00, 0xE3, 0x80, 0x01, 0xDE, 0x00, 0x39, 0xC0, 0x00,
  0x77, 0x00, 0x0E, 0x70, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x07, 0xE0,
  0x00, 0xEE, 0x00, 0x01, 0xF8, 0x00, 0x3B, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x03,
  0x80, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x03,
  0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x0E,
  0x78, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x9C, 0x00, 0x03, 0x8E,
  0x00, 0x03, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xE1, 0xE0, 0x01, 0xE0,
  0x70, 0x00, 0xE0, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0xF0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x78, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x3C,
  0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x1E, 0x00, 0x03, 0x8E,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x20,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x18, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x18, 0x0E, 0x07,
  0x03, 0x80, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x30, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x0E, 0x00, 0x3C, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x06, 0x07, 0x00,
  0x03, 0x87, 0x80, 0x01, 0xC3, 0x80, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0,
  0x00, 0x1D, 0xC0, 0x00, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x70, 0x78, 0x38, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0xF0, 0xC0, 0x3F, 0xFC, 0xE0, 0x3E, 0x0E, 0x70, 0x3C,
  0x03, 0xB8, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x1C, 0x00, 0x1E, 0x1E,
  0x00, 0x0F, 0x0E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07,
  0x0F, 0x00, 0x03, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01,
  0xF0, 0x70, 0x01, 0xF0, 0x38, 0x00, 0xF8, 0x1E, 0x00, 0xDC, 0x0F, 0x01,
  0xCE, 0x03, 0xE3, 0xC7, 0x00, 0xFF, 0xC3, 0x00, 0x3F, 0xC3, 0x80, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0xF1, 0xFF, 0x00,
  0x38, 0xFF, 0xE0, 0x0E, 0x78, 0x3C, 0x03, 0xB8, 0x07, 0x80, 0xFC, 0x01,
  0xE0, 0x7E, 0x00, 0x38, 0x1F, 0x00, 0x0E, 0x07, 0x80, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x83,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x1C, 0x00, 0x03,
  0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x3C, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x70, 0x3C,
  0x00, 0x3C, 0x1F, 0x00, 0x0E, 0x07, 0x60, 0x07, 0x81, 0xDC, 0x07, 0xC0,
  0x67, 0xC7, 0xE0, 0x38, 0xFF, 0xF0, 0x0E, 0x1F, 0xF0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xE0, 0x30,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x01, 0x01, 0xF0, 0x70, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0A,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x1C,
  0x00, 0x3F, 0xF1, 0xE0, 0x03, 0xFF, 0xCE, 0x00, 0x3E, 0x0F, 0x70, 0x03,
  0xC0, 0x1B, 0x80, 0x3C, 0x00, 0xDC, 0x03, 0xC0, 0x03, 0xE0, 0x1C, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C,
  0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x70, 0x1E,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C,
  0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xF0, 0x07,
  0x00, 0x1F, 0x80, 0x38, 0x00, 0xD8, 0x01, 0xE0, 0x0D, 0xC0, 0x0F, 0x01,
  0xEE, 0x00, 0x3E, 0x1E, 0x70, 0x00, 0xFF, 0xE3, 0x80, 0x03, 0xFC, 0x18,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x7F,
  0xFC, 0x07, 0xC1, 0xE0, 0x78, 0x07, 0x87, 0x80, 0x1C, 0x78, 0x00, 0xE3,
  0x80, 0x07, 0x3C, 0x00, 0x79, 0xC0, 0x03, 0x9E, 0x00, 0x3C, 0xE0, 0x03,
  0xC7, 0x00, 0x3C, 0x78, 0x07, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF,
  0xC0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x03, 0x03, 0xE0, 0xF8, 0x0F, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7C, 0x20, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x1E, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xFE, 0x1C, 0x01, 0xFF, 0xE3, 0x00, 0x7C,
  0x1E, 0xE0, 0x1E, 0x00, 0xDC, 0x07, 0x80, 0x1B, 0x81, 0xE0, 0x01, 0xF0,
  0x38, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xE0, 0x38, 0x00, 0xFC,
  0x07, 0x00, 0x1B, 0x80, 0xF0, 0x06, 0xE0, 0x1E, 0x03, 0xDC, 0x01, 0xF0,
  0xF3, 0x80, 0x1F, 0xFC, 0x70, 0x01, 0xFE, 0x1C, 0x00, 0x04, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x80, 0x07, 0x80, 0x1E, 0x07, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x0F,
  0x80, 0x1C, 0x3F, 0xF0, 0x0E, 0x3F, 0xFC, 0x07, 0x38, 0x1E, 0x03, 0xB8,
  0x07, 0x01, 0xF8, 0x03, 0xC1, 0xF8, 0x00, 0xE0, 0xF8, 0x00, 0x70, 0x78,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xC1,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x38,
  0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x07,
  0x83, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x70, 0x70, 0x00, 0x78, 0x78, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x01, 0x0F, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x08, 0x1E, 0x00, 0x78, 0x0E, 0x00,
  0x78, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x38, 0x01, 0xC0,
  0x38, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x3C, 0x00, 0x03,
  0xBE, 0x00, 0x03, 0xBF, 0x80, 0x01, 0xFD, 0xC0, 0x00, 0xFC, 0xE0, 0x00,
  0x78, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0x1C, 0x03, 0x80,
  0x0E, 0x01, 0xC0, 0x07, 0x00, 0xF0, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x78, 0x00,
  0xF0, 0x38, 0x00, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x03, 0xF0, 0x07, 0x0F, 0xF8, 0x1F, 0xF0, 0x0E, 0x7F, 0xF0, 0x7F,
  0xF0, 0x1D, 0xE0, 0xF1, 0xC1, 0xF0, 0x3B, 0x00, 0xE7, 0x01, 0xE0, 0x6C,
  0x01, 0xDC, 0x01, 0xC1, 0xF0, 0x03, 0xF0, 0x03, 0x83, 0xE0, 0x03, 0xC0,
  0x07, 0x07, 0x80, 0x0F, 0x80, 0x0E, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x78, 0x00, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE0,
  0x01, 0xE1, 0xC0, 0x01, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x80, 0x07, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0x01, 0xC3,
  0xC0, 0x03, 0x80, 0x03, 0x87, 0x00, 0x07, 0x00, 0x0F, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x00, 0x70,
  0xE0, 0x00, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC0, 0x03, 0xC3, 0x80, 0x03,
  0x80, 0x07, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xC3, 0xFF,
  0x00, 0xE3, 0xFF, 0xC0, 0x73, 0xC1, 0xE0, 0x3B, 0x80, 0x78, 0x3B, 0x80,
  0x3C, 0x1F, 0x80, 0x1E, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0,
  0x03, 0xC3, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70,
  0x00, 0x78, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x07, 0x00, 0x07, 0x83, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xC1,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x78, 0x00, 0x38,
  0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x07,
  0x87, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xF0, 0x7C, 0x03, 0xC0, 0x1E, 0x07, 0x80,
  0x0E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x3C, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x78, 0x00,
  0x07, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0xF0, 0x00,
  0x1C, 0xF0, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0x70, 0x00,
  0xF0, 0x78, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x1F, 0x0F, 0x80, 0x0F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03,
  0x87, 0xFC, 0x00, 0x1C, 0x7F, 0xF0, 0x00, 0xE7, 0x83, 0xC0, 0x07, 0x70,
  0x0F, 0x00, 0x37, 0x00, 0x78, 0x03, 0xB0, 0x01, 0xC0, 0x1F, 0x00, 0x0E,
  0x00, 0xF8, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x38, 0x07, 0x00,
  0x01, 0xC0, 0x78, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x70, 0x07, 0x80,
  0x07, 0x80, 0x7C, 0x00, 0x38, 0x03, 0xB0, 0x03, 0xC0, 0x1D, 0xC0, 0x7C,
  0x00, 0xE7, 0x8F, 0xC0, 0x0F, 0x3F, 0xFC, 0x00, 0x70, 0x7F, 0x80, 0x03,
  0x80, 0x40, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0xF8, 0x70, 0x0F, 0xFF, 0x18, 0x07, 0xC1, 0xEE,
  0x03, 0xC0, 0x1B, 0x81, 0xE0, 0x06, 0xE0, 0xF0, 0x00, 0xF8, 0x38, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0x87, 0x80, 0x00, 0xE1,
  0xC0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x03, 0xE0, 0x70, 0x01, 0xF8, 0x1C, 0x00, 0x6E, 0x07,
  0x80, 0x37, 0x01, 0xE0, 0x3D, 0xC0, 0x3E, 0x1E, 0x70, 0x07, 0xFF, 0x1C,
  0x00, 0xFF, 0x0E, 0x00, 0x04, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x38, 0x7F, 0x03, 0x8F, 0xF0, 0x39, 0xE1, 0x03, 0xB8, 0x00, 0x37,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0xFE,
  0x0F, 0x80, 0xE0, 0x70, 0x01, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE1, 0x80, 0x1E, 0x0F, 0x83, 0xF0, 0x7F, 0xFF, 0x00, 0xFF,
  0xE0, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x7F, 0xFE, 0xFF, 0xFC, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC2, 0x07,
  0xFC, 0x07, 0xF8, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E,
  0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0xF0, 0x00, 0x70,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x01, 0xF0,
  0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xE0, 0xE0, 0x07, 0xE0, 0xE0, 0x0E, 0xE0,
  0xF0, 0x1C, 0xC0, 0xF8, 0x79, 0xC0, 0x7F, 0xF1, 0xC0, 0x3F, 0xE1, 0xC0,
  0x02, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xEE, 0x00, 0x07, 0xB8,
  0x00, 0x1C, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x1C, 0x00,
  0x70, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x70, 0x1C, 0x01, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70,
  0x38, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0xE0,
  0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x3B, 0x80, 0x00,
  0xEE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x7B, 0x80,
  0x0F, 0x80, 0x0E, 0x70, 0x01, 0xF0, 0x01, 0xCE, 0x00, 0x36, 0x00, 0x71,
  0xE0, 0x0E, 0xC0, 0x0E, 0x1C, 0x01, 0x98, 0x03, 0x83, 0x80, 0x73, 0x00,
  0x70, 0x70, 0x0E, 0x60, 0x1E, 0x0E, 0x03, 0x8C, 0x03, 0x81, 0xC0, 0x71,
  0x80, 0x70, 0x38, 0x1C, 0x38, 0x1C, 0x07, 0x03, 0x87, 0x03, 0x80, 0xE0,
  0xE0, 0xE0, 0xE0, 0x1C, 0x1C, 0x1C, 0x1C, 0x03, 0x87, 0x03, 0x87, 0x00,
  0x70, 0xE0, 0x70, 0xE0, 0x0E, 0x18, 0x0E, 0x3C, 0x01, 0xC7, 0x01, 0xC7,
  0x00, 0x38, 0xE0, 0x38, 0xE0, 0x07, 0x38, 0x07, 0x38, 0x00, 0xE7, 0x00,
  0xE7, 0x00, 0x1D, 0xC0, 0x1D, 0xC0, 0x03, 0xB8, 0x03, 0xB8, 0x00, 0x7E,
  0x00, 0x76, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x78, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x07, 0x80, 0x0F, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x1C,
  0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1E, 0x3C,
  0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x07, 0x00, 0x0F,
  0x00, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x38,
  0x07, 0x80, 0x07, 0x81, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x00,
  0xE0, 0x0F, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x00, 0xC7, 0x80, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x87, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x08, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x9F, 0xFC, 0x00, 0xDF, 0xFF, 0x81, 0xFC, 0x03, 0xFF,
  0xEC, 0x00, 0x7F, 0xE4, 0x00, 0x0F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 13, 42, 13, 1, -41 },
  { 70, 14, 15, 19, 6, -41 },
  { 97, 31, 41, 31, 1, -41 },
  { 256, 26, 46, 28, 1, -43 },
  { 406, 33, 42, 40, 4, -41 },
  { 580, 30, 42, 32, 1, -41 },
  { 738, 6, 15, 11, 6, -41 },
  { 750, 17, 50, 15, 2, -41 },
  { 857, 17, 50, 15, -4, -41 },
  { 964, 22, 22, 27, 6, -43 },
  { 1025, 25, 27, 29, 3, -34 },
  { 1110, 9, 13, 12, -2, -6 },
  { 1125, 13, 3, 17, 2, -17 },
  { 1130, 5, 6, 12, 1, -5 },
  { 1134, 26, 41, 18, -3, -41 },
  { 1268, 24, 42, 28, 3, -41 },
  { 1394, 14, 41, 28, 8, -41 },
  { 1466, 26, 41, 28, 0, -41 },
  { 1600, 27, 42, 28, 0, -41 },
  { 1742, 26, 41, 28, 0, -41 },
  { 1876, 26, 42, 28, 1, -41 },
  { 2013, 25, 42, 28, 3, -41 },
  { 2145, 25, 41, 28, 4, -41 },
  { 2274, 26, 42, 28, 1, -41 },
  { 2411, 24, 42, 28, 2, -41 },
  { 2537, 10, 32, 12, 1, -31 },
  { 2577, 14, 38, 12, -3, -31 },
  { 2644, 25, 25, 29, 3, -33 },
  { 2723, 24, 14, 29, 3, -27 },
  { 2765, 25, 25, 29, 3, -33 },
  { 2844, 19, 42, 21, 3, -41 },
  { 2944, 39, 46, 42, 2, -41 },
  { 3169, 27, 41, 28, -3, -41 },
  { 3308, 28, 41, 30, 2, -41 },
  { 3452, 28, 42, 29, 4, -41 },
  { 3599, 30, 41, 33, 2, -41 },
  { 3753, 26, 41, 26, 2, -41 },
  { 3887, 26, 41, 24, 2, -41 },
  { 4021, 30, 42, 35, 4, -41 },
  { 4179, 33, 41, 34, 2, -41 },
  { 4349, 20, 41, 15, -1, -41 },
  { 4452, 23, 51, 13, -9, -41 },
  { 4599, 31, 41, 28, 2, -41 },
  { 4758, 18, 41, 24, 2, -41 },
  { 4851, 41, 41, 43, 2, -41 },
  { 5062, 34, 41, 35, 2, -41 },
  { 5237, 30, 42, 36, 4, -41 },
  { 5395, 27, 41, 28, 2, -41 },
  { 5534, 30, 51, 36, 4, -41 },
  { 5726, 27, 41, 29, 2, -41 },
  { 5865, 27, 42, 26, 0, -41 },
  { 6007, 24, 41, 24, 5, -41 },
  { 6130, 31, 42, 34, 4, -41 },
  { 6293, 27, 41, 27, 5, -41 },
  { 6432, 42, 41, 43, 6, -41 },
  { 6648, 33, 41, 25, -3, -41 },
  { 6818, 25, 41, 25, 5, -41 },
  { 6947, 30, 41, 26, -1, -41 },
  { 7101, 22, 50, 17, -1, -41 },
  { 7239, 9, 41, 19, 6, -41 },
  { 7286, 21, 50, 17, -4, -41 },
  { 7418, 25, 24, 29, 2, -41 },
  { 7493, 20, 3, 20, -5, 5 },
  { 7501, 8, 9, 14, 8, -44 },
  { 7510, 25, 32, 29, 2, -31 },
  { 7610, 26, 44, 29, 1, -43 },
  { 7753, 21, 32, 22, 2, -31 },
  { 7837, 29, 44, 29, 2, -43 },
  { 7997, 21, 32, 25, 3, -31 },
  { 8081, 29, 58, 15, -7, -44 },
  { 8292, 27, 45, 29, 1, -31 },
  { 8444, 25, 43, 28, 1, -43 },
  { 8579, 12, 41, 12, 1, -41 },
  { 8641, 21, 55, 12, -8, -41 },
  { 8786, 25, 43, 24, 1, -43 },
  { 8921, 12, 43, 12, 1, -43 },
  { 8986, 39, 31, 43, 1, -31 },
  { 9138, 25, 31, 28, 1, -31 },
  { 9235, 24, 32, 28, 2, -31 },
  { 9331, 29, 44, 29, -2, -31 },
  { 9491, 26, 44, 29, 2, -31 },
  { 9634, 20, 31, 19, 1, -31 },
  { 9712, 21, 32, 22, 0, -31 },
  { 9796, 15, 39, 16, 2, -38 },
  { 9870, 24, 31, 29, 3, -30 },
  { 9963, 22, 30, 22, 3, -30 },
  { 10046, 35, 30, 35, 3, -30 },
  { 10178, 27, 30, 23, -2, -30 },
  { 10280, 31, 44, 22, -6, -30 },
  { 10451, 23, 30, 21, -1, -30 },
  { 10538, 21, 50, 19, 1, -41 },
  { 10670, 3, 57, 27, 13, -43 },
  { 10692, 21, 50, 19, -3, -41 },
  { 10824, 25, 6, 29, 3, -23 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC57PT7B_H_
