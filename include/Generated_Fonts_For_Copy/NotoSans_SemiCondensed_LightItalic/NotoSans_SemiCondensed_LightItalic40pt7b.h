#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC40PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x07,
  0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x38, 0x1C, 0x0E, 0x00, 0x30, 0xCC,
  0x33, 0x1D, 0xC6, 0x61, 0x98, 0x66, 0x19, 0x84, 0x43, 0x30, 0xCC, 0x30,
  0x00, 0x30, 0x20, 0x01, 0x83, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06,
  0x0C, 0x00, 0x20, 0x60, 0x03, 0x03, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x03, 0x06, 0x00, 0x10, 0x30, 0x01, 0x81,
  0x80, 0x0C, 0x18, 0x00, 0x40, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x60, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0xC0, 0x80, 0x06, 0x0C, 0x00, 0x20, 0x60,
  0x03, 0x03, 0x00, 0x18, 0x30, 0x00, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60,
  0xC0, 0x03, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x03, 0xFC, 0x03, 0xFF, 0xC1, 0xC4, 0x60, 0xE3, 0x00, 0x30, 0xC0, 0x0C,
  0x30, 0x07, 0x08, 0x01, 0xC6, 0x00, 0x31, 0x80, 0x0E, 0x60, 0x01, 0xD0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x37, 0x00, 0x08, 0xE0,
  0x02, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60, 0x04, 0x38, 0x01,
  0x0C, 0x30, 0xCE, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x80, 0x0C, 0x3F, 0x80, 0x30, 0x63,
  0x00, 0x61, 0x83, 0x01, 0x87, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18,
  0x30, 0x60, 0x20, 0xC0, 0xC0, 0xC1, 0x81, 0x81, 0x86, 0x03, 0x03, 0x18,
  0x06, 0x06, 0x30, 0x0C, 0x18, 0xC7, 0xD8, 0x33, 0x19, 0xF0, 0xC6, 0x61,
  0xE3, 0x99, 0x83, 0x7E, 0x63, 0x06, 0x78, 0xCE, 0x0C, 0x03, 0x18, 0x18,
  0x0C, 0x30, 0x30, 0x18, 0x60, 0x60, 0x60, 0xC0, 0xC1, 0x83, 0x03, 0x03,
  0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x38, 0x18, 0x30, 0x60, 0x18, 0x61, 0x80,
  0x3B, 0x87, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF8, 0x00, 0x70,
  0xC0, 0x07, 0x07, 0x00, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00,
  0x60, 0x70, 0x03, 0x03, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x80, 0x07, 0x70,
  0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xCC, 0x01, 0x1C,
  0x70, 0x31, 0xC1, 0x81, 0x9C, 0x0E, 0x18, 0xC0, 0x30, 0xCE, 0x01, 0xCC,
  0x60, 0x06, 0xE3, 0x00, 0x3E, 0x18, 0x00, 0xE0, 0xC0, 0x07, 0x07, 0x00,
  0x7C, 0x1C, 0x0E, 0x60, 0xFF, 0xE3, 0x83, 0xFC, 0x0E, 0x00, 0x33, 0x37,
  0x66, 0x66, 0x4C, 0xC0, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x30, 0x07, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x18, 0x20, 0x40, 0xE1, 0x03, 0xEC,
  0x01, 0xF7, 0xC1, 0xFF, 0x07, 0x00, 0x36, 0x03, 0x98, 0x1C, 0x30, 0xE0,
  0xC1, 0x03, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0E, 0x18,
  0x70, 0xC3, 0x86, 0x1C, 0x30, 0xC0, 0xFF, 0xFF, 0xC0, 0x5F, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0xE1, 0xC0,
  0xC0, 0x60, 0xE0, 0x30, 0xE0, 0x1C, 0x60, 0x06, 0x30, 0x03, 0x30, 0x01,
  0x98, 0x01, 0xDC, 0x00, 0xEC, 0x00, 0x76, 0x00, 0x3B, 0x00, 0x1B, 0x80,
  0x0D, 0xC0, 0x06, 0xC0, 0x07, 0x60, 0x03, 0xB0, 0x01, 0x98, 0x00, 0xCC,
  0x00, 0xE6, 0x00, 0x63, 0x00, 0x71, 0x80, 0x30, 0xC0, 0x38, 0x70, 0x18,
  0x1C, 0x38, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0x81, 0xC3, 0xE3, 0xB3,
  0xBF, 0x9B, 0x0D, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x30,
  0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18,
  0x0C, 0x0E, 0x06, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1E, 0x0F, 0x01,
  0x80, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF, 0x0F, 0xFF,
  0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1E, 0x0F, 0x01, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC3, 0x00, 0x70, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x6C, 0x00, 0x1B,
  0x00, 0x06, 0x60, 0x01, 0xCC, 0x00, 0x31, 0x80, 0x0C, 0x70, 0x03, 0x0C,
  0x00, 0xC1, 0x80, 0x38, 0x30, 0x06, 0x06, 0x01, 0x81, 0xC0, 0x60, 0x30,
  0x1C, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x30, 0x07, 0x0F, 0xFF, 0xFD,
  0xFF, 0xFF, 0x80, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xF0,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0xF0,
  0x07, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x07, 0x08, 0x03, 0x83, 0xFF, 0xC0, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC3, 0x80, 0x77, 0xF8, 0x1B, 0x87, 0x07, 0x80, 0xE1, 0xC0,
  0x18, 0xE0, 0x06, 0x38, 0x01, 0x8E, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06,
  0x30, 0x01, 0x8C, 0x00, 0xE3, 0x00, 0x30, 0xE0, 0x1C, 0x18, 0x06, 0x07,
  0x03, 0x80, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xD0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x7F, 0xC0, 0x38, 0x38, 0x1C, 0x07, 0x06, 0x00, 0xC3, 0x80, 0x30, 0xC0,
  0x0C, 0x30, 0x03, 0x0E, 0x01, 0xC1, 0x80, 0x60, 0x60, 0x38, 0x1C, 0x18,
  0x03, 0x9C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3C, 0xE0, 0x1C, 0x1C, 0x0E,
  0x03, 0x87, 0x00, 0x61, 0x80, 0x1C, 0xE0, 0x07, 0x30, 0x00, 0xCC, 0x00,
  0x73, 0x00, 0x1C, 0xE0, 0x06, 0x38, 0x03, 0x87, 0x01, 0xC0, 0xFF, 0xE0,
  0x1F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x78, 0x70, 0x18, 0x0E,
  0x0E, 0x01, 0x87, 0x00, 0x61, 0x80, 0x18, 0x60, 0x07, 0x38, 0x01, 0xCE,
  0x00, 0x73, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x8E, 0x00, 0xE1, 0x80,
  0x78, 0x70, 0x3E, 0x0F, 0xFB, 0x01, 0xF8, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x04, 0x1C, 0x78,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x07, 0x0E, 0x1C, 0x00, 0x00, 0x80, 0x70, 0x3C, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60,
  0x18, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0x80, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0xC3, 0x87,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xC1, 0xE0, 0x07, 0x80, 0x1C, 0x03,
  0x80, 0x03, 0x81, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x30, 0x00, 0x03,
  0x18, 0x01, 0x00, 0xCE, 0x03, 0xFC, 0x33, 0x03, 0x86, 0x04, 0xC1, 0xC1,
  0x81, 0x60, 0x60, 0x60, 0xD8, 0x30, 0x18, 0x34, 0x0C, 0x0C, 0x0F, 0x06,
  0x03, 0x03, 0xC1, 0x80, 0xC0, 0xF0, 0x60, 0x30, 0x2C, 0x30, 0x18, 0x1B,
  0x0C, 0x06, 0x06, 0xC3, 0x03, 0x83, 0x30, 0x60, 0xA1, 0xCC, 0x18, 0xCC,
  0xE3, 0x03, 0xE3, 0xF0, 0xC0, 0x20, 0x20, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x10, 0x00,
  0xF0, 0x38, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xD8, 0x00, 0x1B,
  0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x31, 0x80, 0x06, 0x38, 0x01, 0x87,
  0x00, 0x30, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x30, 0x0C, 0x06,
  0x03, 0x00, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0x00, 0x60, 0xC0, 0x0C,
  0x38, 0x01, 0xC6, 0x00, 0x39, 0xC0, 0x07, 0x30, 0x00, 0x6E, 0x00, 0x0D,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x06, 0x03, 0xF8, 0x00, 0x3F, 0xF8,
  0x03, 0x07, 0xC0, 0x30, 0x0E, 0x07, 0x00, 0x70, 0x60, 0x07, 0x06, 0x00,
  0x70, 0x60, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x06, 0x0C, 0x00, 0xE0, 0xC0,
  0x1C, 0x0C, 0x03, 0x81, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0x80, 0x70, 0x18,
  0x03, 0x81, 0x80, 0x18, 0x38, 0x01, 0xC3, 0x00, 0x1C, 0x30, 0x01, 0xC3,
  0x00, 0x1C, 0x30, 0x01, 0x87, 0x00, 0x18, 0x60, 0x03, 0x86, 0x00, 0x70,
  0x60, 0x1E, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x1F,
  0xFC, 0x07, 0x83, 0x83, 0xC0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x10,
  0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xC3,
  0xF0, 0x06, 0x01, 0xC0, 0x70, 0x07, 0x03, 0x00, 0x18, 0x18, 0x00, 0xE0,
  0xC0, 0x03, 0x0E, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00,
  0x30, 0xC0, 0x01, 0x8E, 0x00, 0x0C, 0x70, 0x00, 0x63, 0x00, 0x07, 0x18,
  0x00, 0x38, 0xC0, 0x01, 0x8E, 0x00, 0x1C, 0x60, 0x00, 0xE3, 0x00, 0x06,
  0x18, 0x00, 0x70, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0x60, 0x07, 0x03, 0x00,
  0x70, 0x18, 0x0F, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xC0, 0x78, 0x1E,
  0x0F, 0x00, 0x20, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x7F, 0x98, 0x03, 0xFC, 0xC0, 0x00,
  0xE6, 0x00, 0x07, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60,
  0x00, 0xE3, 0x00, 0x06, 0x1C, 0x00, 0x30, 0xE0, 0x01, 0x83, 0x80, 0x0C,
  0x0E, 0x00, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x06,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x70, 0x70, 0x00, 0xC0,
  0xC0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x1C, 0x1C,
  0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x83, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00,
  0xE0, 0xE0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C,
  0x0C, 0x00, 0x38, 0x38, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81,
  0x80, 0x07, 0x03, 0x00, 0x0E, 0x0E, 0x00, 0x18, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x1F, 0x80, 0xFF, 0x00,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x03, 0x00, 0x1C, 0x0C, 0x00, 0xE0, 0x30, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x01, 0xC0, 0x18, 0x0E, 0x00, 0x60, 0x70, 0x01, 0x83, 0x80, 0x0E, 0x1C,
  0x00, 0x38, 0x60, 0x00, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x0C, 0xE0, 0x00,
  0x77, 0x00, 0x01, 0xBE, 0x00, 0x07, 0x98, 0x00, 0x1C, 0x70, 0x00, 0x60,
  0xC0, 0x03, 0x83, 0x00, 0x0C, 0x0E, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x60,
  0x03, 0x01, 0xC0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x06,
  0x00, 0x60, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x38,
  0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xF0, 0x6C,
  0x00, 0x0F, 0x03, 0x60, 0x00, 0xD8, 0x1B, 0x00, 0x0E, 0xC0, 0xD8, 0x00,
  0x6E, 0x0E, 0xC0, 0x07, 0x60, 0x66, 0x00, 0x33, 0x03, 0x30, 0x03, 0x98,
  0x18, 0xC0, 0x18, 0xC0, 0xC6, 0x01, 0x8E, 0x0E, 0x30, 0x0C, 0x60, 0x61,
  0x80, 0xC3, 0x03, 0x0C, 0x06, 0x18, 0x18, 0x60, 0x60, 0xC0, 0xC3, 0x03,
  0x0E, 0x0E, 0x18, 0x30, 0x60, 0x60, 0xC3, 0x83, 0x03, 0x03, 0x18, 0x18,
  0x18, 0x19, 0xC1, 0xC0, 0xC0, 0xCC, 0x0E, 0x0C, 0x06, 0xE0, 0x60, 0x60,
  0x36, 0x03, 0x03, 0x01, 0xE0, 0x18, 0x18, 0x0F, 0x01, 0xC1, 0xC0, 0x70,
  0x0C, 0x0C, 0x03, 0x80, 0x60, 0x00, 0x03, 0x80, 0x03, 0x03, 0x80, 0x07,
  0x03, 0x80, 0x06, 0x03, 0xC0, 0x06, 0x06, 0xC0, 0x06, 0x06, 0xC0, 0x06,
  0x06, 0xE0, 0x0E, 0x06, 0x60, 0x0C, 0x0E, 0x60, 0x0C, 0x0C, 0x60, 0x0C,
  0x0C, 0x30, 0x0C, 0x0C, 0x30, 0x1C, 0x0C, 0x30, 0x18, 0x1C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0x18, 0x1C, 0x38, 0x18, 0x0C, 0x30,
  0x38, 0x0C, 0x30, 0x30, 0x0E, 0x30, 0x30, 0x06, 0x70, 0x30, 0x06, 0x60,
  0x30, 0x07, 0x60, 0x60, 0x03, 0x60, 0x60, 0x03, 0x60, 0x60, 0x03, 0xE0,
  0x60, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x1E, 0x0F, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x38, 0x38,
  0x00, 0x60, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x18, 0x00, 0x0C, 0xE0, 0x00,
  0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x76,
  0x00, 0x01, 0xD8, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0xEE, 0x00,
  0x03, 0xB8, 0x00, 0x0C, 0x60, 0x00, 0x71, 0x80, 0x01, 0xC6, 0x00, 0x0E,
  0x18, 0x00, 0x30, 0x70, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0xC0, 0x70, 0x07,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x0C, 0x3E,
  0x01, 0x80, 0xE0, 0x70, 0x0E, 0x0C, 0x01, 0xC1, 0x80, 0x18, 0x30, 0x03,
  0x0E, 0x00, 0x61, 0xC0, 0x1C, 0x30, 0x03, 0x86, 0x00, 0x60, 0xC0, 0x1C,
  0x38, 0x07, 0x06, 0x01, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1E, 0x0F, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0x38, 0x38, 0x00, 0x60, 0xC0, 0x01, 0xC7, 0x00, 0x07,
  0x18, 0x00, 0x0C, 0xE0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x70,
  0x00, 0x1D, 0xC0, 0x00, 0x76, 0x00, 0x01, 0xD8, 0x00, 0x06, 0x60, 0x00,
  0x19, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0C, 0x60, 0x00, 0x71,
  0x80, 0x01, 0xC6, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x70, 0x01, 0xC0, 0xE0,
  0x0E, 0x03, 0xC0, 0x70, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x0C, 0x3F,
  0x01, 0x80, 0xE0, 0x70, 0x0E, 0x0C, 0x01, 0xC1, 0x80, 0x18, 0x30, 0x03,
  0x0E, 0x00, 0x61, 0xC0, 0x1C, 0x30, 0x03, 0x86, 0x00, 0x60, 0xC0, 0x1C,
  0x38, 0x07, 0x06, 0x07, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0x06, 0x00,
  0xE0, 0xE0, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x03,
  0x80, 0x60, 0x60, 0x0E, 0x0C, 0x01, 0xC1, 0x80, 0x18, 0x70, 0x03, 0x0E,
  0x00, 0x70, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x0F, 0x07, 0x03, 0x80, 0x20,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x83, 0x00, 0xF0, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x06, 0x38, 0x00, 0x71,
  0x80, 0x03, 0x8C, 0x00, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x06, 0x30, 0x00,
  0x71, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x06, 0x30,
  0x00, 0x71, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x0E,
  0x30, 0x00, 0x71, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0xC3, 0x00,
  0x0C, 0x18, 0x00, 0x60, 0xC0, 0x07, 0x07, 0x00, 0x70, 0x1C, 0x07, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00,
  0x07, 0x60, 0x00, 0xCC, 0x00, 0x39, 0x80, 0x06, 0x30, 0x01, 0xC6, 0x00,
  0x30, 0xE0, 0x0E, 0x1C, 0x01, 0x81, 0x80, 0x70, 0x30, 0x0C, 0x06, 0x03,
  0x80, 0xC0, 0x60, 0x18, 0x1C, 0x03, 0x03, 0x00, 0x60, 0xE0, 0x0C, 0x18,
  0x01, 0x87, 0x00, 0x30, 0xC0, 0x06, 0x38, 0x00, 0xC6, 0x00, 0x1D, 0xC0,
  0x03, 0xB0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x6C, 0x00,
  0x70, 0x03, 0xB0, 0x03, 0xC0, 0x0C, 0xC0, 0x0F, 0x00, 0x73, 0x00, 0x3C,
  0x01, 0x8C, 0x01, 0xB0, 0x06, 0x30, 0x06, 0xC0, 0x30, 0xE0, 0x33, 0x00,
  0xC3, 0x80, 0xCC, 0x07, 0x0E, 0x06, 0x30, 0x18, 0x38, 0x18, 0xC0, 0xE0,
  0xE0, 0xE3, 0x03, 0x03, 0x83, 0x0C, 0x0C, 0x0E, 0x0C, 0x30, 0x60, 0x18,
  0x60, 0xC1, 0x80, 0x61, 0x83, 0x0E, 0x01, 0x8C, 0x0C, 0x30, 0x06, 0x30,
  0x31, 0xC0, 0x19, 0x80, 0xC6, 0x00, 0x66, 0x03, 0x18, 0x01, 0xB8, 0x04,
  0xC0, 0x06, 0xC0, 0x13, 0x00, 0x1B, 0x00, 0x58, 0x00, 0x78, 0x01, 0x60,
  0x01, 0xE0, 0x05, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x60, 0x01, 0x80, 0x00, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x60, 0x0E, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x38,
  0x00, 0x30, 0xE0, 0x00, 0x61, 0x80, 0x00, 0xC6, 0x00, 0x01, 0xDC, 0x00,
  0x01, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x98, 0x00, 0x07, 0x30, 0x00, 0x0C,
  0x70, 0x00, 0x30, 0x60, 0x00, 0xE0, 0xC0, 0x03, 0x81, 0x80, 0x06, 0x03,
  0x80, 0x18, 0x03, 0x00, 0x70, 0x06, 0x01, 0xC0, 0x0E, 0x03, 0x00, 0x0C,
  0x0E, 0x00, 0x18, 0x00, 0xC0, 0x03, 0xE0, 0x01, 0xB0, 0x01, 0xDC, 0x01,
  0xCE, 0x00, 0xC3, 0x00, 0xE1, 0x80, 0x60, 0xC0, 0x60, 0x70, 0x70, 0x18,
  0x30, 0x0C, 0x30, 0x06, 0x38, 0x03, 0x18, 0x01, 0xDC, 0x00, 0x6C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFE, 0x01, 0xFC, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0xC1, 0x83, 0x03, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x60, 0x00, 0xD8,
  0x00, 0x62, 0x00, 0x38, 0xC0, 0x0C, 0x30, 0x06, 0x06, 0x01, 0x81, 0x80,
  0xC0, 0x60, 0x30, 0x0C, 0x18, 0x03, 0x0E, 0x00, 0x63, 0x00, 0x19, 0x80,
  0x06, 0xE0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xC7, 0x18, 0xE3, 0x0C,
  0x60, 0x00, 0xE0, 0x01, 0xFC, 0xC3, 0xC6, 0x63, 0x81, 0xB1, 0x80, 0x71,
  0xC0, 0x38, 0xC0, 0x1C, 0xE0, 0x0E, 0x60, 0x07, 0x70, 0x03, 0x38, 0x01,
  0x98, 0x00, 0xCC, 0x00, 0xE6, 0x00, 0x73, 0x00, 0x31, 0x80, 0x38, 0xC0,
  0x1C, 0x60, 0x1E, 0x30, 0x1A, 0x1C, 0x1B, 0x07, 0xF9, 0x81, 0xF8, 0xC0,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x18, 0x03, 0x1F, 0xC0, 0xDC,
  0x70, 0x36, 0x0E, 0x1F, 0x01, 0x87, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x07,
  0x18, 0x01, 0xCE, 0x00, 0x73, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C,
  0x00, 0xE7, 0x00, 0x31, 0xC0, 0x0C, 0x70, 0x07, 0x1C, 0x03, 0x87, 0x00,
  0xC3, 0x60, 0x70, 0xCF, 0xF8, 0x31, 0xF8, 0x00, 0x00, 0xF0, 0x0F, 0xF0,
  0xF8, 0xC7, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x08, 0x7F, 0xE0, 0x7F, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0xE1, 0xC0, 0x7F, 0x30, 0x3C,
  0x76, 0x0E, 0x02, 0xC1, 0x80, 0x78, 0x70, 0x06, 0x0C, 0x00, 0xC3, 0x80,
  0x18, 0x60, 0x03, 0x1C, 0x00, 0xE3, 0x80, 0x18, 0x60, 0x03, 0x0C, 0x00,
  0x61, 0x80, 0x1C, 0x30, 0x03, 0x86, 0x00, 0xE0, 0xC0, 0x1C, 0x18, 0x07,
  0x83, 0x01, 0xB0, 0x70, 0x66, 0x07, 0xF9, 0x80, 0x7E, 0x30, 0x00, 0x00,
  0xE0, 0x07, 0xF0, 0x3C, 0x70, 0x60, 0x71, 0x80, 0xE7, 0x01, 0xCC, 0x03,
  0x30, 0x06, 0x60, 0x19, 0xC0, 0xF3, 0xFF, 0x87, 0xFC, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x83, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xC0, 0x01,
  0xE4, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x02, 0x70, 0x00, 0x1F,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xCC, 0x0F, 0x1D,
  0x83, 0x80, 0xB0, 0x60, 0x1E, 0x1C, 0x01, 0x83, 0x00, 0x30, 0xE0, 0x06,
  0x18, 0x00, 0xC7, 0x00, 0x38, 0xE0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18,
  0x60, 0x07, 0x0C, 0x00, 0xE1, 0x80, 0x38, 0x30, 0x07, 0x06, 0x01, 0xE0,
  0xC0, 0x6C, 0x1C, 0x1B, 0x81, 0xFE, 0x60, 0x1F, 0x8C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x08,
  0x03, 0x81, 0xE3, 0xE0, 0x1F, 0xF0, 0x00, 0x30, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x1C, 0x06, 0x3F, 0x83, 0x71, 0xE1, 0xA0, 0x71, 0xE0,
  0x18, 0xF0, 0x0C, 0x70, 0x06, 0x30, 0x03, 0x18, 0x03, 0x9C, 0x01, 0x8C,
  0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x39, 0xC0, 0x18, 0xC0, 0x0C,
  0x60, 0x06, 0x30, 0x07, 0x18, 0x03, 0x9C, 0x01, 0x8C, 0x00, 0xC6, 0x00,
  0x60, 0x03, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x02, 0x0C, 0x0C, 0x0C,
  0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60,
  0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x9C, 0x03, 0xE0,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x01,
  0xC3, 0x01, 0x81, 0x81, 0x81, 0xC1, 0xC0, 0xC1, 0xC0, 0x61, 0xC0, 0x31,
  0xC0, 0x19, 0xC0, 0x1D, 0xC0, 0x0D, 0xE0, 0x07, 0xF0, 0x03, 0xCC, 0x01,
  0xC6, 0x01, 0xC3, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x38, 0x18, 0x0C,
  0x1C, 0x06, 0x0C, 0x03, 0x86, 0x00, 0xC0, 0x03, 0x03, 0x03, 0x07, 0x06,
  0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18,
  0x38, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xC0,
  0xC0, 0x00, 0x38, 0x07, 0x01, 0x9F, 0xC3, 0xF8, 0x37, 0x1C, 0xE7, 0x87,
  0x81, 0xB0, 0x31, 0xE0, 0x3C, 0x06, 0x3C, 0x07, 0x00, 0xC7, 0x00, 0xE0,
  0x18, 0xC0, 0x18, 0x03, 0x18, 0x03, 0x00, 0x67, 0x00, 0xE0, 0x1C, 0xC0,
  0x18, 0x03, 0x18, 0x03, 0x00, 0x63, 0x00, 0x60, 0x0C, 0x60, 0x0C, 0x01,
  0x9C, 0x03, 0x80, 0x73, 0x00, 0x60, 0x0C, 0x60, 0x0C, 0x01, 0x8C, 0x01,
  0x80, 0x31, 0x80, 0x30, 0x06, 0x70, 0x0E, 0x01, 0xCC, 0x01, 0x80, 0x31,
  0x80, 0x30, 0x06, 0x00, 0x00, 0x1C, 0x06, 0x3F, 0x83, 0x79, 0xE1, 0xF0,
  0x71, 0xE0, 0x18, 0xF0, 0x0C, 0x70, 0x06, 0x38, 0x03, 0x18, 0x03, 0x9C,
  0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x71, 0x80, 0x39, 0xC0, 0x18,
  0xC0, 0x0C, 0x60, 0x06, 0x30, 0x07, 0x38, 0x03, 0x9C, 0x01, 0x8C, 0x00,
  0xC6, 0x00, 0xE0, 0x00, 0x60, 0x03, 0xFC, 0x0F, 0x1E, 0x1C, 0x06, 0x18,
  0x07, 0x38, 0x03, 0x30, 0x03, 0x60, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0,
  0x0C, 0xC0, 0x1C, 0xE0, 0x38, 0x70, 0x70, 0x7F, 0xE0, 0x1F, 0xC0, 0x00,
  0x07, 0x00, 0x31, 0xFC, 0x03, 0x31, 0xC0, 0x36, 0x0E, 0x03, 0xC0, 0x60,
  0x78, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x06, 0x00, 0x70, 0xE0, 0x07,
  0x0E, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x0E, 0x1C, 0x00,
  0xC1, 0xC0, 0x0C, 0x1C, 0x01, 0xC1, 0xC0, 0x38, 0x1C, 0x03, 0x03, 0x60,
  0x70, 0x33, 0xFE, 0x03, 0x1F, 0x80, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFC, 0xC3, 0xC7, 0x63,
  0x80, 0xB1, 0x80, 0x79, 0xC0, 0x38, 0xC0, 0x0C, 0xE0, 0x06, 0x60, 0x03,
  0x70, 0x03, 0xB8, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x73, 0x00,
  0x39, 0x80, 0x38, 0xC0, 0x1C, 0x60, 0x1E, 0x30, 0x1B, 0x1C, 0x1B, 0x87,
  0xF9, 0x81, 0xF8, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x33, 0xF0, 0xDE, 0x83, 0x60, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x01, 0xE0, 0x0F, 0xFC, 0x38, 0x70, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC4, 0x03, 0x8F, 0xFE, 0x0F, 0xF0, 0x00, 0x06, 0x03, 0x00, 0xC0,
  0x30, 0x1C, 0x3F, 0xFF, 0xFC, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xFC, 0x1F, 0x00, 0x18, 0x01, 0x8C, 0x01, 0xC6, 0x00, 0xC7,
  0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x1C, 0xE0, 0x0C, 0x60, 0x06,
  0x30, 0x03, 0x18, 0x01, 0x8C, 0x01, 0xCE, 0x00, 0xC6, 0x00, 0x63, 0x00,
  0x71, 0x80, 0x38, 0xC0, 0x38, 0x60, 0x3C, 0x38, 0x36, 0x1F, 0xF3, 0x07,
  0xF1, 0x80, 0xC0, 0x07, 0xC0, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0x60, 0x18,
  0x60, 0x38, 0x60, 0x30, 0x60, 0x70, 0x60, 0x60, 0x60, 0xC0, 0x60, 0xC0,
  0x61, 0x80, 0x61, 0x80, 0x63, 0x00, 0x73, 0x00, 0x36, 0x00, 0x36, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x18, 0x03, 0xE0,
  0x3C, 0x07, 0xE0, 0x3C, 0x06, 0xE0, 0x6C, 0x0E, 0xE0, 0x6C, 0x0C, 0xE0,
  0xCC, 0x0C, 0x60, 0xCC, 0x18, 0x60, 0xCC, 0x18, 0x61, 0x8C, 0x30, 0x61,
  0x8C, 0x30, 0x63, 0x0C, 0x70, 0x63, 0x0C, 0x60, 0x66, 0x0C, 0xE0, 0x66,
  0x0C, 0xC0, 0x6C, 0x0C, 0xC0, 0x6C, 0x0D, 0x80, 0x78, 0x0D, 0x80, 0x78,
  0x0F, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0x70, 0x0E, 0x00, 0x07,
  0x00, 0xF0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x18, 0x38, 0x01, 0x87, 0x00,
  0x1C, 0x60, 0x00, 0xCC, 0x00, 0x0D, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xB0, 0x00, 0x3B, 0x80, 0x07, 0x18,
  0x00, 0x61, 0x80, 0x0C, 0x0C, 0x01, 0xC0, 0xC0, 0x38, 0x0C, 0x03, 0x00,
  0x60, 0xE0, 0x06, 0x00, 0x03, 0x80, 0x1C, 0x06, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x01, 0x80, 0x60, 0x06, 0x03, 0x80, 0x18, 0x0C, 0x00,
  0x60, 0x70, 0x01, 0x81, 0x80, 0x06, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x31,
  0xC0, 0x00, 0xC6, 0x00, 0x03, 0x38, 0x00, 0x0C, 0xC0, 0x00, 0x37, 0x00,
  0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x9E, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xFF, 0xF8, 0xFF, 0xF0,
  0x00, 0x04, 0x00, 0xF0, 0x0F, 0x80, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x1C, 0x03, 0xC0, 0x0F, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFC, 0x01,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xF0, 0x03, 0xC0, 0x38, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x03, 0xF0, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0xBF, 0xE0, 0xF0, 0x3F, 0xF0, 0x07, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 29, 9, 1, -29 },
  { 34, 10, 11, 13, 4, -29 },
  { 48, 21, 29, 22, 1, -29 },
  { 125, 18, 32, 19, 1, -30 },
  { 197, 23, 29, 28, 3, -29 },
  { 281, 21, 29, 23, 1, -29 },
  { 358, 4, 11, 7, 4, -29 },
  { 364, 12, 35, 10, 1, -29 },
  { 417, 12, 35, 10, -3, -29 },
  { 470, 14, 15, 19, 5, -30 },
  { 497, 17, 19, 21, 2, -24 },
  { 538, 7, 9, 8, -2, -4 },
  { 546, 9, 2, 12, 1, -12 },
  { 549, 3, 4, 9, 1, -4 },
  { 551, 18, 29, 13, -2, -29 },
  { 617, 17, 29, 19, 2, -29 },
  { 679, 9, 29, 19, 6, -29 },
  { 712, 19, 29, 19, 0, -29 },
  { 781, 19, 29, 19, 0, -29 },
  { 850, 19, 29, 19, 0, -29 },
  { 919, 18, 29, 19, 1, -29 },
  { 985, 18, 29, 19, 2, -29 },
  { 1051, 17, 29, 19, 3, -29 },
  { 1113, 18, 29, 19, 1, -29 },
  { 1179, 18, 29, 19, 1, -29 },
  { 1245, 7, 22, 9, 1, -22 },
  { 1265, 10, 27, 9, -2, -22 },
  { 1299, 17, 18, 21, 2, -23 },
  { 1338, 17, 10, 21, 2, -19 },
  { 1360, 17, 18, 21, 2, -23 },
  { 1399, 14, 29, 14, 2, -29 },
  { 1450, 26, 33, 29, 2, -29 },
  { 1558, 19, 29, 19, -2, -29 },
  { 1627, 20, 29, 21, 1, -29 },
  { 1700, 19, 29, 20, 3, -29 },
  { 1769, 21, 29, 23, 1, -29 },
  { 1846, 19, 29, 18, 1, -29 },
  { 1915, 19, 29, 17, 1, -29 },
  { 1984, 21, 29, 24, 3, -29 },
  { 2061, 23, 29, 24, 1, -29 },
  { 2145, 14, 29, 11, -1, -29 },
  { 2196, 16, 36, 9, -6, -29 },
  { 2268, 22, 29, 20, 1, -29 },
  { 2348, 13, 29, 17, 1, -29 },
  { 2396, 29, 29, 30, 1, -29 },
  { 2502, 24, 29, 25, 1, -29 },
  { 2589, 22, 29, 25, 2, -29 },
  { 2669, 19, 29, 20, 1, -29 },
  { 2738, 22, 36, 25, 2, -29 },
  { 2837, 19, 29, 20, 1, -29 },
  { 2906, 19, 29, 18, 0, -29 },
  { 2975, 17, 29, 17, 4, -29 },
  { 3037, 21, 29, 24, 3, -29 },
  { 3114, 19, 29, 19, 4, -29 },
  { 3183, 30, 29, 30, 4, -29 },
  { 3292, 23, 29, 18, -2, -29 },
  { 3376, 17, 29, 17, 4, -29 },
  { 3438, 21, 29, 18, -1, -29 },
  { 3515, 15, 35, 12, -1, -29 },
  { 3581, 7, 29, 13, 4, -29 },
  { 3607, 15, 35, 12, -3, -29 },
  { 3673, 18, 17, 20, 1, -29 },
  { 3712, 14, 2, 14, -3, 4 },
  { 3716, 5, 7, 10, 6, -31 },
  { 3721, 17, 22, 20, 2, -22 },
  { 3768, 18, 30, 20, 1, -30 },
  { 3836, 14, 22, 16, 2, -22 },
  { 3875, 19, 30, 20, 2, -30 },
  { 3947, 15, 22, 18, 2, -22 },
  { 3989, 21, 41, 10, -5, -31 },
  { 4097, 19, 32, 20, 0, -22 },
  { 4173, 17, 30, 20, 1, -30 },
  { 4237, 8, 29, 8, 1, -29 },
  { 4266, 14, 39, 8, -5, -29 },
  { 4335, 17, 30, 17, 1, -30 },
  { 4399, 8, 30, 8, 1, -30 },
  { 4429, 27, 22, 30, 1, -22 },
  { 4504, 17, 22, 20, 1, -22 },
  { 4551, 16, 22, 20, 2, -22 },
  { 4595, 20, 31, 20, -1, -22 },
  { 4673, 17, 31, 20, 2, -22 },
  { 4739, 14, 22, 13, 1, -22 },
  { 4778, 15, 22, 15, 0, -22 },
  { 4820, 10, 26, 11, 2, -26 },
  { 4853, 17, 21, 20, 2, -21 },
  { 4898, 16, 21, 16, 2, -21 },
  { 4940, 24, 21, 25, 2, -21 },
  { 5003, 20, 21, 16, -2, -21 },
  { 5056, 22, 31, 16, -4, -21 },
  { 5142, 16, 21, 15, -1, -21 },
  { 5184, 14, 35, 13, 1, -29 },
  { 5246, 2, 40, 19, 9, -30 },
  { 5256, 14, 35, 13, -2, -29 },
  { 5318, 17, 4, 21, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC40PT7B_H_
