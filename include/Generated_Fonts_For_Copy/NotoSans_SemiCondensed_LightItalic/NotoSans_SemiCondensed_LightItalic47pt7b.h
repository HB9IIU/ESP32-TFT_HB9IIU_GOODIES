#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC47PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00,
  0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x00, 0x38, 0x73, 0x86, 0x30,
  0x67, 0x0E, 0x70, 0xE7, 0x0C, 0x60, 0xC6, 0x0C, 0x60, 0xCE, 0x18, 0xC1,
  0x8C, 0x18, 0xC1, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x07, 0x00, 0x07,
  0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xE0, 0x00,
  0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x38, 0x00, 0x38, 0x18, 0x07,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x06, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x01, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x70, 0x00, 0x70, 0x30, 0x00, 0x30, 0x18, 0x07, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x06, 0x03, 0x00, 0x03, 0x03,
  0x80, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0xE0,
  0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x71, 0x82,
  0x07, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x83, 0x00, 0x1C, 0x18, 0x00, 0xE1,
  0x80, 0x07, 0x0C, 0x00, 0x38, 0x60, 0x00, 0xE3, 0x00, 0x03, 0x90, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x13,
  0xC0, 0x01, 0x8E, 0x00, 0x0C, 0x38, 0x00, 0x61, 0xC0, 0x03, 0x0E, 0x00,
  0x30, 0x70, 0x01, 0x83, 0x80, 0x0C, 0x18, 0x00, 0x61, 0xC3, 0x03, 0x1C,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xC0, 0x7F, 0x00, 0x1C, 0x0E, 0x38, 0x01, 0x81, 0xC3, 0x80, 0x30,
  0x18, 0x18, 0x07, 0x03, 0x81, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x01,
  0x81, 0xC0, 0x60, 0x18, 0x18, 0x06, 0x03, 0x83, 0x00, 0x60, 0x38, 0x70,
  0x06, 0x03, 0x06, 0x00, 0xE0, 0x30, 0xC0, 0x0E, 0x07, 0x1C, 0x10, 0xE0,
  0x61, 0x8F, 0xCE, 0x06, 0x31, 0xFE, 0xE0, 0xE7, 0x38, 0x76, 0x0C, 0x63,
  0x07, 0x73, 0x8C, 0x70, 0x37, 0xF1, 0xC6, 0x03, 0x1E, 0x18, 0xE0, 0x30,
  0x03, 0x0C, 0x07, 0x00, 0x70, 0xC0, 0x70, 0x06, 0x0C, 0x06, 0x00, 0xE1,
  0xC0, 0x60, 0x1C, 0x1C, 0x06, 0x01, 0x81, 0x80, 0xE0, 0x38, 0x18, 0x0C,
  0x07, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x1C, 0x0E, 0x01, 0xC1, 0x80, 0xC0,
  0x1C, 0x38, 0x18, 0x00, 0xFF, 0x03, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0,
  0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x30, 0x01, 0x80, 0x30, 0x01, 0x80,
  0x70, 0x01, 0x80, 0x70, 0x01, 0x80, 0xE0, 0x01, 0x80, 0xE0, 0x01, 0xC1,
  0xC0, 0x01, 0xC3, 0x80, 0x00, 0xCF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0x1C,
  0x07, 0x38, 0x0C, 0x07, 0x38, 0x0E, 0x0E, 0x70, 0x07, 0x0E, 0x60, 0x07,
  0x1C, 0xE0, 0x03, 0x98, 0xE0, 0x03, 0xB8, 0xE0, 0x01, 0xF0, 0xE0, 0x01,
  0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xF0, 0x70, 0x07, 0x70, 0x78, 0x1E,
  0x38, 0x3F, 0xFC, 0x38, 0x1F, 0xF0, 0x1C, 0x39, 0xCC, 0x67, 0x39, 0x8C,
  0x67, 0x31, 0x8C, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x40, 0x60, 0x18, 0x18, 0x0F, 0x84, 0x00, 0xFB, 0x00, 0x07, 0xDF,
  0xC0, 0x7F, 0xF0, 0x1C, 0x00, 0x1D, 0x80, 0x0E, 0x60, 0x07, 0x0C, 0x03,
  0x83, 0x01, 0xC0, 0xE0, 0x30, 0x18, 0x00, 0x07, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x0E, 0x1C, 0x38, 0xE1, 0xC7, 0x0E,
  0x18, 0x70, 0xC3, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01, 0xF3,
  0xC0, 0x3C, 0x0E, 0x03, 0x80, 0x60, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x18, 0x00, 0x73, 0x80, 0x07, 0x38,
  0x00, 0x73, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x66,
  0x00, 0x06, 0x60, 0x00, 0xE6, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0C,
  0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0x8E, 0x00, 0x38, 0xE0, 0x03,
  0x8E, 0x00, 0x70, 0xE0, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x1C, 0x03, 0x83,
  0x80, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x30, 0x0F, 0x01, 0xF0, 0x7F,
  0x0F, 0x61, 0xEE, 0x78, 0xEF, 0x0E, 0x40, 0xC0, 0x0C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0x80, 0x1F, 0x8F, 0x00, 0xF0, 0x0E, 0x01, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0xC0, 0x1F, 0x0F, 0x80, 0xE0, 0x0E, 0x01, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x08, 0x00, 0x78, 0x38, 0x03, 0xC0, 0xFF,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xD8, 0x00, 0x06, 0xE0, 0x00, 0x33,
  0x80, 0x01, 0xCC, 0x00, 0x0E, 0x30, 0x00, 0x31, 0xC0, 0x01, 0x87, 0x00,
  0x0E, 0x18, 0x00, 0x70, 0x60, 0x03, 0x83, 0x80, 0x0C, 0x0E, 0x00, 0x60,
  0x38, 0x03, 0x80, 0xC0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x70,
  0x1C, 0x01, 0xC0, 0xE0, 0x06, 0x07, 0x00, 0x18, 0x18, 0x00, 0xE1, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x0C, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC2, 0x00, 0x3C,
  0x1C, 0x07, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0xC0, 0x1F, 0x84, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x3E, 0x00, 0xE7, 0xFC,
  0x06, 0x79, 0xF0, 0x76, 0x03, 0xC3, 0xE0, 0x0E, 0x1E, 0x00, 0x70, 0xE0,
  0x01, 0x87, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x80, 0x03, 0x1C, 0x00, 0x18,
  0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x06, 0x00,
  0x38, 0x38, 0x03, 0x81, 0xC0, 0x38, 0x07, 0x03, 0xC0, 0x1F, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0x00, 0x7C, 0x3C, 0x03, 0x80, 0xF0, 0x38, 0x03, 0x81, 0x80,
  0x0C, 0x1C, 0x00, 0x60, 0xE0, 0x03, 0x07, 0x00, 0x18, 0x38, 0x01, 0xC1,
  0xC0, 0x0E, 0x06, 0x00, 0xE0, 0x38, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x9E,
  0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x01, 0xE3, 0xC0, 0x3C,
  0x07, 0x03, 0xC0, 0x38, 0x1C, 0x00, 0xE1, 0xC0, 0x03, 0x0C, 0x00, 0x1C,
  0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0x8E, 0x00,
  0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x0E, 0x07, 0x81, 0xE0, 0x1F, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7C, 0x78, 0x07,
  0x81, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x18, 0x38, 0x00, 0xE1, 0xC0, 0x07,
  0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x30, 0x00, 0x71, 0x80,
  0x03, 0x8C, 0x00, 0x1C, 0x60, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xF0,
  0xF0, 0x0F, 0x83, 0xC1, 0xDC, 0x0F, 0xFC, 0xC0, 0x3F, 0x8E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0xF0,
  0x10, 0x0F, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x07, 0x0F, 0x0F,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xF0, 0xF0, 0xE0, 0x00, 0xE0,
  0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x07, 0xF0, 0x7F, 0xF0, 0xF9, 0xF1, 0x80, 0xF0, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x03,
  0x80, 0x3C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0C, 0x30, 0x07, 0xFC, 0x18,
  0xC0, 0x3F, 0xF0, 0x31, 0x80, 0xE0, 0x60, 0x66, 0x03, 0x80, 0xC0, 0xCC,
  0x06, 0x03, 0x81, 0xB8, 0x18, 0x06, 0x03, 0x60, 0x70, 0x0C, 0x06, 0xC0,
  0xC0, 0x18, 0x0D, 0x81, 0x80, 0x70, 0x1F, 0x07, 0x00, 0xC0, 0x7E, 0x0C,
  0x01, 0x80, 0xD8, 0x18, 0x07, 0x01, 0xB0, 0x30, 0x0E, 0x07, 0x60, 0x60,
  0x3C, 0x0C, 0xC0, 0xC0, 0x70, 0x31, 0x81, 0xC1, 0xB0, 0xE3, 0x01, 0xC6,
  0x63, 0x87, 0x03, 0xF8, 0xFE, 0x0E, 0x01, 0xE0, 0x70, 0x0C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x37, 0x00, 0x00, 0xEE, 0x00, 0x01, 0x9C, 0x00, 0x07, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x60, 0xC0, 0x01, 0xC1, 0x80, 0x03,
  0x03, 0x00, 0x0E, 0x07, 0x00, 0x18, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0xE0, 0x03, 0x01, 0x80, 0x06, 0x07, 0x00, 0x0C, 0x0C, 0x00, 0x18,
  0x38, 0x00, 0x38, 0x60, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x00, 0x01, 0xCE,
  0x00, 0x03, 0x98, 0x00, 0x07, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x0C, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0C, 0x01, 0xE0, 0x18,
  0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x01, 0x81, 0xC0, 0x03, 0x03, 0x00,
  0x06, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x01,
  0xC0, 0xC0, 0x07, 0x03, 0x80, 0x3C, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x30, 0x03, 0x80, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x83,
  0x80, 0x07, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70,
  0x00, 0x70, 0xE0, 0x00, 0xE1, 0x80, 0x03, 0x83, 0x00, 0x07, 0x0E, 0x00,
  0x1C, 0x1C, 0x00, 0xF0, 0x38, 0x0F, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xFC, 0xF8, 0x0F, 0x80,
  0x20, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xC0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x30, 0x0F, 0x80, 0x18, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x0E, 0x00,
  0x1C, 0x07, 0x00, 0x07, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0xC1, 0xC0,
  0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0x60, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x06, 0x00, 0x0F, 0x03, 0x00, 0x0F, 0x03, 0x80, 0x0F,
  0x01, 0xC0, 0x1F, 0x00, 0xE0, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xC7, 0xE0, 0x3E, 0x00, 0x70, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x38, 0x01, 0xFF, 0x9C, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00,
  0x38, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x0E, 0x00,
  0x07, 0x07, 0x00, 0x03, 0x83, 0xC0, 0x01, 0x80, 0xF0, 0x01, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x38, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x18,
  0x00, 0x0E, 0x07, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x30, 0x1C, 0x00, 0x0E,
  0x03, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x38, 0x1C, 0x00, 0x06, 0x03, 0x80,
  0x00, 0xC0, 0x70, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xE0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x30, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x1C, 0x06,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0C, 0x07, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x70, 0x18, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x30, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x38,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x78, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x02, 0x00,
  0x00, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x07, 0x00,
  0x0E, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x70, 0x70,
  0x00, 0x1C, 0x3C, 0x00, 0x07, 0x1E, 0x00, 0x01, 0x8F, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF8, 0x00, 0x03, 0xEE, 0x00, 0x00,
  0xF1, 0x80, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x03, 0x80,
  0x01, 0x80, 0xE0, 0x00, 0x60, 0x38, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01,
  0xC0, 0x03, 0x80, 0x30, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0x60, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x60, 0x00, 0xE0,
  0x38, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x01, 0x7F, 0xFE, 0xFF, 0xFE,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x03, 0x60, 0x3F, 0x00, 0x01, 0xD8, 0x0C, 0xC0, 0x00, 0x6E, 0x03, 0x30,
  0x00, 0x3B, 0x80, 0xCC, 0x00, 0x1C, 0xE0, 0x73, 0x00, 0x07, 0x30, 0x1C,
  0xC0, 0x03, 0x9C, 0x06, 0x38, 0x00, 0xE7, 0x01, 0x8E, 0x00, 0x71, 0xC0,
  0xE3, 0x80, 0x18, 0x60, 0x38, 0xE0, 0x0E, 0x18, 0x0E, 0x18, 0x03, 0x0E,
  0x03, 0x06, 0x01, 0xC3, 0x80, 0xC1, 0x80, 0x60, 0xE0, 0x70, 0x60, 0x38,
  0x30, 0x1C, 0x18, 0x0C, 0x0C, 0x07, 0x07, 0x07, 0x07, 0x01, 0x81, 0xC1,
  0x81, 0xC0, 0x60, 0x70, 0xE0, 0x70, 0x38, 0x1C, 0x70, 0x18, 0x0E, 0x03,
  0x1C, 0x0E, 0x03, 0x80, 0xCE, 0x03, 0x80, 0xC0, 0x33, 0x00, 0xE0, 0x30,
  0x0D, 0xC0, 0x38, 0x1C, 0x03, 0x60, 0x0C, 0x07, 0x00, 0xF8, 0x07, 0x01,
  0x80, 0x3C, 0x01, 0xC0, 0x60, 0x0F, 0x00, 0x70, 0x38, 0x01, 0x80, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x1E, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x70,
  0x1E, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x60, 0x3F, 0x00, 0x06, 0x03, 0xB0,
  0x00, 0xE0, 0x33, 0x80, 0x0E, 0x03, 0x38, 0x00, 0xE0, 0x31, 0x80, 0x0C,
  0x07, 0x1C, 0x00, 0xC0, 0x71, 0xC0, 0x1C, 0x06, 0x0C, 0x01, 0xC0, 0x60,
  0xC0, 0x1C, 0x0E, 0x0E, 0x01, 0x80, 0xE0, 0xE0, 0x38, 0x0E, 0x06, 0x03,
  0x80, 0xC0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x01, 0xC0, 0x30, 0x30, 0x1C,
  0x03, 0x87, 0x01, 0xC0, 0x38, 0x70, 0x18, 0x01, 0x87, 0x01, 0x80, 0x1C,
  0x60, 0x38, 0x01, 0xC6, 0x03, 0x80, 0x0C, 0xE0, 0x38, 0x00, 0xEE, 0x03,
  0x00, 0x0E, 0xE0, 0x30, 0x00, 0x6C, 0x07, 0x00, 0x07, 0xC0, 0x70, 0x00,
  0x7C, 0x06, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x3C, 0x03,
  0xC0, 0x38, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x1C, 0x00,
  0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x39,
  0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x07, 0x00, 0x07, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x07,
  0x80, 0x3C, 0x0F, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0C, 0x03, 0xC0, 0x18,
  0x03, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x07, 0x03, 0x00,
  0x0E, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0x30, 0x38, 0x00, 0xE0, 0x70, 0x01,
  0xC0, 0xC0, 0x03, 0x83, 0x80, 0x0E, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0xF0,
  0x1C, 0x07, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x3C,
  0x03, 0xC0, 0x38, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x1C,
  0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00,
  0x07, 0x0C, 0x00, 0x07, 0x07, 0x00, 0x07, 0x03, 0x80, 0x07, 0x80, 0xE0,
  0x07, 0x80, 0x3C, 0x0F, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0C, 0x03,
  0xC0, 0x18, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x03, 0x01, 0xC0, 0x07,
  0x03, 0x00, 0x0E, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x38, 0x00, 0xE0,
  0x70, 0x01, 0xC0, 0xC0, 0x03, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x38, 0x0E,
  0x01, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xC0,
  0xE0, 0x03, 0x81, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x80, 0x38, 0x07,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x01, 0x80, 0x1C, 0x03, 0x00, 0x38,
  0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x60, 0x00, 0xC1,
  0xC0, 0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x1F, 0xCF, 0xC0,
  0xF0, 0x02, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x08, 0x00, 0x78, 0x38, 0x07, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18,
  0x18, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0x30, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x70, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x07,
  0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x18, 0x18, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x38,
  0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0x80, 0xE0, 0x00, 0xE0,
  0x18, 0x00, 0x70, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x3E, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x39, 0x80,
  0x00, 0x73, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x8C, 0x00, 0x0E, 0x18, 0x00,
  0x1C, 0x30, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0x81, 0xC0, 0x07,
  0x03, 0x80, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x18, 0x07, 0x00, 0x30, 0x0E, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x70, 0x01,
  0x81, 0xC0, 0x03, 0x03, 0x80, 0x06, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C,
  0x70, 0x00, 0x38, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xDC,
  0x00, 0x01, 0xB8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x0E,
  0xE0, 0x03, 0xE0, 0x03, 0xB8, 0x00, 0xF8, 0x01, 0xCE, 0x00, 0x7E, 0x00,
  0x73, 0x80, 0x1B, 0x80, 0x18, 0xE0, 0x0E, 0xE0, 0x0E, 0x38, 0x03, 0x38,
  0x03, 0x0E, 0x01, 0xCE, 0x01, 0xC3, 0x80, 0x63, 0x80, 0x70, 0xE0, 0x18,
  0xE0, 0x38, 0x38, 0x0E, 0x38, 0x0E, 0x0E, 0x03, 0x0E, 0x03, 0x03, 0x81,
  0xC1, 0x81, 0xC0, 0xE0, 0x60, 0x60, 0x60, 0x38, 0x38, 0x18, 0x38, 0x0E,
  0x0C, 0x06, 0x0E, 0x03, 0x87, 0x01, 0x87, 0x00, 0xE1, 0x80, 0x61, 0xC0,
  0x38, 0x60, 0x18, 0x60, 0x0E, 0x38, 0x06, 0x38, 0x03, 0x8C, 0x01, 0x8C,
  0x00, 0xE7, 0x00, 0x67, 0x00, 0x39, 0x80, 0x19, 0x80, 0x0E, 0xE0, 0x06,
  0x60, 0x03, 0xB0, 0x01, 0xB8, 0x00, 0x6C, 0x00, 0x6C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x60,
  0x0C, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0x60, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x60, 0x00,
  0x18, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x06, 0x38,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x18, 0x00,
  0x0E, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0x80, 0x70, 0x00, 0x30, 0x1E,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0x98, 0x00, 0x38, 0xE0,
  0x01, 0xC7, 0x00, 0x1C, 0x38, 0x01, 0xC0, 0xC0, 0x0E, 0x06, 0x00, 0xE0,
  0x38, 0x06, 0x01, 0xC0, 0x70, 0x0E, 0x07, 0x00, 0x30, 0x38, 0x01, 0x83,
  0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x9C, 0x00, 0x0C, 0xC0, 0x00,
  0x6E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xF8, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x00, 0xC1, 0x83, 0x87, 0x0E, 0x0C, 0x18, 0x30,
  0x60, 0xE1, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x38, 0x70, 0x60, 0xC1, 0x83,
  0x07, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xE1, 0xC3, 0x83, 0x06, 0x0C, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xE0, 0x01, 0xC6, 0x00, 0x18, 0x60, 0x03,
  0x87, 0x00, 0x30, 0x30, 0x07, 0x03, 0x80, 0xE0, 0x18, 0x0C, 0x01, 0x81,
  0xC0, 0x1C, 0x18, 0x00, 0xC3, 0x80, 0x0E, 0x30, 0x00, 0xE7, 0x00, 0x06,
  0xE0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0,
  0xE3, 0x87, 0x0C, 0x38, 0x60, 0xC3, 0x00, 0xFE, 0x38, 0x1F, 0xF9, 0x81,
  0xE0, 0xCC, 0x1E, 0x03, 0xE0, 0xE0, 0x0F, 0x0E, 0x00, 0x70, 0xE0, 0x03,
  0x87, 0x00, 0x1C, 0x30, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x30, 0xC0,
  0x01, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x70,
  0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x01, 0xE1, 0xC0, 0x1E, 0x0E, 0x00,
  0xF0, 0x38, 0x0D, 0x81, 0xC1, 0xCC, 0x07, 0xFC, 0xE0, 0x1F, 0xC6, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x3F, 0x80, 0x63, 0xFE, 0x03, 0x30,
  0x78, 0x3B, 0x01, 0xC1, 0xF0, 0x07, 0x0F, 0x00, 0x38, 0x78, 0x01, 0xC3,
  0x80, 0x0E, 0x3C, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x60, 0x00,
  0xE3, 0x00, 0x06, 0x38, 0x00, 0x31, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x60,
  0x00, 0xC3, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xE0, 0x07, 0x0F, 0x00, 0x70,
  0x68, 0x07, 0x87, 0x70, 0x78, 0x31, 0xFF, 0x81, 0x87, 0xF0, 0x00, 0x00,
  0xFF, 0x81, 0xFF, 0xC1, 0xE0, 0x21, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x20,
  0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x07, 0xF1, 0xC0, 0x3F, 0xF3, 0x80, 0xF0, 0x76, 0x03, 0xC0, 0x6C,
  0x0F, 0x00, 0x78, 0x1C, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0xE0, 0x03, 0x83,
  0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x30, 0x70,
  0x00, 0x60, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00,
  0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x38, 0x03, 0xE0, 0x70, 0x07,
  0xC0, 0x70, 0x1B, 0x00, 0xE0, 0xE6, 0x00, 0xFF, 0x8C, 0x00, 0xFE, 0x38,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x78, 0x38, 0x3C, 0x06, 0x0E, 0x01,
  0xC7, 0x00, 0x73, 0x80, 0x18, 0xE0, 0x0E, 0x70, 0x03, 0x9C, 0x03, 0xC7,
  0x03, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xF3, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x8E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x86, 0x01, 0xFF,
  0x9C, 0x07, 0x83, 0xB0, 0x1E, 0x03, 0x60, 0x78, 0x03, 0xC0, 0xE0, 0x07,
  0x83, 0x80, 0x0F, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70,
  0x70, 0x00, 0xE0, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0,
  0x07, 0x81, 0xC0, 0x1F, 0x03, 0x80, 0x3E, 0x03, 0x80, 0xD8, 0x07, 0x07,
  0x30, 0x07, 0xFC, 0xE0, 0x07, 0xF1, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x80, 0x0E, 0x01, 0xC0, 0x78, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x71, 0xFC, 0x06, 0x3F, 0xE0,
  0x6E, 0x0F, 0x0E, 0xC0, 0x70, 0xF8, 0x03, 0x0F, 0x00, 0x30, 0xE0, 0x03,
  0x0E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x06, 0x18, 0x00,
  0x61, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xC3, 0x00,
  0x0C, 0x30, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC6, 0x00, 0x18, 0x60,
  0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x30, 0x01, 0xC0, 0xF0,
  0x3C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x18,
  0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06,
  0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03,
  0x80, 0xE0, 0x38, 0x00, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x1F,
  0xC0, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x07, 0x06, 0x00,
  0xE0, 0x60, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x0E, 0x0E, 0x00, 0xC1,
  0xC0, 0x0C, 0x38, 0x01, 0xC7, 0x00, 0x1C, 0xE0, 0x01, 0xDC, 0x00, 0x19,
  0xE0, 0x01, 0xB6, 0x00, 0x3E, 0x70, 0x03, 0xC7, 0x00, 0x38, 0x30, 0x03,
  0x03, 0x80, 0x30, 0x38, 0x07, 0x01, 0x80, 0x70, 0x1C, 0x06, 0x01, 0xC0,
  0x60, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07,
  0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0x06, 0x1F, 0x81, 0xFC, 0x06,
  0x7F, 0xC3, 0xFE, 0x06, 0xE0, 0xE7, 0x0F, 0x0E, 0xC0, 0xEC, 0x07, 0x0F,
  0x80, 0x78, 0x03, 0x0F, 0x00, 0x78, 0x03, 0x0E, 0x00, 0x70, 0x03, 0x0E,
  0x00, 0x70, 0x07, 0x1C, 0x00, 0xE0, 0x07, 0x1C, 0x00, 0xE0, 0x07, 0x1C,
  0x00, 0xE0, 0x06, 0x18, 0x00, 0xC0, 0x06, 0x18, 0x00, 0xC0, 0x0E, 0x38,
  0x01, 0xC0, 0x0E, 0x38, 0x01, 0xC0, 0x0E, 0x38, 0x01, 0xC0, 0x0C, 0x30,
  0x01, 0x80, 0x0C, 0x30, 0x03, 0x80, 0x1C, 0x70, 0x03, 0x80, 0x1C, 0x70,
  0x03, 0x80, 0x1C, 0x60, 0x03, 0x00, 0x18, 0x60, 0x03, 0x00, 0x18, 0xE0,
  0x07, 0x00, 0x38, 0xE0, 0x07, 0x00, 0x38, 0xE0, 0x07, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x61, 0xFC, 0x06, 0x7F, 0xE0, 0x6E, 0x0F, 0x0E, 0xC0, 0x70,
  0xF8, 0x07, 0x0F, 0x00, 0x30, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x07,
  0x1C, 0x00, 0x71, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x0E, 0x38, 0x00,
  0xE3, 0x80, 0x0E, 0x38, 0x00, 0xC3, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00,
  0x1C, 0x70, 0x01, 0xC7, 0x00, 0x18, 0x60, 0x03, 0x8E, 0x00, 0x38, 0xE0,
  0x03, 0x8E, 0x00, 0x30, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x1E, 0x0F, 0x07,
  0x00, 0xE1, 0xE0, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0x19, 0xC0, 0x03, 0x70,
  0x00, 0x6E, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x06, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80,
  0x0E, 0x70, 0x01, 0xCE, 0x00, 0x70, 0xE0, 0x1C, 0x1E, 0x07, 0x01, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0x01, 0x87, 0xF0, 0x03, 0x1F, 0xF0, 0x06, 0x60,
  0xF0, 0x1D, 0x80, 0xE0, 0x3E, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0xF0, 0x03,
  0x81, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x30, 0x00, 0x70, 0x60, 0x00, 0xC1, 0xC0, 0x01, 0x83, 0x80, 0x07, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xF0,
  0x03, 0x81, 0xE0, 0x0E, 0x03, 0x40, 0x3C, 0x0E, 0xE0, 0xF0, 0x1C, 0xFF,
  0xC0, 0x38, 0xFE, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x18, 0x1F, 0xF9, 0xC1, 0xE0, 0xEC, 0x1E, 0x03, 0x61, 0xE0,
  0x0F, 0x0E, 0x00, 0x78, 0xE0, 0x03, 0xC7, 0x00, 0x1C, 0x30, 0x00, 0xE3,
  0x80, 0x07, 0x1C, 0x00, 0x38, 0xC0, 0x01, 0x8E, 0x00, 0x0C, 0x70, 0x00,
  0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38,
  0x01, 0xE1, 0xC0, 0x1F, 0x0E, 0x00, 0xF8, 0x30, 0x0D, 0x81, 0xC1, 0xCC,
  0x07, 0xFC, 0xE0, 0x1F, 0xC7, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x1F, 0x06, 0x7F, 0x06, 0xF0, 0x0E, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xC0, 0x61, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC4, 0x00, 0xE3,
  0x00, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x7F, 0xF7, 0xFF, 0x8C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x0E, 0x00, 0x30, 0xC0, 0x07, 0x1C,
  0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0xE3,
  0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x1C,
  0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0x86, 0x00, 0x38, 0xE0, 0x03,
  0x8E, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x0B, 0x0E, 0x01,
  0xF0, 0xF0, 0x77, 0x07, 0xFE, 0x60, 0x3F, 0x86, 0x00, 0xE0, 0x00, 0xEC,
  0x00, 0x39, 0x80, 0x06, 0x30, 0x01, 0xC6, 0x00, 0x70, 0xC0, 0x0E, 0x1C,
  0x03, 0x83, 0x80, 0x70, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x38,
  0x1C, 0x03, 0x07, 0x00, 0x60, 0xE0, 0x0C, 0x38, 0x01, 0x87, 0x00, 0x31,
  0xC0, 0x06, 0x38, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x0E, 0x00,
  0x7C, 0x00, 0xE0, 0x06, 0xC0, 0x1E, 0x00, 0xEC, 0x01, 0xE0, 0x0C, 0xC0,
  0x3E, 0x01, 0xCC, 0x03, 0x60, 0x18, 0xC0, 0x76, 0x03, 0x8C, 0x06, 0x60,
  0x38, 0xC0, 0x67, 0x03, 0x0C, 0x0C, 0x70, 0x70, 0xC0, 0xC7, 0x06, 0x0E,
  0x1C, 0x70, 0xE0, 0xE1, 0x87, 0x0C, 0x0E, 0x38, 0x71, 0xC0, 0xE3, 0x03,
  0x1C, 0x0E, 0x70, 0x33, 0x80, 0xE6, 0x03, 0x38, 0x0E, 0xE0, 0x33, 0x00,
  0xEC, 0x03, 0x70, 0x0E, 0xC0, 0x36, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x03,
  0x80, 0x1C, 0x0E, 0x00, 0x18, 0x38, 0x00, 0x38, 0x70, 0x00, 0x31, 0xC0,
  0x00, 0x67, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x66, 0x00, 0x01,
  0xCE, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x38, 0x00, 0xE0,
  0x70, 0x03, 0x80, 0x60, 0x0E, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0xF0, 0x01,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0xE0,
  0x01, 0x80, 0x70, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x03,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0x0C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0C, 0xE0, 0x00,
  0x03, 0x30, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x10, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x78,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x17, 0xFE, 0x03, 0xE1,
  0xFC, 0xF8, 0x07, 0xFE, 0x80, 0x0F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 10, 34, 11, 1, -34 },
  { 44, 12, 13, 16, 5, -34 },
  { 64, 25, 34, 26, 1, -34 },
  { 171, 21, 39, 23, 1, -36 },
  { 274, 28, 35, 33, 3, -34 },
  { 397, 24, 34, 27, 1, -34 },
  { 499, 5, 13, 9, 5, -34 },
  { 508, 14, 41, 12, 1, -34 },
  { 580, 14, 41, 12, -3, -34 },
  { 652, 18, 19, 22, 5, -36 },
  { 695, 20, 22, 24, 3, -28 },
  { 750, 7, 11, 10, -2, -5 },
  { 760, 11, 3, 14, 1, -14 },
  { 765, 4, 4, 10, 1, -4 },
  { 767, 21, 34, 15, -2, -34 },
  { 857, 20, 34, 23, 2, -34 },
  { 942, 12, 34, 23, 6, -34 },
  { 993, 22, 34, 23, 0, -34 },
  { 1087, 22, 34, 23, 0, -34 },
  { 1181, 22, 34, 23, 0, -34 },
  { 1275, 21, 34, 23, 1, -34 },
  { 1365, 21, 34, 23, 2, -34 },
  { 1455, 21, 34, 23, 3, -34 },
  { 1545, 21, 34, 23, 1, -34 },
  { 1635, 21, 34, 23, 1, -34 },
  { 1725, 8, 25, 10, 1, -25 },
  { 1750, 11, 31, 10, -2, -25 },
  { 1793, 20, 22, 24, 3, -28 },
  { 1848, 20, 12, 24, 3, -23 },
  { 1878, 20, 22, 24, 3, -28 },
  { 1933, 15, 34, 17, 3, -34 },
  { 1997, 31, 38, 34, 2, -34 },
  { 2145, 23, 34, 23, -3, -34 },
  { 2243, 23, 34, 25, 1, -34 },
  { 2341, 23, 34, 24, 3, -34 },
  { 2439, 25, 34, 28, 1, -34 },
  { 2546, 22, 34, 22, 1, -34 },
  { 2640, 22, 34, 20, 1, -34 },
  { 2734, 25, 34, 28, 3, -34 },
  { 2841, 27, 34, 28, 1, -34 },
  { 2956, 16, 34, 13, -1, -34 },
  { 3024, 18, 43, 11, -7, -34 },
  { 3121, 26, 34, 23, 1, -34 },
  { 3232, 16, 34, 20, 1, -34 },
  { 3300, 34, 34, 35, 1, -34 },
  { 3445, 28, 34, 29, 1, -34 },
  { 3564, 25, 34, 29, 3, -34 },
  { 3671, 23, 34, 23, 1, -34 },
  { 3769, 25, 42, 29, 3, -34 },
  { 3901, 23, 34, 24, 1, -34 },
  { 3999, 22, 34, 21, 0, -34 },
  { 4093, 20, 34, 20, 4, -34 },
  { 4178, 26, 34, 28, 3, -34 },
  { 4289, 23, 34, 23, 4, -34 },
  { 4387, 34, 34, 36, 5, -34 },
  { 4532, 27, 34, 21, -3, -34 },
  { 4647, 21, 34, 20, 4, -34 },
  { 4737, 25, 34, 21, -1, -34 },
  { 4844, 18, 41, 14, -1, -34 },
  { 4937, 7, 34, 16, 5, -34 },
  { 4967, 17, 41, 14, -3, -34 },
  { 5055, 20, 20, 24, 2, -34 },
  { 5105, 17, 3, 16, -4, 4 },
  { 5112, 6, 8, 11, 7, -36 },
  { 5118, 21, 25, 24, 2, -25 },
  { 5184, 21, 36, 24, 1, -36 },
  { 5279, 17, 25, 19, 2, -25 },
  { 5333, 23, 36, 24, 2, -36 },
  { 5437, 18, 25, 21, 2, -25 },
  { 5494, 24, 47, 12, -6, -36 },
  { 5635, 23, 36, 24, 0, -25 },
  { 5739, 20, 36, 23, 1, -36 },
  { 5829, 10, 34, 10, 1, -34 },
  { 5872, 17, 45, 10, -6, -34 },
  { 5968, 20, 36, 20, 1, -36 },
  { 6058, 10, 36, 10, 1, -36 },
  { 6103, 32, 25, 36, 1, -25 },
  { 6203, 20, 26, 23, 1, -26 },
  { 6268, 19, 25, 23, 2, -25 },
  { 6328, 23, 36, 24, -1, -25 },
  { 6432, 21, 36, 24, 2, -25 },
  { 6527, 16, 25, 16, 1, -25 },
  { 6577, 17, 25, 18, 0, -25 },
  { 6631, 12, 31, 13, 2, -31 },
  { 6678, 20, 25, 24, 2, -25 },
  { 6741, 19, 25, 18, 2, -25 },
  { 6801, 28, 25, 29, 3, -25 },
  { 6889, 23, 25, 19, -2, -25 },
  { 6961, 26, 36, 19, -5, -25 },
  { 7078, 19, 25, 18, -1, -25 },
  { 7138, 17, 41, 16, 1, -34 },
  { 7226, 2, 47, 22, 11, -36 },
  { 7238, 17, 41, 16, -2, -34 },
  { 7326, 20, 5, 24, 3, -19 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC47PT7B_H_
