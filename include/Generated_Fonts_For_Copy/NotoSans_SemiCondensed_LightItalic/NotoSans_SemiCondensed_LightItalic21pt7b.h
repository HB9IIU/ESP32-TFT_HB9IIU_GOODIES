#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC21PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0xC4, 0x21, 0x08, 0xC4, 0x21, 0x08, 0x80, 0x23, 0x00, 0x4A,
  0x52, 0x99, 0x00, 0x02, 0x20, 0x44, 0x04, 0x40, 0x44, 0x3F, 0xF0, 0x88,
  0x08, 0x80, 0x90, 0x11, 0x07, 0xFC, 0x91, 0x02, 0x20, 0x22, 0x02, 0x20,
  0x44, 0x00, 0x02, 0x02, 0x07, 0xE4, 0x96, 0x42, 0x41, 0xA0, 0x70, 0x1C,
  0x07, 0x04, 0x82, 0x41, 0x24, 0xB3, 0xE0, 0x40, 0x20, 0x00, 0x3C, 0x11,
  0x21, 0x11, 0x10, 0x88, 0x84, 0x48, 0x22, 0x82, 0x25, 0xC9, 0x51, 0x76,
  0x88, 0x24, 0x42, 0x42, 0x32, 0x21, 0x11, 0x10, 0x99, 0x83, 0x80, 0x07,
  0x81, 0x10, 0x22, 0x0C, 0x41, 0x98, 0x16, 0x03, 0x80, 0xE0, 0x26, 0x28,
  0x45, 0x0D, 0x60, 0xEC, 0x18, 0x87, 0x0F, 0x10, 0x55, 0x80, 0x0C, 0x61,
  0x08, 0x21, 0x04, 0x30, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81, 0x00,
  0x18, 0x20, 0x83, 0x04, 0x10, 0x41, 0x0C, 0x20, 0x82, 0x10, 0x43, 0x08,
  0x42, 0x00, 0x0C, 0x08, 0xC8, 0x39, 0x1E, 0x28, 0x64, 0x44, 0x08, 0x04,
  0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x2D, 0x28,
  0xF8, 0x70, 0x00, 0x80, 0x40, 0x40, 0x60, 0x20, 0x20, 0x10, 0x10, 0x08,
  0x08, 0x04, 0x04, 0x06, 0x02, 0x03, 0x00, 0x0F, 0x08, 0x88, 0x2C, 0x14,
  0x0A, 0x05, 0x07, 0x03, 0x81, 0x40, 0xA0, 0x50, 0x48, 0x26, 0x21, 0xE0,
  0x19, 0xD7, 0x21, 0x08, 0x46, 0x21, 0x08, 0xC4, 0x21, 0x00, 0x0F, 0x84,
  0x20, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x0F, 0xF0, 0x0F, 0x84, 0x30, 0x04, 0x01, 0x00, 0xC0,
  0x20, 0x30, 0x78, 0x01, 0x00, 0x40, 0x18, 0x04, 0x01, 0x20, 0xCF, 0xC0,
  0x00, 0xC0, 0x60, 0x38, 0x0A, 0x04, 0x82, 0x61, 0x10, 0xC4, 0x21, 0x10,
  0x4F, 0xFC, 0x08, 0x02, 0x00, 0x80, 0x60, 0x0F, 0xC2, 0x01, 0x00, 0x40,
  0x10, 0x0C, 0x03, 0xE0, 0x04, 0x01, 0x80, 0x20, 0x08, 0x06, 0x01, 0x20,
  0xCF, 0xC0, 0x07, 0x8C, 0x04, 0x04, 0x06, 0x02, 0x01, 0x79, 0xC2, 0xC1,
  0x40, 0xA0, 0x50, 0x28, 0x22, 0x31, 0xF0, 0xFF, 0x80, 0x80, 0xC0, 0x40,
  0x60, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x00,
  0x1F, 0x18, 0xC8, 0x24, 0x12, 0x19, 0x88, 0x78, 0x38, 0x66, 0x41, 0xA0,
  0x50, 0x28, 0x34, 0x11, 0xF0, 0x1E, 0x18, 0x98, 0x68, 0x14, 0x0A, 0x0D,
  0x06, 0x86, 0x3D, 0x00, 0x80, 0x80, 0x40, 0x40, 0x43, 0xC0, 0x33, 0x00,
  0x00, 0x00, 0x04, 0xC0, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x18, 0x84,
  0x40, 0x00, 0x81, 0x83, 0x06, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08,
  0x18, 0x30, 0x60, 0xC0, 0x00, 0x7C, 0x84, 0x08, 0x10, 0x20, 0x82, 0x08,
  0x20, 0xC1, 0x00, 0x00, 0x18, 0x30, 0x00, 0x03, 0xE0, 0x30, 0x61, 0x00,
  0x88, 0x01, 0x61, 0xC5, 0x19, 0x14, 0xC4, 0x62, 0x11, 0x88, 0x86, 0x42,
  0x29, 0x08, 0xA2, 0x64, 0x86, 0x62, 0x00, 0x04, 0x00, 0x08, 0x20, 0x1F,
  0x00, 0x01, 0x80, 0x60, 0x28, 0x0A, 0x04, 0x81, 0x20, 0x88, 0x22, 0x10,
  0x87, 0xF2, 0x0C, 0x81, 0x40, 0x50, 0x18, 0x04, 0x1F, 0x0C, 0x32, 0x04,
  0x81, 0x20, 0xC8, 0x26, 0x31, 0xF8, 0x41, 0x10, 0x24, 0x0B, 0x06, 0x81,
  0x20, 0xCF, 0xC0, 0x07, 0xE1, 0x04, 0x40, 0x10, 0x06, 0x00, 0x80, 0x10,
  0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0F, 0xC0,
  0x1F, 0x06, 0x18, 0x81, 0x10, 0x32, 0x06, 0x40, 0xD8, 0x1A, 0x03, 0x40,
  0x48, 0x09, 0x03, 0x60, 0x48, 0x11, 0x0C, 0x3E, 0x00, 0x1F, 0x98, 0x08,
  0x04, 0x02, 0x01, 0x01, 0x80, 0xFE, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04,
  0x13, 0xF0, 0x1F, 0x98, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0xFE, 0x40,
  0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x00, 0x07, 0xF0, 0x82, 0x10, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x3E, 0xC0, 0x4C, 0x04, 0xC0, 0x4C,
  0x04, 0x40, 0xC6, 0x08, 0x3F, 0x80, 0x10, 0x33, 0x02, 0x20, 0x22, 0x02,
  0x20, 0x22, 0x06, 0x60, 0x47, 0xFC, 0x40, 0x44, 0x04, 0x40, 0xCC, 0x08,
  0x80, 0x88, 0x08, 0x81, 0x80, 0x0F, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08,
  0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20, 0xF8, 0x01, 0x01, 0x02, 0x02,
  0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08,
  0x10, 0x30, 0xE0, 0x10, 0x66, 0x18, 0x86, 0x11, 0x82, 0x60, 0x58, 0x1E,
  0x02, 0xC0, 0x6C, 0x08, 0x81, 0x10, 0x63, 0x08, 0x21, 0x04, 0x20, 0x40,
  0x10, 0xC2, 0x08, 0x20, 0x86, 0x10, 0x41, 0x04, 0x30, 0x82, 0x0F, 0xC0,
  0x10, 0x06, 0x70, 0x1C, 0xA0, 0x31, 0x40, 0xA2, 0x81, 0x45, 0x05, 0x9A,
  0x0A, 0x24, 0x24, 0x48, 0xC8, 0x91, 0x11, 0x16, 0x64, 0x28, 0x88, 0x61,
  0x10, 0xC2, 0x21, 0x0C, 0x00, 0x10, 0x13, 0x81, 0x28, 0x32, 0x82, 0x28,
  0x22, 0x42, 0x64, 0x24, 0x44, 0x42, 0x44, 0x24, 0x42, 0x48, 0x14, 0x81,
  0x88, 0x18, 0x81, 0x80, 0x07, 0xC1, 0x86, 0x30, 0x22, 0x02, 0x60, 0x34,
  0x03, 0x40, 0x2C, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x6C, 0x04, 0x40, 0xC6,
  0x18, 0x3E, 0x00, 0x1F, 0x0C, 0x62, 0x08, 0x83, 0x20, 0x88, 0x26, 0x19,
  0x0C, 0x7C, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x00, 0x07, 0xC1,
  0x86, 0x30, 0x22, 0x02, 0x60, 0x34, 0x03, 0x40, 0x2C, 0x02, 0xC0, 0x2C,
  0x02, 0xC0, 0x6C, 0x04, 0x40, 0xC6, 0x18, 0x3E, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x1F, 0x0C, 0x62, 0x08, 0x83, 0x20, 0x88, 0x26, 0x19,
  0xFC, 0x7C, 0x11, 0x04, 0x63, 0x08, 0x82, 0x20, 0x88, 0x30, 0x0F, 0xC4,
  0x13, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x20, 0x8F, 0xC0, 0xFF, 0x84, 0x04, 0x02, 0x01, 0x00, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x10, 0x13,
  0x02, 0x20, 0x22, 0x02, 0x20, 0x26, 0x06, 0x40, 0x44, 0x04, 0x40, 0x44,
  0x04, 0xC0, 0xCC, 0x08, 0xC0, 0x84, 0x10, 0x3E, 0x00, 0x80, 0xE0, 0x28,
  0x1A, 0x04, 0x83, 0x30, 0x8C, 0x61, 0x10, 0x4C, 0x12, 0x05, 0x81, 0x40,
  0x70, 0x18, 0x06, 0x00, 0x81, 0x03, 0x81, 0x82, 0x82, 0x86, 0x82, 0x84,
  0x84, 0x8C, 0x84, 0x88, 0x8C, 0x88, 0x88, 0x90, 0x88, 0x90, 0xD0, 0xA0,
  0xD0, 0xA0, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0x40, 0x80, 0x18, 0x30,
  0x82, 0x08, 0x40, 0xC8, 0x05, 0x80, 0x50, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xA0, 0x11, 0x03, 0x10, 0x21, 0x04, 0x18, 0x80, 0x80, 0x81, 0xC0, 0xB0,
  0x88, 0xC4, 0x42, 0x41, 0x20, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x04, 0x02,
  0x01, 0x00, 0x1F, 0xE0, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00,
  0x60, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x3F, 0xC0, 0x0F,
  0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x80, 0x80, 0xF0, 0x88, 0x44, 0x44, 0x44, 0x62, 0x22, 0x22,
  0x30, 0x1E, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40,
  0x83, 0x04, 0x08, 0x11, 0xE0, 0x0C, 0x06, 0x04, 0x82, 0x42, 0x21, 0x09,
  0x05, 0x82, 0x80, 0x80, 0xFF, 0xC9, 0x80, 0x1E, 0x90, 0xD0, 0x68, 0x2C,
  0x14, 0x0A, 0x0D, 0x04, 0x86, 0x63, 0x1E, 0x80, 0x08, 0x06, 0x01, 0x00,
  0x40, 0x10, 0x05, 0xE3, 0x8C, 0xC1, 0x20, 0x48, 0x12, 0x0D, 0x82, 0x40,
  0x98, 0x66, 0x32, 0x78, 0x1F, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xC0, 0x7C, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x87, 0xA2, 0x19,
  0x06, 0x41, 0x30, 0x48, 0x12, 0x04, 0x83, 0x21, 0x8C, 0x61, 0xE8, 0x1E,
  0x21, 0x41, 0x42, 0x86, 0xF8, 0x80, 0x80, 0x80, 0xC0, 0x7C, 0x00, 0xE0,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x1F, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x08, 0x0E, 0x00, 0x0F, 0x44, 0x32, 0x0C, 0x82, 0x60, 0x90, 0x24, 0x09,
  0x06, 0x43, 0x18, 0xC3, 0xD0, 0x04, 0x03, 0x00, 0x88, 0x63, 0xE0, 0x08,
  0x0C, 0x04, 0x02, 0x01, 0x00, 0xBC, 0xE2, 0x61, 0x20, 0x90, 0x48, 0x2C,
  0x14, 0x12, 0x09, 0x05, 0x82, 0x18, 0x80, 0x01, 0x18, 0x84, 0x21, 0x18,
  0x84, 0x23, 0x00, 0x03, 0x02, 0x00, 0x00, 0x02, 0x06, 0x04, 0x04, 0x04,
  0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x30, 0xE0, 0x08,
  0x0C, 0x04, 0x02, 0x01, 0x00, 0x84, 0xC4, 0x44, 0x24, 0x14, 0x0E, 0x0C,
  0x84, 0x42, 0x31, 0x09, 0x86, 0x08, 0xC4, 0x21, 0x08, 0xC4, 0x21, 0x08,
  0xC4, 0x21, 0x18, 0x17, 0xBC, 0x51, 0x84, 0xC3, 0x09, 0x04, 0x12, 0x08,
  0x64, 0x30, 0x98, 0x41, 0x20, 0x82, 0x41, 0x04, 0x82, 0x13, 0x08, 0x20,
  0x17, 0x8A, 0x23, 0x0C, 0x82, 0x20, 0x88, 0x26, 0x09, 0x06, 0x41, 0x10,
  0x4C, 0x10, 0x1F, 0x10, 0x90, 0x48, 0x38, 0x1C, 0x0A, 0x05, 0x02, 0x82,
  0x63, 0x1F, 0x00, 0x0B, 0xC2, 0x8C, 0x60, 0x88, 0x11, 0x02, 0x20, 0xCC,
  0x11, 0x02, 0x30, 0xC6, 0x30, 0xBC, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06,
  0x00, 0x1E, 0x90, 0xD0, 0x68, 0x2C, 0x14, 0x0A, 0x05, 0x06, 0x86, 0x43,
  0x1E, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x17, 0x28, 0x30, 0x20, 0x20,
  0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x3F, 0x20, 0x60, 0x20, 0x30, 0x18,
  0x04, 0x06, 0x04, 0x84, 0xF8, 0x21, 0x09, 0xF6, 0x21, 0x08, 0x44, 0x21,
  0x08, 0x70, 0x20, 0xA0, 0xD0, 0x48, 0x24, 0x16, 0x0A, 0x0D, 0x04, 0x86,
  0x43, 0x1E, 0x80, 0x81, 0x82, 0x82, 0xC4, 0x44, 0x48, 0x48, 0x50, 0x50,
  0x60, 0x60, 0x82, 0x1C, 0x30, 0xA1, 0x8D, 0x14, 0x48, 0xA2, 0x49, 0x22,
  0x49, 0x1C, 0x50, 0xE2, 0x85, 0x14, 0x10, 0x40, 0x10, 0xC4, 0x20, 0x90,
  0x28, 0x0E, 0x03, 0x00, 0xC0, 0x48, 0x22, 0x18, 0x8C, 0x10, 0x10, 0x23,
  0x08, 0x21, 0x04, 0x40, 0x88, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x07, 0x00, 0x3F, 0x02, 0x06, 0x04,
  0x08, 0x10, 0x30, 0x20, 0x40, 0x80, 0xFC, 0x03, 0x04, 0x08, 0x08, 0x08,
  0x08, 0x18, 0x10, 0x30, 0xE0, 0x20, 0x20, 0x20, 0x20, 0x20, 0x60, 0x60,
  0x30, 0xFF, 0xFF, 0xF8, 0x1C, 0x04, 0x06, 0x04, 0x04, 0x04, 0x04, 0x04,
  0x05, 0x06, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x30, 0xE0, 0x20, 0x6E,
  0x60, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 15, 5, 0, -15 },
  { 11, 5, 5, 7, 2, -15 },
  { 15, 12, 15, 11, 0, -15 },
  { 38, 9, 17, 10, 1, -16 },
  { 58, 13, 15, 15, 1, -15 },
  { 83, 11, 15, 12, 0, -15 },
  { 104, 2, 5, 4, 2, -15 },
  { 106, 6, 18, 5, 1, -15 },
  { 120, 6, 18, 5, -1, -15 },
  { 134, 8, 8, 10, 2, -16 },
  { 142, 9, 10, 11, 1, -12 },
  { 154, 3, 5, 4, -1, -2 },
  { 156, 5, 1, 6, 1, -6 },
  { 157, 2, 2, 4, 0, -2 },
  { 158, 9, 15, 7, -1, -15 },
  { 175, 9, 15, 10, 1, -15 },
  { 192, 5, 15, 10, 3, -15 },
  { 202, 10, 15, 10, 0, -15 },
  { 221, 10, 15, 10, 0, -15 },
  { 240, 10, 15, 10, 0, -15 },
  { 259, 10, 15, 10, 0, -15 },
  { 278, 9, 15, 10, 1, -15 },
  { 295, 9, 15, 10, 2, -15 },
  { 312, 9, 15, 10, 1, -15 },
  { 329, 9, 15, 10, 1, -15 },
  { 346, 4, 11, 4, 0, -11 },
  { 352, 5, 14, 5, -1, -11 },
  { 361, 9, 9, 11, 1, -12 },
  { 372, 9, 5, 11, 1, -10 },
  { 378, 9, 9, 11, 1, -12 },
  { 389, 7, 15, 8, 1, -15 },
  { 403, 14, 17, 15, 1, -15 },
  { 433, 10, 15, 10, -1, -15 },
  { 452, 10, 15, 11, 1, -15 },
  { 471, 11, 15, 11, 1, -15 },
  { 492, 11, 15, 12, 1, -15 },
  { 513, 9, 15, 10, 1, -15 },
  { 530, 9, 15, 9, 1, -15 },
  { 547, 12, 15, 13, 1, -15 },
  { 570, 12, 15, 13, 1, -15 },
  { 593, 8, 15, 6, -1, -15 },
  { 608, 8, 19, 5, -3, -15 },
  { 627, 11, 15, 10, 1, -15 },
  { 648, 6, 15, 9, 1, -15 },
  { 660, 15, 15, 16, 1, -15 },
  { 689, 12, 15, 13, 1, -15 },
  { 712, 12, 15, 13, 1, -15 },
  { 735, 10, 15, 10, 1, -15 },
  { 754, 12, 19, 13, 1, -15 },
  { 783, 10, 15, 11, 1, -15 },
  { 802, 10, 15, 9, 0, -15 },
  { 821, 9, 15, 9, 2, -15 },
  { 838, 12, 15, 13, 1, -15 },
  { 861, 10, 15, 10, 2, -15 },
  { 880, 16, 15, 16, 2, -15 },
  { 910, 12, 15, 9, -1, -15 },
  { 933, 9, 15, 9, 2, -15 },
  { 950, 11, 15, 10, 0, -15 },
  { 971, 8, 18, 6, 0, -15 },
  { 989, 4, 15, 7, 2, -15 },
  { 997, 7, 18, 6, -1, -15 },
  { 1013, 9, 9, 11, 1, -15 },
  { 1024, 8, 1, 7, -2, 2 },
  { 1025, 3, 3, 5, 3, -16 },
  { 1027, 9, 11, 11, 1, -11 },
  { 1040, 10, 16, 11, 0, -16 },
  { 1060, 8, 11, 8, 1, -11 },
  { 1071, 10, 16, 11, 1, -16 },
  { 1091, 8, 11, 9, 1, -11 },
  { 1102, 11, 21, 5, -3, -16 },
  { 1131, 10, 16, 11, 0, -11 },
  { 1151, 9, 16, 10, 0, -16 },
  { 1169, 5, 15, 4, 0, -15 },
  { 1179, 8, 20, 4, -3, -15 },
  { 1199, 9, 16, 9, 0, -16 },
  { 1217, 5, 16, 4, 0, -16 },
  { 1227, 15, 11, 16, 0, -11 },
  { 1248, 10, 11, 10, 0, -11 },
  { 1262, 9, 11, 10, 1, -11 },
  { 1275, 11, 16, 11, -1, -11 },
  { 1297, 9, 16, 11, 1, -11 },
  { 1315, 8, 11, 7, 0, -11 },
  { 1326, 8, 11, 8, 0, -11 },
  { 1337, 5, 14, 6, 1, -14 },
  { 1346, 9, 11, 11, 1, -11 },
  { 1359, 8, 11, 8, 1, -11 },
  { 1370, 13, 11, 13, 1, -11 },
  { 1388, 10, 11, 9, -1, -11 },
  { 1402, 11, 16, 8, -2, -11 },
  { 1424, 8, 11, 8, 0, -11 },
  { 1435, 8, 18, 7, 0, -15 },
  { 1453, 1, 21, 10, 5, -16 },
  { 1456, 8, 18, 7, -1, -15 },
  { 1474, 9, 3, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC21PT7B_H_
