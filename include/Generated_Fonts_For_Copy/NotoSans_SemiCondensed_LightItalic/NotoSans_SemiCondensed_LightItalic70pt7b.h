#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC70PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x78, 0x00, 0x20, 0x00, 0x1F, 0x03, 0xC7, 0x81, 0xF1,
  0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x70, 0xF0,
  0x3C, 0x38, 0x0F, 0x0E, 0x03, 0xC3, 0x80, 0xE1, 0xE0, 0x38, 0x70, 0x0E,
  0x1C, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x60, 0x1C, 0x38, 0x06, 0x00,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFE, 0x71,
  0xF8, 0x03, 0xE0, 0xE0, 0x70, 0x0F, 0x81, 0xC0, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x78, 0x06, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x7C, 0x1C, 0x00, 0x00,
  0x78, 0x30, 0x00, 0x00, 0xFC, 0xE0, 0x00, 0x00, 0xFD, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0x8F, 0x80, 0x00, 0x03, 0x0F, 0x80, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x60, 0x3C, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x18, 0x07, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0xE0, 0x7C,
  0x0C, 0x01, 0xC1, 0xF0, 0x1F, 0x03, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0x00,
  0x78, 0x3C, 0x00, 0x07, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0x38, 0x07,
  0x80, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03,
  0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x70,
  0x00, 0xF0, 0x01, 0xC0, 0x70, 0x00, 0x78, 0x01, 0xE0, 0x78, 0x00, 0x3C,
  0x00, 0xF0, 0x38, 0x00, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x00, 0x38,
  0x3C, 0x03, 0x07, 0x00, 0x3C, 0x1C, 0x1F, 0xE3, 0x80, 0x1C, 0x1E, 0x1F,
  0xF9, 0xC0, 0x1E, 0x1E, 0x1F, 0xFE, 0xE0, 0x0E, 0x0E, 0x1E, 0x0F, 0x70,
  0x0F, 0x0F, 0x1E, 0x03, 0xFC, 0x07, 0x0F, 0x0E, 0x01, 0xEE, 0x07, 0x87,
  0x0F, 0x00, 0x77, 0xDF, 0x87, 0x87, 0x00, 0x39, 0xFF, 0x87, 0x87, 0x80,
  0x1C, 0x7F, 0x83, 0x83, 0x80, 0x0E, 0x0E, 0x03, 0xC1, 0xC0, 0x0F, 0x00,
  0x03, 0xC1, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0xF0, 0x03, 0xC0, 0x01, 0xE0,
  0x70, 0x01, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00,
  0x70, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x00,
  0x70, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x1E,
  0x00, 0x0F, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0x81, 0xE0, 0x0E, 0x00, 0x01,
  0xF3, 0xE0, 0x0F, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x38, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x1F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x00, 0x1E, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x1E, 0x00, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0xF0, 0xF8, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0xF8,
  0x01, 0xE1, 0xE0, 0x07, 0x80, 0x3C, 0x3C, 0x00, 0x3C, 0x03, 0xC7, 0x80,
  0x03, 0xC0, 0x78, 0x78, 0x00, 0x1E, 0x07, 0x8F, 0x00, 0x01, 0xF0, 0xF0,
  0xF0, 0x00, 0x0F, 0x0F, 0x0F, 0x00, 0x00, 0xF9, 0xE0, 0xF0, 0x00, 0x07,
  0xBC, 0x0E, 0x00, 0x00, 0x7F, 0xC0, 0xE0, 0x00, 0x03, 0xF8, 0x0E, 0x00,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x7F, 0x00,
  0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0x80, 0x01, 0xF7, 0x80, 0x7C, 0x00, 0x3E,
  0x7C, 0x07, 0xE0, 0x0F, 0xC3, 0xC0, 0x3F, 0xFF, 0xF0, 0x1E, 0x01, 0xFF,
  0xFE, 0x01, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38,
  0x78, 0x70, 0x70, 0x70, 0x60, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x04,
  0x00, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xFC, 0x0E, 0x00, 0x3F, 0xC3, 0x80,
  0x01, 0xF8, 0xE0, 0x00, 0x1F, 0xB0, 0x3F, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x7C, 0x70, 0x00, 0x3E, 0x0E, 0x00, 0x1F, 0x03, 0x80,
  0x0F, 0x80, 0xF0, 0x07, 0xC0, 0x1C, 0x00, 0x60, 0x07, 0x80, 0x10, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x0F,
  0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3D, 0xF7, 0xFF, 0xFD,
  0xE2, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x01,
  0xF8, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F,
  0x1C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x80,
  0x07, 0xC0, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x1F, 0x78, 0x3F, 0x3C, 0x3F, 0x1C,
  0x7E, 0x1E, 0x7E, 0x0F, 0x3E, 0x07, 0x8C, 0x03, 0xC4, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFC, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x3E, 0x00,
  0x10, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xE0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x40, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x04, 0x00, 0x00, 0x7E, 0x03, 0x80,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x03, 0xC0,
  0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xDF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x80, 0x00, 0x1F, 0x00, 0xC0, 0x00, 0x3F, 0x00,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0x00, 0x20, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x3F, 0x80, 0x03, 0xC3, 0xFF, 0xC0, 0x07, 0x8F, 0xFF,
  0xC0, 0x1E, 0x7E, 0x1F, 0xC0, 0x3D, 0xE0, 0x07, 0xC0, 0x7F, 0x80, 0x07,
  0x80, 0xFC, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x7C, 0x03, 0xC0,
  0x01, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x1E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x38, 0x0F, 0x00, 0x00,
  0x70, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x01, 0xE0, 0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0,
  0x1F, 0x80, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x07, 0x80, 0x7C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3F, 0x0F, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x0F, 0xE0, 0x78, 0x00, 0x7F, 0x81, 0xF0, 0x03, 0xDE, 0x03, 0xF8, 0x7E,
  0x70, 0x07, 0xFF, 0xF3, 0xC0, 0x0F, 0xFF, 0x0F, 0x00, 0x0F, 0xF0, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x30, 0x03, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x60, 0x07, 0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x03, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7C, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x07, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xF0, 0x0F, 0xC1, 0x80, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x3F, 0xC0, 0x07, 0x03, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0x07,
  0x00, 0x0F, 0xFF, 0xE0, 0x1E, 0x1E, 0x00, 0x3E, 0x03, 0xC0, 0x3C, 0x38,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0xF1, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0x00, 0x78, 0x03, 0xCF, 0x00,
  0x70, 0x00, 0xE0, 0x07, 0x9C, 0x01, 0xE0, 0x01, 0xC0, 0x0E, 0x78, 0x03,
  0x80, 0x07, 0x80, 0x1C, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x39, 0xC0, 0x1C,
  0x00, 0x1C, 0x00, 0x73, 0x80, 0x38, 0x00, 0x38, 0x01, 0xE7, 0x00, 0xF0,
  0x00, 0xF0, 0x03, 0x9E, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0x3C, 0x03, 0x80,
  0x03, 0x80, 0x1E, 0x78, 0x07, 0x00, 0x0F, 0x00, 0x3C, 0xF0, 0x0E, 0x00,
  0x1E, 0x00, 0x71, 0xC0, 0x1C, 0x00, 0x7C, 0x01, 0xE3, 0x80, 0x38, 0x00,
  0xF0, 0x03, 0x87, 0x00, 0x70, 0x03, 0xE0, 0x0F, 0x0E, 0x00, 0xF0, 0x06,
  0xE0, 0x3C, 0x1C, 0x01, 0xE0, 0x1D, 0xC0, 0xF0, 0x3C, 0x01, 0xE0, 0xF3,
  0x83, 0xE0, 0x78, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0xF0, 0x03, 0xFF, 0x07,
  0xFC, 0x00, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x07,
  0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x1F,
  0x80, 0x1E, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x07, 0xE0, 0x1E, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x3C, 0x00, 0x1F,
  0x80, 0x01, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x10, 0x00, 0x3F, 0x80, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x07, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x3C,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0xF8,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x07,
  0x80, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x80, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x7F, 0xFE, 0x1E, 0x00, 0x03, 0xFF, 0xF0, 0x78,
  0x00, 0x0F, 0xFF, 0xC1, 0xE0, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0x00, 0x70,
  0x00, 0xFC, 0x00, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x80, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x00, 0x0F, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0xFC, 0x00, 0x00, 0x00, 0xF7,
  0xF0, 0x00, 0x00, 0x07, 0xBF, 0xE0, 0x00, 0x00, 0x1F, 0xE7, 0x80, 0x00,
  0x00, 0x7F, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x00, 0x00, 0x1E, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x73,
  0x80, 0x00, 0x00, 0xF7, 0x80, 0x0E, 0x70, 0x00, 0x00, 0x1E, 0xF0, 0x03,
  0xCE, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x79, 0xC0, 0x00, 0x00, 0xE7, 0x80,
  0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x1E,
  0x00, 0x38, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x00, 0x78,
  0x78, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x38, 0x00, 0x03,
  0xC3, 0xC0, 0x07, 0x07, 0x00, 0x00, 0x78, 0x78, 0x01, 0xE0, 0xE0, 0x00,
  0x1E, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC1, 0xC0, 0x07, 0x83, 0xC0,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x0F,
  0x00, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0xF0,
  0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x01, 0xE0, 0x03,
  0xC0, 0x70, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x0E, 0x00, 0x78, 0x07, 0x80,
  0x1E, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x1E, 0x00,
  0xF0, 0x01, 0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0xF0,
  0x03, 0x80, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x07,
  0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC7, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x79, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x38, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xEF, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x07,
  0x80, 0x03, 0xF8, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0x80, 0x1F, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0xF8,
  0x00, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x73, 0xC0, 0x00,
  0x0F, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x3C, 0x00, 0x00, 0xE0,
  0x03, 0xC7, 0x00, 0x00, 0x78, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x00, 0x38,
  0x78, 0x00, 0x07, 0x80, 0x0E, 0x0E, 0x00, 0x01, 0xE0, 0x07, 0x83, 0xC0,
  0x00, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x0F,
  0x00, 0x1C, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x00, 0xE0, 0x03,
  0xC0, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0x00, 0xF0, 0x03, 0xC0,
  0x03, 0xC0, 0x78, 0x00, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x00, 0x1E,
  0x07, 0x80, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x70,
  0x01, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x1E,
  0x00, 0x01, 0xC3, 0xC0, 0x07, 0x00, 0x00, 0x78, 0xF0, 0x03, 0xC0, 0x00,
  0x1E, 0x38, 0x00, 0xF0, 0x00, 0x07, 0x8E, 0x00, 0x3C, 0x00, 0x00, 0xF7,
  0x80, 0x0F, 0x00, 0x00, 0x3D, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0x78, 0x01,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0xC0, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x01, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x1E, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x7C, 0x00,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x00, 0x0F,
  0x3E, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x01, 0xF8, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x3C, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xF0, 0x07,
  0x80, 0x03, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x00, 0x0F, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0x00, 0x0F, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x00, 0xF8,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x03, 0xE0, 0x1E, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x03, 0xF0, 0x07, 0x80,
  0x03, 0xF0, 0x07, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF8,
  0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x38, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x04, 0x00, 0x00, 0x7C, 0x03,
  0x80, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x7C,
  0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x38, 0x01, 0xE0, 0x00,
  0x38, 0x01, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x1C, 0x78, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00,
  0x1D, 0xE0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x77, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE7, 0x00, 0x01,
  0xF0, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE7, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xC7,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0x07, 0x00, 0x07,
  0x87, 0x00, 0x07, 0x80, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF8, 0x07, 0x00,
  0x0F, 0x07, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x07,
  0x00, 0x1E, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x70, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x07, 0x00, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x70, 0x03,
  0xC0, 0x07, 0x80, 0x38, 0x07, 0x80, 0x78, 0x00, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x07, 0x80, 0x70, 0x07, 0x80, 0x78, 0x00, 0x78, 0x0F, 0x00,
  0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x1E,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x00, 0x78,
  0x1C, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x83, 0xC0, 0x07, 0x83, 0xC0, 0x00,
  0x78, 0x38, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x07, 0x87, 0x80,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x9C, 0x00,
  0x07, 0x9C, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0xB8,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x00, 0x3B, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0xF9, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1F, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x78, 0x7C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x20, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0xF0, 0x7C, 0x1E, 0x0F,
  0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x30, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x3C, 0x00, 0xFF, 0xF8, 0x70, 0x03, 0xFF,
  0xF8, 0xE0, 0x0F, 0x80, 0x73, 0xC0, 0x3E, 0x00, 0x77, 0x80, 0xF8, 0x00,
  0x6E, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00,
  0x01, 0xF8, 0x1E, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x3B, 0x80, 0x78, 0x00, 0xE7, 0x00, 0xF8, 0x03, 0xDE, 0x00, 0xF8, 0x1F,
  0x3C, 0x01, 0xFF, 0xFC, 0x70, 0x01, 0xFF, 0xE0, 0xE0, 0x01, 0xFF, 0x81,
  0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0xF0,
  0x7F, 0xE0, 0x00, 0xF1, 0xFF, 0xF0, 0x00, 0xF3, 0xFF, 0xF8, 0x01, 0xE7,
  0x80, 0x7C, 0x01, 0xEF, 0x00, 0x3C, 0x01, 0xEE, 0x00, 0x1E, 0x01, 0xDC,
  0x00, 0x1E, 0x01, 0xF8, 0x00, 0x1E, 0x03, 0xF0, 0x00, 0x1E, 0x03, 0xF0,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3E, 0x00,
  0x00, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x3F, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x03, 0xC0, 0x3B, 0x00, 0x07, 0xC0, 0x7B, 0x80, 0x1F, 0x80, 0x71, 0xE0,
  0x3F, 0x00, 0x71, 0xFF, 0xFE, 0x00, 0x70, 0xFF, 0xF8, 0x00, 0xF0, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFC, 0x01, 0x80, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x04, 0x03, 0xF0, 0x07, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x1F, 0xFC,
  0x1E, 0x00, 0x0F, 0xFF, 0x87, 0x80, 0x0F, 0xFF, 0xF1, 0xE0, 0x07, 0xE0,
  0x1E, 0x70, 0x01, 0xF0, 0x03, 0xBC, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xF0, 0x0F,
  0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x1F, 0x80,
  0x3C, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x07, 0x78, 0x01, 0xE0, 0x03, 0xDC,
  0x00, 0x7C, 0x01, 0xE7, 0x00, 0x0F, 0x81, 0xF1, 0xC0, 0x03, 0xFF, 0xF8,
  0xF0, 0x00, 0x7F, 0xFC, 0x3C, 0x00, 0x0F, 0xFC, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x01, 0xFE, 0xFE, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x3E,
  0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF1,
  0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03,
  0xE3, 0xC0, 0x01, 0xF1, 0xE0, 0x01, 0xF8, 0x78, 0x01, 0xFC, 0x1E, 0x3F,
  0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x02, 0x01, 0xF0, 0x03, 0x80, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x20, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x81, 0xC0, 0x03, 0xFF, 0xE0, 0xE0, 0x03, 0xFD, 0xF8, 0xF0, 0x07,
  0xE0, 0x1E, 0x70, 0x03, 0xE0, 0x07, 0x38, 0x03, 0xE0, 0x01, 0xFC, 0x03,
  0xE0, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xFC, 0x07, 0x80, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0xF0, 0x00,
  0x3F, 0x80, 0x7C, 0x00, 0x3B, 0xC0, 0x1E, 0x00, 0x3D, 0xC0, 0x0F, 0x80,
  0x3D, 0xE0, 0x03, 0xE0, 0x7C, 0xF0, 0x01, 0xFF, 0xFC, 0x78, 0x00, 0x7F,
  0xFC, 0x3C, 0x00, 0x1F, 0xF8, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x40, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0x00, 0xF0, 0x7F, 0xF0, 0x01,
  0xE3, 0xFF, 0xF0, 0x03, 0x8F, 0xFF, 0xE0, 0x0F, 0x3C, 0x03, 0xE0, 0x1E,
  0xF0, 0x03, 0xC0, 0x3F, 0xC0, 0x07, 0xC0, 0x77, 0x00, 0x07, 0x80, 0xFC,
  0x00, 0x0F, 0x03, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x80,
  0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x78, 0x0E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0x00, 0xF0, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xE0, 0x0F,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0x38, 0x3E, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x01, 0xE3, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x1F, 0x00, 0x00,
  0x0E, 0x7F, 0x00, 0x00, 0x3D, 0xFE, 0x00, 0x00, 0x7F, 0x9E, 0x00, 0x00,
  0xFE, 0x3C, 0x00, 0x01, 0xF8, 0x78, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x70,
  0x03, 0xC0, 0x01, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x70,
  0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x38, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x1C,
  0x7F, 0xFE, 0x0F, 0xDF, 0xE0, 0x0E, 0x78, 0x0F, 0x8F, 0x01, 0xF0, 0x0F,
  0x70, 0x03, 0xCE, 0x00, 0x78, 0x07, 0xF0, 0x01, 0xEE, 0x00, 0x3C, 0x03,
  0xB0, 0x00, 0xFE, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0x81,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xC0,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x10, 0x1F,
  0xC0, 0x01, 0xC0, 0xFF, 0xE0, 0x03, 0x87, 0xFF, 0xE0, 0x07, 0x1F, 0xFF,
  0xE0, 0x1E, 0x7C, 0x07, 0xC0, 0x3D, 0xE0, 0x07, 0x80, 0x7F, 0x80, 0x0F,
  0x80, 0xEE, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x1E, 0x07, 0xE0, 0x00, 0x3C,
  0x0F, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0xF0, 0x0F,
  0x80, 0x07, 0xC0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x03, 0xC7, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x03, 0xC3, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x3E,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0x81, 0xFF, 0x80, 0x00, 0x70, 0x7F, 0xF8,
  0x00, 0x0E, 0x3F, 0xBF, 0x80, 0x01, 0xCF, 0x80, 0xF8, 0x00, 0x7B, 0xC0,
  0x0F, 0x00, 0x0F, 0x70, 0x00, 0xF0, 0x01, 0xDC, 0x00, 0x1E, 0x00, 0x3F,
  0x00, 0x03, 0xC0, 0x0F, 0xE0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x07, 0x80,
  0x3E, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x78, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x07, 0x60, 0x00, 0xF8, 0x01,
  0xEE, 0x00, 0x7E, 0x00, 0x3C, 0xF0, 0x1F, 0x80, 0x07, 0x9F, 0xFF, 0xE0,
  0x00, 0xF1, 0xFF, 0xF8, 0x00, 0x1C, 0x0F, 0xFC, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x1C, 0x00, 0xFF, 0xF8, 0x38, 0x03, 0xFF, 0xF8, 0xF0,
  0x0F, 0x80, 0x79, 0xC0, 0x3E, 0x00, 0x73, 0x80, 0xF8, 0x00, 0x7F, 0x03,
  0xE0, 0x00, 0x7E, 0x07, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF8,
  0x1E, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x3B, 0xC0,
  0x78, 0x00, 0xF7, 0x00, 0xF8, 0x03, 0xDE, 0x00, 0xF8, 0x1F, 0x3C, 0x01,
  0xFF, 0xFC, 0x78, 0x01, 0xFF, 0xF0, 0xF0, 0x01, 0xFF, 0x83, 0xC0, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x70, 0x3F,
  0xC0, 0x38, 0x7F, 0xE0, 0x1C, 0x7F, 0xE0, 0x0E, 0x7C, 0x00, 0x0F, 0x78,
  0x00, 0x07, 0xB8, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFD, 0xFE, 0x03, 0xF0, 0x03, 0x80, 0xF0, 0x00,
  0x20, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x30, 0x00, 0x3C, 0x0F, 0x00, 0x3F, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xF7, 0xFF,
  0xFD, 0xFF, 0xFF, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x7C,
  0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3E, 0x0F,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0xFC, 0x0F, 0x00, 0x07, 0xF0, 0x3C, 0x00, 0x3B, 0xC0, 0xF8, 0x01,
  0xCE, 0x01, 0xF0, 0x1E, 0x38, 0x07, 0xFF, 0xF0, 0xE0, 0x0F, 0xFF, 0x87,
  0x80, 0x1F, 0xF8, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0,
  0xF0, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0x38, 0x00,
  0x3C, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x03, 0xE0, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x01, 0xE0, 0x1E,
  0x00, 0x3C, 0x07, 0xC0, 0x03, 0x80, 0xF0, 0x00, 0x70, 0x3C, 0x00, 0x0E,
  0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xEF, 0x00, 0x03, 0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xF8, 0x00, 0x3C, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x3C, 0x00, 0x3F, 0x80, 0x03, 0xCF, 0x00, 0x0E,
  0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xB8, 0x00, 0x78, 0xF0, 0x01, 0xCE, 0x00,
  0x3C, 0x3C, 0x00, 0x73, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0xE0, 0x07, 0x83,
  0xC0, 0x0E, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x8F, 0x00, 0x70, 0x3C, 0x01,
  0xC3, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x01, 0xC0, 0x38, 0x3C,
  0x07, 0x80, 0x70, 0x1E, 0x0F, 0x01, 0xE0, 0x1C, 0x07, 0x03, 0xC0, 0xF0,
  0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x01, 0xC0, 0xE0, 0x3C, 0x1E, 0x00, 0x70,
  0x78, 0x07, 0x07, 0x80, 0x1C, 0x1E, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00,
  0x70, 0xF0, 0x01, 0xC3, 0xC0, 0x1C, 0x3C, 0x00, 0x70, 0xE0, 0x07, 0x1E,
  0x00, 0x1C, 0x78, 0x01, 0xC7, 0x80, 0x07, 0x1C, 0x00, 0x73, 0xC0, 0x01,
  0xCF, 0x00, 0x1C, 0xF0, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x1D, 0xE0,
  0x01, 0xDE, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x1D,
  0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x1E, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x78, 0x07, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0x70, 0x78, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x3C, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0xF0, 0x00, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0E, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x04, 0xFF, 0xF8, 0x00, 0x37, 0xFF, 0xF8, 0x01, 0xFE,
  0x07, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0xFA, 0x00, 0x03, 0xFF, 0xC8, 0x00,
  0x03, 0xFC, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 16, 51, 16, 1, -50 },
  { 103, 18, 18, 23, 7, -50 },
  { 144, 38, 50, 38, 1, -50 },
  { 382, 31, 57, 34, 2, -53 },
  { 603, 41, 52, 49, 5, -51 },
  { 870, 36, 52, 40, 2, -51 },
  { 1104, 8, 18, 13, 7, -50 },
  { 1122, 21, 61, 18, 2, -50 },
  { 1283, 21, 61, 18, -5, -50 },
  { 1444, 26, 27, 33, 8, -53 },
  { 1532, 30, 33, 36, 4, -41 },
  { 1656, 11, 17, 14, -3, -8 },
  { 1680, 16, 4, 21, 2, -21 },
  { 1688, 6, 7, 15, 1, -6 },
  { 1694, 31, 50, 23, -3, -50 },
  { 1888, 30, 52, 34, 3, -51 },
  { 2083, 17, 50, 34, 10, -50 },
  { 2190, 33, 51, 34, -1, -51 },
  { 2401, 33, 52, 34, 0, -51 },
  { 2616, 32, 50, 34, 0, -50 },
  { 2816, 32, 51, 34, 1, -50 },
  { 3020, 31, 52, 34, 3, -51 },
  { 3222, 30, 50, 34, 5, -50 },
  { 3410, 31, 52, 34, 2, -51 },
  { 3612, 30, 52, 34, 2, -51 },
  { 3807, 13, 39, 15, 1, -38 },
  { 3871, 17, 47, 15, -3, -38 },
  { 3971, 30, 32, 36, 4, -41 },
  { 4091, 30, 18, 36, 4, -34 },
  { 4159, 30, 32, 36, 4, -41 },
  { 4279, 23, 52, 25, 4, -51 },
  { 4429, 47, 56, 51, 3, -50 },
  { 4758, 34, 50, 34, -4, -50 },
  { 4971, 34, 50, 37, 2, -50 },
  { 5184, 35, 52, 35, 4, -51 },
  { 5412, 37, 50, 41, 2, -50 },
  { 5644, 33, 50, 32, 2, -50 },
  { 5851, 33, 50, 30, 2, -50 },
  { 6058, 38, 52, 42, 4, -51 },
  { 6305, 40, 50, 42, 2, -50 },
  { 6555, 25, 50, 19, -2, -50 },
  { 6712, 28, 63, 16, -11, -50 },
  { 6933, 38, 50, 34, 2, -50 },
  { 7171, 23, 50, 30, 2, -50 },
  { 7315, 51, 50, 52, 2, -50 },
  { 7634, 42, 50, 43, 2, -50 },
  { 7897, 38, 52, 44, 4, -51 },
  { 8144, 33, 50, 35, 2, -50 },
  { 8351, 38, 63, 44, 4, -51 },
  { 8651, 33, 50, 35, 2, -50 },
  { 8858, 33, 52, 31, 0, -51 },
  { 9073, 30, 50, 30, 6, -50 },
  { 9261, 38, 51, 42, 5, -50 },
  { 9504, 32, 50, 34, 7, -50 },
  { 9704, 52, 50, 53, 7, -50 },
  { 10029, 40, 50, 31, -4, -50 },
  { 10279, 31, 50, 30, 6, -50 },
  { 10473, 36, 50, 32, -1, -50 },
  { 10698, 26, 61, 20, -1, -50 },
  { 10897, 11, 50, 23, 7, -50 },
  { 10966, 26, 61, 20, -5, -50 },
  { 11165, 31, 29, 35, 2, -50 },
  { 11278, 25, 3, 24, -6, 7 },
  { 11288, 9, 12, 17, 10, -54 },
  { 11302, 31, 39, 35, 3, -38 },
  { 11454, 32, 54, 36, 1, -53 },
  { 11670, 26, 39, 28, 3, -38 },
  { 11797, 34, 54, 36, 3, -53 },
  { 12027, 26, 39, 31, 3, -38 },
  { 12154, 36, 71, 18, -9, -54 },
  { 12474, 33, 55, 36, 1, -38 },
  { 12701, 31, 53, 35, 1, -53 },
  { 12907, 15, 51, 15, 1, -51 },
  { 13003, 25, 68, 15, -9, -51 },
  { 13216, 31, 53, 29, 1, -53 },
  { 13422, 16, 53, 15, 1, -53 },
  { 13528, 49, 38, 53, 1, -38 },
  { 13761, 31, 38, 35, 1, -38 },
  { 13909, 29, 39, 35, 3, -38 },
  { 14051, 35, 54, 36, -2, -38 },
  { 14288, 31, 55, 36, 3, -38 },
  { 14502, 25, 38, 24, 1, -38 },
  { 14621, 26, 39, 27, 0, -38 },
  { 14748, 18, 47, 20, 3, -46 },
  { 14854, 30, 38, 35, 3, -37 },
  { 14997, 27, 37, 27, 4, -37 },
  { 15122, 42, 37, 43, 4, -37 },
  { 15317, 34, 37, 29, -3, -37 },
  { 15475, 38, 54, 28, -7, -37 },
  { 15732, 29, 37, 26, -2, -37 },
  { 15867, 25, 61, 23, 2, -50 },
  { 16058, 3, 70, 33, 16, -53 },
  { 16085, 26, 61, 23, -4, -50 },
  { 16284, 30, 7, 36, 4, -28 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC70PT7B_H_
