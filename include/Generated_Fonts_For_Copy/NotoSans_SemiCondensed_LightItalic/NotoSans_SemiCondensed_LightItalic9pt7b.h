#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC9PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x20, 0xF0, 0x2B, 0xD5, 0xA6, 0x50, 0x27, 0x66, 0x35, 0xE4,
  0x4E, 0xB5, 0xFE, 0xB6, 0xE0, 0x22, 0x94, 0xCA, 0xCB, 0xC0, 0xC0, 0x6A,
  0x49, 0x20, 0x24, 0x92, 0xB0, 0x5D, 0x50, 0x5D, 0x20, 0xC0, 0xC0, 0x80,
  0x32, 0x44, 0x88, 0x25, 0x59, 0x99, 0x60, 0xD5, 0x60, 0x25, 0x11, 0x24,
  0xE0, 0x25, 0x16, 0x11, 0xE0, 0x13, 0x59, 0x62, 0x74, 0x61, 0x1E, 0x16,
  0x47, 0x99, 0x60, 0xF2, 0x44, 0x88, 0x25, 0x52, 0xD9, 0xE0, 0x25, 0x55,
  0x31, 0xE0, 0x40, 0x80, 0x40, 0xA0, 0x71, 0x10, 0xFC, 0xC5, 0x40, 0x61,
  0x12, 0x40, 0x80, 0x3D, 0x7A, 0xEB, 0xBE, 0x07, 0x00, 0x10, 0x8A, 0x74,
  0xE4, 0x7A, 0x5C, 0xA9, 0x78, 0x34, 0x88, 0x88, 0xE0, 0x7A, 0x52, 0x99,
  0x70, 0x74, 0x74, 0x8E, 0x74, 0x74, 0x88, 0x3C, 0x8A, 0x99, 0xF0, 0x4A,
  0x5E, 0x98, 0xC8, 0x69, 0x29, 0x80, 0x24, 0x94, 0x94, 0x5A, 0x98, 0xC9,
  0x48, 0x49, 0x29, 0xC0, 0x42, 0xC9, 0xB3, 0x6B, 0x54, 0x80, 0x45, 0xA6,
  0x96, 0x9A, 0x40, 0x69, 0x99, 0x99, 0xE0, 0x7A, 0x54, 0xC8, 0x40, 0x69,
  0x99, 0x99, 0xE2, 0x20, 0x7A, 0x54, 0xC9, 0x48, 0x34, 0x44, 0x21, 0xE0,
  0xF4, 0x48, 0x88, 0x99, 0x99, 0x9E, 0x9A, 0xAC, 0xC8, 0x97, 0x6B, 0x56,
  0xC9, 0x12, 0x00, 0x2C, 0xA1, 0x0C, 0x53, 0x20, 0xBA, 0xC8, 0x88, 0x78,
  0x88, 0x88, 0x70, 0x69, 0x49, 0x30, 0xFC, 0x31, 0x22, 0x22, 0xE0, 0x25,
  0xD0, 0xE0, 0xC0, 0x35, 0x99, 0xE0, 0x44, 0x75, 0x99, 0xE0, 0x34, 0x88,
  0x60, 0x08, 0x4A, 0xA9, 0x4B, 0x80, 0x35, 0xE8, 0x60, 0x19, 0x1C, 0x42,
  0x21, 0x08, 0xC0, 0x35, 0x99, 0xE1, 0xE0, 0x44, 0x75, 0x99, 0x90, 0x45,
  0xA8, 0x20, 0x94, 0x92, 0xC0, 0x44, 0x56, 0x4A, 0xA0, 0x55, 0xA8, 0x7D,
  0x59, 0x65, 0x94, 0x75, 0x99, 0x90, 0x35, 0x99, 0xE0, 0x75, 0x99, 0xE8,
  0x80, 0x35, 0x99, 0xE1, 0x20, 0x6A, 0x48, 0x71, 0x1E, 0x5D, 0x49, 0x80,
  0x55, 0x99, 0xE0, 0x99, 0xAC, 0x40, 0xAF, 0x6D, 0x4A, 0x00, 0x56, 0x44,
  0xA0, 0x4A, 0x54, 0x42, 0x13, 0x00, 0x65, 0x4E, 0x29, 0x44, 0xB0, 0xFF,
  0x80, 0x69, 0x14, 0xA0, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 8, 4, 0, -7 },
  { 12, 5, 7, 6, 1, -7 },
  { 17, 5, 7, 5, 0, -7 },
  { 22, 1, 2, 2, 1, -6 },
  { 23, 3, 7, 2, 0, -6 },
  { 26, 3, 7, 2, -1, -6 },
  { 29, 3, 4, 4, 1, -7 },
  { 31, 3, 4, 5, 1, -5 },
  { 33, 1, 2, 2, 0, -1 },
  { 34, 2, 1, 3, 0, -3 },
  { 35, 1, 1, 2, 0, -1 },
  { 36, 4, 6, 3, 0, -6 },
  { 39, 4, 7, 4, 0, -7 },
  { 43, 2, 6, 4, 1, -6 },
  { 45, 4, 7, 4, 0, -7 },
  { 49, 4, 7, 4, 0, -7 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 7, 4, 0, -7 },
  { 63, 4, 6, 4, 1, -6 },
  { 66, 4, 7, 4, 0, -7 },
  { 70, 4, 7, 4, 0, -7 },
  { 74, 2, 5, 2, 0, -5 },
  { 76, 2, 6, 2, 0, -5 },
  { 78, 3, 4, 5, 1, -5 },
  { 80, 3, 2, 5, 1, -4 },
  { 81, 3, 4, 5, 1, -5 },
  { 83, 4, 7, 3, 0, -7 },
  { 87, 6, 7, 7, 0, -6 },
  { 93, 5, 6, 4, -1, -6 },
  { 97, 5, 6, 5, 0, -6 },
  { 101, 4, 7, 5, 1, -7 },
  { 105, 5, 6, 5, 0, -6 },
  { 109, 4, 6, 4, 0, -6 },
  { 112, 4, 6, 4, 0, -6 },
  { 115, 4, 7, 5, 1, -7 },
  { 119, 5, 6, 5, 0, -6 },
  { 123, 3, 6, 2, 0, -6 },
  { 126, 3, 8, 2, -1, -6 },
  { 129, 5, 6, 4, 0, -6 },
  { 133, 3, 6, 4, 0, -6 },
  { 136, 7, 6, 7, 0, -6 },
  { 142, 6, 6, 6, 0, -6 },
  { 147, 4, 7, 6, 1, -7 },
  { 151, 5, 6, 4, 0, -6 },
  { 155, 4, 9, 6, 1, -7 },
  { 160, 5, 6, 5, 0, -6 },
  { 164, 4, 7, 4, 0, -7 },
  { 168, 4, 6, 4, 1, -6 },
  { 171, 4, 6, 5, 1, -6 },
  { 174, 4, 6, 4, 1, -6 },
  { 177, 7, 6, 7, 1, -6 },
  { 183, 6, 6, 4, -1, -6 },
  { 188, 4, 6, 4, 1, -6 },
  { 191, 5, 6, 4, 0, -6 },
  { 195, 3, 7, 3, 0, -6 },
  { 198, 1, 6, 3, 1, -6 },
  { 199, 4, 7, 3, -1, -6 },
  { 203, 4, 3, 5, 0, -6 },
  { 205, 3, 1, 3, -1, 1 },
  { 206, 1, 2, 2, 1, -7 },
  { 207, 4, 5, 5, 0, -5 },
  { 210, 4, 7, 5, 0, -7 },
  { 214, 4, 5, 4, 0, -5 },
  { 217, 5, 7, 5, 0, -7 },
  { 222, 4, 5, 4, 0, -5 },
  { 225, 5, 9, 2, -1, -7 },
  { 231, 4, 7, 5, 0, -5 },
  { 235, 4, 7, 4, 0, -7 },
  { 239, 2, 7, 2, 0, -7 },
  { 241, 3, 9, 2, -1, -7 },
  { 245, 4, 7, 4, 0, -7 },
  { 249, 2, 7, 2, 0, -7 },
  { 251, 6, 5, 7, 0, -5 },
  { 255, 4, 5, 4, 0, -5 },
  { 258, 4, 5, 4, 0, -5 },
  { 261, 4, 7, 5, 0, -5 },
  { 265, 4, 7, 5, 0, -5 },
  { 269, 3, 5, 3, 0, -5 },
  { 271, 3, 5, 3, 0, -5 },
  { 273, 3, 6, 3, 0, -6 },
  { 276, 4, 5, 5, 0, -5 },
  { 279, 4, 5, 4, 0, -5 },
  { 282, 5, 5, 6, 1, -5 },
  { 286, 4, 5, 4, 0, -5 },
  { 289, 5, 7, 4, -1, -5 },
  { 294, 3, 5, 3, 0, -5 },
  { 296, 3, 7, 3, 0, -6 },
  { 299, 1, 9, 4, 2, -7 },
  { 301, 3, 7, 3, 0, -6 },
  { 304, 3, 1, 5, 1, -4 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC9PT7B_H_
