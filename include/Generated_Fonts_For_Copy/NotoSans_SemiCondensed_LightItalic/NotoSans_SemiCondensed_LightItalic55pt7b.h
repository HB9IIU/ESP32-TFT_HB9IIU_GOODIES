#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC55PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x02,
  0x00, 0x3C, 0x3C, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x70, 0x71, 0xC1, 0xC7,
  0x07, 0x1C, 0x1C, 0x60, 0x61, 0x81, 0x8E, 0x0E, 0x30, 0x38, 0xC0, 0xC3,
  0x03, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x70,
  0x0C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x18, 0x06,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x70, 0x0C, 0x00, 0x01, 0xC0, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0xE0, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x38, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x06, 0x01, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xE1, 0x83, 0x01, 0xE0, 0xC0,
  0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x60, 0x00, 0x70, 0x30, 0x00, 0x38, 0x18,
  0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x06, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0xF1, 0x80, 0x00, 0x3E, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1D, 0xE0, 0x00,
  0x0C, 0x78, 0x00, 0x06, 0x1E, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x80,
  0x01, 0xC1, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x30, 0x38,
  0x00, 0x18, 0x38, 0x00, 0x1C, 0x3C, 0x18, 0x0C, 0x3C, 0x0F, 0xC6, 0xFC,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1C, 0x07, 0xFC,
  0x00, 0x38, 0x0E, 0x1C, 0x00, 0x30, 0x1C, 0x0E, 0x00, 0x70, 0x18, 0x0E,
  0x00, 0xE0, 0x38, 0x0E, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x70, 0x0E,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0x00, 0x60, 0x0E, 0x07, 0x00, 0x60, 0x0C,
  0x0E, 0x00, 0xE0, 0x0C, 0x0E, 0x00, 0xE0, 0x1C, 0x1C, 0x00, 0xE0, 0x1C,
  0x38, 0x00, 0xE0, 0x18, 0x38, 0x00, 0xC0, 0x38, 0x70, 0xF8, 0xC0, 0x38,
  0xE1, 0xFE, 0xC0, 0x30, 0xE3, 0xDE, 0xE0, 0x71, 0xC7, 0x07, 0xE0, 0xE3,
  0x8E, 0x07, 0xE0, 0xE3, 0x8E, 0x07, 0x7F, 0xC7, 0x1C, 0x07, 0x3F, 0x86,
  0x1C, 0x07, 0x1E, 0x0E, 0x18, 0x07, 0x00, 0x1C, 0x38, 0x07, 0x00, 0x18,
  0x38, 0x07, 0x00, 0x38, 0x38, 0x07, 0x00, 0x70, 0x30, 0x06, 0x00, 0x60,
  0x70, 0x06, 0x00, 0xE0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x00, 0x70, 0x1C, 0x06, 0x00,
  0x70, 0x38, 0x0E, 0x00, 0x70, 0x38, 0x1C, 0x00, 0x38, 0x70, 0x1C, 0x00,
  0x3F, 0xE0, 0x38, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x03, 0xC0, 0x1C, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38,
  0x03, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x1C,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x1C, 0x01, 0xE1, 0xC0, 0xF0,
  0x0E, 0x1C, 0x03, 0x80, 0x71, 0xC0, 0x1E, 0x07, 0x1E, 0x00, 0x70, 0x38,
  0xE0, 0x03, 0xC3, 0x87, 0x00, 0x0E, 0x38, 0x70, 0x00, 0x39, 0xC3, 0x80,
  0x01, 0xFC, 0x1C, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x3E, 0x07, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x1F, 0x80, 0xE0, 0x01, 0xFC, 0x07, 0x80, 0x3E, 0x70,
  0x1F, 0x07, 0xC3, 0xC0, 0x7F, 0xFC, 0x0E, 0x01, 0xFF, 0x80, 0x78, 0x01,
  0x80, 0x00, 0x00, 0x3C, 0xE3, 0x8E, 0x71, 0xC7, 0x1C, 0x61, 0x8E, 0x38,
  0xC3, 0x00, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x20, 0x1C, 0x01, 0xC0, 0xC0, 0x1F, 0x86, 0x00, 0x3E,
  0x30, 0x00, 0x7D, 0x0F, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0x00,
  0x01, 0xD8, 0x00, 0x1C, 0x60, 0x01, 0xC3, 0x00, 0x1C, 0x1C, 0x03, 0xC0,
  0x60, 0x0E, 0x03, 0x80, 0x20, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x07, 0x0F, 0x0F, 0x0E, 0x1E, 0x1C,
  0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xC0, 0x7F, 0xFB, 0xFF, 0xFF, 0xFE,
  0x33, 0xFF, 0xFF, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0x83,
  0xC0, 0x1E, 0x03, 0xC0, 0x78, 0x03, 0x81, 0xE0, 0x07, 0x03, 0x80, 0x0F,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x73,
  0xC0, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0xBC, 0x00, 0x0F, 0x70,
  0x00, 0x1E, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xEE, 0x00,
  0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0x39, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xE7, 0x00, 0x03, 0x8E, 0x00, 0x07,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xC1,
  0xC0, 0x07, 0x83, 0x80, 0x1E, 0x07, 0x80, 0x38, 0x07, 0x80, 0xE0, 0x07,
  0x87, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x78, 0x07, 0xC0, 0x7E, 0x0F, 0xE0, 0xF7, 0x1F, 0x39, 0xE1, 0xDE, 0x0E,
  0xE0, 0xE2, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x3F, 0x03, 0xE0, 0x0E, 0x00, 0x78, 0x02, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xE0, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x20, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0xC0, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01,
  0xE0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x03,
  0x80, 0x70, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x07, 0x00,
  0x07, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x01, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x20, 0x00, 0x78, 0x18, 0x00, 0x78, 0x0F, 0x81, 0xF8,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3E, 0x01, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x7F,
  0x80, 0x39, 0xFF, 0xC0, 0x73, 0xC3, 0xE0, 0x77, 0x00, 0xF0, 0x7C, 0x00,
  0x70, 0x78, 0x00, 0x78, 0xF8, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xF0, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x78, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0xE0, 0xE0, 0x00, 0xE0, 0xF0, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0x3E, 0x1F, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0x03, 0xE0, 0x0F,
  0x00, 0x78, 0x0F, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x03,
  0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70,
  0x38, 0x00, 0x70, 0x0E, 0x00, 0x78, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x78,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x1E, 0x01,
  0xE0, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x0E, 0x00,
  0x03, 0x87, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x71, 0xE0,
  0x00, 0x38, 0xF0, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0F,
  0x00, 0x0E, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xF0, 0x7C, 0x03, 0xC0, 0x1C, 0x07, 0x80,
  0x1E, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1E, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x3C, 0x00,
  0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x1C, 0x00, 0x3E, 0x1C, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x0F, 0x01,
  0xDC, 0x0F, 0xFF, 0x9C, 0x07, 0xFF, 0x1C, 0x01, 0xFC, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0xC0, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x14, 0x00, 0x00, 0x01, 0x80,
  0xE0, 0x7C, 0x1E, 0x07, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x03, 0xE0, 0xF0, 0x3C, 0x04,
  0x00, 0x00, 0x18, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF8,
  0x78, 0x1E, 0x10, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x3C,
  0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x7F, 0xC0, 0x70, 0xE0, 0x0F,
  0xFF, 0x03, 0x8E, 0x00, 0xF0, 0x38, 0x1C, 0x70, 0x0E, 0x01, 0x80, 0x63,
  0x00, 0xE0, 0x1C, 0x07, 0x38, 0x06, 0x00, 0xE0, 0x39, 0xC0, 0x70, 0x06,
  0x01, 0xCC, 0x07, 0x00, 0x30, 0x0E, 0xE0, 0x38, 0x03, 0x80, 0x77, 0x01,
  0x80, 0x1C, 0x03, 0x38, 0x1C, 0x00, 0xC0, 0x19, 0x80, 0xE0, 0x0E, 0x01,
  0xCC, 0x07, 0x00, 0x70, 0x0E, 0xE0, 0x30, 0x03, 0x80, 0x67, 0x01, 0x80,
  0x38, 0x07, 0x38, 0x0C, 0x01, 0xC0, 0x31, 0xC0, 0x60, 0x1E, 0x03, 0x8E,
  0x03, 0x80, 0xF0, 0x38, 0x70, 0x1C, 0x0D, 0xC3, 0xC1, 0x80, 0xF9, 0xC7,
  0x7C, 0x0C, 0x03, 0xFC, 0x3F, 0xC0, 0x70, 0x07, 0xC0, 0xF8, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03, 0x80, 0x00,
  0x0F, 0xF7, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E,
  0x06, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x03, 0x80,
  0x03, 0x80, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x38, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0x03, 0xFE,
  0x00, 0xE0, 0x03, 0xE0, 0x1C, 0x00, 0x3C, 0x03, 0x80, 0x03, 0x80, 0xF0,
  0x00, 0x78, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x38,
  0x0E, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x3C, 0x0E, 0x00,
  0x07, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x3E, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xE0, 0x07,
  0xC0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x1C,
  0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07,
  0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xF0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xE0,
  0x70, 0x00, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x03, 0xF0, 0x0E, 0x00, 0x7C, 0x00, 0x20, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x10, 0x00,
  0xFC, 0x1F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x70, 0x7F,
  0xC0, 0x03, 0x80, 0x1F, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0xF0,
  0x0F, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x70, 0x1C,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x83, 0x80, 0x00, 0x78, 0x1C,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x3C, 0x03, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x7C, 0x01, 0xC0, 0x0F, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x02, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x7C, 0x00, 0x18, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xE1, 0xC0,
  0x03, 0xFF, 0x87, 0x00, 0x0F, 0xFE, 0x1C, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x70, 0x07, 0x80, 0x01, 0xC0, 0x1F, 0x00, 0x07, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x1E, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x78, 0x07, 0x00, 0x07, 0x80, 0x70, 0x00, 0x78, 0x03, 0x80, 0x07,
  0x80, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00,
  0x70, 0x07, 0x80, 0x03, 0x80, 0x78, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0x73, 0xE0, 0x00, 0x03, 0xBF, 0x00, 0x00, 0x1F, 0xB8, 0x00, 0x01, 0xF9,
  0xE0, 0x00, 0x0F, 0x87, 0x00, 0x00, 0x78, 0x38, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x1C, 0x07, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x70, 0x07, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x80, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0E, 0xC0, 0x37, 0x00, 0x00, 0x1F,
  0x80, 0xEE, 0x00, 0x00, 0x77, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x03, 0xB8,
  0x00, 0x03, 0x9C, 0x07, 0x30, 0x00, 0x0F, 0x70, 0x0E, 0x60, 0x00, 0x1C,
  0xE0, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0xE3,
  0x80, 0x03, 0x8F, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x03, 0x8E, 0x00, 0x1C,
  0x38, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x38,
  0x30, 0x01, 0xC3, 0xC0, 0x70, 0x60, 0x07, 0x07, 0x01, 0xC0, 0xE0, 0x0E,
  0x0E, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0x70, 0x38, 0x0E,
  0x07, 0x01, 0xC0, 0xE0, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x38, 0x07, 0x01, 0xC0, 0x30, 0x70, 0x0E, 0x03,
  0x80, 0x61, 0xC0, 0x38, 0x07, 0x00, 0xE3, 0x80, 0x70, 0x1C, 0x01, 0xCE,
  0x00, 0xE0, 0x38, 0x03, 0x9C, 0x01, 0xC0, 0x70, 0x07, 0x70, 0x07, 0x80,
  0xE0, 0x0E, 0xE0, 0x0E, 0x01, 0xC0, 0x1F, 0x80, 0x1C, 0x07, 0x00, 0x3F,
  0x00, 0x38, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x1C, 0x00, 0x78, 0x01, 0xE0,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x07, 0x01, 0xF0, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x0E, 0x01, 0xF8,
  0x00, 0x0E, 0x01, 0xB8, 0x00, 0x0E, 0x03, 0xB8, 0x00, 0x0E, 0x03, 0x9C,
  0x00, 0x0E, 0x03, 0x9C, 0x00, 0x1C, 0x03, 0x9C, 0x00, 0x1C, 0x03, 0x8E,
  0x00, 0x1C, 0x07, 0x0E, 0x00, 0x1C, 0x07, 0x0E, 0x00, 0x1C, 0x07, 0x07,
  0x00, 0x38, 0x07, 0x07, 0x00, 0x38, 0x07, 0x07, 0x00, 0x38, 0x0E, 0x07,
  0x80, 0x38, 0x0E, 0x03, 0x80, 0x78, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0xC0, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x1C, 0x01,
  0xC0, 0xE0, 0x1C, 0x00, 0xE0, 0xE0, 0x1C, 0x00, 0xE0, 0xE0, 0x38, 0x00,
  0xE0, 0xE0, 0x38, 0x00, 0x70, 0xE0, 0x38, 0x00, 0x71, 0xC0, 0x38, 0x00,
  0x71, 0xC0, 0x38, 0x00, 0x39, 0xC0, 0x70, 0x00, 0x39, 0xC0, 0x70, 0x00,
  0x39, 0xC0, 0x70, 0x00, 0x1F, 0x80, 0x70, 0x00, 0x1F, 0x80, 0x70, 0x00,
  0x1F, 0x80, 0xE0, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1D, 0xE0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x87, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1C,
  0x1F, 0xE0, 0x07, 0x00, 0x7C, 0x01, 0xC0, 0x07, 0x80, 0x70, 0x00, 0xE0,
  0x3C, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00,
  0xF0, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x03,
  0x80, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0x38, 0x03, 0xE0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00,
  0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x2F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1C, 0x1F,
  0xE0, 0x07, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x80, 0x70, 0x00, 0xE0, 0x3C,
  0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xF0,
  0x38, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x03, 0x80,
  0x07, 0x80, 0xE0, 0x07, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x1E, 0x00, 0x1C, 0x03, 0x80,
  0x0F, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x1E, 0x01, 0xC0, 0x03, 0x80, 0x70,
  0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0,
  0xE0, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xF0, 0x1E, 0x01,
  0xF0, 0x01, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0xC0, 0x03, 0xE0, 0x3F, 0x07,
  0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x78,
  0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xE0,
  0x0F, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1C,
  0x70, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x81, 0xC0,
  0x01, 0xC0, 0x70, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x1E, 0x01,
  0xC0, 0x07, 0x00, 0x70, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x78,
  0x00, 0xE0, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80,
  0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x03,
  0x83, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x38, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x67, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x06, 0xE0,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x7C, 0x00, 0x0E, 0xE0, 0x00, 0x7C,
  0x00, 0x1C, 0xE0, 0x00, 0xFC, 0x00, 0x1C, 0xE0, 0x00, 0xFC, 0x00, 0x3C,
  0xE0, 0x01, 0xDC, 0x00, 0x38, 0xE0, 0x01, 0xDC, 0x00, 0x38, 0xE0, 0x01,
  0x9C, 0x00, 0x70, 0xE0, 0x03, 0x9C, 0x00, 0x70, 0xE0, 0x03, 0x9C, 0x00,
  0xE0, 0xE0, 0x07, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x1C, 0x01, 0xE0, 0xE0,
  0x0E, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x1C, 0x01, 0xC0, 0xE0, 0x1C, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x1C, 0x03, 0x80, 0xE0, 0x18, 0x1C, 0x07, 0x00,
  0xE0, 0x38, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x1C, 0x0F, 0x00, 0xE0, 0x70,
  0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x1C, 0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x1C,
  0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x00, 0xE1,
  0xC0, 0x1C, 0x38, 0x00, 0xE1, 0x80, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x1C,
  0x70, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x00,
  0xE7, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x0D, 0xC0, 0x00, 0xEE, 0x00,
  0x0D, 0xC0, 0x00, 0xEC, 0x00, 0x0D, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x3C, 0x70,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x3C,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78,
  0x70, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x38, 0x01, 0xC0,
  0x38, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x3C, 0x07, 0x00, 0x1C, 0x0F, 0x00,
  0x1C, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03,
  0x01, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x06, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3B, 0x80, 0x00, 0x39, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x60, 0x03, 0x80, 0x70,
  0x03, 0x80, 0x70, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38,
  0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0xE1, 0xC1, 0xC3, 0x83, 0x83, 0x07, 0x06, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0xC3, 0x00, 0xFF, 0xE3, 0x03, 0xE0, 0xE7, 0x03, 0xC0,
  0x37, 0x07, 0x80, 0x36, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x1C, 0x00,
  0x1E, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x38, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0x70, 0x03,
  0x60, 0x70, 0x07, 0x60, 0x78, 0x0E, 0xE0, 0x3C, 0x3C, 0xE0, 0x3F, 0xF8,
  0xE0, 0x0F, 0xE0, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x1E, 0x00,
  0x1C, 0x3F, 0xC0, 0x0E, 0x7F, 0xF8, 0x07, 0x78, 0x3C, 0x07, 0x70, 0x0F,
  0x03, 0xB0, 0x03, 0x81, 0xF0, 0x01, 0xC0, 0xF8, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1C, 0x00, 0x0F, 0x0E, 0x00,
  0x07, 0x07, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x70, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38,
  0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x07,
  0xC0, 0x07, 0x83, 0xE0, 0x07, 0x81, 0xD8, 0x07, 0x80, 0xCF, 0x0F, 0x80,
  0xE3, 0xFF, 0x80, 0x70, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xE0, 0x60, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x40, 0x7E, 0x0E, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x38, 0x00, 0xFF, 0x87, 0x00, 0x3F, 0xF9, 0xC0, 0x1F,
  0x03, 0xB8, 0x07, 0xC0, 0x37, 0x00, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x7C,
  0x07, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x3C, 0x0E, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x70, 0x3C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x1C,
  0x00, 0x1E, 0x03, 0x80, 0x03, 0xC0, 0x78, 0x00, 0xF8, 0x07, 0x00, 0x3F,
  0x00, 0xE0, 0x0E, 0xE0, 0x1E, 0x03, 0x98, 0x01, 0xE1, 0xE7, 0x00, 0x3F,
  0xF8, 0xE0, 0x01, 0xFE, 0x1C, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xC0, 0xE0, 0x3C, 0x07, 0x83,
  0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03,
  0x8E, 0x00, 0x3C, 0x70, 0x03, 0xC7, 0x80, 0x3C, 0x38, 0x0F, 0xC1, 0xFF,
  0xFC, 0x0F, 0xFF, 0x00, 0x7A, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x20, 0x3E, 0x0F, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xDF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xFE, 0x1C, 0x01, 0xFF, 0xE3, 0x00, 0x7C, 0x0E, 0x60, 0x0F,
  0x00, 0xDC, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0x1C, 0x00, 0x3C,
  0x07, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x07, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xC0, 0xF0, 0x00,
  0x38, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x78, 0x0E,
  0x00, 0x0F, 0x01, 0xE0, 0x03, 0xE0, 0x1C, 0x00, 0xFC, 0x03, 0x80, 0x3B,
  0x80, 0x78, 0x0E, 0xE0, 0x07, 0x87, 0x9C, 0x00, 0xFF, 0xE3, 0x80, 0x07,
  0xF8, 0x70, 0x00, 0x30, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x3C, 0x00,
  0xFE, 0x7F, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x81, 0xF0, 0x03, 0x87, 0xFC, 0x03, 0x9F, 0xFE, 0x03, 0xBC, 0x1E, 0x07,
  0x70, 0x0F, 0x07, 0x60, 0x07, 0x07, 0xC0, 0x07, 0x07, 0x80, 0x07, 0x07,
  0x80, 0x07, 0x0F, 0x00, 0x07, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x1C,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x38,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x78, 0x00, 0x38, 0x70,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0xDF, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x01, 0x03, 0x80, 0x0E,
  0x03, 0x80, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xE0,
  0x07, 0x01, 0xC0, 0x07, 0x03, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x0F, 0x00,
  0x0E, 0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x78, 0x00, 0x0C, 0xF8, 0x00,
  0x1C, 0xF8, 0x00, 0x1D, 0xF8, 0x00, 0x1F, 0x9C, 0x00, 0x1F, 0x1C, 0x00,
  0x1E, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0F, 0x00,
  0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x70, 0x03, 0x80,
  0x70, 0x03, 0x80, 0x70, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xE0,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x0E, 0x3F, 0xE0, 0x7F,
  0xC0, 0x39, 0xFF, 0xC3, 0xFF, 0x80, 0xCE, 0x0F, 0x1C, 0x1E, 0x07, 0x70,
  0x1C, 0xE0, 0x3C, 0x1D, 0x80, 0x3F, 0x00, 0x70, 0x7C, 0x00, 0xF8, 0x01,
  0xC1, 0xE0, 0x03, 0xC0, 0x07, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x3C, 0x00,
  0x38, 0x00, 0x70, 0xF0, 0x01, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x00, 0xE1, 0xC0, 0x01,
  0xC0, 0x03, 0x87, 0x00, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x70, 0x00, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0x03, 0x83,
  0x80, 0x07, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE0,
  0x00, 0xE1, 0xC0, 0x03, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xF0, 0x03, 0x87, 0xFC, 0x03, 0x9F, 0xFE, 0x03,
  0x3C, 0x1E, 0x07, 0x70, 0x0F, 0x07, 0x60, 0x07, 0x07, 0xC0, 0x07, 0x07,
  0x80, 0x07, 0x07, 0x80, 0x07, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x1C,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x38,
  0x00, 0x3C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x78,
  0x00, 0x38, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70,
  0x00, 0x70, 0xF0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0xE0,
  0x03, 0x83, 0xC0, 0x07, 0x8F, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x77, 0x80, 0x00, 0xEE, 0x00, 0x01,
  0xDC, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0x70, 0x00, 0x1D, 0xE0, 0x00, 0x3B,
  0x80, 0x00, 0x77, 0x00, 0x01, 0xEE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x3C,
  0x00, 0x1C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xE0, 0xF0, 0x03, 0xC0, 0xF0,
  0x0F, 0x01, 0xF0, 0x7C, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x0F, 0xF0, 0x00, 0x73, 0xFF,
  0xC0, 0x06, 0x78, 0x3C, 0x00, 0xE6, 0x01, 0xE0, 0x0E, 0xC0, 0x0E, 0x00,
  0xF8, 0x00, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x1F, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x70, 0x1E, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0,
  0x1C, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0xE0, 0x38, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x1C,
  0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x38, 0x07, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x70, 0x0F, 0x80, 0x0F, 0x00, 0xF8, 0x01, 0xE0, 0x0E, 0xC0, 0x3C,
  0x00, 0xEF, 0x0F, 0x80, 0x1C, 0x7F, 0xF0, 0x01, 0xC3, 0xFE, 0x00, 0x1C,
  0x02, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0xE1, 0xC0, 0x3F, 0xF8, 0xC0, 0x7C, 0x0E, 0x60, 0x3C, 0x03,
  0x70, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x1C, 0x00, 0x3C, 0x1C, 0x00,
  0x1E, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x87, 0x00, 0x03, 0xC3, 0x80,
  0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70,
  0x00, 0x38, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1C, 0x00, 0x0F, 0x0E,
  0x00, 0x07, 0x87, 0x00, 0x07, 0x83, 0x80, 0x03, 0xC1, 0xE0, 0x03, 0xE0,
  0x70, 0x03, 0xF0, 0x38, 0x03, 0xB8, 0x1E, 0x03, 0xB8, 0x07, 0x87, 0x9C,
  0x03, 0xFF, 0x8E, 0x00, 0x7F, 0x87, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x71, 0xFC, 0x0C, 0x7F, 0x81, 0x9E, 0x00, 0x77, 0x00,
  0x0E, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7C, 0x07, 0x0F, 0x00,
  0x10, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x80, 0x0F, 0x0F, 0x03, 0xE0, 0xFF, 0xFC,
  0x07, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x3F, 0xFF, 0x7F, 0xFC, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x81, 0xFF, 0x01,
  0xFE, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x38, 0x00, 0x38, 0x78, 0x00, 0x38, 0x70, 0x00, 0x70, 0x70, 0x00,
  0x70, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01,
  0xE0, 0xF0, 0x03, 0xE0, 0x70, 0x06, 0xE0, 0x70, 0x0E, 0xE0, 0x7C, 0x3C,
  0xE0, 0x3F, 0xF8, 0xC0, 0x1F, 0xE1, 0xC0, 0x02, 0x00, 0x00, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xB8, 0x00, 0x3D, 0xC0, 0x01, 0xCE, 0x00, 0x1E, 0x70,
  0x00, 0xE3, 0x80, 0x0F, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x83, 0x80, 0x38,
  0x1C, 0x03, 0xC0, 0xE0, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x01, 0xC0,
  0xF0, 0x0E, 0x07, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x0C, 0x38, 0x00,
  0x71, 0xC0, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0x70,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x01, 0xE0, 0x03, 0xB8,
  0x00, 0xF0, 0x01, 0xDC, 0x00, 0xF8, 0x01, 0xEE, 0x00, 0x7C, 0x00, 0xE7,
  0x00, 0x76, 0x00, 0x73, 0x80, 0x3B, 0x80, 0x71, 0xC0, 0x19, 0xC0, 0x38,
  0xE0, 0x1C, 0xE0, 0x38, 0x70, 0x0C, 0x70, 0x1C, 0x38, 0x0E, 0x38, 0x1C,
  0x0C, 0x06, 0x1C, 0x0E, 0x06, 0x07, 0x0E, 0x0F, 0x03, 0x03, 0x87, 0x07,
  0x01, 0x83, 0x83, 0x83, 0x80, 0xC1, 0xC1, 0xC3, 0x80, 0x71, 0xC0, 0xE1,
  0xC0, 0x38, 0xE0, 0x71, 0xC0, 0x1C, 0xE0, 0x38, 0xE0, 0x0E, 0x70, 0x1C,
  0xE0, 0x07, 0x30, 0x0E, 0x70, 0x03, 0xB8, 0x03, 0x38, 0x01, 0xD8, 0x01,
  0xB8, 0x00, 0xFC, 0x00, 0xDC, 0x00, 0x7E, 0x00, 0x6C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x1E, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x0F, 0x00, 0x07,
  0x07, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x78, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x0F, 0x01, 0xE0, 0x01, 0xC0, 0xF0, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x0D, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x33, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x5F, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0xF0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xE0, 0x01,
  0x7F, 0xF8, 0x03, 0xF8, 0xFE, 0x0F, 0xC0, 0x1F, 0xFE, 0x80, 0x07, 0xFC,
  0x00, 0x00, 0x40,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 12, 40, 13, 1, -39 },
  { 61, 14, 14, 18, 6, -39 },
  { 86, 30, 39, 30, 1, -39 },
  { 233, 25, 45, 27, 1, -42 },
  { 374, 32, 41, 39, 4, -40 },
  { 538, 29, 41, 31, 1, -40 },
  { 687, 6, 14, 10, 6, -39 },
  { 698, 16, 48, 14, 2, -39 },
  { 794, 16, 48, 14, -4, -39 },
  { 890, 21, 22, 26, 6, -42 },
  { 948, 24, 26, 28, 3, -32 },
  { 1026, 8, 13, 11, -2, -6 },
  { 1039, 13, 3, 16, 1, -16 },
  { 1044, 5, 6, 12, 1, -5 },
  { 1048, 24, 39, 18, -2, -39 },
  { 1165, 23, 41, 27, 3, -40 },
  { 1283, 13, 39, 27, 8, -39 },
  { 1347, 25, 40, 27, 0, -40 },
  { 1472, 26, 41, 27, 0, -40 },
  { 1606, 26, 39, 27, 0, -39 },
  { 1733, 25, 40, 27, 1, -39 },
  { 1858, 24, 41, 27, 3, -40 },
  { 1981, 24, 39, 27, 4, -39 },
  { 2098, 25, 41, 27, 1, -40 },
  { 2227, 24, 41, 27, 2, -40 },
  { 2350, 10, 31, 12, 1, -30 },
  { 2389, 14, 37, 12, -3, -30 },
  { 2454, 24, 25, 28, 3, -32 },
  { 2529, 23, 14, 28, 3, -26 },
  { 2570, 24, 25, 28, 3, -32 },
  { 2645, 18, 41, 20, 3, -40 },
  { 2738, 37, 44, 40, 2, -39 },
  { 2942, 27, 39, 27, -3, -39 },
  { 3074, 27, 39, 29, 2, -39 },
  { 3206, 28, 41, 28, 3, -40 },
  { 3350, 29, 39, 32, 2, -39 },
  { 3492, 25, 39, 25, 2, -39 },
  { 3614, 25, 39, 23, 2, -39 },
  { 3736, 30, 41, 33, 3, -40 },
  { 3890, 31, 39, 33, 2, -39 },
  { 4042, 19, 39, 15, -1, -39 },
  { 4135, 22, 49, 12, -9, -39 },
  { 4270, 29, 39, 27, 2, -39 },
  { 4412, 17, 39, 23, 2, -39 },
  { 4495, 39, 39, 41, 2, -39 },
  { 4686, 32, 39, 34, 2, -39 },
  { 4842, 30, 41, 34, 3, -40 },
  { 4996, 26, 39, 27, 2, -39 },
  { 5123, 30, 49, 34, 3, -40 },
  { 5307, 26, 39, 28, 2, -39 },
  { 5434, 26, 41, 25, 0, -40 },
  { 5568, 23, 39, 24, 5, -39 },
  { 5681, 30, 40, 33, 4, -39 },
  { 5831, 26, 39, 26, 5, -39 },
  { 5958, 40, 39, 42, 6, -39 },
  { 6153, 32, 39, 24, -3, -39 },
  { 6309, 24, 39, 24, 5, -39 },
  { 6426, 29, 39, 25, -1, -39 },
  { 6568, 21, 48, 16, -1, -39 },
  { 6694, 9, 39, 18, 6, -39 },
  { 6738, 21, 48, 16, -4, -39 },
  { 6864, 24, 22, 28, 2, -39 },
  { 6930, 20, 3, 19, -5, 5 },
  { 6938, 7, 9, 13, 8, -42 },
  { 6946, 24, 31, 28, 2, -30 },
  { 7039, 25, 43, 28, 1, -42 },
  { 7174, 21, 31, 22, 2, -30 },
  { 7256, 27, 43, 28, 2, -42 },
  { 7402, 21, 31, 24, 2, -30 },
  { 7484, 28, 55, 14, -7, -42 },
  { 7677, 27, 43, 28, 0, -30 },
  { 7823, 24, 42, 27, 1, -42 },
  { 7949, 12, 40, 12, 1, -40 },
  { 8009, 20, 53, 12, -7, -40 },
  { 8142, 24, 42, 23, 1, -42 },
  { 8268, 12, 42, 12, 1, -42 },
  { 8331, 38, 30, 42, 1, -30 },
  { 8474, 24, 30, 27, 1, -30 },
  { 8564, 23, 31, 27, 2, -30 },
  { 8654, 28, 43, 28, -2, -30 },
  { 8805, 25, 43, 28, 2, -30 },
  { 8940, 19, 30, 19, 1, -30 },
  { 9012, 20, 31, 21, 0, -30 },
  { 9090, 15, 37, 15, 2, -36 },
  { 9160, 24, 30, 28, 2, -29 },
  { 9250, 21, 29, 21, 3, -29 },
  { 9327, 33, 29, 34, 3, -29 },
  { 9447, 26, 29, 23, -2, -29 },
  { 9542, 30, 42, 22, -6, -29 },
  { 9700, 22, 29, 21, -1, -29 },
  { 9780, 20, 48, 18, 1, -39 },
  { 9900, 3, 55, 26, 12, -42 },
  { 9921, 20, 48, 18, -3, -39 },
  { 10041, 24, 6, 28, 3, -22 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC55PT7B_H_
