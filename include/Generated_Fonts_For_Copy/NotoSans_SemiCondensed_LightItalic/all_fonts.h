#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_SemiCondensed_LightItalic
// Headers: 67

#include "NotoSans_SemiCondensed_LightItalic6pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic7pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic8pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic9pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic10pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic11pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic12pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic13pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic14pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic15pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic16pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic17pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic18pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic19pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic20pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic21pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic22pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic23pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic24pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic25pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic26pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic27pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic28pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic29pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic30pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic31pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic32pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic33pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic34pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic35pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic36pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic37pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic38pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic39pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic40pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic41pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic42pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic43pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic44pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic45pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic46pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic47pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic48pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic49pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic50pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic51pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic52pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic53pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic54pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic55pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic56pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic57pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic58pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic59pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic60pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic61pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic62pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic63pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic64pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic65pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic66pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic67pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic68pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic69pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic70pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic71pt7b.h"
#include "NotoSans_SemiCondensed_LightItalic72pt7b.h"
