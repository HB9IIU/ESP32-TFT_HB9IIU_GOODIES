#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC10PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x48, 0xB8, 0x28, 0xA7, 0xD4, 0xF9, 0x46, 0x00, 0x11, 0xD8,
  0xC2, 0x18, 0xD8, 0x40, 0xEA, 0xCD, 0xBD, 0x55, 0x59, 0x80, 0x3A, 0x4C,
  0xC9, 0xCB, 0xA0, 0xC0, 0x29, 0x49, 0x24, 0x40, 0x24, 0x92, 0x4A, 0x80,
  0x2A, 0x7A, 0x44, 0xF4, 0x40, 0xC0, 0xE0, 0x80, 0x12, 0x24, 0x48, 0x80,
  0x3A, 0x53, 0x19, 0x49, 0x80, 0x74, 0xA4, 0x90, 0x78, 0x42, 0x22, 0x23,
  0xC0, 0x78, 0x44, 0x41, 0x0B, 0x80, 0x19, 0x4C, 0xA9, 0x3C, 0x80, 0x7A,
  0x18, 0x21, 0x0B, 0x80, 0x3A, 0x18, 0xA8, 0xC9, 0xC0, 0xF1, 0x24, 0x48,
  0x80, 0x7A, 0x54, 0xC9, 0x49, 0xC0, 0x7A, 0x52, 0xA3, 0x0B, 0x80, 0x40,
  0x80, 0x40, 0xA0, 0x16, 0x86, 0x10, 0xF0, 0xF0, 0x86, 0x16, 0x80, 0xE4,
  0xA8, 0x20, 0x3C, 0x85, 0x7D, 0x5A, 0xB7, 0x90, 0x1C, 0x08, 0xCA, 0x57,
  0xA6, 0x20, 0x7A, 0x52, 0xE4, 0xC7, 0xC0, 0x7C, 0x21, 0x08, 0x43, 0x80,
  0x79, 0x14, 0x51, 0x4A, 0x2F, 0x00, 0x7A, 0x10, 0xE4, 0x43, 0xC0, 0x7A,
  0x10, 0xE4, 0x42, 0x00, 0x7C, 0x21, 0x78, 0xCB, 0xC0, 0x45, 0x14, 0x5E,
  0x4A, 0x28, 0x80, 0x69, 0x24, 0xB0, 0x11, 0x11, 0x12, 0x22, 0xC0, 0x4D,
  0x46, 0x18, 0x52, 0x49, 0x00, 0x44, 0x44, 0x48, 0xF0, 0x23, 0x62, 0x66,
  0x6A, 0x6A, 0xB2, 0x94, 0x25, 0x96, 0x55, 0x5A, 0x68, 0x80, 0x7C, 0x63,
  0x18, 0xCB, 0x80, 0x7A, 0x52, 0xE4, 0x42, 0x00, 0x7C, 0x63, 0x18, 0xCB,
  0x84, 0x20, 0x7A, 0x52, 0xE5, 0x4A, 0x40, 0x7A, 0x10, 0x41, 0x0B, 0x80,
  0xF4, 0x44, 0x48, 0x80, 0x8C, 0x63, 0x19, 0x4B, 0x80, 0x8C, 0xA5, 0x4A,
  0x62, 0x00, 0x93, 0x66, 0xD5, 0xAD, 0x51, 0x22, 0x00, 0x24, 0xA1, 0x04,
  0x31, 0x2C, 0x80, 0x9A, 0xA4, 0x48, 0x80, 0x78, 0x84, 0x44, 0x43, 0xC0,
  0x74, 0x44, 0x88, 0x88, 0xC0, 0xAA, 0x94, 0x31, 0x12, 0x22, 0x22, 0xC0,
  0x21, 0x95, 0x10, 0xF0, 0x90, 0x7A, 0x65, 0x27, 0x00, 0x22, 0x14, 0xD4,
  0xC6, 0x5E, 0x74, 0x88, 0x70, 0x08, 0x4E, 0x94, 0xCA, 0x4E, 0x75, 0xE8,
  0x70, 0x19, 0x0C, 0x42, 0x11, 0x08, 0x46, 0x00, 0x7A, 0x65, 0x27, 0x0B,
  0x80, 0x22, 0x14, 0xD4, 0xCA, 0x52, 0x45, 0xA8, 0x20, 0x92, 0x92, 0xC0,
  0x22, 0x12, 0xA6, 0x32, 0x92, 0x55, 0x6A, 0x7E, 0xA6, 0x4C, 0x99, 0x20,
  0x7A, 0x65, 0x29, 0x00, 0x7A, 0x63, 0x27, 0x00, 0x7A, 0x63, 0x2F, 0x42,
  0x00, 0x7A, 0x65, 0x27, 0x08, 0x40, 0x74, 0x88, 0x80, 0x74, 0x22, 0xE0,
  0x4D, 0x29, 0x30, 0x4A, 0x65, 0x2F, 0x00, 0xB7, 0x48, 0xAF, 0xAA, 0xA4,
  0xA0, 0x56, 0x46, 0xA0, 0x49, 0x4C, 0x42, 0x13, 0x00, 0x72, 0x48, 0xE0,
  0x32, 0x44, 0xC4, 0x48, 0x40, 0xFF, 0xC0, 0x31, 0x12, 0x12, 0x24, 0x80,
  0xF0,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 3, 2, 3, 1, -7 },
  { 4, 6, 7, 5, 0, -7 },
  { 10, 5, 9, 5, 0, -8 },
  { 16, 6, 7, 7, 1, -7 },
  { 22, 5, 7, 6, 0, -7 },
  { 27, 1, 2, 2, 1, -7 },
  { 28, 3, 9, 3, 0, -7 },
  { 32, 3, 9, 3, -1, -7 },
  { 36, 4, 4, 5, 1, -8 },
  { 38, 4, 5, 5, 1, -6 },
  { 41, 1, 2, 2, 0, -1 },
  { 42, 3, 1, 3, 0, -3 },
  { 43, 1, 1, 2, 0, -1 },
  { 44, 4, 7, 3, 0, -7 },
  { 48, 5, 7, 5, 0, -7 },
  { 53, 3, 7, 5, 1, -7 },
  { 56, 5, 7, 5, 0, -7 },
  { 61, 5, 7, 5, 0, -7 },
  { 66, 5, 7, 5, 0, -7 },
  { 71, 5, 7, 5, 0, -7 },
  { 76, 5, 7, 5, 0, -7 },
  { 81, 4, 7, 5, 1, -7 },
  { 85, 5, 7, 5, 0, -7 },
  { 90, 5, 7, 5, 0, -7 },
  { 95, 2, 5, 2, 0, -5 },
  { 97, 2, 6, 2, 0, -5 },
  { 99, 4, 5, 5, 1, -6 },
  { 102, 4, 3, 5, 1, -5 },
  { 104, 4, 5, 5, 1, -6 },
  { 107, 3, 7, 4, 1, -7 },
  { 110, 7, 8, 7, 0, -7 },
  { 117, 5, 7, 5, -1, -7 },
  { 122, 5, 7, 5, 0, -7 },
  { 127, 5, 7, 5, 1, -7 },
  { 132, 6, 7, 6, 0, -7 },
  { 138, 5, 7, 5, 0, -7 },
  { 143, 5, 7, 4, 0, -7 },
  { 148, 5, 7, 6, 1, -7 },
  { 153, 6, 7, 6, 0, -7 },
  { 159, 3, 7, 3, 0, -7 },
  { 162, 4, 9, 2, -2, -7 },
  { 167, 6, 7, 5, 0, -7 },
  { 173, 4, 7, 4, 0, -7 },
  { 177, 8, 7, 7, 0, -7 },
  { 184, 6, 7, 6, 0, -7 },
  { 190, 5, 7, 6, 1, -7 },
  { 195, 5, 7, 5, 0, -7 },
  { 200, 5, 9, 6, 1, -7 },
  { 206, 5, 7, 5, 0, -7 },
  { 211, 5, 7, 4, 0, -7 },
  { 216, 4, 7, 4, 1, -7 },
  { 220, 5, 7, 6, 1, -7 },
  { 225, 5, 7, 5, 1, -7 },
  { 230, 7, 7, 8, 1, -7 },
  { 237, 6, 7, 4, -1, -7 },
  { 243, 4, 7, 4, 1, -7 },
  { 247, 5, 7, 5, 0, -7 },
  { 252, 4, 9, 3, 0, -7 },
  { 257, 2, 7, 3, 1, -7 },
  { 259, 4, 9, 3, -1, -7 },
  { 264, 5, 4, 5, 0, -7 },
  { 267, 4, 1, 3, -1, 1 },
  { 268, 2, 2, 2, 1, -8 },
  { 269, 5, 5, 5, 0, -5 },
  { 273, 5, 8, 5, 0, -8 },
  { 278, 4, 5, 4, 0, -5 },
  { 281, 5, 8, 5, 0, -8 },
  { 286, 4, 5, 4, 0, -5 },
  { 289, 5, 10, 3, -1, -8 },
  { 296, 5, 7, 5, 0, -5 },
  { 301, 5, 8, 5, 0, -8 },
  { 306, 2, 7, 2, 0, -7 },
  { 308, 3, 9, 2, -1, -7 },
  { 312, 5, 8, 4, 0, -8 },
  { 317, 2, 8, 2, 0, -8 },
  { 319, 7, 5, 8, 0, -5 },
  { 324, 5, 5, 5, 0, -5 },
  { 328, 5, 5, 5, 0, -5 },
  { 332, 5, 7, 5, 0, -5 },
  { 337, 5, 7, 5, 0, -5 },
  { 342, 4, 5, 3, 0, -5 },
  { 345, 4, 5, 4, 0, -5 },
  { 348, 3, 7, 3, 0, -7 },
  { 351, 5, 5, 5, 0, -5 },
  { 355, 3, 5, 4, 1, -5 },
  { 357, 6, 5, 6, 1, -5 },
  { 361, 4, 5, 4, 0, -5 },
  { 364, 5, 7, 4, -1, -5 },
  { 369, 4, 5, 4, 0, -5 },
  { 372, 4, 9, 3, 0, -7 },
  { 377, 1, 10, 5, 2, -8 },
  { 379, 4, 9, 3, -1, -7 },
  { 384, 4, 1, 5, 1, -4 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC10PT7B_H_
