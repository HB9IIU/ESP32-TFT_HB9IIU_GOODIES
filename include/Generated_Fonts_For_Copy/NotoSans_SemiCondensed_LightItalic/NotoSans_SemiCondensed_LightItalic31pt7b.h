#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC31PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC3, 0x18, 0x61, 0x86, 0x10, 0x43, 0x0C, 0x30, 0x82,
  0x18, 0x00, 0x00, 0x30, 0xC3, 0x00, 0x23, 0x63, 0x62, 0x62, 0x46, 0x46,
  0xC4, 0xC4, 0x01, 0x86, 0x01, 0x84, 0x01, 0x04, 0x01, 0x0C, 0x03, 0x08,
  0x02, 0x08, 0x3F, 0xFF, 0x3F, 0xFF, 0x04, 0x10, 0x04, 0x10, 0x0C, 0x30,
  0x0C, 0x20, 0x08, 0x20, 0x08, 0x60, 0xFF, 0xFC, 0x10, 0x40, 0x10, 0xC0,
  0x30, 0xC0, 0x20, 0x80, 0x20, 0x80, 0x61, 0x80, 0x61, 0x00, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0xFC, 0x0F, 0xFC, 0x62, 0x21, 0x88, 0x0C, 0x60,
  0x31, 0x00, 0x44, 0x01, 0x90, 0x03, 0x40, 0x07, 0x00, 0x0F, 0x00, 0x2E,
  0x00, 0x98, 0x02, 0x30, 0x18, 0x80, 0x42, 0x01, 0x18, 0x84, 0xC3, 0xFE,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x1F, 0x01, 0x8C, 0x40,
  0x42, 0x18, 0x31, 0x86, 0x18, 0x41, 0x84, 0x10, 0x43, 0x0C, 0x11, 0x83,
  0x04, 0x40, 0xC3, 0x31, 0x30, 0x99, 0xFC, 0x64, 0xC7, 0x13, 0x61, 0x79,
  0x98, 0x40, 0x44, 0x10, 0x33, 0x04, 0x18, 0xC3, 0x04, 0x30, 0xC3, 0x08,
  0x21, 0x82, 0x08, 0x40, 0x86, 0x30, 0x33, 0x18, 0x07, 0x80, 0x03, 0xF0,
  0x06, 0x38, 0x04, 0x18, 0x0C, 0x18, 0x0C, 0x18, 0x0C, 0x18, 0x0C, 0x30,
  0x0C, 0x60, 0x06, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1B, 0x00, 0x31, 0x83,
  0x61, 0x86, 0xC0, 0xC4, 0xC0, 0x6C, 0x80, 0x78, 0x80, 0x38, 0xC0, 0x30,
  0xC0, 0xF8, 0xE3, 0x98, 0x7F, 0x0C, 0x36, 0x66, 0x44, 0x4C, 0x01, 0x81,
  0x81, 0x80, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x04,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00,
  0x80, 0x40, 0x30, 0x08, 0x00, 0x02, 0x01, 0x80, 0x40, 0x20, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03,
  0x01, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x30, 0x00,
  0x02, 0x00, 0x30, 0x03, 0x04, 0x20, 0xE2, 0x03, 0xA3, 0x07, 0xF0, 0xE0,
  0x1B, 0x03, 0x10, 0x61, 0x80, 0x18, 0x01, 0x00, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xFF, 0xFF, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x39, 0x88, 0xC4, 0x62, 0x00,
  0xFE, 0xFC, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x18, 0xE0, 0xC1, 0x86, 0x02,
  0x18, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x60, 0x09, 0x80, 0x26, 0x01,
  0x98, 0x06, 0x40, 0x19, 0x00, 0x6C, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x01,
  0x84, 0x06, 0x18, 0x30, 0x73, 0x80, 0xFC, 0x00, 0x07, 0x0F, 0x1A, 0x76,
  0xC6, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18,
  0x10, 0x30, 0x30, 0x30, 0x30, 0x20, 0x03, 0xF8, 0x38, 0x70, 0x40, 0xC0,
  0x03, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x03, 0xF8, 0x1C,
  0x38, 0x20, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC4, 0x03, 0x0E, 0x1C,
  0x0F, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x03, 0xC0, 0x1B, 0x00, 0x48,
  0x03, 0x60, 0x19, 0x80, 0xC6, 0x02, 0x18, 0x10, 0x40, 0xC3, 0x06, 0x0C,
  0x30, 0x30, 0x80, 0x86, 0x02, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x07, 0xFC, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xFF, 0x02,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x20, 0x30, 0xC3, 0x83, 0xFC, 0x00, 0x01, 0xF8, 0x38,
  0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x63, 0x06,
  0xFE, 0x3C, 0x19, 0xC0, 0xCC, 0x02, 0x60, 0x1A, 0x00, 0x90, 0x04, 0x80,
  0x64, 0x03, 0x30, 0x31, 0x81, 0x86, 0x38, 0x1F, 0x80, 0x3F, 0xFD, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x07, 0xF0, 0x38, 0x60, 0xC0, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x81,
  0x82, 0x06, 0x0C, 0x70, 0x1B, 0x00, 0x78, 0x07, 0x70, 0x30, 0x61, 0x81,
  0x8C, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x18, 0x71,
  0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x71, 0x86, 0x06, 0x30, 0x33, 0x00, 0x98,
  0x04, 0x80, 0x2C, 0x03, 0x60, 0x19, 0x00, 0xCC, 0x0E, 0x60, 0xF1, 0xF9,
  0x03, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x08,
  0x70, 0x7E, 0x00, 0x11, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x18, 0xC0, 0x06, 0x0C, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x00, 0x00, 0x08, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x04, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x3F, 0x98, 0x60, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x08, 0x06, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x3F, 0x80, 0x0F, 0x0E, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x60, 0xC0,
  0x01, 0x0C, 0x00, 0x0C, 0x40, 0xF8, 0x66, 0x0C, 0x61, 0x20, 0xC2, 0x0B,
  0x0C, 0x10, 0x58, 0x41, 0x86, 0x86, 0x0C, 0x34, 0x20, 0x41, 0x61, 0x06,
  0x0B, 0x08, 0x30, 0xD8, 0x41, 0x84, 0xC2, 0x14, 0x66, 0x1F, 0x3E, 0x10,
  0x20, 0x40, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x10,
  0x01, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0x60, 0x06, 0xC0, 0x09, 0x80, 0x33, 0x00, 0x46, 0x01, 0x84, 0x02,
  0x08, 0x0C, 0x10, 0x10, 0x20, 0x60, 0x40, 0xFF, 0xC3, 0x01, 0x8C, 0x03,
  0x18, 0x06, 0x60, 0x0C, 0xC0, 0x1B, 0x00, 0x36, 0x00, 0x78, 0x00, 0x40,
  0x0F, 0xF8, 0x18, 0x78, 0x30, 0x18, 0x60, 0x30, 0x80, 0x63, 0x00, 0xC6,
  0x01, 0x8C, 0x06, 0x18, 0x0C, 0x20, 0xF0, 0xFF, 0x01, 0x83, 0x83, 0x01,
  0x84, 0x03, 0x18, 0x03, 0x30, 0x06, 0x60, 0x18, 0xC0, 0x31, 0x00, 0xE6,
  0x03, 0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x0F, 0x0C, 0x38, 0x00,
  0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0xC6, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x0C, 0x7C, 0x0C, 0x0E, 0x0C, 0x06, 0x08, 0x03, 0x18, 0x03,
  0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x30, 0x03, 0x20, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x18,
  0x40, 0x38, 0xC0, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xFC, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x03, 0xFF, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x0F,
  0xFC, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0F, 0xFC, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x01, 0xFF, 0x83, 0xC1, 0x83, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x0F, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x11, 0x80, 0x18,
  0xC0, 0x0C, 0x60, 0x06, 0x18, 0x03, 0x0E, 0x01, 0x03, 0xC3, 0x80, 0xFF,
  0x80, 0x0C, 0x00, 0xC3, 0x00, 0x20, 0xC0, 0x18, 0x30, 0x06, 0x08, 0x01,
  0x86, 0x00, 0x61, 0x80, 0x10, 0x60, 0x0C, 0x18, 0x03, 0x04, 0x00, 0xC3,
  0xFF, 0xF0, 0xC0, 0x08, 0x30, 0x06, 0x08, 0x01, 0x82, 0x00, 0x61, 0x80,
  0x10, 0x60, 0x04, 0x18, 0x03, 0x04, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x08,
  0x30, 0x06, 0x00, 0x07, 0xE0, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x81, 0xFC, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00,
  0xC0, 0xFC, 0x07, 0x00, 0x0C, 0x03, 0x86, 0x03, 0x03, 0x03, 0x01, 0x83,
  0x00, 0x83, 0x00, 0xC3, 0x00, 0x63, 0x80, 0x33, 0x80, 0x1B, 0x80, 0x0B,
  0x80, 0x0D, 0xC0, 0x07, 0x20, 0x03, 0x18, 0x01, 0x0C, 0x01, 0x83, 0x00,
  0xC1, 0x80, 0x60, 0xC0, 0x30, 0x30, 0x10, 0x18, 0x18, 0x0C, 0x0C, 0x03,
  0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x04, 0x03, 0x00, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x1C, 0x38, 0x00,
  0x70, 0xE0, 0x03, 0xC2, 0x80, 0x0B, 0x0B, 0x00, 0x68, 0x6C, 0x01, 0x61,
  0xB0, 0x0D, 0x86, 0xC0, 0x26, 0x13, 0x01, 0x98, 0x44, 0x04, 0x43, 0x10,
  0x33, 0x0C, 0x41, 0x8C, 0x31, 0x06, 0x30, 0x86, 0x30, 0x86, 0x18, 0xC2,
  0x18, 0x66, 0x18, 0x61, 0x98, 0x61, 0x86, 0xC1, 0x84, 0x0A, 0x04, 0x30,
  0x38, 0x30, 0xC0, 0xC0, 0xC3, 0x03, 0x03, 0x00, 0x0E, 0x00, 0xC3, 0x80,
  0x30, 0xE0, 0x0C, 0x2C, 0x03, 0x0B, 0x00, 0x86, 0x40, 0x61, 0x98, 0x18,
  0x66, 0x06, 0x11, 0x81, 0x04, 0x30, 0x43, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0x43, 0x08, 0x18, 0x86, 0x06, 0x61, 0x80, 0x98, 0x60, 0x36, 0x18, 0x0D,
  0x84, 0x01, 0x43, 0x00, 0x70, 0xC0, 0x1C, 0x30, 0x03, 0x00, 0x03, 0xFC,
  0x03, 0x87, 0x03, 0x01, 0xC3, 0x00, 0x63, 0x00, 0x31, 0x80, 0x09, 0x80,
  0x06, 0xC0, 0x03, 0x60, 0x01, 0x60, 0x00, 0xB0, 0x00, 0xD8, 0x00, 0x6C,
  0x00, 0x36, 0x00, 0x1B, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x06,
  0x18, 0x06, 0x0C, 0x07, 0x03, 0x8F, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x18,
  0xF0, 0x30, 0x30, 0x60, 0x60, 0x80, 0x43, 0x00, 0xC6, 0x01, 0x0C, 0x06,
  0x18, 0x0C, 0x20, 0x30, 0xC0, 0xE1, 0xFF, 0x83, 0xF8, 0x04, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x00, 0x03, 0xFC, 0x03, 0x87, 0x03, 0x01, 0xC3, 0x00, 0x63,
  0x00, 0x31, 0x80, 0x09, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0x60, 0x00,
  0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x19, 0x80,
  0x0C, 0xC0, 0x06, 0x60, 0x06, 0x18, 0x06, 0x0C, 0x07, 0x03, 0x8F, 0x00,
  0xFE, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x0F, 0xF0, 0x18, 0xF0, 0x30, 0x30, 0x60, 0x60, 0x80, 0x63, 0x00,
  0xC6, 0x01, 0x0C, 0x06, 0x18, 0x0C, 0x20, 0x30, 0xC1, 0xC1, 0xFF, 0x03,
  0x18, 0x04, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0x40, 0xC0, 0xC1, 0x01,
  0x86, 0x03, 0x0C, 0x03, 0x18, 0x06, 0x00, 0x03, 0xFE, 0x0E, 0x18, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x0E, 0x1C, 0x0F, 0xF0,
  0x00, 0xFF, 0xF8, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x42, 0x00, 0x63, 0x00, 0x31,
  0x80, 0x18, 0xC0, 0x08, 0x60, 0x04, 0x20, 0x06, 0x30, 0x03, 0x18, 0x01,
  0x8C, 0x00, 0x84, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0,
  0x18, 0x60, 0x0C, 0x30, 0x0C, 0x1C, 0x0E, 0x07, 0x0E, 0x01, 0xFC, 0x00,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xB0, 0x06, 0xC0, 0x33, 0x00, 0xCC, 0x06,
  0x30, 0x18, 0x40, 0xC1, 0x03, 0x04, 0x18, 0x10, 0x60, 0x63, 0x01, 0x8C,
  0x06, 0x60, 0x19, 0x80, 0x6C, 0x01, 0xB0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0xC0, 0x30, 0x07, 0x80, 0x70, 0x1B, 0x00, 0xE0, 0x36,
  0x03, 0xC0, 0x4C, 0x05, 0x81, 0x98, 0x1B, 0x03, 0x30, 0x26, 0x0C, 0x60,
  0xCC, 0x18, 0xC1, 0x98, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0x61, 0x06, 0x10,
  0xC6, 0x04, 0x61, 0x88, 0x08, 0x83, 0x30, 0x13, 0x06, 0x60, 0x24, 0x0D,
  0x80, 0x58, 0x1B, 0x00, 0xB0, 0x34, 0x01, 0x40, 0x78, 0x03, 0x80, 0xE0,
  0x06, 0x01, 0xC0, 0x0C, 0x03, 0x80, 0x00, 0x06, 0x00, 0xC0, 0xC0, 0x60,
  0x30, 0x30, 0x04, 0x0C, 0x01, 0x86, 0x00, 0x63, 0x00, 0x18, 0x80, 0x02,
  0x60, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0xC8, 0x00, 0x23, 0x00, 0x18, 0xC0, 0x0C, 0x10, 0x06, 0x06, 0x01,
  0x81, 0x80, 0xC0, 0x60, 0x60, 0x08, 0x38, 0x03, 0x00, 0xC0, 0x1E, 0x01,
  0xB0, 0x0C, 0x80, 0xC6, 0x0C, 0x30, 0x61, 0x86, 0x0C, 0x60, 0x23, 0x01,
  0xB0, 0x0D, 0x00, 0x78, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x07, 0xE0, 0xC0, 0x10,
  0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0x83, 0xE0, 0x00, 0xC6, 0x10,
  0x84, 0x31, 0x8C, 0x21, 0x08, 0x63, 0x18, 0xC2, 0x10, 0x86, 0x31, 0x84,
  0x07, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x1F, 0x83,
  0xF0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x3C, 0x01, 0x90, 0x04, 0x40, 0x31,
  0x80, 0x82, 0x06, 0x0C, 0x30, 0x30, 0xC0, 0x46, 0x01, 0x90, 0x02, 0xC0,
  0x0C, 0xFF, 0xE0, 0x8C, 0x46, 0x30, 0x03, 0x80, 0x3F, 0xB1, 0xC2, 0xC6,
  0x06, 0x30, 0x18, 0x80, 0x66, 0x01, 0x98, 0x04, 0x40, 0x33, 0x00, 0xCC,
  0x03, 0x30, 0x0C, 0xC0, 0x63, 0x03, 0x86, 0x0E, 0x18, 0xD8, 0x3E, 0x60,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03,
  0x1C, 0x1B, 0xF0, 0xB0, 0xCF, 0x06, 0x70, 0x13, 0x00, 0x98, 0x04, 0x80,
  0x2C, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x04, 0xC0, 0x6E, 0x06, 0x70, 0x32,
  0xC7, 0x13, 0xF0, 0x03, 0xC0, 0xFF, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x07, 0x08, 0x3F, 0x80, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x03, 0xCC, 0x0F, 0xEC, 0x1C,
  0x3C, 0x18, 0x18, 0x30, 0x18, 0x20, 0x18, 0x60, 0x18, 0x60, 0x18, 0x40,
  0x10, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x70, 0xC0, 0xE0, 0x60,
  0xA0, 0x63, 0x60, 0x3E, 0x60, 0x03, 0xC0, 0x7E, 0x1C, 0x31, 0x83, 0x30,
  0x32, 0x03, 0x60, 0x66, 0x1C, 0x7F, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x07, 0x0C, 0x1F, 0x80, 0x00, 0x0E, 0x00, 0x1F, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x03,
  0xF8, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x0F,
  0xEC, 0x38, 0x78, 0x60, 0x61, 0x80, 0xC2, 0x01, 0x8C, 0x03, 0x18, 0x06,
  0x20, 0x08, 0xC0, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x03, 0x8C, 0x0E, 0x0C,
  0x34, 0x18, 0xD8, 0x1F, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x30, 0x60, 0x7F, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x1C, 0x1B, 0xF0, 0xB0, 0xCE, 0x06,
  0x70, 0x33, 0x01, 0x98, 0x0C, 0x80, 0x4C, 0x02, 0x60, 0x33, 0x01, 0x98,
  0x0C, 0x80, 0x4C, 0x06, 0x60, 0x33, 0x01, 0x90, 0x0C, 0x04, 0x30, 0xC0,
  0x00, 0x00, 0x06, 0x10, 0xC3, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x84, 0x30,
  0xC3, 0x08, 0x00, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x81, 0xE0, 0x00, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x01, 0x18, 0x30,
  0x83, 0x0C, 0x30, 0x63, 0x03, 0x30, 0x1B, 0x00, 0x98, 0x0D, 0xC0, 0x72,
  0x03, 0x18, 0x10, 0xC0, 0x82, 0x0C, 0x18, 0x60, 0xC3, 0x03, 0x10, 0x18,
  0x04, 0x30, 0xC3, 0x08, 0x21, 0x86, 0x18, 0x43, 0x0C, 0x30, 0xC2, 0x18,
  0x61, 0x86, 0x10, 0xC3, 0x0C, 0x20, 0x09, 0xE0, 0xE0, 0x9F, 0x9F, 0x85,
  0x0D, 0x86, 0x70, 0x38, 0x33, 0x81, 0x81, 0x98, 0x0C, 0x0C, 0xC0, 0xC0,
  0x64, 0x06, 0x02, 0x60, 0x30, 0x33, 0x01, 0x01, 0x98, 0x08, 0x0C, 0xC0,
  0xC0, 0x64, 0x06, 0x02, 0x60, 0x30, 0x33, 0x01, 0x01, 0x98, 0x18, 0x0C,
  0x80, 0xC0, 0x40, 0x18, 0xE0, 0x9F, 0x85, 0x86, 0x78, 0x33, 0x81, 0x98,
  0x0C, 0xC0, 0x64, 0x02, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0x64, 0x02,
  0x60, 0x33, 0x01, 0x98, 0x0C, 0x80, 0x60, 0x03, 0xC0, 0x7F, 0x87, 0x0C,
  0x30, 0x33, 0x01, 0xB0, 0x0D, 0x80, 0x6C, 0x03, 0x40, 0x1E, 0x00, 0xF0,
  0x05, 0x80, 0x6C, 0x03, 0x60, 0x31, 0x83, 0x8E, 0x38, 0x3F, 0x00, 0x02,
  0x38, 0x09, 0xF8, 0x16, 0x18, 0x78, 0x30, 0xE0, 0x21, 0x80, 0x43, 0x00,
  0x84, 0x01, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x21, 0x80, 0xC7,
  0x03, 0x0E, 0x06, 0x1E, 0x38, 0x27, 0xE0, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x03, 0x80, 0x3F, 0xB1,
  0xC3, 0xC6, 0x06, 0x30, 0x18, 0x80, 0x66, 0x01, 0x98, 0x06, 0x40, 0x13,
  0x00, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x73, 0x03, 0x86, 0x0A, 0x18, 0xD8,
  0x3E, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x00, 0xE2, 0x78, 0x58, 0x1E, 0x03, 0x80, 0x60, 0x0C, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x00, 0x07, 0x83, 0xFC, 0x60, 0x98, 0x03, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x66, 0x1C,
  0xFF, 0x00, 0x0C, 0x08, 0x18, 0x18, 0x7F, 0x10, 0x30, 0x30, 0x30, 0x20,
  0x20, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xE4, 0x78, 0x18, 0x0C,
  0x40, 0x23, 0x01, 0x8C, 0x06, 0x30, 0x18, 0x80, 0x66, 0x01, 0x18, 0x0C,
  0x60, 0x31, 0x80, 0xC4, 0x06, 0x30, 0x18, 0xC0, 0xE3, 0x07, 0x86, 0x36,
  0x1F, 0x90, 0x80, 0x78, 0x06, 0xC0, 0xCC, 0x0C, 0xC1, 0x8C, 0x18, 0xC3,
  0x0C, 0x20, 0xC6, 0x04, 0x40, 0x4C, 0x04, 0x80, 0x58, 0x05, 0x00, 0x70,
  0x06, 0x00, 0x80, 0xC0, 0xF0, 0x70, 0x3C, 0x14, 0x1B, 0x0D, 0x06, 0xC2,
  0x43, 0x31, 0x90, 0xCC, 0x64, 0x23, 0x11, 0x18, 0xCC, 0x44, 0x32, 0x13,
  0x0D, 0x84, 0xC3, 0x41, 0x60, 0xF0, 0x58, 0x38, 0x14, 0x0E, 0x07, 0x03,
  0x01, 0x80, 0x0C, 0x0E, 0x18, 0x30, 0x10, 0xC0, 0x31, 0x00, 0x66, 0x00,
  0x58, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x32, 0x00, 0xC6,
  0x01, 0x0C, 0x06, 0x08, 0x18, 0x18, 0x60, 0x30, 0x06, 0x03, 0x83, 0x01,
  0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0xC0, 0x30, 0x60, 0x08, 0x60, 0x04,
  0x30, 0x02, 0x30, 0x01, 0x18, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0xC0, 0x00, 0x80, 0x00, 0x0F,
  0xF8, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x1F,
  0xF8, 0x01, 0xE0, 0x70, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x20, 0x0C, 0x07, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x07,
  0x80, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0x80, 0x3C, 0x00, 0xC0, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x07, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C,
  0x07, 0x80, 0xE0, 0x00, 0x18, 0x07, 0xF0, 0x60, 0xFF, 0x01, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 22, 7, 1, -22 },
  { 18, 8, 8, 10, 3, -22 },
  { 26, 16, 22, 17, 1, -22 },
  { 70, 14, 26, 15, 1, -24 },
  { 116, 18, 22, 22, 2, -22 },
  { 166, 16, 22, 18, 1, -22 },
  { 210, 4, 8, 6, 3, -22 },
  { 214, 9, 27, 8, 1, -22 },
  { 245, 9, 27, 8, -2, -22 },
  { 276, 12, 13, 14, 3, -24 },
  { 296, 13, 14, 16, 2, -18 },
  { 319, 5, 7, 6, -1, -3 },
  { 324, 7, 1, 9, 1, -9 },
  { 325, 2, 3, 7, 1, -3 },
  { 326, 14, 22, 10, -1, -22 },
  { 365, 14, 22, 15, 1, -22 },
  { 404, 8, 22, 15, 4, -22 },
  { 426, 14, 22, 15, 0, -22 },
  { 465, 15, 22, 15, 0, -22 },
  { 507, 14, 22, 15, 0, -22 },
  { 546, 14, 22, 15, 1, -22 },
  { 585, 13, 22, 15, 2, -22 },
  { 621, 14, 22, 15, 2, -22 },
  { 660, 14, 22, 15, 1, -22 },
  { 699, 13, 22, 15, 1, -22 },
  { 735, 5, 17, 7, 1, -17 },
  { 746, 7, 21, 7, -1, -17 },
  { 765, 13, 14, 16, 2, -18 },
  { 788, 13, 8, 16, 2, -15 },
  { 801, 13, 14, 16, 2, -18 },
  { 824, 10, 22, 11, 2, -22 },
  { 852, 21, 25, 23, 1, -22 },
  { 918, 15, 22, 15, -2, -22 },
  { 960, 15, 22, 16, 1, -22 },
  { 1002, 15, 22, 16, 2, -22 },
  { 1044, 16, 22, 18, 1, -22 },
  { 1088, 14, 22, 14, 1, -22 },
  { 1127, 14, 22, 13, 1, -22 },
  { 1166, 17, 22, 19, 2, -22 },
  { 1213, 18, 22, 19, 1, -22 },
  { 1263, 11, 22, 8, -1, -22 },
  { 1294, 12, 28, 7, -5, -22 },
  { 1336, 17, 22, 15, 1, -22 },
  { 1383, 10, 22, 13, 1, -22 },
  { 1411, 22, 22, 23, 1, -22 },
  { 1472, 18, 22, 19, 1, -22 },
  { 1522, 17, 22, 19, 2, -22 },
  { 1569, 15, 22, 15, 1, -22 },
  { 1611, 17, 27, 19, 2, -22 },
  { 1669, 15, 22, 16, 1, -22 },
  { 1711, 15, 22, 14, 0, -22 },
  { 1753, 13, 22, 13, 3, -22 },
  { 1789, 17, 22, 19, 2, -22 },
  { 1836, 14, 22, 15, 3, -22 },
  { 1875, 23, 22, 24, 3, -22 },
  { 1939, 18, 22, 14, -2, -22 },
  { 1989, 13, 22, 13, 3, -22 },
  { 2025, 17, 22, 14, -1, -22 },
  { 2072, 11, 27, 9, 0, -22 },
  { 2110, 5, 22, 10, 3, -22 },
  { 2124, 11, 27, 9, -2, -22 },
  { 2162, 14, 13, 16, 1, -22 },
  { 2185, 11, 1, 11, -3, 3 },
  { 2187, 4, 5, 8, 5, -24 },
  { 2190, 14, 17, 16, 1, -17 },
  { 2220, 13, 24, 16, 1, -24 },
  { 2259, 12, 17, 12, 1, -17 },
  { 2285, 16, 24, 16, 1, -24 },
  { 2333, 12, 17, 14, 1, -17 },
  { 2359, 16, 31, 8, -4, -24 },
  { 2421, 15, 24, 16, 0, -17 },
  { 2466, 13, 24, 15, 1, -24 },
  { 2505, 6, 23, 7, 1, -23 },
  { 2523, 11, 30, 7, -4, -23 },
  { 2565, 13, 24, 13, 1, -24 },
  { 2604, 6, 24, 6, 1, -24 },
  { 2622, 21, 17, 23, 1, -17 },
  { 2667, 13, 17, 15, 1, -17 },
  { 2695, 13, 17, 15, 1, -17 },
  { 2723, 15, 24, 16, -1, -17 },
  { 2768, 14, 24, 16, 1, -17 },
  { 2810, 11, 17, 10, 1, -17 },
  { 2834, 11, 17, 12, 0, -17 },
  { 2858, 8, 20, 9, 1, -20 },
  { 2878, 14, 16, 16, 1, -16 },
  { 2906, 12, 16, 12, 2, -16 },
  { 2930, 18, 16, 19, 2, -16 },
  { 2966, 15, 16, 13, -1, -16 },
  { 2996, 17, 24, 12, -3, -16 },
  { 3047, 13, 16, 12, -1, -16 },
  { 3073, 11, 27, 10, 1, -22 },
  { 3111, 2, 31, 15, 7, -24 },
  { 3119, 12, 27, 10, -2, -22 },
  { 3160, 13, 4, 16, 2, -13 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC31PT7B_H_
