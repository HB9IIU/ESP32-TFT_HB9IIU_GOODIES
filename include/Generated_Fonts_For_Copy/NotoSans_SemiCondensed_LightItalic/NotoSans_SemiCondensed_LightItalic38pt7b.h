#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC38PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0xE0, 0xE0, 0x31, 0xDC, 0x66, 0x19, 0x86, 0x63, 0x18, 0xC4,
  0x33, 0x0C, 0xC2, 0x30, 0x80, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60,
  0xC0, 0x0C, 0x08, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0x81, 0x00, 0x18,
  0x30, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03,
  0x06, 0x00, 0x60, 0x40, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x04, 0x08, 0x0F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x81, 0x80, 0x18, 0x10, 0x01, 0x83, 0x00,
  0x18, 0x30, 0x01, 0x02, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x20, 0x40,
  0x00, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x0F, 0x00, 0x3F, 0xF8,
  0x39, 0x98, 0x38, 0x80, 0x18, 0x40, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x10,
  0x03, 0x88, 0x00, 0xC4, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x31, 0x80, 0x10, 0xC0, 0x08, 0x60,
  0x0C, 0x30, 0x06, 0x38, 0x83, 0x38, 0x7F, 0xF8, 0x1F, 0xF0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x02, 0x00, 0x08, 0x3E, 0x00,
  0xC1, 0x9C, 0x03, 0x0C, 0x30, 0x18, 0x60, 0xC0, 0xC1, 0x83, 0x03, 0x04,
  0x0C, 0x18, 0x30, 0x30, 0xC0, 0xC0, 0xC3, 0x03, 0x02, 0x18, 0x0C, 0x18,
  0xC0, 0x30, 0x63, 0x08, 0x81, 0x99, 0xFA, 0x0C, 0xCE, 0x7C, 0x33, 0x30,
  0xF1, 0x99, 0x83, 0x7C, 0xC6, 0x0C, 0x43, 0x10, 0x30, 0x18, 0xC0, 0xC0,
  0x43, 0x03, 0x03, 0x0C, 0x08, 0x18, 0x30, 0x60, 0x60, 0x81, 0x83, 0x02,
  0x06, 0x18, 0x08, 0x30, 0x60, 0x30, 0xC3, 0x00, 0xEE, 0x18, 0x01, 0xF0,
  0x00, 0x10, 0x00, 0x1F, 0xC0, 0x07, 0x38, 0x01, 0xC1, 0x80, 0x30, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x38, 0x06, 0x06, 0x00, 0xE1, 0xC0,
  0x0C, 0x70, 0x01, 0x98, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0xE7, 0x00, 0x38, 0x60, 0x6E, 0x0E, 0x0D, 0x80, 0xC3, 0x60, 0x1C, 0xEC,
  0x01, 0x99, 0x80, 0x1E, 0x30, 0x03, 0xC6, 0x00, 0x70, 0xC0, 0x1F, 0x1C,
  0x07, 0x61, 0xEF, 0x8E, 0x1F, 0xE0, 0xE0, 0x37, 0x66, 0x66, 0x4C, 0xCC,
  0x00, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01,
  0x00, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x02, 0x0C, 0x06, 0x18, 0x1F, 0x20, 0x07,
  0x47, 0x03, 0xFE, 0x07, 0x02, 0x1B, 0x00, 0x62, 0x01, 0x86, 0x07, 0x0C,
  0x04, 0x0C, 0x00, 0x10, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x71, 0x86, 0x30, 0xC6, 0x18, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x20, 0x01, 0xFC, 0x03, 0x9E, 0x06, 0x06, 0x0C,
  0x06, 0x1C, 0x03, 0x18, 0x03, 0x38, 0x03, 0x30, 0x03, 0x30, 0x03, 0x60,
  0x03, 0x60, 0x07, 0x60, 0x07, 0xE0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0,
  0x38, 0xC0, 0x30, 0xE0, 0x70, 0x60, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x01,
  0xC1, 0xE0, 0xF8, 0x76, 0x71, 0xB8, 0xC4, 0x30, 0x0C, 0x03, 0x01, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x7F, 0x80, 0x3C, 0xF0, 0x1C, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x7F, 0xC0, 0x7C, 0x78, 0x18, 0x06, 0x04, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x20, 0x0F, 0x0F, 0xDF,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x36,
  0x00, 0x1D, 0x80, 0x06, 0xC0, 0x03, 0x30, 0x01, 0x8C, 0x00, 0xC3, 0x00,
  0x30, 0xC0, 0x18, 0x60, 0x0C, 0x18, 0x06, 0x06, 0x03, 0x81, 0x80, 0xC0,
  0xE0, 0x60, 0x30, 0x30, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC3, 0xFF, 0xFE,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0xFE, 0x01, 0xEF, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x80, 0x70, 0x7F, 0xF0, 0x1F,
  0xF0, 0x00, 0x00, 0x0C, 0x80, 0x3F, 0x80, 0x7C, 0x40, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x3C, 0x06, 0x7F, 0x83, 0x60, 0xE1, 0xC0, 0x31, 0xE0, 0x18,
  0xE0, 0x0E, 0x60, 0x07, 0x30, 0x03, 0x98, 0x01, 0x8C, 0x00, 0xC6, 0x00,
  0x63, 0x00, 0x71, 0x80, 0x30, 0xE0, 0x38, 0x30, 0x38, 0x0F, 0xF8, 0x03,
  0xF8, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0xFF,
  0x00, 0xF3, 0xC0, 0xE0, 0x70, 0x60, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x18,
  0x03, 0x0C, 0x01, 0x86, 0x01, 0x81, 0x81, 0xC0, 0xE1, 0xC0, 0x3B, 0x80,
  0x0F, 0x00, 0x1F, 0xC0, 0x1C, 0x70, 0x38, 0x1C, 0x38, 0x06, 0x18, 0x03,
  0x9C, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x19, 0x80, 0x18, 0xE0,
  0x0C, 0x38, 0x0C, 0x0F, 0x7C, 0x03, 0xFC, 0x00, 0x00, 0x20, 0x00, 0xFE,
  0x00, 0xE3, 0x80, 0xC0, 0xE0, 0xC0, 0x30, 0xE0, 0x18, 0x60, 0x0E, 0x30,
  0x07, 0x30, 0x03, 0x98, 0x01, 0xCC, 0x00, 0xE6, 0x00, 0x63, 0x00, 0x31,
  0x80, 0x38, 0x60, 0x3C, 0x38, 0x76, 0x0F, 0xF6, 0x01, 0xE3, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x70, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x1C, 0x71, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x30, 0x01,
  0x81, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0E, 0x06, 0x03, 0x03, 0x01, 0x81,
  0x80, 0xC0, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x00, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x01, 0x00, 0xFF, 0x0F, 0x3C, 0x40,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x78,
  0x03, 0x00, 0x70, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x60, 0x00, 0x18, 0x70,
  0x00, 0x06, 0x30, 0x04, 0x03, 0x30, 0x1F, 0xE1, 0x98, 0x18, 0x60, 0xD8,
  0x18, 0x30, 0x6C, 0x18, 0x18, 0x34, 0x18, 0x0C, 0x1E, 0x0C, 0x0C, 0x0F,
  0x04, 0x06, 0x07, 0x86, 0x03, 0x06, 0xC3, 0x01, 0x83, 0x61, 0x81, 0x81,
  0xB0, 0xC0, 0xC1, 0x98, 0x60, 0xA0, 0xCC, 0x30, 0xD0, 0xC6, 0x0F, 0xCF,
  0xC3, 0x03, 0xC3, 0x81, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x10, 0x00, 0xF0, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1B, 0x00, 0x06, 0x40, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x61, 0x80, 0x18,
  0x60, 0x0C, 0x18, 0x03, 0x06, 0x01, 0x81, 0x80, 0x60, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xC0, 0x1C, 0x30, 0x03, 0x18,
  0x00, 0xC6, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x60, 0x00, 0xD8, 0x00,
  0x3C, 0x00, 0x0C, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x18, 0x07, 0x03, 0x00,
  0x60, 0x60, 0x0E, 0x0C, 0x00, 0xC3, 0x80, 0x38, 0x60, 0x07, 0x0C, 0x00,
  0xC1, 0x80, 0x38, 0x30, 0x0E, 0x0E, 0x07, 0x81, 0xFF, 0xC0, 0x3F, 0xF8,
  0x06, 0x01, 0xC0, 0xC0, 0x18, 0x30, 0x03, 0x86, 0x00, 0x70, 0xC0, 0x06,
  0x18, 0x01, 0xC7, 0x00, 0x38, 0xC0, 0x06, 0x18, 0x01, 0xC3, 0x00, 0x70,
  0x60, 0x1C, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x06, 0x00, 0x0F,
  0xFC, 0x03, 0xEF, 0x81, 0xE0, 0x10, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x80, 0x7F, 0xF0,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x06, 0x03, 0xC0, 0x60,
  0x0E, 0x06, 0x00, 0x60, 0x60, 0x07, 0x0E, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0xC0, 0x03, 0x18, 0x00, 0x31,
  0x80, 0x03, 0x18, 0x00, 0x71, 0x80, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0E,
  0x30, 0x00, 0xC3, 0x00, 0x1C, 0x70, 0x01, 0x86, 0x00, 0x38, 0x60, 0x07,
  0x06, 0x01, 0xE0, 0x60, 0x7C, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC1, 0xFF, 0xF0, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x80, 0x3E, 0x7E, 0x07, 0x80, 0x20,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x7F, 0x8C, 0x03, 0xFC, 0xE0, 0x00, 0xE7, 0x00, 0x06,
  0x38, 0x00, 0x31, 0xC0, 0x01, 0x8E, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80,
  0x06, 0x0E, 0x00, 0x30, 0x30, 0x01, 0x81, 0xE0, 0x1C, 0x07, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x81,
  0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0xE0, 0x01, 0x83, 0x00,
  0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x07, 0x00, 0x1C,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x30,
  0x00, 0xE0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00,
  0xC1, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83,
  0x80, 0x0E, 0x0C, 0x00, 0x30, 0x00, 0x03, 0xF8, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0xF0,
  0x3F, 0xC0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0xFE, 0x01, 0xF0, 0x00, 0x03, 0x00, 0x78, 0x38, 0x03, 0x01,
  0x80, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x03, 0x03, 0x00, 0x38, 0x38,
  0x01, 0x83, 0x80, 0x0C, 0x38, 0x00, 0x63, 0x80, 0x03, 0x38, 0x00, 0x3B,
  0x80, 0x01, 0xBC, 0x00, 0x0F, 0xE0, 0x00, 0x73, 0x80, 0x03, 0x0C, 0x00,
  0x30, 0x60, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x70, 0x07, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x07,
  0x00, 0x70, 0x30, 0x01, 0x80, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3E,
  0x07, 0x80, 0x03, 0x60, 0x68, 0x00, 0x6C, 0x0C, 0xC0, 0x06, 0xC0, 0xCC,
  0x00, 0xCC, 0x0C, 0xC0, 0x0C, 0xC0, 0xCC, 0x01, 0x9C, 0x0C, 0xC0, 0x19,
  0x81, 0x8C, 0x03, 0x18, 0x18, 0xC0, 0x31, 0x81, 0x8C, 0x06, 0x18, 0x18,
  0x40, 0x63, 0x81, 0x86, 0x0C, 0x30, 0x30, 0x61, 0xC3, 0x03, 0x06, 0x18,
  0x30, 0x30, 0x63, 0x83, 0x03, 0x06, 0x30, 0x70, 0x70, 0x66, 0x06, 0x06,
  0x06, 0x60, 0x60, 0x60, 0x6C, 0x06, 0x06, 0x02, 0xC0, 0x60, 0x60, 0x38,
  0x0C, 0x0C, 0x03, 0x80, 0xC0, 0xC0, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x0E,
  0x0F, 0x00, 0x18, 0x1E, 0x00, 0x30, 0x3C, 0x00, 0x60, 0x7C, 0x00, 0xC0,
  0xD8, 0x03, 0x03, 0x30, 0x06, 0x06, 0x70, 0x0C, 0x0C, 0x60, 0x18, 0x18,
  0xC0, 0x30, 0x31, 0xC0, 0xC0, 0xC1, 0x81, 0x81, 0x83, 0x03, 0x03, 0x06,
  0x06, 0x06, 0x06, 0x1C, 0x0C, 0x0C, 0x30, 0x30, 0x18, 0x60, 0x60, 0x18,
  0xC0, 0xC0, 0x31, 0x81, 0x80, 0x66, 0x07, 0x00, 0x6C, 0x0C, 0x00, 0xD8,
  0x18, 0x01, 0xB0, 0x30, 0x01, 0xE0, 0x60, 0x03, 0x81, 0x80, 0x07, 0x03,
  0x00, 0x0E, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFC, 0x00, 0x7D, 0xF0, 0x07,
  0x01, 0xC0, 0x70, 0x07, 0x07, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x07,
  0x38, 0x00, 0x39, 0x80, 0x00, 0xCC, 0x00, 0x0E, 0xE0, 0x00, 0x76, 0x00,
  0x03, 0xB0, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0xE0, 0x00, 0x37,
  0x00, 0x03, 0xB8, 0x00, 0x19, 0xC0, 0x00, 0xCE, 0x00, 0x0E, 0x30, 0x00,
  0x61, 0x80, 0x07, 0x0E, 0x00, 0x70, 0x30, 0x07, 0x01, 0xC0, 0x70, 0x07,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x60, 0x38,
  0x18, 0x07, 0x06, 0x00, 0xC1, 0x80, 0x30, 0xE0, 0x0C, 0x30, 0x03, 0x0C,
  0x00, 0xC3, 0x00, 0x70, 0xC0, 0x18, 0x70, 0x0E, 0x18, 0x07, 0x06, 0x07,
  0x81, 0xFF, 0xC0, 0x7F, 0x80, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFC, 0x00,
  0x7D, 0xF0, 0x07, 0x01, 0xC0, 0x70, 0x07, 0x07, 0x00, 0x18, 0x70, 0x00,
  0xC3, 0x00, 0x07, 0x38, 0x00, 0x39, 0x80, 0x00, 0xCC, 0x00, 0x0E, 0xE0,
  0x00, 0x76, 0x00, 0x03, 0xB0, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x06,
  0xE0, 0x00, 0x37, 0x00, 0x03, 0xB8, 0x00, 0x19, 0xC0, 0x00, 0xCE, 0x00,
  0x0E, 0x30, 0x00, 0x61, 0x80, 0x07, 0x0E, 0x00, 0x70, 0x30, 0x07, 0x01,
  0xC0, 0x70, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x60, 0x38, 0x18, 0x07, 0x06, 0x00, 0xC1,
  0x80, 0x30, 0xE0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x70, 0xC0,
  0x18, 0x70, 0x0E, 0x18, 0x07, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x61, 0xC0,
  0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x80, 0xC0, 0x60, 0x70, 0x18, 0x18,
  0x06, 0x06, 0x01, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x38, 0x03, 0x8C, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x3F, 0xE0, 0x3E, 0xFC, 0x1C, 0x02, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x20, 0x0E, 0x0F,
  0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x0E, 0x18, 0x00,
  0x60, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x0E, 0x18,
  0x00, 0x60, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x0C,
  0x18, 0x00, 0x61, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0xC3, 0x00,
  0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x0E, 0x00, 0x38, 0x70, 0x01, 0x81,
  0x80, 0x1C, 0x0C, 0x00, 0xC0, 0x70, 0x1C, 0x01, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xD8, 0x00, 0xEC, 0x00, 0x66,
  0x00, 0x73, 0x00, 0x31, 0x80, 0x38, 0xC0, 0x18, 0x60, 0x1C, 0x30, 0x0C,
  0x18, 0x0E, 0x06, 0x06, 0x03, 0x07, 0x01, 0x83, 0x00, 0xC3, 0x80, 0x61,
  0x80, 0x31, 0xC0, 0x18, 0xC0, 0x0C, 0xE0, 0x06, 0x60, 0x03, 0x30, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x7C, 0x00, 0xE0, 0x06, 0xC0, 0x0E, 0x00, 0xEC, 0x01, 0xE0,
  0x0C, 0xC0, 0x1E, 0x00, 0xCC, 0x03, 0x60, 0x18, 0xC0, 0x36, 0x01, 0x8C,
  0x06, 0x60, 0x38, 0xC0, 0x66, 0x03, 0x0C, 0x06, 0x60, 0x70, 0xC0, 0xC6,
  0x06, 0x0C, 0x0C, 0x60, 0x60, 0xC1, 0x86, 0x0C, 0x0C, 0x18, 0x60, 0xC0,
  0xC3, 0x06, 0x18, 0x0C, 0x30, 0x61, 0x80, 0xC7, 0x02, 0x38, 0x0C, 0x60,
  0x23, 0x00, 0xC6, 0x02, 0x30, 0x0C, 0xC0, 0x26, 0x00, 0xCC, 0x02, 0x60,
  0x0D, 0x80, 0x2C, 0x00, 0xD8, 0x02, 0xC0, 0x0D, 0x00, 0x2C, 0x00, 0x70,
  0x03, 0x80, 0x07, 0x00, 0x38, 0x00, 0x60, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x1C, 0x06, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x00, 0xC0, 0xE0,
  0x03, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x67, 0x00, 0x01,
  0x98, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x36, 0x00, 0x01, 0xD8, 0x00, 0x06, 0x30, 0x00,
  0x30, 0xC0, 0x01, 0xC3, 0x00, 0x0E, 0x06, 0x00, 0x30, 0x18, 0x01, 0x80,
  0x60, 0x0E, 0x01, 0x80, 0x30, 0x03, 0x01, 0x80, 0x0C, 0x0E, 0x00, 0x30,
  0x00, 0xE0, 0x03, 0xB0, 0x03, 0x98, 0x01, 0x8C, 0x01, 0xC7, 0x00, 0xC1,
  0x80, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x30, 0x60, 0x1C, 0x70, 0x06, 0x30,
  0x03, 0x30, 0x01, 0x98, 0x00, 0xD8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0xC3, 0x0C, 0x30,
  0x61, 0x86, 0x18, 0x61, 0x82, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x61, 0x86,
  0x18, 0x61, 0x82, 0x0C, 0x30, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x36, 0x00, 0x19, 0x80, 0x18, 0xC0, 0x0C, 0x20, 0x0C,
  0x18, 0x0C, 0x0C, 0x06, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC3, 0x00, 0x33,
  0x80, 0x19, 0x80, 0x07, 0x80, 0x03, 0xFF, 0xF8, 0xCC, 0x66, 0x31, 0x00,
  0xC0, 0x07, 0xF3, 0x0F, 0x3B, 0x1C, 0x0B, 0x38, 0x0F, 0x30, 0x0E, 0x70,
  0x06, 0x60, 0x06, 0x60, 0x0E, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x38, 0xC0, 0x58, 0xE0,
  0xD8, 0x7F, 0x90, 0x3E, 0x30, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x18,
  0x06, 0x7F, 0x03, 0x73, 0xC3, 0x60, 0x61, 0xE0, 0x30, 0xE0, 0x1C, 0x70,
  0x06, 0x30, 0x03, 0x38, 0x03, 0x98, 0x01, 0xCC, 0x00, 0xC6, 0x00, 0x63,
  0x00, 0x33, 0x80, 0x39, 0x80, 0x18, 0xC0, 0x0C, 0x70, 0x0C, 0x78, 0x0E,
  0x36, 0x0E, 0x1B, 0xDE, 0x0C, 0xFE, 0x00, 0x00, 0x40, 0x1F, 0xF0, 0xF1,
  0x87, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x02, 0x1F, 0x70, 0x3F, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0xC3, 0x81, 0xFC, 0xC0, 0xF3, 0xB0, 0x70, 0x2C, 0x38,
  0x07, 0x0C, 0x01, 0xC7, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x30, 0x01,
  0x8C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x07, 0x0C, 0x01, 0xC3,
  0x00, 0xE0, 0xC0, 0x38, 0x30, 0x1E, 0x0E, 0x0D, 0x81, 0xEE, 0x60, 0x3F,
  0x30, 0x00, 0x00, 0x40, 0x1F, 0xE0, 0xF3, 0x87, 0x07, 0x38, 0x0C, 0xC0,
  0x37, 0x01, 0xD8, 0x06, 0x60, 0x33, 0x07, 0x8F, 0xFC, 0x3E, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x02, 0x1F,
  0x78, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x30, 0x20, 0x3F, 0x88, 0x0F, 0x3B, 0x03, 0x81, 0x60,
  0xE0, 0x1C, 0x18, 0x03, 0x87, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x86,
  0x00, 0x30, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x0E, 0x0C,
  0x01, 0xC1, 0x80, 0x70, 0x30, 0x0E, 0x06, 0x03, 0xC0, 0xE0, 0xD8, 0x0F,
  0x77, 0x00, 0xFC, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x38, 0x0F, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x10, 0x0C, 0xFE, 0x0D, 0xCF,
  0x1B, 0x03, 0x1E, 0x03, 0x1C, 0x03, 0x1C, 0x03, 0x18, 0x03, 0x38, 0x03,
  0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x60, 0x0E, 0x60, 0x0C,
  0x60, 0x0C, 0x60, 0x0C, 0xE0, 0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x18,
  0x02, 0x07, 0x07, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x1C, 0x18,
  0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60,
  0xE0, 0xC0, 0xC0, 0xC0, 0x00, 0x08, 0x00, 0x70, 0x01, 0xC0, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xC0, 0x3F, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x07, 0x0C, 0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x18,
  0x70, 0x18, 0xE0, 0x19, 0xC0, 0x31, 0x80, 0x33, 0x00, 0x37, 0x80, 0x3D,
  0x80, 0x39, 0x80, 0x70, 0xC0, 0x60, 0xC0, 0x60, 0xE0, 0x60, 0x60, 0xE0,
  0x60, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x38, 0x03, 0x03, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x38,
  0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0,
  0x00, 0x30, 0x04, 0x03, 0x3F, 0x0F, 0xE0, 0x98, 0xE7, 0x38, 0x6C, 0x1B,
  0x07, 0x1E, 0x07, 0x80, 0xC7, 0x01, 0xC0, 0x31, 0x80, 0x70, 0x0C, 0x60,
  0x18, 0x03, 0x38, 0x06, 0x01, 0x8C, 0x01, 0x80, 0x63, 0x00, 0xE0, 0x18,
  0xC0, 0x30, 0x06, 0x30, 0x0C, 0x03, 0x98, 0x03, 0x00, 0xC6, 0x00, 0xC0,
  0x31, 0x80, 0x60, 0x0C, 0x60, 0x18, 0x03, 0x38, 0x06, 0x01, 0xCC, 0x01,
  0x80, 0x63, 0x00, 0x60, 0x18, 0xC0, 0x30, 0x06, 0x00, 0x00, 0x38, 0x0C,
  0xFE, 0x0D, 0xCF, 0x1B, 0x03, 0x1E, 0x03, 0x1C, 0x03, 0x1C, 0x03, 0x18,
  0x03, 0x38, 0x03, 0x30, 0x07, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x60,
  0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0xE0, 0x0C, 0xC0, 0x1C, 0xC0,
  0x18, 0xC0, 0x18, 0x00, 0x40, 0x0F, 0xF0, 0x3C, 0x70, 0xE0, 0x63, 0x80,
  0x66, 0x00, 0xDC, 0x01, 0xB0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xB0, 0x03, 0x60, 0x0E, 0xC0, 0x19, 0x80,
  0x71, 0x81, 0xC3, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x67, 0xF0,
  0x0D, 0xCF, 0x03, 0x60, 0x60, 0x78, 0x0C, 0x0E, 0x01, 0xC1, 0xC0, 0x18,
  0x30, 0x03, 0x0E, 0x00, 0xE1, 0x80, 0x1C, 0x30, 0x03, 0x06, 0x00, 0x60,
  0xC0, 0x0C, 0x38, 0x03, 0x86, 0x00, 0x60, 0xC0, 0x0C, 0x1C, 0x03, 0x07,
  0x80, 0xE0, 0xD8, 0x38, 0x1B, 0xDE, 0x03, 0x3F, 0x80, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x83, 0xF8, 0x83,
  0xCE, 0xC3, 0x81, 0x63, 0x80, 0xF1, 0x80, 0x39, 0xC0, 0x18, 0xC0, 0x0C,
  0x60, 0x06, 0x60, 0x03, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00,
  0xE3, 0x00, 0x71, 0x80, 0x70, 0xC0, 0x38, 0x60, 0x3C, 0x38, 0x36, 0x0F,
  0x77, 0x03, 0xF3, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x67, 0xC2, 0x7A, 0x36, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x1F, 0xF0, 0xE1, 0xC6, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0x88, 0x0E, 0x3F, 0xF0, 0x7F, 0x80, 0x0C,
  0x03, 0x00, 0xC0, 0x60, 0x18, 0x3F, 0xFF, 0xF8, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0xB0, 0x7C, 0x00, 0x18, 0x03, 0x38, 0x03, 0x30,
  0x07, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x70, 0x06, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x0C, 0x60, 0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x18, 0xC0,
  0x38, 0xC0, 0x38, 0xC0, 0x58, 0xC0, 0xF0, 0xF7, 0xB0, 0x7E, 0x30, 0xC0,
  0x0F, 0x80, 0x1B, 0x00, 0x66, 0x01, 0xCC, 0x03, 0x1C, 0x0E, 0x18, 0x18,
  0x30, 0x70, 0x60, 0xC0, 0xC3, 0x81, 0x86, 0x03, 0x1C, 0x06, 0x30, 0x0C,
  0xE0, 0x19, 0x80, 0x37, 0x00, 0x6C, 0x00, 0x58, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x1B, 0x01, 0xE0, 0x36, 0x03, 0xC0,
  0xCC, 0x0D, 0x81, 0x98, 0x1B, 0x06, 0x30, 0x66, 0x0C, 0x60, 0xCC, 0x38,
  0xC3, 0x18, 0x61, 0x86, 0x30, 0xC1, 0x08, 0x63, 0x02, 0x30, 0xC6, 0x06,
  0x61, 0x98, 0x0D, 0x83, 0x30, 0x1B, 0x06, 0xC0, 0x3C, 0x05, 0x80, 0x78,
  0x0B, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x00, 0x0E,
  0x01, 0xC1, 0x80, 0xC0, 0x60, 0x70, 0x1C, 0x38, 0x03, 0x0C, 0x00, 0xC6,
  0x00, 0x3B, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x0D, 0x80, 0x07, 0x60, 0x01, 0x98, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0x38,
  0x30, 0x1C, 0x06, 0x06, 0x01, 0x83, 0x00, 0x70, 0x03, 0x00, 0x38, 0x18,
  0x01, 0x80, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0x60,
  0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x61,
  0x80, 0x03, 0x0C, 0x00, 0x08, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x60, 0x00,
  0x1B, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x3E, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F,
  0x80, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x0F, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x1C, 0x03, 0xE0, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x01, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x7F, 0x01, 0xE7, 0xE3, 0x80, 0xFF,
  0x00, 0x1C,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 27, 9, 1, -27 },
  { 28, 10, 10, 13, 4, -27 },
  { 41, 20, 27, 21, 1, -27 },
  { 109, 17, 31, 18, 1, -29 },
  { 175, 22, 28, 27, 3, -28 },
  { 252, 19, 28, 22, 1, -28 },
  { 319, 4, 10, 7, 4, -27 },
  { 324, 11, 33, 10, 1, -27 },
  { 370, 12, 33, 10, -3, -27 },
  { 420, 15, 15, 18, 4, -29 },
  { 449, 16, 18, 20, 2, -22 },
  { 485, 6, 9, 8, -2, -4 },
  { 492, 9, 2, 11, 1, -11 },
  { 495, 3, 3, 8, 1, -3 },
  { 497, 17, 27, 12, -2, -27 },
  { 555, 16, 28, 18, 2, -28 },
  { 611, 10, 27, 18, 5, -27 },
  { 645, 18, 28, 18, 0, -28 },
  { 708, 18, 28, 18, 0, -28 },
  { 771, 18, 27, 18, 0, -27 },
  { 832, 17, 27, 18, 1, -27 },
  { 890, 17, 28, 18, 2, -28 },
  { 950, 16, 27, 18, 3, -27 },
  { 1004, 17, 28, 18, 1, -28 },
  { 1064, 17, 28, 18, 1, -28 },
  { 1124, 6, 20, 8, 1, -20 },
  { 1139, 9, 25, 8, -2, -20 },
  { 1168, 16, 17, 20, 2, -22 },
  { 1202, 16, 9, 20, 2, -18 },
  { 1220, 16, 17, 20, 2, -22 },
  { 1254, 13, 28, 14, 2, -28 },
  { 1300, 25, 30, 28, 2, -27 },
  { 1394, 18, 27, 18, -2, -27 },
  { 1455, 19, 27, 20, 1, -27 },
  { 1520, 19, 28, 19, 2, -28 },
  { 1587, 20, 27, 22, 1, -27 },
  { 1655, 18, 27, 18, 1, -27 },
  { 1716, 18, 27, 16, 1, -27 },
  { 1777, 21, 28, 23, 2, -28 },
  { 1851, 22, 27, 23, 1, -27 },
  { 1926, 13, 27, 10, -1, -27 },
  { 1970, 15, 34, 9, -6, -27 },
  { 2034, 21, 27, 19, 1, -27 },
  { 2105, 12, 27, 16, 1, -27 },
  { 2146, 28, 27, 28, 1, -27 },
  { 2241, 23, 27, 23, 1, -27 },
  { 2319, 21, 28, 24, 2, -28 },
  { 2393, 18, 27, 19, 1, -27 },
  { 2454, 21, 34, 24, 2, -28 },
  { 2544, 18, 27, 19, 1, -27 },
  { 2605, 18, 28, 17, 0, -28 },
  { 2668, 17, 27, 16, 3, -27 },
  { 2726, 21, 27, 23, 2, -27 },
  { 2797, 17, 27, 18, 4, -27 },
  { 2855, 28, 27, 29, 4, -27 },
  { 2950, 22, 27, 17, -2, -27 },
  { 3025, 17, 27, 16, 3, -27 },
  { 3083, 20, 27, 17, -1, -27 },
  { 3151, 15, 33, 11, -1, -27 },
  { 3213, 6, 27, 13, 4, -27 },
  { 3234, 15, 33, 11, -3, -27 },
  { 3296, 17, 16, 19, 1, -27 },
  { 3330, 13, 1, 13, -3, 4 },
  { 3332, 4, 6, 9, 6, -29 },
  { 3335, 16, 21, 19, 2, -21 },
  { 3377, 17, 29, 19, 1, -29 },
  { 3439, 14, 21, 15, 2, -21 },
  { 3476, 18, 29, 19, 2, -29 },
  { 3542, 14, 21, 17, 2, -21 },
  { 3579, 20, 38, 10, -5, -29 },
  { 3674, 19, 30, 19, 0, -21 },
  { 3746, 16, 29, 19, 1, -29 },
  { 3804, 8, 28, 8, 1, -28 },
  { 3832, 14, 37, 8, -5, -28 },
  { 3897, 16, 29, 16, 1, -29 },
  { 3955, 8, 29, 8, 1, -29 },
  { 3984, 26, 21, 29, 1, -21 },
  { 4053, 16, 21, 19, 1, -21 },
  { 4095, 15, 21, 19, 2, -21 },
  { 4135, 19, 30, 19, -1, -21 },
  { 4207, 17, 30, 19, 2, -21 },
  { 4271, 13, 21, 13, 1, -21 },
  { 4306, 14, 21, 14, 0, -21 },
  { 4343, 10, 25, 11, 2, -25 },
  { 4375, 16, 20, 19, 2, -20 },
  { 4415, 15, 20, 15, 2, -20 },
  { 4453, 23, 20, 24, 2, -20 },
  { 4511, 18, 20, 16, -1, -20 },
  { 4556, 21, 29, 15, -4, -20 },
  { 4633, 16, 20, 14, -1, -20 },
  { 4673, 14, 33, 13, 1, -27 },
  { 4731, 1, 38, 18, 9, -29 },
  { 4736, 14, 33, 13, -2, -27 },
  { 4794, 16, 4, 20, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC38PT7B_H_
