#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC67PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3C, 0x00, 0x20, 0x00, 0x1E, 0x07, 0x8F,
  0x03, 0xC7, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xE0, 0x38,
  0x70, 0x1C, 0x38, 0x1E, 0x3C, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x01,
  0xC3, 0x80, 0xC1, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x00, 0x00, 0x00,
  0x78, 0x03, 0x80, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x70, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xF3, 0x87, 0xC0, 0x3E,
  0x1C, 0x04, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0, 0x30,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x3C, 0x06, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x07, 0x03, 0x80, 0x00, 0x3C,
  0x1C, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x07, 0xC6, 0x00, 0x00, 0x1F, 0x70,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xBF, 0x00, 0x00,
  0x1C, 0xF8, 0x00, 0x00, 0xC3, 0xE0, 0x00, 0x06, 0x0F, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xC0, 0x78,
  0x00, 0x06, 0x03, 0xC0, 0x00, 0x70, 0x1E, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0xC0, 0x78, 0x20, 0x0E, 0x0F, 0x81, 0xC0, 0x70,
  0xF8, 0x0F, 0xF3, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xC0, 0x3F, 0x7C, 0x00,
  0x07, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x07,
  0x80, 0xF0, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x03, 0xC0, 0x3C, 0x01, 0xC0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0x70, 0x00,
  0xE0, 0x03, 0x81, 0xE0, 0x01, 0xC0, 0x0F, 0x03, 0x80, 0x03, 0x80, 0x1C,
  0x0E, 0x00, 0x07, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x00, 0x70, 0x70, 0x7F,
  0x1C, 0x01, 0xC1, 0xC1, 0xFF, 0x38, 0x03, 0x87, 0x87, 0xFF, 0x70, 0x0F,
  0x0E, 0x1E, 0x0E, 0xE0, 0x1C, 0x38, 0x78, 0x1F, 0xC0, 0x78, 0xF1, 0xE0,
  0x1F, 0xC1, 0xE1, 0xC3, 0x80, 0x3B, 0xEF, 0x87, 0x07, 0x00, 0x77, 0xFE,
  0x1E, 0x1C, 0x00, 0xE7, 0xF8, 0x38, 0x38, 0x01, 0xC1, 0x80, 0xF0, 0xF0,
  0x03, 0x80, 0x03, 0xC1, 0xC0, 0x07, 0x00, 0x07, 0x03, 0x80, 0x1E, 0x00,
  0x1E, 0x07, 0x00, 0x38, 0x00, 0x78, 0x1E, 0x00, 0x70, 0x00, 0xE0, 0x3C,
  0x00, 0xE0, 0x03, 0xC0, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x1C, 0x01, 0xC0,
  0x1C, 0x00, 0x38, 0x07, 0x00, 0x70, 0x00, 0x70, 0x1E, 0x01, 0xE0, 0x00,
  0xF0, 0x78, 0x03, 0x80, 0x00, 0xF1, 0xE0, 0x0E, 0x00, 0x01, 0xFF, 0x80,
  0x3C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x1F,
  0x00, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xBC, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0xF0, 0x7C, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0xF0, 0x07, 0x87, 0x80, 0x1E,
  0x00, 0xF0, 0xF0, 0x01, 0xE0, 0x3C, 0x3C, 0x00, 0x3E, 0x07, 0x87, 0x00,
  0x03, 0xC1, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x3C, 0x00, 0x07, 0x8F, 0x07,
  0x00, 0x00, 0x7B, 0xC0, 0xE0, 0x00, 0x0F, 0xF8, 0x3C, 0x00, 0x00, 0xFE,
  0x07, 0x80, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00,
  0x7E, 0x01, 0xE0, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x07, 0xBC, 0x07, 0xC0,
  0x03, 0xE7, 0x80, 0x7E, 0x01, 0xF8, 0x78, 0x07, 0xFF, 0xFE, 0x0F, 0x00,
  0x7F, 0xFF, 0x00, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0x00, 0x0E, 0x80, 0x00,
  0x00, 0x1E, 0x3C, 0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0xF1, 0xC3, 0x87,
  0x0E, 0x18, 0x70, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x01, 0x00, 0x38, 0x01, 0xE0, 0x38,
  0x00, 0xF8, 0x1C, 0x00, 0x7F, 0x0E, 0x00, 0x07, 0xE7, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x01,
  0xD8, 0x00, 0x03, 0xCE, 0x00, 0x03, 0xC7, 0x00, 0x03, 0xC1, 0xC0, 0x03,
  0xC0, 0xE0, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x20, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x39, 0xF7, 0xFF, 0xFD, 0xE2, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x01, 0xE0,
  0x1F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x70, 0x78, 0x00, 0x07, 0x07, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x07, 0x1E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x1E, 0x70, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x07, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x1F, 0x78, 0x1F, 0x3C, 0x3F, 0x1C, 0x3E,
  0x1E, 0x7E, 0x0F, 0x1C, 0x07, 0x84, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x18, 0x00, 0x1E, 0x00, 0x10, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0xC0,
  0x0F, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x0F, 0x80, 0x10, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x0C, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xF0, 0x0F, 0x00,
  0x01, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xC0,
  0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x02, 0x00, 0x00, 0x7C, 0x06, 0x00,
  0x03, 0xF0, 0x0F, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xE0, 0x08, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x1E, 0x1F, 0xFC, 0x00, 0x71, 0xFF, 0xF8, 0x03, 0xCF, 0xEF, 0xF0,
  0x0F, 0x78, 0x07, 0xE0, 0x3B, 0x80, 0x07, 0x80, 0xFC, 0x00, 0x1E, 0x07,
  0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x7C, 0x07,
  0x80, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x07, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0x80, 0x78, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x1E,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xE0, 0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x70, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7E, 0x0F,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x7F, 0x81, 0xF0, 0x07, 0xB8, 0x07, 0xE1,
  0xF9, 0xC0, 0x1F, 0xFF, 0x9E, 0x00, 0x7F, 0xF0, 0xF0, 0x00, 0xFE, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x40, 0x0F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0xC0, 0xFC, 0x0F,
  0xC0, 0xF8, 0x0F, 0x80, 0x20, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0x01, 0xF8, 0x20, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x38, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x10, 0x00, 0x38, 0x1C, 0x00, 0x1F, 0xFC, 0x01,
  0xC1, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0x0E, 0x00, 0x3F, 0x0F, 0x80, 0x78,
  0xF0, 0x03, 0xE0, 0x1C, 0x03, 0xC7, 0x00, 0x3C, 0x01, 0xE0, 0x1E, 0x38,
  0x03, 0xC0, 0x0E, 0x00, 0xF3, 0xC0, 0x1C, 0x00, 0x70, 0x07, 0x9C, 0x01,
  0xE0, 0x03, 0x80, 0x38, 0xE0, 0x0E, 0x00, 0x3C, 0x01, 0xCF, 0x00, 0xE0,
  0x01, 0xC0, 0x0E, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x73, 0x80, 0x78, 0x00,
  0xF0, 0x03, 0x9C, 0x03, 0x80, 0x07, 0x00, 0x3D, 0xE0, 0x1C, 0x00, 0x38,
  0x01, 0xCF, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x70, 0x0F, 0x00, 0x1E, 0x00,
  0xF3, 0x80, 0x78, 0x00, 0xF0, 0x07, 0x1C, 0x03, 0x80, 0x0F, 0x00, 0x38,
  0xE0, 0x1C, 0x00, 0x78, 0x03, 0xC7, 0x00, 0xE0, 0x07, 0xC0, 0x1C, 0x38,
  0x07, 0x80, 0x3E, 0x01, 0xC1, 0xC0, 0x3C, 0x03, 0xF0, 0x1E, 0x0E, 0x00,
  0xE0, 0x39, 0xC1, 0xE0, 0x70, 0x07, 0xC7, 0x8F, 0x1E, 0x03, 0xC0, 0x1F,
  0xF8, 0x7F, 0xE0, 0x1E, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xF0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0xF0, 0x3E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x07, 0xE0, 0x03, 0xC0, 0x00, 0xF8, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x3F,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x03, 0xF0, 0x01, 0xC0, 0x00,
  0x7C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xF0, 0x07,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xF0,
  0x0F, 0x80, 0x07, 0xE0, 0x00, 0x40, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x0F, 0xE0, 0x00,
  0xF0, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x0E, 0x00,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x0F,
  0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x03, 0xE0,
  0x0F, 0x00, 0x01, 0xF8, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x3F,
  0x80, 0x07, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x3F,
  0x00, 0x00, 0x20, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0xF8, 0x70, 0x00, 0x1F, 0xFF, 0x8F, 0x00, 0x01, 0xFF,
  0xF8, 0xF0, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x78, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x3E, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0xC3, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x38,
  0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x78, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x03, 0xE0, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x1E, 0x07, 0xC0,
  0x00, 0x01, 0xC0, 0xF8, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x00,
  0x38, 0xF8, 0x00, 0x00, 0x07, 0x9F, 0x80, 0x00, 0x00, 0x7B, 0xFC, 0x00,
  0x00, 0x07, 0xFB, 0xC0, 0x00, 0x00, 0x7F, 0x3C, 0x00, 0x00, 0x0F, 0xE1,
  0xE0, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x00, 0x78, 0x00, 0x70, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xB8, 0x00, 0x00,
  0x07, 0xF0, 0x01, 0xDC, 0x00, 0x00, 0x07, 0xB8, 0x01, 0xEE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0xF7, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x7B, 0x80, 0x00,
  0x01, 0xCF, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x1C, 0xF0, 0x00,
  0x00, 0xE7, 0x80, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00,
  0x00, 0x71, 0xE0, 0x07, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x03, 0x87, 0x00,
  0x00, 0x78, 0x70, 0x01, 0xC3, 0x80, 0x00, 0x3C, 0x78, 0x01, 0xE1, 0xC0,
  0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x78,
  0x00, 0x1E, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x1C, 0x1E,
  0x00, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x0F, 0x03,
  0x80, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xC0, 0x03, 0x80, 0xE0, 0x03, 0x80,
  0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x70, 0x01, 0xC0, 0x78, 0x01, 0xE0,
  0x38, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x1E, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x38, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x70, 0x3C, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x8E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xCF, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xE7, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF7, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x3B, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x1F, 0xC0, 0x03, 0xC0,
  0x0F, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x07, 0xE0, 0x01, 0xE0,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x7E,
  0x00, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x00,
  0x1E, 0x00, 0x7F, 0x00, 0x00, 0x1C, 0x00, 0xF7, 0x00, 0x00, 0x3C, 0x00,
  0xF7, 0x80, 0x00, 0x3C, 0x00, 0xF7, 0x80, 0x00, 0x3C, 0x00, 0xE3, 0x80,
  0x00, 0x3C, 0x00, 0xE3, 0xC0, 0x00, 0x38, 0x01, 0xE3, 0xC0, 0x00, 0x78,
  0x01, 0xE1, 0xC0, 0x00, 0x78, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x01, 0xC1,
  0xE0, 0x00, 0x70, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x03,
  0x80, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x0E, 0x00, 0x0E, 0x03,
  0xC0, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x1E,
  0x00, 0x07, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x1C, 0x00, 0x07,
  0x87, 0x00, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x3C, 0x00, 0x03, 0xCF, 0x00,
  0x3C, 0x00, 0x03, 0xCF, 0x00, 0x3C, 0x00, 0x01, 0xCF, 0x00, 0x38, 0x00,
  0x01, 0xEE, 0x00, 0x38, 0x00, 0x01, 0xEE, 0x00, 0x78, 0x00, 0x00, 0xEE,
  0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x70,
  0x00, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0xFC,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x78, 0x03, 0x80, 0x00, 0xF8, 0x07, 0x80, 0x01, 0xF0,
  0x07, 0x80, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0xF1,
  0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0xF8, 0x03, 0x80,
  0x01, 0xF0, 0x07, 0x80, 0x03, 0xF0, 0x07, 0x80, 0x1F, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0x80, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x0C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x0E, 0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3E, 0x70,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x78,
  0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0x8F, 0x00, 0x0F,
  0x03, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xC1, 0xC0, 0x03,
  0x80, 0xF0, 0x00, 0xE0, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x70, 0x01,
  0xE0, 0x3C, 0x00, 0x70, 0x38, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x1C, 0x00,
  0xF0, 0x0F, 0x00, 0x38, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x07, 0x00,
  0x78, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x00, 0x38, 0x0F, 0x00, 0x70,
  0x1E, 0x00, 0x1C, 0x07, 0x80, 0x38, 0x0F, 0x00, 0x0E, 0x03, 0x80, 0x1C,
  0x0F, 0x00, 0x07, 0x03, 0xC0, 0x0E, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x07,
  0x03, 0x80, 0x01, 0xC1, 0xE0, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0xE0, 0x01,
  0xC1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0x78, 0x00,
  0x70, 0xF0, 0x00, 0x1C, 0x78, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x3C, 0x00,
  0x1C, 0x78, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x9E, 0x00,
  0x07, 0x3C, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xEF, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x77, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x77, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1E,
  0x07, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x0F,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x7C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x70, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80,
  0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x1E, 0x1C,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x78, 0x0F, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x38,
  0x00, 0x1C, 0x01, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x0F,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x78,
  0x78, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0x07, 0x00, 0x0F, 0xF0, 0x38, 0x01,
  0xFF, 0xC1, 0xC0, 0x1F, 0xFF, 0x0E, 0x03, 0xF8, 0x3C, 0xF0, 0x1F, 0x00,
  0x77, 0x01, 0xF0, 0x03, 0xB8, 0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7E,
  0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C,
  0x0F, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x77, 0x03, 0xE0, 0x03, 0xB8, 0x0F,
  0x00, 0x7B, 0xC0, 0x7C, 0x07, 0x9C, 0x01, 0xFF, 0xF8, 0xE0, 0x07, 0xFF,
  0x87, 0x00, 0x1F, 0xF0, 0x38, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0xE0, 0x00, 0xE0,
  0xFF, 0xE0, 0x07, 0x8F, 0xFF, 0xC0, 0x1E, 0x7C, 0x1F, 0x00, 0x7B, 0xC0,
  0x3E, 0x01, 0xDE, 0x00, 0x78, 0x07, 0x70, 0x00, 0xF0, 0x3F, 0x80, 0x03,
  0xC0, 0xFC, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF0,
  0x3C, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0x81, 0xFC,
  0x00, 0x3E, 0x07, 0xB8, 0x01, 0xF0, 0x1C, 0xF0, 0x1F, 0x80, 0x71, 0xFF,
  0xFC, 0x01, 0xC3, 0xFF, 0xE0, 0x0E, 0x07, 0xFE, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFC,
  0x07, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x78, 0x00, 0x3F,
  0xFC, 0x38, 0x00, 0x3F, 0xFF, 0x1C, 0x00, 0x7F, 0x07, 0x9E, 0x00, 0x3E,
  0x00, 0xEF, 0x00, 0x3C, 0x00, 0x37, 0x80, 0x3C, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x07, 0xC0, 0x1E, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x0F,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F,
  0xC0, 0x1E, 0x00, 0x0F, 0xE0, 0x0F, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x07,
  0x70, 0x01, 0xE0, 0x07, 0x38, 0x00, 0xF8, 0x0F, 0x1C, 0x00, 0x3F, 0xFF,
  0x1E, 0x00, 0x0F, 0xFF, 0x0E, 0x00, 0x03, 0xFE, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x1F, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80,
  0x01, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xF1, 0xC0, 0x01, 0xF1, 0xE0,
  0x01, 0xF0, 0xF0, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x20, 0x3F, 0x00, 0x70, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0x02, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x02, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x07,
  0x00, 0x0F, 0xFF, 0x0E, 0x00, 0x1F, 0xFF, 0x8E, 0x00, 0x7F, 0x07, 0x8E,
  0x00, 0x7C, 0x01, 0xDE, 0x00, 0xF0, 0x00, 0xDE, 0x01, 0xF0, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x70,
  0x1E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0xC0,
  0x3C, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0x3B, 0x80,
  0x1E, 0x00, 0xF7, 0x80, 0x1F, 0x01, 0xE7, 0x80, 0x0F, 0xFF, 0xC7, 0x80,
  0x07, 0xFF, 0x87, 0x00, 0x03, 0xFE, 0x07, 0x00, 0x00, 0xF8, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x80, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x0F, 0xF0, 0x00, 0xE1,
  0xFF, 0xE0, 0x0F, 0x1F, 0xFF, 0x80, 0x79, 0xF0, 0x7C, 0x03, 0xDE, 0x01,
  0xF0, 0x1D, 0xC0, 0x07, 0x80, 0xEC, 0x00, 0x3C, 0x0F, 0xC0, 0x00, 0xE0,
  0x7E, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x38, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x78, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x07, 0x03, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x04, 0x3E, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0xF8, 0x00,
  0xE0, 0x0F, 0x80, 0x0F, 0x00, 0xF8, 0x00, 0x78, 0x0F, 0x80, 0x03, 0xC0,
  0xF8, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x78, 0x78, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x01,
  0xE7, 0xE0, 0x00, 0x0F, 0x7F, 0x00, 0x00, 0x77, 0xBC, 0x00, 0x03, 0xF9,
  0xE0, 0x00, 0x1F, 0x8F, 0x00, 0x01, 0xF8, 0x3C, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x78, 0x0F, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x1C, 0x01, 0xE0, 0x01,
  0xE0, 0x07, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x01, 0xC3, 0xFF, 0x80, 0xFF, 0xE0,
  0x07, 0x8F, 0xFF, 0x83, 0xFF, 0xE0, 0x0E, 0x3C, 0x1F, 0x0F, 0x07, 0xE0,
  0x1C, 0xE0, 0x1E, 0x38, 0x03, 0xC0, 0x3B, 0x80, 0x1E, 0xE0, 0x07, 0x80,
  0x7E, 0x00, 0x3F, 0x80, 0x07, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1C, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x38, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x70, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x78, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1C, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x7F, 0xC0,
  0x07, 0x0F, 0xFF, 0x00, 0x78, 0xFF, 0xFC, 0x03, 0x8F, 0x83, 0xF0, 0x1C,
  0xF0, 0x0F, 0x80, 0xEE, 0x00, 0x3C, 0x07, 0xE0, 0x01, 0xE0, 0x7E, 0x00,
  0x0F, 0x03, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x38, 0x1E,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x1C,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E,
  0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xF0, 0x00, 0x0E, 0x0F,
  0xFE, 0x00, 0x0F, 0x1F, 0xFF, 0x80, 0x07, 0x1F, 0x07, 0xC0, 0x03, 0x9E,
  0x01, 0xF0, 0x01, 0xDE, 0x00, 0x78, 0x00, 0xEE, 0x00, 0x1E, 0x00, 0xFE,
  0x00, 0x0F, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x03, 0xC0, 0x1F,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x07,
  0xC0, 0x1E, 0xE0, 0x07, 0xC0, 0x0F, 0x78, 0x0F, 0xC0, 0x07, 0x9F, 0xFF,
  0xC0, 0x03, 0x87, 0xFF, 0xC0, 0x03, 0xC1, 0xFF, 0x80, 0x01, 0xE0, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x1C, 0x00, 0xFF, 0xF0, 0xE0,
  0x07, 0xFF, 0xE3, 0x80, 0x3F, 0x07, 0x8E, 0x01, 0xF0, 0x07, 0x38, 0x0F,
  0x80, 0x0D, 0xE0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x0F,
  0xC0, 0xF0, 0x00, 0x7F, 0x03, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x0E, 0xE0,
  0x1E, 0x00, 0x77, 0x80, 0x7C, 0x07, 0x9E, 0x00, 0xFF, 0xFC, 0x78, 0x01,
  0xFF, 0xE1, 0xC0, 0x03, 0xFE, 0x07, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x7F, 0x00, 0xE1,
  0xFF, 0x01, 0xE3, 0xFE, 0x01, 0xC7, 0xE2, 0x01, 0xCF, 0x00, 0x01, 0xDC,
  0x00, 0x01, 0xD8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7E, 0x01, 0xE0, 0x3C, 0x00, 0x30, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC1, 0x00, 0x03, 0xE0, 0xF0,
  0x03, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xDF,
  0xFF, 0xE7, 0xFF, 0xF8, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x1C, 0x0E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x7C, 0x0F, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x7F, 0x03, 0xC0, 0x07,
  0x78, 0x1E, 0x00, 0x7B, 0x80, 0x78, 0x07, 0x9C, 0x03, 0xFF, 0xF8, 0xE0,
  0x0F, 0xFF, 0x07, 0x00, 0x3F, 0xF0, 0x70, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x79, 0xC0, 0x00,
  0x1E, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0x78, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x81,
  0xE0, 0x01, 0xE0, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x03, 0x80, 0x1E,
  0x00, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0,
  0x78, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x38,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0xFC, 0x00, 0x3C, 0xF0, 0x00,
  0xFC, 0x00, 0x3C, 0xF0, 0x01, 0xDC, 0x00, 0x38, 0xF0, 0x01, 0xDC, 0x00,
  0x78, 0xF0, 0x03, 0xDC, 0x00, 0x70, 0xF0, 0x03, 0x9C, 0x00, 0xF0, 0xF0,
  0x07, 0x9C, 0x00, 0xF0, 0xF0, 0x07, 0x1C, 0x01, 0xE0, 0xF0, 0x0F, 0x1C,
  0x01, 0xE0, 0xF0, 0x0E, 0x1C, 0x01, 0xC0, 0xF0, 0x0E, 0x1C, 0x03, 0xC0,
  0xF0, 0x1C, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x1E, 0x07, 0x80, 0xF0, 0x3C,
  0x1E, 0x07, 0x80, 0xF0, 0x38, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x1E, 0x0F,
  0x00, 0xF0, 0x70, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0E, 0x1E, 0x00, 0x70,
  0xE0, 0x0E, 0x1C, 0x00, 0x71, 0xE0, 0x0E, 0x3C, 0x00, 0x71, 0xC0, 0x0E,
  0x38, 0x00, 0x73, 0xC0, 0x0E, 0x78, 0x00, 0x73, 0x80, 0x0E, 0x78, 0x00,
  0x73, 0x80, 0x0E, 0x70, 0x00, 0x77, 0x80, 0x0E, 0xF0, 0x00, 0x77, 0x00,
  0x0E, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1C, 0x01,
  0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x0E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x07, 0x87, 0x00, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x83, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x80, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x13, 0xFF, 0xC0, 0x01, 0x7F,
  0xFF, 0x00, 0x3F, 0x03, 0xFF, 0x1F, 0xE0, 0x07, 0xFF, 0xE8, 0x00, 0x1F,
  0xFC, 0x80, 0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 15, 49, 15, 1, -48 },
  { 93, 17, 17, 22, 7, -48 },
  { 130, 36, 48, 36, 1, -48 },
  { 346, 29, 55, 32, 2, -51 },
  { 546, 39, 50, 47, 5, -49 },
  { 790, 35, 50, 38, 1, -49 },
  { 1009, 7, 17, 12, 7, -48 },
  { 1024, 20, 59, 17, 2, -48 },
  { 1172, 20, 59, 17, -5, -48 },
  { 1320, 25, 26, 31, 8, -51 },
  { 1402, 28, 31, 34, 4, -39 },
  { 1511, 11, 16, 14, -3, -7 },
  { 1533, 16, 4, 20, 2, -20 },
  { 1541, 6, 7, 14, 1, -6 },
  { 1547, 30, 48, 22, -3, -48 },
  { 1727, 28, 50, 32, 3, -49 },
  { 1902, 17, 48, 32, 9, -48 },
  { 2004, 32, 49, 32, -1, -49 },
  { 2200, 31, 50, 32, 0, -49 },
  { 2394, 31, 48, 32, 0, -48 },
  { 2580, 31, 49, 32, 1, -48 },
  { 2770, 30, 50, 32, 3, -49 },
  { 2958, 29, 48, 32, 5, -48 },
  { 3132, 30, 50, 32, 2, -49 },
  { 3320, 29, 50, 32, 2, -49 },
  { 3502, 12, 37, 14, 1, -36 },
  { 3558, 16, 45, 14, -3, -36 },
  { 3648, 28, 30, 34, 4, -39 },
  { 3753, 28, 17, 34, 4, -32 },
  { 3813, 28, 30, 34, 4, -39 },
  { 3918, 22, 50, 24, 4, -49 },
  { 4056, 45, 54, 49, 3, -48 },
  { 4360, 33, 48, 33, -4, -48 },
  { 4558, 33, 48, 35, 2, -48 },
  { 4756, 34, 50, 34, 4, -49 },
  { 4969, 35, 48, 39, 2, -48 },
  { 5179, 31, 48, 31, 2, -48 },
  { 5365, 31, 48, 29, 2, -48 },
  { 5551, 36, 50, 41, 4, -49 },
  { 5776, 39, 48, 40, 2, -48 },
  { 6010, 24, 48, 18, -2, -48 },
  { 6154, 26, 60, 15, -10, -48 },
  { 6349, 36, 48, 33, 2, -48 },
  { 6565, 22, 48, 28, 2, -48 },
  { 6697, 49, 48, 50, 2, -48 },
  { 6991, 40, 48, 41, 2, -48 },
  { 7231, 36, 50, 42, 4, -49 },
  { 7456, 32, 48, 33, 2, -48 },
  { 7648, 36, 60, 42, 4, -49 },
  { 7918, 32, 48, 34, 2, -48 },
  { 8110, 31, 50, 30, 0, -49 },
  { 8304, 28, 48, 29, 6, -48 },
  { 8472, 37, 49, 40, 4, -48 },
  { 8699, 32, 48, 32, 6, -48 },
  { 8891, 49, 48, 51, 7, -48 },
  { 9185, 39, 48, 30, -4, -48 },
  { 9419, 29, 48, 29, 6, -48 },
  { 9593, 35, 48, 31, -1, -48 },
  { 9803, 25, 59, 19, -1, -48 },
  { 9988, 11, 48, 22, 7, -48 },
  { 10054, 25, 59, 19, -5, -48 },
  { 10239, 30, 28, 34, 2, -48 },
  { 10344, 24, 3, 23, -6, 6 },
  { 10353, 8, 10, 16, 10, -51 },
  { 10363, 29, 37, 34, 3, -36 },
  { 10498, 30, 52, 34, 1, -51 },
  { 10693, 24, 37, 26, 3, -36 },
  { 10804, 33, 52, 34, 3, -51 },
  { 11019, 25, 37, 30, 3, -36 },
  { 11135, 34, 67, 17, -8, -51 },
  { 11420, 32, 52, 34, 1, -36 },
  { 11628, 29, 51, 33, 1, -51 },
  { 11813, 14, 49, 14, 1, -49 },
  { 11899, 25, 65, 14, -9, -49 },
  { 12103, 29, 51, 28, 1, -51 },
  { 12288, 15, 51, 14, 1, -51 },
  { 12384, 47, 36, 51, 1, -36 },
  { 12596, 29, 36, 33, 1, -36 },
  { 12727, 28, 37, 33, 3, -36 },
  { 12857, 33, 52, 34, -2, -36 },
  { 13072, 30, 52, 34, 3, -36 },
  { 13267, 24, 36, 23, 1, -36 },
  { 13375, 25, 37, 25, 0, -36 },
  { 13491, 18, 45, 19, 3, -44 },
  { 13593, 29, 37, 34, 3, -36 },
  { 13728, 26, 36, 26, 3, -36 },
  { 13845, 40, 36, 41, 4, -36 },
  { 14025, 32, 36, 28, -3, -36 },
  { 14169, 37, 52, 26, -7, -36 },
  { 14410, 27, 36, 25, -1, -36 },
  { 14532, 25, 59, 22, 1, -48 },
  { 14717, 3, 67, 32, 15, -51 },
  { 14743, 24, 59, 22, -3, -48 },
  { 14920, 28, 7, 34, 4, -27 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC67PT7B_H_
