#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC68PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x40, 0x00, 0x1E,
  0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0x80, 0xE3, 0xC0, 0xF1, 0xE0, 0x78,
  0xF0, 0x3C, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x1E, 0x07, 0x8E, 0x03,
  0x87, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xC0, 0x30, 0xE0, 0x38, 0x70,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0x1C, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0x1C, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x01,
  0xFE, 0xEF, 0xE0, 0x0F, 0x83, 0x03, 0x80, 0x7C, 0x1C, 0x02, 0x01, 0xE0,
  0x70, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x06, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0x7C, 0x70, 0x00, 0x00, 0xFD, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x77, 0xE0, 0x00, 0x01, 0xC7,
  0xC0, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x18, 0x1E, 0x00, 0x00, 0x60, 0x78,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x70, 0x1C, 0x00, 0x01, 0xC0, 0xF0, 0x20, 0x06, 0x07, 0x80, 0xF0, 0x38,
  0x7C, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x38,
  0x01, 0xFF, 0x00, 0x00, 0x78, 0x03, 0xFF, 0x80, 0x00, 0x70, 0x07, 0x83,
  0xC0, 0x00, 0xE0, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x01,
  0xC0, 0x1E, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x00,
  0x70, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x03,
  0x80, 0xE0, 0x00, 0xE0, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0x03, 0x81, 0xC0,
  0x00, 0xE0, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0x07, 0x07, 0x80, 0xE0, 0xE0,
  0x07, 0x07, 0x07, 0xF8, 0xE0, 0x0F, 0x0F, 0x0F, 0xFC, 0xE0, 0x0E, 0x1E,
  0x1F, 0x3E, 0xE0, 0x1E, 0x1C, 0x3C, 0x1E, 0xE0, 0x1C, 0x3C, 0x78, 0x0E,
  0xF0, 0x3C, 0x78, 0x70, 0x0F, 0x70, 0x78, 0x70, 0xF0, 0x0F, 0x7F, 0xF0,
  0xF0, 0xE0, 0x0F, 0x3F, 0xE1, 0xE1, 0xE0, 0x0F, 0x1F, 0x81, 0xC1, 0xC0,
  0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x0E, 0x00,
  0x07, 0x03, 0xC0, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x1C,
  0x00, 0x38, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x07, 0x80, 0xF0, 0x07,
  0x80, 0x07, 0x80, 0xE0, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x0E, 0x00, 0x03,
  0xE7, 0xC0, 0x1E, 0x00, 0x01, 0xFF, 0x80, 0x3C, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xDE,
  0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x10, 0x3E, 0x0F, 0x00, 0x0E, 0x07,
  0x80, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x03,
  0xC3, 0xE0, 0x03, 0xC0, 0x3C, 0x3C, 0x00, 0x1E, 0x07, 0x87, 0x80, 0x01,
  0xF0, 0x70, 0x78, 0x00, 0x0F, 0x0F, 0x07, 0x80, 0x00, 0xF9, 0xE0, 0x70,
  0x00, 0x07, 0x9E, 0x07, 0x00, 0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x03, 0xF8,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00,
  0x3F, 0x00, 0x78, 0x00, 0x07, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x3C,
  0x00, 0x3E, 0x3C, 0x03, 0xF0, 0x0F, 0xC3, 0xC0, 0x1F, 0xFF, 0xF8, 0x1E,
  0x00, 0xFF, 0xFE, 0x01, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF3, 0xC7, 0x8F, 0x1C, 0x38, 0x71, 0xE3,
  0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x01, 0x00, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0xF8, 0x0C, 0x00, 0x7F, 0x06,
  0x00, 0x0F, 0xE7, 0x00, 0x01, 0xFB, 0x80, 0xF0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xEE, 0x00, 0x01,
  0xE7, 0x00, 0x01, 0xE1, 0xC0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0x38, 0x01,
  0xE0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x30, 0x03, 0x80, 0x10, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01,
  0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1C, 0x03,
  0x80, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x39, 0xF7, 0xFF,
  0xFD, 0xE2, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x03,
  0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xB8, 0x1F, 0xBC,
  0x1F, 0x9E, 0x3F, 0x0F, 0x3F, 0x07, 0x3E, 0x07, 0x8E, 0x03, 0xC2, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x08, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x20, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x20,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x80, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x07, 0x9C, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x1E, 0x38, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x03, 0xC0, 0x0F, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x7F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x04, 0x00, 0x00, 0xF8,
  0x0C, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFE, 0x02, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x81, 0xFE, 0x00, 0x1E, 0x3F, 0xFE, 0x00, 0x71, 0xFF, 0xFC, 0x03, 0xCF,
  0x83, 0xF8, 0x0F, 0x70, 0x03, 0xE0, 0x3B, 0x80, 0x07, 0xC0, 0xFC, 0x00,
  0x0F, 0x07, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x70, 0x7C, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x3C, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFD, 0xF0, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x01, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0xF8,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38,
  0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0xF8, 0x78, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x83, 0xC0,
  0x00, 0xFC, 0x0F, 0x80, 0x07, 0xF0, 0x1E, 0x00, 0x3F, 0xC0, 0x7E, 0x03,
  0xEF, 0x00, 0xFF, 0xFF, 0x38, 0x01, 0xFF, 0xF0, 0xE0, 0x03, 0xFF, 0x87,
  0x80, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x02, 0x00, 0x3F, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x60, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0,
  0x1E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xE0, 0xFE,
  0x0C, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xFF,
  0x00, 0x1C, 0x1C, 0x00, 0x1F, 0xFF, 0x00, 0xE1, 0xE0, 0x03, 0xFF, 0xF8,
  0x07, 0x0E, 0x00, 0x3E, 0x03, 0x80, 0x38, 0xF0, 0x03, 0xC0, 0x1C, 0x01,
  0xC7, 0x00, 0x3C, 0x00, 0xE0, 0x0E, 0x38, 0x03, 0xC0, 0x0F, 0x00, 0x73,
  0xC0, 0x1C, 0x00, 0x70, 0x03, 0x9C, 0x01, 0xE0, 0x03, 0x80, 0x1C, 0xE0,
  0x0E, 0x00, 0x1C, 0x00, 0xEF, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x70, 0x07,
  0x00, 0x0E, 0x00, 0x7B, 0x80, 0x78, 0x00, 0x70, 0x03, 0x9C, 0x03, 0x80,
  0x03, 0x80, 0x1D, 0xE0, 0x1C, 0x00, 0x3C, 0x00, 0xEF, 0x00, 0xE0, 0x01,
  0xC0, 0x0F, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x73, 0x80, 0x78, 0x00, 0xF0,
  0x03, 0x9C, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0xE0, 0x1E, 0x00, 0x7C, 0x01,
  0xC7, 0x00, 0xF0, 0x03, 0xE0, 0x1E, 0x38, 0x07, 0x80, 0x3F, 0x01, 0xE1,
  0xC0, 0x1C, 0x03, 0xB8, 0x0E, 0x0E, 0x00, 0xF0, 0x39, 0xC0, 0xF0, 0x70,
  0x07, 0xE7, 0x8F, 0xBF, 0x03, 0xC0, 0x1F, 0xFC, 0x3F, 0xF0, 0x1E, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x70, 0x00, 0x60, 0x01, 0x80, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1C,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78,
  0x1F, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x0E, 0x0F, 0x80, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x07, 0xF0, 0x03, 0xC0, 0x00, 0xF8, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F,
  0x80, 0x1E, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x0F, 0xE0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x01, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x78, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x1C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x01, 0xF0, 0x03, 0x80,
  0x00, 0x3F, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x01, 0xF8, 0x00,
  0x78, 0x00, 0x7F, 0x00, 0x07, 0x81, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xF8,
  0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x00, 0x10, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x0F, 0xFF, 0xC3, 0xC0, 0x00, 0x7F, 0xFC, 0x1E, 0x00, 0x03, 0xFF, 0xE1,
  0xE0, 0x00, 0x3F, 0xFF, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x03, 0x80,
  0x3C, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x08, 0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x78, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x7C, 0x00,
  0x00, 0x3C, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x0E, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x00,
  0x3C, 0x7C, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x0E, 0x7E, 0x00,
  0x00, 0x00, 0xF3, 0xF8, 0x00, 0x00, 0x07, 0xBF, 0xC0, 0x00, 0x00, 0x3F,
  0xDE, 0x00, 0x00, 0x01, 0xF8, 0x78, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x00, 0xF8, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0xEE, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x77, 0x80, 0x00, 0x01, 0xEF,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7,
  0x80, 0x1E, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x0E, 0x78, 0x00, 0x00, 0x79,
  0xE0, 0x0F, 0x1C, 0x00, 0x00, 0x78, 0xF0, 0x07, 0x8E, 0x00, 0x00, 0x3C,
  0xF0, 0x03, 0xC7, 0x00, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0x80, 0x00, 0x1E,
  0x3C, 0x00, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x00, 0x0F,
  0x0E, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x07,
  0x07, 0x80, 0x1C, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x0E, 0x07, 0x00, 0x03,
  0x81, 0xE0, 0x0F, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x07, 0x81, 0xC0, 0x01,
  0xC0, 0xF0, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0x78, 0x01, 0xC0, 0x78, 0x01,
  0xE0, 0x3C, 0x00, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00,
  0xF0, 0x0E, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x3C, 0x01, 0xC0, 0x0F, 0x00, 0x70, 0x1C, 0x01, 0xE0, 0x07, 0x80, 0x38,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x87, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0xC7, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE3, 0x80, 0x0F, 0x00, 0x38, 0x00,
  0x73, 0xC0, 0x07, 0x80, 0x1C, 0x00, 0x3B, 0xC0, 0x03, 0xC0, 0x1E, 0x00,
  0x1D, 0xE0, 0x01, 0xC0, 0x0F, 0x00, 0x0F, 0xE0, 0x01, 0xE0, 0x07, 0x80,
  0x07, 0xF0, 0x00, 0xF0, 0x03, 0x80, 0x03, 0xF0, 0x00, 0x78, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0x00, 0x0E,
  0x00, 0x7F, 0x00, 0x00, 0x1E, 0x00, 0x77, 0x80, 0x00, 0x1E, 0x00, 0x77,
  0x80, 0x00, 0x1E, 0x00, 0xF7, 0x80, 0x00, 0x1C, 0x00, 0xF3, 0xC0, 0x00,
  0x3C, 0x00, 0xE3, 0xC0, 0x00, 0x3C, 0x00, 0xE3, 0xC0, 0x00, 0x3C, 0x01,
  0xE1, 0xC0, 0x00, 0x3C, 0x01, 0xE1, 0xE0, 0x00, 0x38, 0x01, 0xE1, 0xE0,
  0x00, 0x78, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x01, 0xC0, 0xF0, 0x00, 0x78,
  0x03, 0xC0, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x70, 0x00, 0x70, 0x03, 0xC0,
  0x78, 0x00, 0xF0, 0x03, 0x80, 0x78, 0x00, 0xF0, 0x03, 0x80, 0x38, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x01, 0xE0, 0x07, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0x00, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x01, 0xC0, 0x0F, 0x00, 0x0F, 0x03, 0xC0,
  0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x0E, 0x00, 0x0F, 0x03, 0xC0, 0x1E, 0x00,
  0x07, 0x83, 0xC0, 0x1E, 0x00, 0x07, 0x83, 0x80, 0x1E, 0x00, 0x07, 0x87,
  0x80, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x1C, 0x00, 0x03, 0xC7, 0x80, 0x3C,
  0x00, 0x03, 0xC7, 0x00, 0x3C, 0x00, 0x01, 0xC7, 0x00, 0x3C, 0x00, 0x01,
  0xEF, 0x00, 0x38, 0x00, 0x01, 0xEF, 0x00, 0x38, 0x00, 0x00, 0xEF, 0x00,
  0x78, 0x00, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x78, 0x00,
  0x00, 0x7E, 0x00, 0x70, 0x00, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x3C,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x3C, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x0F,
  0x3E, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x3E,
  0x3C, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x78, 0x01, 0xFC, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x7C, 0x03, 0x80, 0x00, 0xF8, 0x07,
  0x80, 0x01, 0xF0, 0x07, 0x80, 0x07, 0xE0, 0x07, 0x80, 0x7F, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x3C, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x78, 0x01, 0xFC, 0x00, 0x78,
  0x00, 0x7E, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0xF8, 0x03, 0x80, 0x01, 0xF8, 0x07, 0x80,
  0x07, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F,
  0x00, 0x0E, 0x00, 0x7C, 0x00, 0x02, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07, 0x80, 0x38, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x1E, 0x38, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x78, 0xF0, 0x00,
  0x0E, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x0F, 0x00,
  0x01, 0xCE, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF3, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x38, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x0F,
  0x00, 0x07, 0x8E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x80,
  0xF0, 0x00, 0xF0, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x78,
  0x07, 0x00, 0x1E, 0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x0F,
  0x00, 0x70, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x78, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x1E, 0x03, 0xC0,
  0x3C, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x07, 0x00, 0xE0, 0x0F, 0x01, 0xE0, 0x01, 0xC0, 0x78, 0x03,
  0xC0, 0xF0, 0x00, 0x70, 0x1C, 0x00, 0xF0, 0x3C, 0x00, 0x1C, 0x0F, 0x00,
  0x3C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x0F, 0x07, 0x80, 0x01, 0xC1, 0xE0,
  0x03, 0xC1, 0xC0, 0x00, 0x70, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x1C,
  0x00, 0x3C, 0x3C, 0x00, 0x07, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xC3,
  0x80, 0x03, 0xC7, 0x80, 0x00, 0x71, 0xE0, 0x00, 0xF1, 0xC0, 0x00, 0x1C,
  0x70, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x38, 0x00, 0x01,
  0xCF, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x77, 0x80, 0x00,
  0x1D, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x7C, 0x0E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x80, 0x1C,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80,
  0x3C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1C, 0x3C, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x04, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0,
  0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x3C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0,
  0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x07,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1C, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x07, 0x03,
  0x80, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x70, 0x07, 0xFF,
  0xC3, 0x80, 0x3F, 0xFF, 0x8E, 0x01, 0xF8, 0x0F, 0x38, 0x0F, 0x80, 0x1D,
  0xE0, 0x3C, 0x00, 0x37, 0x81, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF0,
  0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x78, 0x3C,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x3F, 0x03, 0xC0, 0x01, 0xFC, 0x0F, 0x00, 0x07, 0xE0, 0x1E, 0x00,
  0x3B, 0x80, 0x78, 0x01, 0xCE, 0x01, 0xF0, 0x1E, 0x38, 0x03, 0xFF, 0xF1,
  0xE0, 0x07, 0xFF, 0x87, 0x00, 0x0F, 0xF8, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x0F, 0x80, 0x00, 0xF0, 0x7F, 0xC0, 0x01, 0xC3, 0xFF, 0xE0, 0x07,
  0x8F, 0xDF, 0xC0, 0x0F, 0x3C, 0x07, 0xC0, 0x1E, 0xE0, 0x07, 0xC0, 0x3B,
  0x80, 0x07, 0x80, 0x7E, 0x00, 0x0F, 0x01, 0xFC, 0x00, 0x1E, 0x03, 0xF0,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0xF8, 0x0E,
  0xC0, 0x03, 0xE0, 0x3D, 0xC0, 0x0F, 0x80, 0x73, 0xC0, 0x3E, 0x00, 0xE3,
  0xFF, 0xF8, 0x01, 0xC3, 0xFF, 0xE0, 0x07, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x1F, 0xF7, 0xE0, 0x1F, 0x80, 0x10, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80,
  0x30, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x1F, 0xF8, 0x3C,
  0x00, 0x3F, 0xFF, 0x1E, 0x00, 0x3F, 0xFF, 0xCF, 0x00, 0x3F, 0x00, 0xE7,
  0x00, 0x3E, 0x00, 0x3B, 0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x07,
  0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x1E,
  0x00, 0x07, 0xE0, 0x0F, 0x00, 0x07, 0xF0, 0x07, 0x80, 0x03, 0xF8, 0x01,
  0xE0, 0x03, 0xBC, 0x00, 0xF0, 0x03, 0x9C, 0x00, 0x7C, 0x07, 0x8E, 0x00,
  0x1F, 0xFF, 0x87, 0x00, 0x07, 0xFF, 0x83, 0x80, 0x01, 0xFF, 0x83, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x1F, 0xEF, 0xE0, 0x1F, 0x80, 0xF8, 0x1F, 0x00, 0x3C,
  0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x0F, 0x00, 0x03, 0x87, 0x80, 0x01,
  0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0xF1, 0xE0, 0x00,
  0xF8, 0xE0, 0x00, 0xF8, 0xF0, 0x01, 0xF8, 0x78, 0x07, 0xF8, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x08,
  0x1F, 0x80, 0x38, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x60, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x87, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x07, 0x00, 0x1F,
  0xFF, 0x87, 0x00, 0x3F, 0xFF, 0xCF, 0x00, 0x7E, 0x01, 0xCE, 0x00, 0xF8,
  0x00, 0xEE, 0x00, 0xF0, 0x00, 0x6E, 0x01, 0xE0, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x7E, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x07, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0xC0, 0x3C, 0x00,
  0x1F, 0xC0, 0x3C, 0x00, 0x1F, 0xC0, 0x1E, 0x00, 0x3B, 0xC0, 0x1E, 0x00,
  0x73, 0x80, 0x1F, 0x01, 0xE3, 0x80, 0x0F, 0xFF, 0xC7, 0x80, 0x07, 0xFF,
  0x87, 0x80, 0x03, 0xFF, 0x07, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0xF0,
  0x7F, 0xE0, 0x03, 0x87, 0xFF, 0xC0, 0x1E, 0x3F, 0xFF, 0x80, 0x79, 0xE0,
  0x3E, 0x01, 0xEE, 0x00, 0x78, 0x07, 0x70, 0x00, 0xF0, 0x1F, 0x80, 0x03,
  0xC0, 0xFC, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF0,
  0x3C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x78, 0x1E,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1C, 0x0F, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x04, 0x1F, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0x00, 0xF0, 0x00,
  0x78, 0x03, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x1C, 0x01, 0xF0, 0x00,
  0xF0, 0x0F, 0x80, 0x03, 0xC0, 0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x38,
  0x1F, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xC7, 0xC0, 0x00, 0x0F, 0x3F, 0x00,
  0x00, 0x3D, 0xFE, 0x00, 0x00, 0xFF, 0x78, 0x00, 0x03, 0xF9, 0xE0, 0x00,
  0x0F, 0xC3, 0xC0, 0x00, 0x7E, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x03, 0xC0,
  0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xC1, 0xFF, 0x80,
  0x7F, 0xE0, 0x03, 0x8F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0x3F, 0xFF, 0x07,
  0xEF, 0xE0, 0x1E, 0xF0, 0x1F, 0x1E, 0x03, 0xE0, 0x39, 0xC0, 0x1E, 0x70,
  0x03, 0xC0, 0x77, 0x00, 0x3D, 0xC0, 0x07, 0x80, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3C, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0x83, 0xFF, 0x80,
  0x0E, 0x1F, 0xFF, 0x00, 0x78, 0xFF, 0xFE, 0x01, 0xE7, 0x80, 0xF8, 0x07,
  0x38, 0x01, 0xE0, 0x1D, 0xC0, 0x03, 0xC0, 0x7E, 0x00, 0x0F, 0x03, 0xF0,
  0x00, 0x3C, 0x0F, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x0E, 0x07, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x38,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C,
  0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x07,
  0x80, 0x03, 0xC0, 0x7C, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x03, 0xFE, 0x00, 0x01, 0xC3, 0xFF,
  0xE0, 0x00, 0xF1, 0xF9, 0xF8, 0x00, 0x3C, 0xF0, 0x1F, 0x00, 0x0E, 0x78,
  0x03, 0xE0, 0x03, 0xB8, 0x00, 0x78, 0x00, 0xEE, 0x00, 0x1E, 0x00, 0x7F,
  0x00, 0x07, 0x80, 0x1F, 0x80, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x3C, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0xF0, 0x07,
  0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x1D, 0x80, 0x07, 0xC0, 0x0F, 0x70, 0x03, 0xE0, 0x03, 0xDE, 0x01, 0xF0,
  0x00, 0xF3, 0xFF, 0xF8, 0x00, 0x38, 0x7F, 0xFC, 0x00, 0x1E, 0x0F, 0xFC,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x70, 0x07, 0xFF, 0xE1, 0xC0, 0x3F, 0xFF,
  0xCF, 0x01, 0xF8, 0x07, 0x38, 0x0F, 0x80, 0x0E, 0xE0, 0x3C, 0x00, 0x3B,
  0x81, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x7C,
  0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x0F,
  0x00, 0x01, 0xF8, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3F, 0x03, 0xC0,
  0x00, 0xFC, 0x0F, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x3B, 0xC0, 0x78, 0x01,
  0xCE, 0x01, 0xF0, 0x1E, 0x38, 0x03, 0xFF, 0xF1, 0xE0, 0x07, 0xFF, 0x87,
  0x80, 0x0F, 0xFC, 0x1E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xE0, 0xFF, 0x00,
  0xE1, 0xFF, 0x01, 0xE3, 0xFF, 0x01, 0xC7, 0x80, 0x01, 0xCE, 0x00, 0x01,
  0xDC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xCF, 0xF0, 0x3E, 0x00, 0x30,
  0x1E, 0x00, 0x08, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x80, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x07, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xF8, 0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7E, 0x0F, 0x00, 0x07, 0xE0,
  0x78, 0x00, 0x37, 0x03, 0xC0, 0x03, 0xF8, 0x1F, 0x00, 0x7B, 0xC0, 0x7C,
  0x07, 0x9C, 0x03, 0xFF, 0xF8, 0xE0, 0x0F, 0xFF, 0x87, 0x00, 0x3F, 0xF0,
  0x38, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x3C, 0x00,
  0x07, 0x8F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x01, 0xE0,
  0x1C, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78,
  0x1E, 0x00, 0x1E, 0x07, 0x80, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0xF0, 0x00,
  0x38, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xBC, 0x00, 0x1F, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0x80, 0x03, 0xCF,
  0x00, 0x0F, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0xF0, 0x01, 0xE3, 0xC0, 0x07,
  0xF8, 0x00, 0xF1, 0xE0, 0x03, 0xBC, 0x00, 0x70, 0xF0, 0x03, 0xDE, 0x00,
  0x78, 0x78, 0x01, 0xCF, 0x00, 0x38, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0x1E,
  0x00, 0xE1, 0xC0, 0x1E, 0x0F, 0x00, 0x70, 0xE0, 0x1E, 0x07, 0x80, 0x70,
  0x70, 0x0F, 0x03, 0xC0, 0x38, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x1C, 0x07,
  0x80, 0xF0, 0x1C, 0x0E, 0x03, 0x80, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0x3C,
  0x0E, 0x03, 0x81, 0xC0, 0x1E, 0x0F, 0x01, 0xC1, 0xE0, 0x07, 0x07, 0x00,
  0xE0, 0xF0, 0x03, 0x87, 0x80, 0x70, 0xF0, 0x01, 0xC3, 0x80, 0x38, 0x78,
  0x00, 0xE3, 0xC0, 0x1C, 0x38, 0x00, 0x71, 0xC0, 0x0E, 0x3C, 0x00, 0x38,
  0xE0, 0x07, 0x1C, 0x00, 0x1C, 0xF0, 0x03, 0x9E, 0x00, 0x0E, 0x70, 0x01,
  0xCE, 0x00, 0x07, 0x78, 0x00, 0xE7, 0x00, 0x03, 0xB8, 0x00, 0x77, 0x80,
  0x01, 0xFC, 0x00, 0x3B, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x3C, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x07,
  0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x38, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x00, 0x1C, 0x78,
  0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x5F, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFA,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 15, 50, 16, 1, -49 },
  { 95, 17, 18, 23, 7, -49 },
  { 134, 37, 49, 37, 1, -49 },
  { 361, 30, 56, 33, 2, -52 },
  { 571, 40, 50, 48, 5, -49 },
  { 821, 36, 50, 39, 1, -49 },
  { 1046, 7, 18, 13, 7, -49 },
  { 1062, 20, 60, 18, 2, -49 },
  { 1212, 20, 60, 18, -5, -49 },
  { 1362, 25, 27, 32, 8, -52 },
  { 1447, 29, 32, 35, 4, -40 },
  { 1563, 11, 17, 14, -3, -8 },
  { 1587, 16, 3, 20, 2, -20 },
  { 1593, 6, 7, 14, 1, -6 },
  { 1599, 30, 49, 22, -3, -49 },
  { 1783, 29, 50, 33, 3, -49 },
  { 1965, 17, 49, 33, 9, -49 },
  { 2070, 32, 49, 33, -1, -49 },
  { 2266, 32, 50, 33, 0, -49 },
  { 2466, 32, 49, 33, 0, -49 },
  { 2662, 31, 50, 33, 1, -49 },
  { 2856, 30, 50, 33, 3, -49 },
  { 3044, 29, 49, 33, 5, -49 },
  { 3222, 31, 50, 33, 2, -49 },
  { 3416, 30, 50, 33, 2, -49 },
  { 3604, 12, 38, 14, 1, -37 },
  { 3661, 16, 46, 15, -3, -37 },
  { 3753, 29, 31, 35, 4, -40 },
  { 3866, 29, 18, 35, 4, -33 },
  { 3932, 29, 31, 35, 4, -40 },
  { 4045, 22, 50, 25, 4, -49 },
  { 4183, 45, 54, 50, 3, -48 },
  { 4487, 33, 49, 33, -4, -49 },
  { 4690, 33, 49, 36, 2, -49 },
  { 4893, 34, 50, 34, 4, -49 },
  { 5106, 36, 49, 40, 2, -49 },
  { 5327, 32, 49, 31, 2, -49 },
  { 5523, 32, 49, 29, 2, -49 },
  { 5719, 37, 50, 41, 4, -49 },
  { 5951, 39, 49, 41, 2, -49 },
  { 6190, 24, 49, 18, -2, -49 },
  { 6337, 27, 61, 15, -11, -49 },
  { 6543, 37, 49, 33, 2, -49 },
  { 6770, 22, 49, 29, 2, -49 },
  { 6905, 49, 49, 51, 2, -49 },
  { 7206, 40, 49, 42, 2, -49 },
  { 7451, 37, 50, 43, 4, -49 },
  { 7683, 32, 49, 34, 2, -49 },
  { 7879, 37, 61, 43, 4, -49 },
  { 8162, 32, 49, 34, 2, -49 },
  { 8358, 32, 50, 31, 0, -49 },
  { 8558, 29, 49, 29, 6, -49 },
  { 8736, 37, 50, 41, 4, -49 },
  { 8968, 32, 49, 33, 6, -49 },
  { 9164, 50, 49, 52, 7, -49 },
  { 9471, 39, 49, 30, -4, -49 },
  { 9710, 30, 49, 29, 6, -49 },
  { 9894, 35, 49, 31, -1, -49 },
  { 10109, 25, 60, 20, -1, -49 },
  { 10297, 11, 49, 22, 7, -49 },
  { 10365, 26, 60, 20, -5, -49 },
  { 10560, 30, 29, 34, 2, -49 },
  { 10669, 24, 4, 24, -6, 6 },
  { 10681, 9, 11, 17, 10, -52 },
  { 10694, 30, 38, 34, 3, -37 },
  { 10837, 31, 53, 35, 1, -52 },
  { 11043, 25, 38, 27, 3, -37 },
  { 11162, 33, 53, 35, 3, -52 },
  { 11381, 25, 38, 30, 3, -37 },
  { 11500, 35, 68, 18, -8, -52 },
  { 11798, 32, 53, 35, 1, -37 },
  { 12010, 30, 52, 34, 1, -52 },
  { 12205, 15, 49, 14, 1, -49 },
  { 12297, 25, 65, 14, -9, -49 },
  { 12501, 30, 52, 28, 1, -52 },
  { 12696, 15, 52, 14, 1, -52 },
  { 12794, 47, 37, 51, 1, -37 },
  { 13012, 30, 37, 34, 1, -37 },
  { 13151, 28, 38, 34, 3, -37 },
  { 13284, 34, 53, 35, -2, -37 },
  { 13510, 30, 53, 35, 3, -37 },
  { 13709, 24, 37, 23, 1, -37 },
  { 13820, 25, 38, 26, 0, -37 },
  { 13939, 18, 46, 19, 3, -45 },
  { 14043, 29, 37, 34, 3, -36 },
  { 14178, 26, 36, 26, 4, -36 },
  { 14295, 41, 36, 42, 4, -36 },
  { 14480, 33, 36, 28, -3, -36 },
  { 14629, 37, 52, 27, -7, -36 },
  { 14870, 28, 36, 25, -2, -36 },
  { 14996, 25, 60, 23, 1, -49 },
  { 15184, 4, 68, 32, 15, -52 },
  { 15218, 24, 60, 23, -3, -49 },
  { 15398, 29, 8, 35, 4, -28 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC68PT7B_H_
