#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC52PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x0E, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0x1C, 0x3C, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x38,
  0x30, 0xC1, 0xC3, 0x07, 0x1C, 0x1C, 0x70, 0x61, 0x81, 0x86, 0x06, 0x18,
  0x38, 0xE0, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x06,
  0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x38, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x03, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x07,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x03, 0x01,
  0xC0, 0x00, 0x70, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x38, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x07, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x1C, 0x06, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3E, 0xDF, 0x80, 0xE1, 0x83,
  0x03, 0x83, 0x00, 0x0E, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x30, 0x00,
  0x60, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x86, 0x00, 0x03,
  0x8C, 0x00, 0x07, 0x98, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x06, 0xF0, 0x00, 0x0C, 0xF0, 0x00, 0x30,
  0xE0, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0xC0, 0x01, 0x83, 0x80, 0x07, 0x07,
  0x00, 0x0C, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x30, 0x70, 0x80, 0x61, 0xC1,
  0xE1, 0x8F, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xC0, 0xFF, 0x80,
  0x06, 0x07, 0x0E, 0x00, 0x38, 0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x70, 0x06,
  0x03, 0x01, 0xC0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01,
  0x80, 0x70, 0x38, 0x0E, 0x01, 0x81, 0xC0, 0x38, 0x06, 0x06, 0x00, 0xE0,
  0x18, 0x38, 0x03, 0x00, 0xE1, 0xC0, 0x0C, 0x03, 0x86, 0x00, 0x30, 0x0C,
  0x38, 0x30, 0xC0, 0x71, 0xC3, 0xFB, 0x01, 0xC6, 0x3F, 0xEC, 0x06, 0x38,
  0xE1, 0xF0, 0x38, 0xC7, 0x07, 0xE1, 0xC7, 0x38, 0x0D, 0xFE, 0x38, 0xE0,
  0x37, 0xF0, 0xC3, 0x00, 0xC2, 0x07, 0x1C, 0x03, 0x00, 0x38, 0x70, 0x1C,
  0x00, 0xC1, 0x80, 0x70, 0x07, 0x06, 0x01, 0xC0, 0x38, 0x38, 0x06, 0x00,
  0xC0, 0xE0, 0x18, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0,
  0x30, 0x0C, 0x07, 0x00, 0xC0, 0x70, 0x38, 0x03, 0x81, 0x80, 0xC0, 0x0E,
  0x0E, 0x07, 0x00, 0x18, 0x70, 0x38, 0x00, 0x7F, 0x81, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0,
  0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x1C, 0x00,
  0x38, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0x60, 0x1C, 0x00, 0x0E, 0x07,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x1E, 0x1C, 0x01, 0xC7, 0x81, 0xC0, 0x31, 0xE0,
  0x38, 0x0E, 0x38, 0x03, 0x81, 0x8E, 0x00, 0x70, 0x71, 0xC0, 0x07, 0x1C,
  0x70, 0x00, 0xF3, 0x8E, 0x00, 0x0E, 0xE1, 0xC0, 0x01, 0xF8, 0x38, 0x00,
  0x1F, 0x07, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0xF8, 0x0E, 0x00, 0x3F, 0x81,
  0xE0, 0x0F, 0x78, 0x3E, 0x07, 0x87, 0x03, 0xFF, 0xE0, 0xF0, 0x1F, 0xF0,
  0x0F, 0x00, 0x60, 0x00, 0x00, 0x39, 0xDC, 0xE7, 0x31, 0x9C, 0xE6, 0x31,
  0x8C, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x40, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x80, 0xE0, 0x38,
  0x18, 0x07, 0xC3, 0x00, 0x3E, 0x60, 0x01, 0xF9, 0xFC, 0x07, 0xFF, 0x80,
  0xF0, 0x00, 0x3E, 0x00, 0x0E, 0x60, 0x03, 0x8C, 0x00, 0xE1, 0xC0, 0x38,
  0x18, 0x0E, 0x03, 0x80, 0x80, 0x70, 0x00, 0x07, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x07, 0x0F, 0x0E, 0x0E,
  0x1C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0xE0, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0x33, 0xBF, 0xEF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x38, 0x0F, 0x00, 0x70, 0x38, 0x01, 0xC1,
  0xC0, 0x07, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xC7, 0x00,
  0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07,
  0x38, 0x00, 0x1C, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70,
  0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x60, 0x00,
  0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0xE3,
  0x80, 0x03, 0x86, 0x00, 0x1C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0x81, 0xC0,
  0x1C, 0x03, 0x80, 0xF0, 0x0F, 0x0F, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x38, 0x07, 0xC0, 0x7E, 0x0F, 0x60, 0xF7,
  0x1F, 0x39, 0xE1, 0xDE, 0x0C, 0x60, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0xC0, 0x0E, 0x00, 0x80, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xF0, 0x1E, 0x01,
  0xC0, 0x0F, 0x01, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0xC0, 0x03, 0xC0, 0xF8, 0x0F, 0xC0, 0xFF,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x36, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xEE, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x9C, 0x00,
  0x07, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x18, 0x00,
  0x38, 0x38, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x01,
  0xC0, 0x30, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E,
  0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x06, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x80, 0x07, 0x80, 0xF0, 0x1F, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xC0, 0x1F, 0x01, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x1F,
  0x80, 0x71, 0xFF, 0x81, 0xDF, 0xBF, 0x07, 0xE0, 0x1E, 0x1B, 0x00, 0x38,
  0xF8, 0x00, 0xE3, 0xC0, 0x01, 0xCF, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0,
  0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x0E, 0x30, 0x00, 0x38, 0xC0, 0x00,
  0xE3, 0x00, 0x03, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03, 0x83,
  0xC0, 0x1E, 0x07, 0x00, 0xF0, 0x0F, 0x07, 0x80, 0x3F, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xF0, 0x3E, 0x01,
  0xE0, 0x0E, 0x01, 0xC0, 0x0F, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03,
  0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x0E, 0x03,
  0x80, 0x0E, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0xF0, 0x00,
  0xF1, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xE7, 0x80, 0x0F, 0x81, 0xC0, 0x1E, 0x00, 0xE0, 0x3C, 0x00, 0xF0, 0x38,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x38, 0x60, 0x00, 0x38, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0x70,
  0x00, 0x70, 0x70, 0x00, 0xE0, 0x78, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x1F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xF8, 0x3C, 0x03, 0x80, 0x78, 0x1C, 0x00,
  0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71,
  0xC0, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80,
  0x01, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x3C, 0xE0, 0x01, 0xE3, 0xC0, 0x07,
  0x87, 0x00, 0x3E, 0x1E, 0x03, 0xB8, 0x3F, 0xFC, 0xE0, 0x7F, 0xE7, 0x00,
  0x7E, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x20, 0x3E, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x83, 0xC1, 0xE0,
  0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xF0,
  0x78, 0x3C, 0x1E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x07, 0xFE, 0x0F, 0xFF, 0x83,
  0x81, 0xE1, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x18, 0x38, 0x00,
  0xF8, 0x03, 0x87, 0x00, 0x7F, 0xE0, 0x71, 0xC0, 0x1F, 0x7C, 0x0E, 0x38,
  0x0F, 0x03, 0x80, 0xCE, 0x01, 0xC0, 0x60, 0x19, 0xC0, 0x70, 0x0C, 0x07,
  0x30, 0x1C, 0x03, 0x80, 0xEE, 0x03, 0x00, 0x70, 0x1D, 0xC0, 0xE0, 0x0C,
  0x03, 0xB8, 0x18, 0x01, 0x80, 0x66, 0x03, 0x00, 0x70, 0x0C, 0xC0, 0xE0,
  0x0E, 0x03, 0xB8, 0x1C, 0x01, 0x80, 0x77, 0x03, 0x80, 0x70, 0x0C, 0xE0,
  0x70, 0x0E, 0x03, 0x9C, 0x0E, 0x03, 0xC0, 0x63, 0x81, 0xC0, 0x78, 0x1C,
  0x70, 0x38, 0x1B, 0x07, 0x0E, 0x03, 0x86, 0x71, 0xC1, 0xC0, 0x7F, 0xCF,
  0xF0, 0x18, 0x07, 0xE0, 0xFC, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x8E, 0x00, 0x01,
  0xC7, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x70, 0x30, 0x00, 0x70, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x38, 0x07, 0x00,
  0x1C, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0x80, 0x07,
  0x01, 0xC0, 0x03, 0x81, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x38, 0x00,
  0x03, 0x9C, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x38, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x70, 0x7F, 0x80,
  0x38, 0x01, 0xE0, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x38, 0x00,
  0x78, 0x1C, 0x00, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xE0, 0x70,
  0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x06, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xE1,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0x70, 0x01, 0xF0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xF8, 0x0E, 0x00,
  0xF8, 0x00, 0x80, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x03, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0x0F, 0xF8, 0x00, 0xE0, 0x0F, 0x80, 0x38, 0x00, 0x78, 0x07, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00,
  0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0xF1, 0xC0,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x3C,
  0x18, 0x00, 0x07, 0x07, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x1C, 0x00,
  0x1E, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0x1C, 0x01, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x20, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x1F, 0xFC, 0x70, 0x01, 0xFF, 0xCE, 0x00, 0x1F, 0xF8, 0xE0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x0C, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x70, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x70, 0x0C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x38, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x08, 0x3C, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x3C, 0x00,
  0x38, 0x07, 0x80, 0x03, 0x00, 0xF0, 0x00, 0x70, 0x1E, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x70, 0x78, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x0E, 0x3C, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0E, 0xF8, 0x00, 0x00, 0xEF,
  0x80, 0x00, 0x1D, 0xF8, 0x00, 0x01, 0xF9, 0xC0, 0x00, 0x1F, 0x1C, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38,
  0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 0x00, 0x38,
  0x00, 0x70, 0x03, 0x80, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0xE0, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x0E, 0xC0, 0x00, 0x1D, 0xC0, 0x66, 0x00, 0x00, 0xEE,
  0x03, 0x30, 0x00, 0x0E, 0xE0, 0x39, 0xC0, 0x00, 0x67, 0x01, 0xCE, 0x00,
  0x07, 0x38, 0x0E, 0x70, 0x00, 0x71, 0xC0, 0x73, 0x80, 0x03, 0x8E, 0x07,
  0x1C, 0x00, 0x38, 0xE0, 0x38, 0xE0, 0x01, 0xC7, 0x01, 0xC3, 0x00, 0x1C,
  0x38, 0x0E, 0x18, 0x00, 0xE1, 0xC0, 0x60, 0xC0, 0x0E, 0x0E, 0x07, 0x07,
  0x00, 0x70, 0xE0, 0x38, 0x38, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0x38, 0x38,
  0x0E, 0x0E, 0x03, 0x81, 0xC0, 0x60, 0x70, 0x18, 0x1C, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x38, 0x0C, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0xE0, 0x38, 0x0E,
  0x03, 0x0E, 0x01, 0xC0, 0x60, 0x1C, 0x70, 0x1C, 0x07, 0x00, 0xE7, 0x00,
  0xE0, 0x38, 0x07, 0x38, 0x07, 0x01, 0xC0, 0x3B, 0x80, 0x38, 0x0C, 0x01,
  0xDC, 0x01, 0xC0, 0xE0, 0x07, 0xC0, 0x1C, 0x07, 0x00, 0x3E, 0x00, 0xE0,
  0x38, 0x01, 0xE0, 0x07, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x0C, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x70, 0x1E,
  0x00, 0x01, 0xC0, 0x7C, 0x00, 0x07, 0x03, 0xF0, 0x00, 0x18, 0x0F, 0xC0,
  0x00, 0xE0, 0x3B, 0x80, 0x03, 0x80, 0xCE, 0x00, 0x0E, 0x03, 0x38, 0x00,
  0x38, 0x1C, 0x70, 0x01, 0xC0, 0x71, 0xC0, 0x07, 0x01, 0xC7, 0x00, 0x1C,
  0x07, 0x0E, 0x00, 0x70, 0x38, 0x38, 0x01, 0x80, 0xE0, 0xE0, 0x0E, 0x03,
  0x81, 0x80, 0x38, 0x0E, 0x07, 0x00, 0xE0, 0x30, 0x1C, 0x03, 0x81, 0xC0,
  0x30, 0x0C, 0x07, 0x00, 0xE0, 0x70, 0x1C, 0x03, 0x81, 0xC0, 0x70, 0x0E,
  0x07, 0x01, 0x80, 0x1C, 0x1C, 0x0E, 0x00, 0x70, 0x60, 0x38, 0x01, 0xC3,
  0x80, 0xE0, 0x03, 0x8E, 0x03, 0x80, 0x0E, 0x38, 0x0C, 0x00, 0x38, 0xE0,
  0x70, 0x00, 0x73, 0x01, 0xC0, 0x01, 0xDC, 0x07, 0x00, 0x07, 0x70, 0x18,
  0x00, 0x0F, 0xC0, 0xE0, 0x00, 0x3E, 0x03, 0x80, 0x00, 0xF8, 0x0E, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0xF0, 0x03, 0xC0, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x78,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x1E, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x38,
  0xF0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xC3, 0xFC,
  0x01, 0xC0, 0x3E, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x0F, 0x03, 0x80, 0x07,
  0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07,
  0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x78, 0x1C, 0x01, 0xF0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0xF0, 0x03, 0xC0,
  0x1C, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x1C, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x01, 0xF8, 0x3F, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xC3, 0xFC,
  0x01, 0xC0, 0x3E, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x0F, 0x03, 0x80, 0x07,
  0x03, 0x80, 0x07, 0x03, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07,
  0x07, 0x00, 0x07, 0x07, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1E,
  0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0xF8, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x07, 0x00,
  0x38, 0x07, 0x00, 0x38, 0x07, 0x00, 0x38, 0x07, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x03, 0x80, 0x70, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0,
  0x70, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0xF8, 0x0F, 0x01, 0xE0, 0x02, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0xC0, 0x03, 0xC0, 0xF8, 0x1F, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x30, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x06, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0xE0, 0x0E, 0x00, 0x07, 0x00, 0x78, 0x00, 0x70, 0x01, 0xE0, 0x0F, 0x80,
  0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x78, 0x60, 0x00, 0x70, 0x60, 0x00, 0xF0, 0x60, 0x00, 0xE0,
  0x70, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x70, 0x03, 0x80,
  0x70, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x70, 0x0E, 0x00,
  0x70, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x30, 0x38, 0x00,
  0x30, 0x38, 0x00, 0x30, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x3B, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1F, 0xC0,
  0x00, 0xF0, 0x00, 0x39, 0x80, 0x01, 0xE0, 0x00, 0xE3, 0x00, 0x03, 0xC0,
  0x01, 0xC6, 0x00, 0x0F, 0x80, 0x03, 0x8C, 0x00, 0x1B, 0x00, 0x0E, 0x18,
  0x00, 0x76, 0x00, 0x1C, 0x30, 0x00, 0xCC, 0x00, 0x70, 0x60, 0x03, 0x98,
  0x00, 0xE0, 0xC0, 0x07, 0x30, 0x03, 0x81, 0x80, 0x1C, 0x60, 0x07, 0x03,
  0x00, 0x38, 0xC0, 0x0E, 0x06, 0x00, 0xE1, 0x80, 0x38, 0x0E, 0x01, 0xC3,
  0x00, 0x70, 0x1C, 0x03, 0x06, 0x01, 0xC0, 0x38, 0x0E, 0x0C, 0x03, 0x80,
  0x70, 0x18, 0x18, 0x0E, 0x00, 0xE0, 0x70, 0x30, 0x1C, 0x01, 0xC0, 0xE0,
  0x60, 0x30, 0x03, 0x83, 0x80, 0xC0, 0xE0, 0x07, 0x07, 0x01, 0x81, 0xC0,
  0x0E, 0x1C, 0x03, 0x07, 0x00, 0x1C, 0x38, 0x07, 0x0E, 0x00, 0x38, 0x60,
  0x0E, 0x38, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x00, 0xE3, 0x00, 0x38, 0xC0,
  0x01, 0xCE, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x07, 0x70,
  0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0x1D, 0x80, 0x07, 0x60,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x60, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x70, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xEE, 0x00, 0x07, 0xB8, 0x00,
  0x1C, 0x70, 0x00, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1C, 0x1C, 0x00, 0xE0,
  0x30, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x38,
  0x1C, 0x00, 0x60, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x1C, 0x00, 0x1C, 0x70,
  0x00, 0x73, 0x80, 0x00, 0xDC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x20,
  0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xE0, 0x30, 0x18, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x60, 0x30,
  0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x07, 0x03,
  0x80, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x38,
  0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF8, 0x00, 0x03, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x38,
  0xE0, 0x00, 0x70, 0xC0, 0x01, 0xC1, 0xC0, 0x03, 0x03, 0x80, 0x0E, 0x03,
  0x00, 0x38, 0x07, 0x00, 0x70, 0x06, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1C,
  0x0E, 0x00, 0x18, 0x18, 0x00, 0x38, 0x70, 0x00, 0x71, 0xC0, 0x00, 0x63,
  0x80, 0x00, 0xEE, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3,
  0x8F, 0x1C, 0x38, 0xE1, 0xC3, 0x00, 0x7F, 0x06, 0x01, 0xFF, 0x1C, 0x0F,
  0xCF, 0x38, 0x3E, 0x07, 0x60, 0x70, 0x07, 0xC1, 0xC0, 0x0F, 0x87, 0x80,
  0x0F, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00,
  0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C,
  0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87,
  0x00, 0x0F, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x7C, 0x38, 0x01, 0xF0, 0x38,
  0x03, 0x60, 0x70, 0x0D, 0xC0, 0xF8, 0x73, 0x80, 0xFF, 0xC6, 0x00, 0xFF,
  0x0C, 0x00, 0x20, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x7E, 0x00, 0x63, 0xFF, 0x01, 0xCF, 0x3F,
  0x03, 0xB8, 0x0E, 0x07, 0xE0, 0x1E, 0x0D, 0x80, 0x1C, 0x1E, 0x00, 0x38,
  0x7C, 0x00, 0x70, 0xF0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87,
  0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0,
  0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x0F, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x38, 0xF0, 0x00, 0xE1, 0xE0, 0x03, 0xC3, 0xE0, 0x0F,
  0x06, 0xC0, 0x3C, 0x0C, 0xE0, 0xF0, 0x39, 0xFF, 0xC0, 0x60, 0xFF, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x07, 0xE7, 0x83, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC1, 0xC0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x3F, 0x0E, 0x00, 0x3F, 0xE3, 0x80, 0x3F, 0x3C,
  0xE0, 0x1F, 0x01, 0xB8, 0x07, 0x00, 0x6C, 0x03, 0x80, 0x0F, 0x01, 0xE0,
  0x03, 0xC0, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x03,
  0x80, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00,
  0x3C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0x38,
  0x00, 0xF8, 0x0E, 0x00, 0x7E, 0x01, 0xC0, 0x1B, 0x00, 0x70, 0x0C, 0xC0,
  0x1F, 0x0E, 0x70, 0x03, 0xFF, 0x1C, 0x00, 0x7F, 0x87, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xF3, 0xE0, 0x3C, 0x0E,
  0x07, 0x00, 0x70, 0xE0, 0x07, 0x1E, 0x00, 0x71, 0xC0, 0x06, 0x38, 0x00,
  0xE3, 0x80, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0x78, 0x70, 0x7F, 0x07, 0xFF,
  0xC0, 0x7F, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x01, 0x03, 0xE0, 0x70, 0x1F, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x23, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC1, 0x80, 0x1F, 0xF8, 0xC0, 0x3F,
  0x3C, 0xE0, 0x3E, 0x03, 0x70, 0x1C, 0x01, 0xB0, 0x1C, 0x00, 0x78, 0x1E,
  0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x03,
  0x80, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1E,
  0x0E, 0x00, 0x0E, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x07,
  0xC0, 0xE0, 0x07, 0xE0, 0x38, 0x03, 0x60, 0x1C, 0x07, 0x70, 0x0F, 0x07,
  0x38, 0x03, 0xFF, 0x1C, 0x00, 0xFF, 0x0E, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x08, 0x00, 0x70, 0x07,
  0x80, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x7F, 0x00, 0x63,
  0xFF, 0x01, 0xCF, 0x9F, 0x03, 0xB8, 0x0E, 0x07, 0xE0, 0x1C, 0x0D, 0x80,
  0x18, 0x1E, 0x00, 0x38, 0x78, 0x00, 0xE0, 0xF0, 0x01, 0xC1, 0xC0, 0x03,
  0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x70,
  0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x06, 0x0E,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0,
  0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x04, 0x78, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x60, 0x07,
  0x01, 0xC0, 0x1E, 0x03, 0x80, 0x78, 0x07, 0x01, 0xE0, 0x0E, 0x07, 0x80,
  0x18, 0x1E, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x03,
  0x8E, 0x00, 0x06, 0x38, 0x00, 0x1C, 0xF0, 0x00, 0x3B, 0xE0, 0x00, 0x7E,
  0xE0, 0x00, 0xF9, 0xC0, 0x03, 0xE3, 0x80, 0x07, 0x83, 0x80, 0x0E, 0x07,
  0x00, 0x1C, 0x0E, 0x00, 0x30, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0C, 0x00, 0x70, 0x38, 0x00, 0xE0,
  0x70, 0x01, 0xE0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0x03, 0x07,
  0xE0, 0x1F, 0x80, 0x31, 0xFF, 0x07, 0xFC, 0x07, 0x3C, 0xF8, 0xF3, 0xE0,
  0x77, 0x03, 0x9C, 0x0F, 0x07, 0xC0, 0x3B, 0x00, 0x70, 0x6C, 0x01, 0xB0,
  0x07, 0x07, 0x80, 0x1E, 0x00, 0x70, 0xF0, 0x01, 0xC0, 0x07, 0x0F, 0x00,
  0x3C, 0x00, 0x70, 0xE0, 0x03, 0x80, 0x06, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0xE0, 0x03, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x00,
  0x0E, 0x1C, 0x00, 0x70, 0x00, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x38, 0x00,
  0x70, 0x01, 0xC3, 0x80, 0x06, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0x01, 0xC3,
  0x80, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x00,
  0x38, 0x70, 0x00, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x00, 0x30, 0x70, 0x01,
  0xC0, 0x07, 0x06, 0x00, 0x1C, 0x00, 0x70, 0xE0, 0x01, 0xC0, 0x07, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x03, 0x07, 0xF0, 0x06, 0x3F, 0xF0, 0x1C, 0xFB,
  0xF0, 0x3B, 0x80, 0xE0, 0x7E, 0x01, 0xC0, 0xD8, 0x03, 0xC1, 0xE0, 0x03,
  0x87, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70,
  0xF0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x0E,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0x3F, 0x01, 0xE0, 0x1C,
  0x07, 0x00, 0x78, 0x38, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x07, 0x38,
  0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00,
  0x1D, 0xC0, 0x00, 0xE6, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B,
  0x80, 0x01, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x80,
  0x03, 0x87, 0x00, 0x1C, 0x1C, 0x00, 0xF0, 0x78, 0x07, 0x80, 0xF0, 0x7C,
  0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x60, 0xFC, 0x00, 0x18, 0xFF,
  0xC0, 0x0E, 0x79, 0xF8, 0x03, 0xB8, 0x0E, 0x00, 0xFC, 0x03, 0xC0, 0x36,
  0x00, 0x70, 0x0F, 0x00, 0x1C, 0x07, 0xC0, 0x07, 0x01, 0xE0, 0x01, 0xC0,
  0x78, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x03, 0x80, 0x01,
  0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x07,
  0x00, 0x07, 0x03, 0xC0, 0x03, 0x80, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0xF0,
  0x0F, 0x80, 0x78, 0x03, 0x38, 0x3C, 0x01, 0xC7, 0xFE, 0x00, 0x70, 0xFF,
  0x00, 0x1C, 0x04, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x06, 0x01, 0xFF, 0x8C, 0x0F, 0xCF,
  0x38, 0x3E, 0x07, 0x70, 0x70, 0x06, 0xC1, 0xC0, 0x07, 0x87, 0x80, 0x0F,
  0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE3,
  0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70,
  0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x01, 0xE3, 0x80, 0x03, 0x87, 0x00,
  0x0F, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x7C, 0x38, 0x00, 0xF8, 0x38, 0x03,
  0x60, 0x70, 0x0D, 0xC0, 0xF0, 0x73, 0x80, 0xFF, 0xC7, 0x00, 0xFF, 0x0E,
  0x00, 0x30, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x03,
  0x07, 0xC0, 0xC7, 0xF0, 0x73, 0xFC, 0x1D, 0xC0, 0x07, 0xE0, 0x01, 0xB0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0x9F, 0x87, 0x80, 0x20,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x80,
  0x0E, 0x1C, 0x07, 0xC3, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x01, 0xFF, 0xDF,
  0xFF, 0x7F, 0xF8, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x20, 0x7F, 0x80, 0xFE, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0xE0, 0x01, 0xC1, 0x80, 0x03, 0x87, 0x00, 0x06, 0x0E, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0x83,
  0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70,
  0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x00, 0x0F, 0x0E, 0x00,
  0x1C, 0x1C, 0x00, 0x78, 0x38, 0x01, 0xF0, 0x70, 0x03, 0xE0, 0x70, 0x1D,
  0xC0, 0xF0, 0x73, 0x01, 0xFF, 0xC6, 0x00, 0xFE, 0x0C, 0x00, 0x20, 0x00,
  0x00, 0xE0, 0x00, 0x7E, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1C, 0xE0,
  0x01, 0xCE, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x70, 0xE0, 0x07, 0x06,
  0x00, 0xE0, 0x60, 0x0E, 0x06, 0x01, 0xC0, 0x70, 0x3C, 0x07, 0x03, 0x80,
  0x70, 0x78, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xC0,
  0x07, 0x1C, 0x00, 0x33, 0x80, 0x03, 0x38, 0x00, 0x33, 0x00, 0x03, 0x70,
  0x00, 0x36, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x77, 0x00,
  0x3C, 0x00, 0xEE, 0x00, 0xF8, 0x03, 0x9C, 0x01, 0xB0, 0x07, 0x38, 0x07,
  0x60, 0x0E, 0x70, 0x0C, 0xC0, 0x38, 0xE0, 0x39, 0x80, 0x71, 0xC0, 0x63,
  0x01, 0xC3, 0x81, 0xC7, 0x03, 0x87, 0x03, 0x8E, 0x0E, 0x0E, 0x06, 0x1C,
  0x1C, 0x1C, 0x1C, 0x38, 0x30, 0x38, 0x30, 0x70, 0xE0, 0x70, 0xE0, 0xE1,
  0xC0, 0xE1, 0x81, 0xC7, 0x01, 0xC7, 0x03, 0x8E, 0x01, 0x8C, 0x07, 0x38,
  0x03, 0x38, 0x0E, 0x70, 0x06, 0x60, 0x1C, 0xC0, 0x0D, 0xC0, 0x3B, 0x80,
  0x1B, 0x80, 0x76, 0x00, 0x36, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x07, 0x80, 0xE0, 0x03, 0x80, 0x70, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x0E, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x00, 0xE1,
  0xC0, 0x00, 0x71, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x71, 0xC0, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x06, 0x00,
  0x3C, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x38,
  0x1E, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x00, 0x60, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70,
  0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x30, 0x38, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x30, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x3C, 0x00,
  0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x78, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x05, 0xFF, 0xC0, 0x1F,
  0x1F, 0xC1, 0xF0, 0x0F, 0xFE, 0x80, 0x0F, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 11, 37, 12, 1, -37 },
  { 52, 14, 13, 17, 5, -37 },
  { 75, 28, 37, 28, 1, -37 },
  { 205, 23, 42, 25, 1, -39 },
  { 326, 30, 39, 36, 4, -38 },
  { 473, 27, 39, 29, 1, -38 },
  { 605, 5, 13, 10, 6, -37 },
  { 614, 15, 45, 14, 2, -37 },
  { 699, 16, 45, 14, -4, -37 },
  { 789, 19, 21, 24, 6, -40 },
  { 839, 22, 25, 27, 3, -31 },
  { 908, 8, 13, 11, -2, -6 },
  { 921, 13, 2, 15, 1, -15 },
  { 925, 5, 5, 11, 1, -5 },
  { 929, 23, 37, 17, -2, -37 },
  { 1036, 22, 39, 25, 2, -38 },
  { 1144, 13, 37, 25, 7, -37 },
  { 1205, 24, 38, 25, 0, -38 },
  { 1319, 24, 39, 25, 0, -38 },
  { 1436, 24, 37, 25, 0, -37 },
  { 1547, 24, 38, 25, 1, -37 },
  { 1661, 22, 39, 25, 3, -38 },
  { 1769, 22, 37, 25, 4, -37 },
  { 1871, 24, 39, 25, 1, -38 },
  { 1988, 22, 39, 25, 2, -38 },
  { 2096, 9, 28, 11, 1, -28 },
  { 2128, 12, 35, 11, -2, -28 },
  { 2181, 22, 23, 27, 3, -30 },
  { 2245, 22, 13, 27, 3, -25 },
  { 2281, 22, 23, 27, 3, -30 },
  { 2345, 17, 38, 19, 3, -38 },
  { 2426, 35, 42, 38, 2, -37 },
  { 2610, 25, 37, 25, -3, -37 },
  { 2726, 25, 37, 27, 2, -37 },
  { 2842, 26, 39, 26, 3, -38 },
  { 2969, 27, 37, 30, 2, -37 },
  { 3094, 24, 37, 24, 2, -37 },
  { 3205, 24, 37, 22, 2, -37 },
  { 3316, 28, 39, 32, 3, -38 },
  { 3453, 30, 37, 31, 2, -37 },
  { 3592, 18, 37, 14, -1, -37 },
  { 3676, 20, 46, 12, -8, -37 },
  { 3791, 28, 37, 25, 2, -37 },
  { 3921, 16, 37, 22, 2, -37 },
  { 3995, 37, 37, 39, 2, -37 },
  { 4167, 30, 37, 32, 2, -37 },
  { 4306, 28, 39, 33, 3, -38 },
  { 4443, 24, 37, 26, 2, -37 },
  { 4554, 28, 47, 33, 3, -38 },
  { 4719, 24, 37, 26, 2, -37 },
  { 4830, 24, 39, 23, 0, -38 },
  { 4947, 22, 37, 22, 5, -37 },
  { 5049, 29, 38, 31, 3, -37 },
  { 5187, 24, 37, 25, 5, -37 },
  { 5298, 39, 37, 40, 5, -37 },
  { 5479, 30, 37, 23, -3, -37 },
  { 5618, 22, 37, 23, 5, -37 },
  { 5720, 27, 37, 24, -1, -37 },
  { 5845, 20, 45, 15, -1, -37 },
  { 5958, 9, 37, 17, 5, -37 },
  { 6000, 20, 45, 15, -4, -37 },
  { 6113, 23, 21, 26, 2, -37 },
  { 6174, 18, 2, 18, -4, 5 },
  { 6179, 6, 8, 13, 8, -40 },
  { 6185, 23, 29, 26, 2, -28 },
  { 6269, 23, 41, 26, 1, -40 },
  { 6387, 19, 29, 20, 2, -28 },
  { 6456, 26, 41, 27, 2, -40 },
  { 6590, 20, 29, 23, 2, -28 },
  { 6663, 26, 52, 14, -6, -40 },
  { 6832, 25, 40, 27, 0, -28 },
  { 6957, 23, 40, 26, 1, -40 },
  { 7072, 11, 38, 11, 1, -38 },
  { 7125, 19, 50, 11, -7, -38 },
  { 7244, 23, 40, 22, 1, -40 },
  { 7359, 11, 40, 11, 1, -40 },
  { 7414, 36, 28, 39, 1, -28 },
  { 7540, 23, 28, 26, 1, -28 },
  { 7621, 22, 28, 26, 2, -28 },
  { 7698, 26, 40, 26, -2, -28 },
  { 7828, 23, 40, 27, 2, -28 },
  { 7943, 18, 28, 18, 1, -28 },
  { 8006, 19, 29, 20, 0, -28 },
  { 8075, 14, 35, 15, 2, -34 },
  { 8137, 23, 29, 26, 2, -28 },
  { 8221, 20, 28, 20, 3, -28 },
  { 8291, 31, 28, 32, 3, -28 },
  { 8400, 25, 28, 21, -2, -28 },
  { 8488, 28, 41, 20, -5, -28 },
  { 8632, 21, 28, 19, -1, -28 },
  { 8706, 19, 45, 17, 1, -37 },
  { 8813, 2, 53, 25, 12, -40 },
  { 8827, 19, 45, 17, -3, -37 },
  { 8934, 22, 5, 27, 3, -21 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC52PT7B_H_
