#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC36PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18,
  0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x20, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0xE0, 0xC0, 0x71, 0xB1, 0xD8, 0xCC, 0x64, 0x36, 0x1B, 0x09, 0x8C,
  0x86, 0x42, 0x00, 0x00, 0x60, 0x80, 0x08, 0x30, 0x03, 0x06, 0x00, 0x60,
  0x80, 0x08, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x10, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFC, 0x0C, 0x10, 0x01, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x10,
  0x01, 0x06, 0x00, 0x60, 0xC0, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x20, 0xC0,
  0x0C, 0x18, 0x01, 0x82, 0x00, 0x20, 0xC0, 0x0C, 0x18, 0x01, 0x82, 0x00,
  0x20, 0xC0, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x03,
  0xFE, 0x07, 0xFF, 0x0C, 0x61, 0x1C, 0x60, 0x18, 0x40, 0x18, 0x40, 0x18,
  0xC0, 0x18, 0xC0, 0x0C, 0x80, 0x0F, 0x80, 0x03, 0x80, 0x01, 0xE0, 0x01,
  0xF0, 0x01, 0x38, 0x01, 0x18, 0x01, 0x0C, 0x03, 0x08, 0x03, 0x18, 0x02,
  0x18, 0x82, 0x30, 0xFF, 0xE0, 0x7F, 0xC0, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0F, 0x00, 0x60, 0xFC, 0x03, 0x0C, 0x60, 0x30, 0xC1,
  0x03, 0x06, 0x08, 0x18, 0x60, 0x41, 0x83, 0x06, 0x08, 0x18, 0x30, 0xC0,
  0xC1, 0x8C, 0x04, 0x0C, 0x40, 0x20, 0x46, 0x39, 0x06, 0x67, 0xE8, 0x22,
  0x63, 0x63, 0x33, 0x0F, 0xF3, 0x30, 0x6F, 0x11, 0x83, 0x01, 0x88, 0x18,
  0x18, 0xC0, 0x80, 0x86, 0x0C, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x10, 0x60, 0x61, 0x86, 0x03, 0x08, 0x30, 0x18, 0xC3, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0x00, 0x30, 0x60, 0x1C, 0x18, 0x06, 0x06, 0x01,
  0x81, 0x80, 0x60, 0x60, 0x18, 0x30, 0x06, 0x1C, 0x01, 0x8E, 0x00, 0x37,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0x8C, 0x0C, 0xC1, 0x83,
  0x60, 0x61, 0xB8, 0x0C, 0x6C, 0x03, 0x33, 0x00, 0x7C, 0xC0, 0x1E, 0x30,
  0x03, 0x0C, 0x01, 0xE3, 0x81, 0xD8, 0x7B, 0xE3, 0x0F, 0xE0, 0xE0, 0x76,
  0x66, 0x6C, 0xCC, 0x88, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0,
  0x30, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x30, 0xC0, 0xF3, 0x00, 0xFC, 0x30, 0x7F, 0xC1, 0xC0, 0x0D, 0x00,
  0x66, 0x07, 0x18, 0x18, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x7F, 0xFF,
  0xFF, 0xFE, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x71, 0x86, 0x30, 0xC6, 0x18, 0xC0,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xF0, 0x0F, 0xF0, 0x38, 0x30, 0x60, 0x61, 0x80, 0x63, 0x00, 0xCC,
  0x01, 0x98, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x3C, 0x00,
  0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x1D, 0x80, 0x33, 0x00, 0x66,
  0x01, 0xCC, 0x03, 0x18, 0x0E, 0x30, 0x18, 0x70, 0x60, 0x7B, 0x80, 0x7E,
  0x00, 0x01, 0x83, 0xC3, 0xC3, 0xE7, 0x37, 0x19, 0x0C, 0x0C, 0x06, 0x03,
  0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x81, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01,
  0xC1, 0xC0, 0x80, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFC,
  0x7F, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x03, 0xC0, 0xC0, 0x80, 0x70,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x3E, 0x00, 0x3F, 0x80, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x71, 0x00, 0x70, 0xF9, 0xF0, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xB0, 0x01, 0x98,
  0x01, 0x98, 0x00, 0xCC, 0x00, 0xC6, 0x00, 0xC3, 0x00, 0xC1, 0x80, 0x61,
  0x80, 0x60, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x60, 0x10, 0x30, 0x18, 0x30,
  0x0C, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x03, 0xFF, 0x07, 0xFF, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x19, 0x80, 0x3F, 0xF0, 0x18, 0x78, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x80, 0x70, 0xF3, 0xE0, 0xFF, 0x80, 0x00,
  0x7F, 0x01, 0xFE, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x63, 0xE0, 0x6F, 0xF0, 0x78,
  0x38, 0xF0, 0x18, 0xE0, 0x1C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x30, 0x60, 0x60, 0x7B,
  0xC0, 0x3F, 0x80, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x80, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0x07, 0x0C, 0x03,
  0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x06, 0x0E, 0x0E,
  0x06, 0x1C, 0x03, 0xF0, 0x01, 0xC0, 0x0F, 0xE0, 0x1C, 0x30, 0x30, 0x18,
  0x60, 0x1C, 0xE0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x18, 0x60, 0x38, 0x7C, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x03, 0xFC,
  0x06, 0x0E, 0x0C, 0x06, 0x18, 0x06, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x30, 0x03, 0x30, 0x07, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x38, 0x1E,
  0x1E, 0xF6, 0x0F, 0xCC, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0xE7, 0x80, 0xFE, 0x00,
  0x1C, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE3, 0x8C, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x1C, 0x0C, 0x06,
  0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x60, 0x00, 0x0F,
  0x83, 0xFE, 0x20, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x38, 0x03,
  0x80, 0x1C, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18,
  0x06, 0x02, 0x30, 0x3F, 0xC3, 0x60, 0x61, 0x83, 0x60, 0xC1, 0x83, 0x61,
  0x81, 0x83, 0xC1, 0x81, 0x82, 0xC3, 0x03, 0x02, 0xC3, 0x03, 0x06, 0xC3,
  0x03, 0x06, 0x82, 0x02, 0x04, 0x82, 0x06, 0x0C, 0x82, 0x06, 0x08, 0x83,
  0x0A, 0x18, 0x83, 0xBB, 0xF0, 0xC1, 0xE1, 0xE0, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x01, 0x00, 0x1F,
  0x1E, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x60, 0x01, 0xB0, 0x01, 0x98, 0x00, 0xCC, 0x00, 0xC6, 0x00, 0x63,
  0x00, 0x61, 0x80, 0x30, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x18, 0x18, 0x0C,
  0x04, 0x0F, 0xFF, 0x07, 0xFF, 0x86, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x31,
  0x80, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xE0, 0x00,
  0xC0, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x60, 0x78, 0x18, 0x06, 0x06, 0x01,
  0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0xE1,
  0x80, 0x70, 0x60, 0x78, 0x1F, 0xF0, 0x06, 0x1F, 0x03, 0x80, 0xE0, 0xC0,
  0x18, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x06,
  0x18, 0x01, 0x86, 0x00, 0xC1, 0x80, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x3C, 0x0C, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x78, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0xC0, 0x18, 0x1E, 0x03, 0x00, 0xE0, 0x60, 0x0C, 0x18,
  0x01, 0x83, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x60,
  0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xCE, 0x00, 0x39, 0x80,
  0x06, 0x30, 0x00, 0xC6, 0x00, 0x38, 0xC0, 0x06, 0x30, 0x01, 0xC6, 0x00,
  0x70, 0xC0, 0x1C, 0x18, 0x07, 0x03, 0x03, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0,
  0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0xFF, 0xC0, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x03, 0xC0,
  0x60, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x01, 0xFC, 0xC0, 0x3F, 0xCC, 0x00, 0x18, 0xC0, 0x01, 0x8C,
  0x00, 0x18, 0xC0, 0x01, 0x8E, 0x00, 0x38, 0x60, 0x03, 0x06, 0x00, 0x30,
  0x70, 0x03, 0x03, 0x80, 0x30, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0x00,
  0x18, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x06,
  0x00, 0x18, 0x30, 0x01, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03,
  0x06, 0x00, 0x18, 0x30, 0x01, 0x81, 0xFF, 0xFC, 0x0C, 0x00, 0x60, 0xE0,
  0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60,
  0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00,
  0x60, 0xC0, 0x03, 0x06, 0x00, 0x30, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x30,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x3D, 0x07,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x23, 0x80,
  0x7E, 0x00, 0x20, 0x00, 0x07, 0x00, 0x70, 0x60, 0x0C, 0x06, 0x01, 0xC0,
  0x60, 0x38, 0x06, 0x07, 0x00, 0xC0, 0xE0, 0x0C, 0x1C, 0x00, 0xC3, 0x80,
  0x0C, 0x70, 0x00, 0xCE, 0x00, 0x19, 0xC0, 0x01, 0x98, 0x00, 0x1B, 0x80,
  0x01, 0xEC, 0x00, 0x3C, 0xC0, 0x03, 0x8E, 0x00, 0x30, 0x60, 0x03, 0x06,
  0x00, 0x30, 0x70, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0x07, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xFF, 0xFF, 0xFE,
  0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00,
  0x1A, 0x05, 0x80, 0x07, 0x83, 0x60, 0x03, 0x60, 0xD8, 0x00, 0xD8, 0x36,
  0x00, 0x66, 0x0D, 0x80, 0x1B, 0x02, 0x20, 0x0C, 0xC1, 0x88, 0x03, 0x30,
  0x63, 0x01, 0x8C, 0x18, 0xC0, 0xC3, 0x06, 0x30, 0x31, 0x83, 0x0C, 0x18,
  0x60, 0xC3, 0x06, 0x18, 0x30, 0xC3, 0x06, 0x0C, 0x30, 0xC3, 0x83, 0x04,
  0x60, 0xC1, 0x81, 0x18, 0x30, 0x60, 0x6C, 0x0C, 0x18, 0x1B, 0x03, 0x06,
  0x07, 0x81, 0x81, 0x81, 0xE0, 0x60, 0xC0, 0x70, 0x18, 0x30, 0x1C, 0x06,
  0x00, 0x07, 0x00, 0x18, 0x38, 0x00, 0xC1, 0xC0, 0x06, 0x0F, 0x00, 0x30,
  0x58, 0x01, 0x86, 0xC0, 0x18, 0x33, 0x00, 0xC1, 0x98, 0x06, 0x0C, 0xC0,
  0x30, 0x43, 0x03, 0x06, 0x18, 0x18, 0x30, 0xC0, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0xC0, 0xC3, 0x06, 0x07, 0x18, 0x30, 0x18, 0xC1, 0x80, 0xC6,
  0x0C, 0x06, 0x30, 0xC0, 0x1B, 0x06, 0x00, 0xD8, 0x30, 0x06, 0xC1, 0x80,
  0x1E, 0x0C, 0x00, 0xE0, 0xC0, 0x07, 0x06, 0x00, 0x18, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0xF8, 0x03, 0x81, 0xC0, 0x60, 0x0C, 0x0C, 0x00, 0x61, 0xC0,
  0x06, 0x18, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x77, 0x00, 0x07, 0x60,
  0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6C,
  0x00, 0x0E, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0xCE, 0x00, 0x18,
  0x60, 0x03, 0x86, 0x00, 0x30, 0x70, 0x06, 0x03, 0x80, 0xE0, 0x1F, 0xFC,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x01, 0x83, 0xC0, 0xC0, 0x60,
  0x60, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x01,
  0xC6, 0x00, 0xC3, 0x00, 0xE1, 0x80, 0xE0, 0xC3, 0xE0, 0xFF, 0xC0, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x03, 0x81, 0xC0, 0x60, 0x0C, 0x0C, 0x00, 0x61,
  0xC0, 0x06, 0x18, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x77, 0x00, 0x07,
  0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00,
  0x6C, 0x00, 0x0E, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0xCE, 0x00,
  0x18, 0x60, 0x03, 0x86, 0x00, 0x30, 0x70, 0x06, 0x03, 0x80, 0xE0, 0x1F,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x07, 0xF0, 0x03, 0xFF, 0x01,
  0x83, 0xC0, 0xC0, 0x70, 0x60, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03,
  0x0C, 0x01, 0x86, 0x01, 0xC6, 0x00, 0xC3, 0x00, 0xE1, 0x81, 0xE0, 0xFF,
  0xC0, 0xFF, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x18, 0x0C, 0x0C, 0x0C,
  0x06, 0x06, 0x03, 0x83, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0xC0, 0x0C,
  0x60, 0x06, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xC0, 0x41, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x61, 0x00, 0x70, 0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0xC0,
  0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x0C, 0x38,
  0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01, 0x86,
  0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x0E, 0x00, 0x60, 0x60, 0x0C,
  0x07, 0x01, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0xC0, 0x01, 0xE0, 0x01,
  0xD8, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x63, 0x00, 0x31, 0x80, 0x30, 0xC0,
  0x18, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x03,
  0x03, 0x01, 0x83, 0x00, 0x41, 0x80, 0x21, 0x80, 0x18, 0xC0, 0x0C, 0xC0,
  0x06, 0x60, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0xF0, 0x07, 0x00, 0x3C, 0x01,
  0xC0, 0x1B, 0x00, 0x70, 0x06, 0xC0, 0x3C, 0x03, 0x30, 0x0F, 0x00, 0xCC,
  0x06, 0xC0, 0x63, 0x01, 0xB0, 0x18, 0xC0, 0xCC, 0x06, 0x30, 0x33, 0x03,
  0x0C, 0x18, 0xC0, 0xC3, 0x06, 0x30, 0x60, 0xC1, 0x0C, 0x18, 0x30, 0xC1,
  0x0C, 0x0C, 0x30, 0x43, 0x03, 0x18, 0x10, 0xC0, 0xC6, 0x04, 0x60, 0x33,
  0x01, 0x18, 0x0C, 0xC0, 0x4C, 0x03, 0x60, 0x13, 0x00, 0xD8, 0x05, 0x80,
  0x36, 0x01, 0x60, 0x0F, 0x00, 0x58, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x03, 0x00, 0x38, 0x18, 0x01, 0x80, 0x60,
  0x18, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00,
  0x18, 0xE0, 0x00, 0xC6, 0x00, 0x03, 0x60, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x40, 0x00, 0x3B, 0x00, 0x01,
  0x98, 0x00, 0x18, 0xC0, 0x01, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0xC0,
  0x0C, 0x06, 0x00, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x60, 0x06, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0xE0, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x18,
  0x60, 0x38, 0x30, 0x30, 0x30, 0x60, 0x30, 0xE0, 0x30, 0xC0, 0x31, 0x80,
  0x19, 0x80, 0x1B, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x80, 0x01, 0xFC, 0x07, 0xF0,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x07, 0xF0, 0x3F, 0x80, 0xC3, 0x0C, 0x30, 0xC1, 0x04, 0x18, 0x61, 0x86,
  0x18, 0x20, 0xC3, 0x0C, 0x30, 0xC1, 0x04, 0x18, 0x61, 0x86, 0x18, 0x30,
  0x03, 0xF8, 0x1F, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x03, 0xF8, 0x1F, 0x80, 0x00, 0x40, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xB0,
  0x03, 0x30, 0x03, 0x10, 0x06, 0x18, 0x06, 0x18, 0x0C, 0x08, 0x18, 0x0C,
  0x18, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x60, 0x02, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xC3, 0x18, 0x63, 0x0C, 0x00, 0x40, 0x03, 0xF1, 0x07, 0x1B,
  0x0C, 0x0B, 0x18, 0x07, 0x18, 0x06, 0x30, 0x06, 0x30, 0x06, 0x60, 0x06,
  0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0xE0, 0x1C, 0xE0, 0x18,
  0x60, 0x38, 0x60, 0x78, 0x60, 0xD8, 0x3B, 0x98, 0x3F, 0x10, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0xFC, 0x19, 0x8E, 0x1A, 0x06, 0x1E, 0x07, 0x1C, 0x03,
  0x18, 0x03, 0x38, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x06, 0x20, 0x06,
  0x60, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0x60, 0x1C, 0xF0, 0x18, 0xD0, 0x30,
  0xDC, 0xE0, 0x8F, 0xC0, 0x00, 0x80, 0x3F, 0xC3, 0x84, 0x30, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x1E, 0x70, 0x7F,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x03, 0xF3, 0x01, 0xC6, 0xC0,
  0xC0, 0xF0, 0x60, 0x1C, 0x38, 0x07, 0x0C, 0x01, 0x83, 0x00, 0x61, 0x80,
  0x18, 0x60, 0x06, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0xE0, 0x1C,
  0x38, 0x07, 0x06, 0x03, 0x81, 0x81, 0xE0, 0x60, 0x58, 0x0E, 0x66, 0x03,
  0xF1, 0x80, 0x00, 0x80, 0x3F, 0x83, 0x8E, 0x30, 0x33, 0x01, 0x98, 0x0D,
  0x80, 0x6C, 0x06, 0xC0, 0xE6, 0xFE, 0x3F, 0xC1, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x01, 0x1E, 0x70, 0x7F, 0x80, 0x00,
  0x01, 0x00, 0x03, 0xF0, 0x01, 0xC4, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x20, 0x40, 0x7E, 0x20, 0x38, 0xD8, 0x18, 0x1E, 0x0C, 0x03, 0x83, 0x00,
  0xE1, 0x80, 0x30, 0x60, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x70,
  0xC0, 0x18, 0x30, 0x06, 0x1C, 0x03, 0x87, 0x00, 0xE0, 0xC0, 0x70, 0x30,
  0x3C, 0x0C, 0x1B, 0x03, 0xCC, 0xC0, 0x7E, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x0E, 0x0E, 0x03,
  0xFF, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0xFC, 0x33, 0x1C,
  0x68, 0x18, 0xE0, 0x31, 0xC0, 0x63, 0x00, 0xCE, 0x01, 0x98, 0x03, 0x30,
  0x0E, 0x60, 0x18, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x03, 0x18, 0x06,
  0x60, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0xC0, 0x06, 0x0C, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0x61,
  0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x1C,
  0x07, 0xC0, 0x18, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x0E, 0x30, 0x38, 0x60,
  0xE0, 0xC1, 0x81, 0x86, 0x03, 0x18, 0x0C, 0x60, 0x19, 0x80, 0x37, 0x00,
  0x7E, 0x00, 0xE6, 0x03, 0x8C, 0x06, 0x18, 0x0C, 0x18, 0x18, 0x30, 0x60,
  0x70, 0xC0, 0x61, 0x80, 0xC3, 0x00, 0xC0, 0x07, 0x06, 0x06, 0x06, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0x00, 0x20,
  0x08, 0x04, 0x7C, 0x3F, 0x06, 0xE7, 0x39, 0xC3, 0x41, 0xB0, 0x61, 0xC0,
  0x70, 0x38, 0xE0, 0x30, 0x18, 0x60, 0x38, 0x0C, 0x70, 0x18, 0x06, 0x30,
  0x0C, 0x03, 0x18, 0x06, 0x01, 0x8C, 0x03, 0x00, 0xC6, 0x03, 0x00, 0xC6,
  0x01, 0x80, 0x63, 0x00, 0xC0, 0x31, 0x80, 0x60, 0x18, 0xC0, 0x30, 0x18,
  0xC0, 0x30, 0x0C, 0x60, 0x18, 0x06, 0x30, 0x0C, 0x03, 0x18, 0x06, 0x01,
  0x80, 0x00, 0x20, 0x11, 0xF8, 0x6E, 0x38, 0xD0, 0x31, 0xC0, 0x63, 0x80,
  0xC6, 0x01, 0x9C, 0x03, 0x30, 0x06, 0x60, 0x1C, 0xC0, 0x33, 0x80, 0x66,
  0x00, 0xCC, 0x01, 0x98, 0x06, 0x30, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00,
  0x66, 0x01, 0x80, 0x07, 0xF0, 0x38, 0xE1, 0x81, 0xCC, 0x03, 0x70, 0x0D,
  0x80, 0x36, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1B, 0x00, 0x6C, 0x03, 0x30, 0x0C, 0xE0, 0x61, 0xEF, 0x03, 0xF8,
  0x00, 0x02, 0x3F, 0x01, 0x98, 0xE0, 0x6C, 0x18, 0x1E, 0x07, 0x07, 0x00,
  0xC1, 0x80, 0x30, 0xE0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x60,
  0xC0, 0x18, 0x60, 0x06, 0x18, 0x03, 0x86, 0x00, 0xC1, 0x80, 0x70, 0xF0,
  0x18, 0x34, 0x0C, 0x0D, 0xCE, 0x03, 0x3F, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x40, 0x81, 0xF8, 0x81, 0xC6, 0xC1, 0x81, 0xE1, 0x80,
  0x70, 0xC0, 0x38, 0xC0, 0x18, 0x60, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18,
  0x03, 0x0C, 0x01, 0x86, 0x00, 0xC7, 0x00, 0xE3, 0x80, 0x70, 0xC0, 0x70,
  0x60, 0x78, 0x30, 0x2C, 0x1E, 0x66, 0x07, 0xE3, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x08, 0xF1, 0xBD, 0x1A, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x3F,
  0xC7, 0x8E, 0x30, 0x03, 0x80, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x64, 0x07, 0x3D, 0xF1, 0xFF, 0x00, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C,
  0x1F, 0xF7, 0xFC, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x38, 0x07, 0x21, 0xF8,
  0x38, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x63, 0x00, 0xCC, 0x01, 0x98,
  0x03, 0x30, 0x06, 0x60, 0x18, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x03,
  0x18, 0x06, 0x30, 0x1C, 0x60, 0x78, 0xC1, 0xB1, 0xCE, 0x41, 0xF9, 0x80,
  0xC0, 0x1F, 0x00, 0x6C, 0x03, 0x30, 0x0C, 0xC0, 0x63, 0x01, 0x8C, 0x0C,
  0x10, 0x30, 0x61, 0x81, 0x86, 0x06, 0x30, 0x18, 0xC0, 0x66, 0x01, 0x98,
  0x06, 0xC0, 0x1B, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x00, 0x00, 0xC0, 0x30,
  0x1F, 0x01, 0xC0, 0x6C, 0x07, 0x03, 0xB0, 0x3C, 0x0C, 0xC0, 0xB0, 0x33,
  0x06, 0xC1, 0x8C, 0x1B, 0x06, 0x30, 0xCC, 0x30, 0xC3, 0x10, 0xC3, 0x18,
  0x46, 0x0C, 0x61, 0x18, 0x33, 0x04, 0x60, 0xCC, 0x13, 0x03, 0x20, 0x4C,
  0x0D, 0x81, 0x60, 0x14, 0x05, 0x80, 0x70, 0x14, 0x01, 0xC0, 0x70, 0x06,
  0x01, 0x80, 0x00, 0x0C, 0x03, 0x83, 0x03, 0x01, 0x83, 0x80, 0xC1, 0x80,
  0x31, 0x80, 0x19, 0x80, 0x0D, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x66, 0x00, 0x63, 0x00, 0x61, 0x80, 0x70,
  0x60, 0x30, 0x30, 0x30, 0x1C, 0x30, 0x06, 0x00, 0x03, 0x00, 0x30, 0x30,
  0x06, 0x03, 0x00, 0xE0, 0x30, 0x0C, 0x01, 0x01, 0xC0, 0x18, 0x18, 0x01,
  0x83, 0x80, 0x18, 0x30, 0x01, 0x87, 0x00, 0x18, 0x60, 0x01, 0x8E, 0x00,
  0x18, 0xC0, 0x01, 0x98, 0x00, 0x09, 0x80, 0x00, 0xB0, 0x00, 0x0B, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x38, 0x07, 0xC0, 0x70, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x1E, 0x00, 0xF0, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xF8, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x1F, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0F, 0x00, 0x78, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x03, 0xE0, 0x18, 0x00, 0x18,
  0x00, 0xFE, 0x07, 0x0F, 0xFC, 0x07, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 26, 8, 1, -26 },
  { 27, 9, 10, 12, 4, -26 },
  { 39, 19, 26, 20, 1, -26 },
  { 101, 16, 29, 17, 1, -27 },
  { 159, 21, 26, 25, 3, -26 },
  { 228, 18, 26, 20, 1, -26 },
  { 287, 4, 10, 7, 4, -26 },
  { 292, 11, 32, 9, 1, -26 },
  { 336, 11, 32, 9, -3, -26 },
  { 380, 14, 14, 17, 4, -27 },
  { 405, 15, 17, 19, 2, -21 },
  { 437, 6, 9, 7, -2, -4 },
  { 444, 8, 2, 11, 1, -11 },
  { 446, 3, 3, 8, 1, -3 },
  { 448, 17, 26, 12, -2, -26 },
  { 504, 15, 26, 17, 2, -26 },
  { 553, 9, 26, 17, 5, -26 },
  { 583, 17, 26, 17, 0, -26 },
  { 639, 17, 26, 17, 0, -26 },
  { 695, 17, 26, 17, 0, -26 },
  { 751, 16, 26, 17, 1, -26 },
  { 803, 16, 26, 17, 2, -26 },
  { 855, 15, 26, 17, 3, -26 },
  { 904, 16, 26, 17, 1, -26 },
  { 956, 16, 26, 17, 1, -26 },
  { 1008, 6, 19, 8, 1, -19 },
  { 1023, 9, 24, 8, -2, -19 },
  { 1050, 15, 16, 19, 2, -21 },
  { 1080, 15, 9, 19, 2, -17 },
  { 1097, 15, 16, 19, 2, -21 },
  { 1127, 12, 26, 13, 2, -26 },
  { 1166, 24, 29, 26, 2, -26 },
  { 1253, 17, 26, 17, -2, -26 },
  { 1309, 18, 26, 19, 1, -26 },
  { 1368, 18, 26, 18, 2, -26 },
  { 1427, 19, 26, 21, 1, -26 },
  { 1489, 17, 26, 17, 1, -26 },
  { 1545, 17, 26, 15, 1, -26 },
  { 1601, 20, 26, 22, 2, -26 },
  { 1666, 21, 26, 22, 1, -26 },
  { 1735, 13, 26, 10, -1, -26 },
  { 1778, 15, 33, 8, -6, -26 },
  { 1840, 20, 26, 18, 1, -26 },
  { 1905, 12, 26, 15, 1, -26 },
  { 1944, 26, 26, 27, 1, -26 },
  { 2029, 21, 26, 22, 1, -26 },
  { 2098, 20, 26, 23, 2, -26 },
  { 2163, 17, 26, 18, 1, -26 },
  { 2219, 20, 32, 23, 2, -26 },
  { 2299, 17, 26, 18, 1, -26 },
  { 2355, 17, 26, 16, 0, -26 },
  { 2411, 16, 26, 15, 3, -26 },
  { 2463, 20, 26, 22, 2, -26 },
  { 2528, 17, 26, 17, 3, -26 },
  { 2584, 26, 26, 27, 4, -26 },
  { 2669, 21, 26, 16, -2, -26 },
  { 2738, 16, 26, 16, 3, -26 },
  { 2790, 19, 26, 16, -1, -26 },
  { 2852, 14, 32, 10, -1, -26 },
  { 2908, 6, 26, 12, 4, -26 },
  { 2928, 13, 32, 10, -2, -26 },
  { 2980, 16, 15, 18, 1, -26 },
  { 3010, 13, 2, 12, -3, 3 },
  { 3014, 5, 6, 9, 5, -28 },
  { 3018, 16, 20, 18, 1, -20 },
  { 3058, 16, 27, 18, 1, -27 },
  { 3112, 13, 20, 14, 2, -20 },
  { 3145, 18, 27, 18, 1, -27 },
  { 3206, 13, 20, 16, 2, -20 },
  { 3239, 18, 37, 9, -4, -28 },
  { 3323, 18, 29, 18, 0, -20 },
  { 3389, 15, 27, 18, 1, -27 },
  { 3440, 7, 26, 8, 1, -26 },
  { 3463, 13, 35, 8, -5, -26 },
  { 3520, 15, 27, 15, 1, -27 },
  { 3571, 8, 27, 8, 1, -27 },
  { 3598, 25, 20, 27, 1, -20 },
  { 3661, 15, 20, 18, 1, -20 },
  { 3699, 14, 19, 18, 2, -19 },
  { 3733, 18, 27, 18, -1, -19 },
  { 3794, 17, 29, 18, 1, -20 },
  { 3856, 12, 19, 12, 1, -19 },
  { 3885, 13, 20, 14, 0, -20 },
  { 3918, 10, 24, 10, 1, -24 },
  { 3948, 15, 19, 18, 2, -19 },
  { 3984, 14, 19, 14, 2, -19 },
  { 4018, 22, 19, 22, 2, -19 },
  { 4071, 17, 19, 15, -1, -19 },
  { 4112, 20, 28, 14, -4, -19 },
  { 4182, 15, 19, 13, -1, -19 },
  { 4218, 13, 32, 12, 1, -26 },
  { 4270, 2, 36, 17, 8, -27 },
  { 4279, 13, 32, 12, -2, -26 },
  { 4331, 15, 4, 19, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC36PT7B_H_
