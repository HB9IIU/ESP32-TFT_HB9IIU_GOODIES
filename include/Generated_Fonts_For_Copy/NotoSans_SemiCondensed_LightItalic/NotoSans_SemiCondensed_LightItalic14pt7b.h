#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC14PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x94, 0x90, 0x10, 0x55, 0x9A, 0x0A, 0x12, 0x12, 0x7F, 0x24,
  0x24, 0xFE, 0x48, 0x48, 0x50, 0x08, 0x30, 0xBA, 0x45, 0x06, 0x06, 0x0A,
  0x15, 0xF0, 0x81, 0x00, 0x71, 0x92, 0x94, 0x94, 0xAB, 0xF5, 0x19, 0x29,
  0x49, 0xC6, 0x1C, 0x24, 0x24, 0x28, 0x10, 0x71, 0x4A, 0x84, 0x84, 0x7A,
  0x5A, 0x19, 0x08, 0x84, 0x22, 0x10, 0x84, 0x10, 0x80, 0x11, 0x11, 0x11,
  0x11, 0x22, 0x4C, 0x21, 0x2A, 0xEA, 0x08, 0x20, 0x82, 0x3F, 0x20, 0x80,
  0x29, 0x40, 0xF0, 0x80, 0x06, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x41,
  0x80, 0x39, 0x18, 0x61, 0x86, 0x28, 0xA2, 0x93, 0x80, 0x2E, 0x92, 0x92,
  0x50, 0x3C, 0x10, 0x41, 0x04, 0x21, 0x08, 0x43, 0xE0, 0x3C, 0x04, 0x08,
  0x23, 0x81, 0x01, 0x02, 0x09, 0xF0, 0x06, 0x18, 0x50, 0xA2, 0x49, 0x22,
  0x7E, 0x08, 0x10, 0x3E, 0x40, 0x81, 0x07, 0x80, 0x81, 0x02, 0x09, 0xE0,
  0x3D, 0x04, 0x20, 0xFA, 0x28, 0xA2, 0x8B, 0xC0, 0x7C, 0x10, 0x84, 0x10,
  0x82, 0x10, 0x42, 0x00, 0x1C, 0x44, 0x89, 0x21, 0x85, 0x11, 0x42, 0x84,
  0xF0, 0x1C, 0x49, 0x0A, 0x14, 0x47, 0x81, 0x04, 0x09, 0xE0, 0x24, 0x00,
  0x04, 0x11, 0x00, 0x00, 0x24, 0x48, 0x0C, 0xCC, 0x30, 0x30, 0x30, 0xFC,
  0x00, 0x3F, 0xC0, 0xC0, 0x83, 0x72, 0x00, 0xF1, 0x11, 0x24, 0x80, 0x08,
  0x1E, 0x10, 0x90, 0x33, 0xDA, 0x4D, 0x26, 0x93, 0x5A, 0x92, 0x40, 0x1F,
  0x00, 0x04, 0x18, 0x28, 0x91, 0x24, 0x4F, 0xA1, 0x43, 0x04, 0x3E, 0x44,
  0x89, 0x13, 0xC8, 0x90, 0xA1, 0x45, 0xF0, 0x1E, 0x41, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x80, 0xF0, 0x3C, 0x22, 0x21, 0x21, 0x41, 0x41, 0x42, 0x42,
  0x44, 0xF8, 0x3E, 0x40, 0x81, 0x03, 0xC8, 0x10, 0x20, 0x41, 0xF0, 0x3E,
  0x40, 0x81, 0x04, 0x0F, 0x90, 0x20, 0x41, 0x00, 0x1E, 0x41, 0x04, 0x08,
  0x11, 0xE0, 0xC2, 0x84, 0xF8, 0x21, 0x21, 0x21, 0x21, 0x3F, 0x42, 0x42,
  0x42, 0x42, 0x82, 0x39, 0x08, 0x42, 0x21, 0x08, 0x47, 0x00, 0x08, 0x42,
  0x11, 0x08, 0x42, 0x11, 0x08, 0x4C, 0x00, 0x21, 0x22, 0x24, 0x28, 0x50,
  0x70, 0x48, 0x48, 0x44, 0x84, 0x21, 0x08, 0x44, 0x21, 0x08, 0x47, 0xC0,
  0x30, 0x66, 0x08, 0xC3, 0x18, 0xA5, 0x14, 0xA5, 0x14, 0xA2, 0x64, 0x4C,
  0x91, 0x10, 0x30, 0x98, 0x4C, 0x45, 0x24, 0x92, 0x49, 0x18, 0x8C, 0x46,
  0x41, 0x00, 0x3C, 0x85, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x84, 0xF0, 0x3C,
  0x44, 0x89, 0x14, 0x4F, 0x10, 0x20, 0x41, 0x00, 0x3C, 0x85, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x84, 0xF0, 0x40, 0x40, 0x3C, 0x44, 0x89, 0x14, 0x4F,
  0x12, 0x24, 0x45, 0x08, 0x3E, 0x41, 0x02, 0x02, 0x03, 0x02, 0x02, 0x09,
  0xE0, 0xFC, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x00, 0x41, 0x42, 0x42,
  0x42, 0x82, 0x84, 0x84, 0x84, 0x88, 0x78, 0x83, 0x0A, 0x14, 0x44, 0x8A,
  0x14, 0x30, 0x60, 0x80, 0x84, 0x30, 0x8A, 0x31, 0x46, 0x49, 0x49, 0x2A,
  0x29, 0x45, 0x28, 0x46, 0x08, 0x40, 0x11, 0x12, 0x12, 0x14, 0x08, 0x18,
  0x18, 0x24, 0x44, 0x84, 0x86, 0x24, 0x94, 0x51, 0x84, 0x10, 0x41, 0x00,
  0x3E, 0x08, 0x10, 0x41, 0x02, 0x08, 0x20, 0x81, 0xF0, 0x39, 0x08, 0x44,
  0x21, 0x08, 0x84, 0x21, 0xC0, 0x89, 0x24, 0x92, 0x24, 0x38, 0x42, 0x11,
  0x08, 0x42, 0x11, 0x09, 0xC0, 0x08, 0x30, 0xA1, 0x24, 0x58, 0x40, 0xF8,
  0x94, 0x31, 0x38, 0xA2, 0x8A, 0x29, 0x3C, 0x20, 0x40, 0x81, 0x43, 0x4C,
  0x50, 0xA2, 0x44, 0x8A, 0xE0, 0x3A, 0x21, 0x08, 0x42, 0x1E, 0x04, 0x10,
  0x4D, 0x4E, 0x28, 0xA2, 0x8A, 0x6E, 0x80, 0x32, 0x63, 0x2E, 0x42, 0x1E,
  0x06, 0x10, 0x20, 0xE0, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x1C,
  0x00, 0x18, 0x4D, 0x12, 0x24, 0x50, 0x93, 0x3C, 0x08, 0x13, 0xC0, 0x20,
  0x82, 0x0A, 0x35, 0x14, 0x51, 0x46, 0x18, 0x80, 0x20, 0x14, 0x92, 0x90,
  0x08, 0x00, 0x11, 0x08, 0x42, 0x21, 0x08, 0x4C, 0x00, 0x20, 0x82, 0x09,
  0x29, 0x25, 0x1C, 0x52, 0x28, 0x80, 0x24, 0x92, 0x92, 0x52, 0x00, 0x09,
  0x9D, 0x94, 0x45, 0x11, 0x44, 0x51, 0x28, 0x8A, 0x22, 0x09, 0xD6, 0x51,
  0x45, 0x18, 0x62, 0x32, 0x63, 0x18, 0xC6, 0x3E, 0x08, 0xA9, 0x8A, 0x14,
  0x48, 0x91, 0x5C, 0x81, 0x02, 0x00, 0x31, 0x38, 0xA2, 0x8A, 0x29, 0xBC,
  0x10, 0x41, 0x00, 0x0A, 0x98, 0x84, 0x22, 0x10, 0x32, 0x50, 0x83, 0x08,
  0x5E, 0x5D, 0x49, 0x24, 0xC0, 0xC6, 0x28, 0xA2, 0x8A, 0x4F, 0x00, 0x8C,
  0xA5, 0x4A, 0x63, 0x00, 0x91, 0x92, 0xAA, 0xAA, 0xCC, 0xCC, 0x88, 0x26,
  0x28, 0x60, 0x82, 0x85, 0x31, 0x00, 0x22, 0x48, 0x91, 0x42, 0x86, 0x04,
  0x10, 0x21, 0x80, 0x78, 0x84, 0x44, 0x43, 0xC0, 0x08, 0x84, 0x42, 0x13,
  0x08, 0x42, 0x10, 0xC0, 0xFF, 0xFC, 0x10, 0x42, 0x21, 0x08, 0x62, 0x21,
  0x09, 0x80, 0x66, 0x60,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 10, 3, 0, -10 },
  { 5, 4, 4, 5, 1, -10 },
  { 7, 8, 10, 8, 0, -10 },
  { 17, 7, 12, 7, 0, -11 },
  { 28, 8, 10, 10, 1, -10 },
  { 38, 8, 10, 8, 0, -10 },
  { 48, 2, 4, 3, 1, -10 },
  { 49, 5, 12, 4, 0, -10 },
  { 57, 4, 12, 4, -1, -10 },
  { 63, 5, 6, 7, 2, -11 },
  { 67, 6, 6, 7, 1, -8 },
  { 72, 3, 4, 3, -1, -2 },
  { 74, 4, 1, 4, 0, -4 },
  { 75, 1, 1, 3, 0, -1 },
  { 76, 7, 10, 5, -1, -10 },
  { 85, 6, 10, 7, 1, -10 },
  { 93, 3, 10, 7, 2, -10 },
  { 97, 6, 10, 7, 0, -10 },
  { 105, 7, 10, 7, 0, -10 },
  { 114, 7, 10, 7, 0, -10 },
  { 123, 7, 10, 7, 0, -10 },
  { 132, 6, 10, 7, 1, -10 },
  { 140, 6, 10, 7, 1, -10 },
  { 148, 7, 10, 7, 0, -10 },
  { 157, 7, 10, 7, 0, -10 },
  { 166, 3, 8, 3, 0, -8 },
  { 169, 4, 10, 3, -1, -8 },
  { 174, 6, 6, 7, 1, -8 },
  { 179, 6, 4, 7, 1, -7 },
  { 182, 6, 6, 7, 1, -8 },
  { 187, 4, 10, 5, 1, -10 },
  { 192, 9, 11, 10, 1, -10 },
  { 205, 7, 10, 7, -1, -10 },
  { 214, 7, 10, 7, 0, -10 },
  { 223, 7, 10, 7, 1, -10 },
  { 232, 8, 10, 8, 0, -10 },
  { 242, 7, 10, 6, 0, -10 },
  { 251, 7, 10, 6, 0, -10 },
  { 260, 7, 10, 8, 1, -10 },
  { 269, 8, 10, 8, 0, -10 },
  { 279, 5, 10, 4, 0, -10 },
  { 286, 5, 13, 3, -2, -10 },
  { 295, 8, 10, 7, 0, -10 },
  { 305, 5, 10, 6, 0, -10 },
  { 312, 11, 10, 10, 0, -10 },
  { 326, 9, 10, 9, 0, -10 },
  { 338, 7, 10, 9, 1, -10 },
  { 347, 7, 10, 7, 0, -10 },
  { 356, 7, 12, 9, 1, -10 },
  { 367, 7, 10, 7, 0, -10 },
  { 376, 7, 10, 6, 0, -10 },
  { 385, 6, 10, 6, 1, -10 },
  { 393, 8, 10, 8, 1, -10 },
  { 403, 7, 10, 7, 1, -10 },
  { 412, 11, 10, 11, 1, -10 },
  { 426, 8, 10, 6, -1, -10 },
  { 436, 6, 10, 6, 1, -10 },
  { 444, 7, 10, 6, 0, -10 },
  { 453, 5, 12, 4, 0, -10 },
  { 461, 3, 10, 5, 1, -10 },
  { 465, 5, 12, 4, -1, -10 },
  { 473, 7, 6, 7, 0, -10 },
  { 479, 5, 1, 5, -1, 1 },
  { 480, 2, 3, 3, 2, -11 },
  { 481, 6, 8, 7, 1, -8 },
  { 487, 7, 11, 7, 0, -11 },
  { 497, 5, 8, 6, 1, -8 },
  { 502, 6, 11, 7, 1, -11 },
  { 511, 5, 8, 6, 1, -8 },
  { 516, 7, 14, 4, -2, -11 },
  { 529, 7, 11, 7, 0, -8 },
  { 539, 6, 11, 7, 0, -11 },
  { 548, 3, 10, 3, 0, -10 },
  { 552, 5, 13, 3, -2, -10 },
  { 561, 6, 11, 6, 0, -11 },
  { 570, 3, 11, 3, 0, -11 },
  { 575, 10, 8, 11, 0, -8 },
  { 585, 6, 8, 7, 0, -8 },
  { 591, 5, 8, 7, 1, -8 },
  { 596, 7, 11, 7, 0, -8 },
  { 606, 6, 11, 7, 1, -8 },
  { 615, 5, 8, 5, 0, -8 },
  { 620, 5, 8, 5, 0, -8 },
  { 625, 3, 9, 4, 1, -9 },
  { 629, 6, 7, 7, 1, -7 },
  { 635, 5, 7, 5, 1, -7 },
  { 640, 8, 7, 9, 1, -7 },
  { 647, 7, 7, 6, -1, -7 },
  { 654, 7, 10, 6, -1, -7 },
  { 663, 5, 7, 5, 0, -7 },
  { 668, 5, 12, 5, 0, -10 },
  { 676, 1, 14, 7, 3, -11 },
  { 678, 5, 12, 5, -1, -10 },
  { 686, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC14PT7B_H_
