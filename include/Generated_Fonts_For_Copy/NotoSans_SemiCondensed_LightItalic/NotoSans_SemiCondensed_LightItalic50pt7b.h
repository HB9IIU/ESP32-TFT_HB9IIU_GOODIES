#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC50PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1E, 0x03,
  0xC0, 0x78, 0x00, 0x38, 0x39, 0xC1, 0xCE, 0x1C, 0x70, 0xE3, 0x07, 0x18,
  0x31, 0xC1, 0x8E, 0x0C, 0x60, 0xE3, 0x06, 0x18, 0x30, 0xC1, 0x8C, 0x0C,
  0x00, 0x00, 0x06, 0x03, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x38, 0x0C, 0x00,
  0x06, 0x03, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x06, 0x03,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x06, 0x03, 0x80, 0x00,
  0xC0, 0x70, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x00, 0xC0, 0x70,
  0x00, 0x18, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x18,
  0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x18, 0x0E, 0x00,
  0x03, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x01, 0x80, 0x00,
  0xE0, 0x30, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x60, 0x30,
  0x00, 0x1C, 0x06, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x81,
  0xE3, 0x06, 0x03, 0x86, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x30,
  0x30, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x86,
  0x00, 0x07, 0x88, 0x00, 0x07, 0xB0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0C, 0xF0, 0x00, 0x18, 0xE0,
  0x00, 0x30, 0xE0, 0x00, 0x61, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00,
  0x06, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x70, 0x40, 0x61, 0xE0, 0xE0,
  0xC7, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x70, 0x1F, 0xE0, 0x01, 0x80, 0xE1, 0xC0, 0x0E,
  0x03, 0x07, 0x00, 0x70, 0x1C, 0x0C, 0x01, 0x80, 0x60, 0x30, 0x0E, 0x03,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x30, 0x0C, 0x0E, 0x01, 0xC0,
  0x70, 0x30, 0x06, 0x01, 0xC1, 0x80, 0x18, 0x06, 0x0E, 0x00, 0x60, 0x18,
  0x30, 0x01, 0x80, 0x61, 0x80, 0x06, 0x03, 0x8E, 0x1E, 0x38, 0x0C, 0x31,
  0xFC, 0x60, 0x71, 0xCF, 0x39, 0x81, 0x8E, 0x30, 0x76, 0x0E, 0x31, 0xC1,
  0xDC, 0x71, 0xCE, 0x07, 0x3F, 0x8E, 0x38, 0x1C, 0x7C, 0x30, 0xC0, 0x70,
  0x01, 0xC7, 0x01, 0xC0, 0x0E, 0x1C, 0x07, 0x00, 0x30, 0x60, 0x18, 0x01,
  0xC1, 0x80, 0x60, 0x0E, 0x06, 0x01, 0x80, 0x30, 0x38, 0x0E, 0x01, 0xC0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0E, 0x07, 0x01, 0xC0, 0x38,
  0x18, 0x0E, 0x00, 0xE0, 0xE0, 0x30, 0x01, 0x87, 0x01, 0xC0, 0x07, 0xF8,
  0x0E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0x87, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x18,
  0x00, 0x30, 0x06, 0x00, 0x1C, 0x01, 0x80, 0x07, 0x00, 0x60, 0x01, 0xC0,
  0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0xC1, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x1E, 0x70,
  0x00, 0x0E, 0x0E, 0x01, 0xC7, 0x03, 0x80, 0xE3, 0x80, 0x70, 0x39, 0xC0,
  0x1C, 0x1C, 0x70, 0x03, 0x87, 0x18, 0x00, 0xF3, 0x8E, 0x00, 0x1D, 0xC3,
  0x80, 0x03, 0xF0, 0xE0, 0x00, 0xF8, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x0F,
  0x03, 0xC0, 0x07, 0xE0, 0x70, 0x07, 0xBC, 0x1F, 0x03, 0xC7, 0x03, 0xFF,
  0xE0, 0xE0, 0x3F, 0xE0, 0x3C, 0x01, 0x00, 0x00, 0x00, 0x3C, 0xE3, 0x8E,
  0x30, 0xC7, 0x1C, 0x61, 0x86, 0x18, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x80, 0x60, 0x38, 0x18,
  0x0F, 0x0C, 0x01, 0xF3, 0x00, 0x0F, 0xC7, 0xC0, 0xFF, 0xF0, 0x1F, 0xE0,
  0x0D, 0x80, 0x06, 0x60, 0x07, 0x1C, 0x03, 0xC3, 0x01, 0xE0, 0xE0, 0x70,
  0x38, 0x08, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x0F, 0x0E, 0x0E, 0x1C,
  0x1C, 0x38, 0x38, 0x30, 0x70, 0x60, 0xE0, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x0F,
  0x1F, 0x00, 0x78, 0x1C, 0x03, 0xC0, 0x38, 0x1E, 0x00, 0xE0, 0x70, 0x03,
  0x83, 0x80, 0x06, 0x0E, 0x00, 0x18, 0x30, 0x00, 0x71, 0xC0, 0x01, 0x87,
  0x00, 0x06, 0x38, 0x00, 0x18, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8C, 0x00,
  0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0C,
  0x70, 0x00, 0x71, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x38, 0xE0,
  0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01,
  0xC1, 0x80, 0x0E, 0x07, 0x00, 0x78, 0x1C, 0x01, 0xC0, 0x78, 0x0E, 0x00,
  0xF0, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x70, 0x0F, 0x01, 0xF0, 0x7F, 0x0F, 0x63, 0xEE, 0x78, 0xEF, 0x0E, 0x40,
  0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x07,
  0xE1, 0xF0, 0x0E, 0x00, 0xE0, 0x08, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xE1, 0xF0, 0x1E, 0x00,
  0xF0, 0x10, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x80, 0x03, 0xC1,
  0xE0, 0x1F, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x06, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x77, 0x00, 0x01, 0xCE, 0x00,
  0x07, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x38, 0xE0, 0x00, 0xE1, 0xC0, 0x03,
  0x83, 0x80, 0x0E, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xC0,
  0x70, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x0E,
  0x03, 0x80, 0x1C, 0x0E, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x70, 0x01, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x84, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x08, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x80, 0x07, 0x81, 0xC0, 0x3E, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xF0, 0x03, 0xF0, 0x40, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x87, 0xF0,
  0x0E, 0x7F, 0xE0, 0x3B, 0xC7, 0xC0, 0xDC, 0x07, 0x87, 0xC0, 0x0E, 0x1E,
  0x00, 0x1C, 0x78, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00,
  0x1C, 0x60, 0x00, 0x73, 0x80, 0x01, 0x8E, 0x00, 0x0E, 0x18, 0x00, 0x38,
  0x60, 0x00, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x38,
  0x07, 0x00, 0xF0, 0x7C, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x80,
  0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xE1, 0xE0, 0x0F, 0x00, 0xE0,
  0x1C, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0x80, 0x07, 0x03,
  0x00, 0x0E, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38,
  0x03, 0x80, 0x38, 0x0E, 0x00, 0x78, 0x78, 0x00, 0x79, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x3E, 0x3C, 0x00, 0xF0, 0x3C,
  0x03, 0x80, 0x3C, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70,
  0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x78, 0x03, 0xC0, 0x78,
  0x0F, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0x0F, 0x00, 0x70, 0x1E, 0x03, 0x80,
  0x38, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x30, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70,
  0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x0F, 0x1C, 0x00, 0x3C, 0x70, 0x01,
  0xE0, 0xE0, 0x0F, 0x83, 0xC0, 0xEE, 0x07, 0xFF, 0x38, 0x0F, 0xF8, 0xC0,
  0x02, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x01, 0xE0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x03, 0xC3, 0xE1, 0xE0, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x78, 0x38, 0x00,
  0x00, 0x60, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x06, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xF8, 0x1F,
  0xFC, 0x3F, 0x3E, 0x10, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x1C,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0x60, 0xE0, 0x03, 0xC0, 0x18, 0x30, 0x07, 0xFE, 0x06,
  0x1C, 0x03, 0xC7, 0x81, 0x86, 0x01, 0xC0, 0xE0, 0x73, 0x80, 0xE0, 0x30,
  0x1C, 0xC0, 0x70, 0x0C, 0x06, 0x30, 0x18, 0x07, 0x01, 0x9C, 0x0E, 0x01,
  0xC0, 0x66, 0x03, 0x00, 0x60, 0x19, 0x81, 0xC0, 0x18, 0x06, 0x60, 0x70,
  0x0E, 0x03, 0xB8, 0x18, 0x03, 0x80, 0xCE, 0x06, 0x00, 0xC0, 0x33, 0x81,
  0x80, 0x70, 0x1C, 0xE0, 0x60, 0x1C, 0x06, 0x38, 0x18, 0x0F, 0x03, 0x8E,
  0x06, 0x03, 0xC1, 0xC3, 0x81, 0xC1, 0xB0, 0xE0, 0xE0, 0x7F, 0xCF, 0xF0,
  0x38, 0x0F, 0xE1, 0xF8, 0x06, 0x00, 0x40, 0x10, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x07, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xDC, 0x00, 0x01, 0x9C, 0x00,
  0x03, 0x8C, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x0C, 0x00,
  0x0E, 0x0C, 0x00, 0x0C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x0E, 0x00,
  0x38, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0x80, 0x06, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x38, 0x03, 0xE0,
  0x1C, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x07,
  0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x60, 0x00,
  0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x0E, 0x00,
  0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xC0,
  0x0F, 0x00, 0xE0, 0x03, 0x80, 0x60, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38,
  0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0xE0,
  0xE0, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x1F,
  0xC7, 0xE0, 0x1F, 0x00, 0x20, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xE0,
  0x0F, 0x80, 0x1C, 0x00, 0xF8, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0xF0,
  0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x0E, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x06, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x1C, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x18,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07,
  0x83, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x03, 0x80,
  0x01, 0xC0, 0x70, 0x00, 0x78, 0x0C, 0x00, 0x1E, 0x03, 0x80, 0x0F, 0x80,
  0x70, 0x07, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFE, 0x3F,
  0x80, 0x7C, 0x00, 0x60, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x07, 0xFE, 0x70, 0x01, 0xFF, 0x8E, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07,
  0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0xE0, 0x1E, 0x00, 0x1C, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x07,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x38, 0x06,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x38, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x06,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x1C, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x0E,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xEF, 0xC0, 0x0F, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x00,
  0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x1C, 0x01,
  0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x38, 0x07, 0x80, 0x03, 0x80, 0xF0, 0x00,
  0x38, 0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x06, 0x78, 0x00, 0x00, 0xEF, 0xC0, 0x00, 0x0F, 0xDC, 0x00, 0x00, 0xF9,
  0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0x80, 0x38, 0x00, 0x38,
  0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x1C,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x07,
  0x00, 0x0F, 0x00, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xDF, 0xFF,
  0xDF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0xDC, 0x00, 0x01, 0xB8, 0x06, 0xE0, 0x00, 0x1D, 0x80,
  0x77, 0x00, 0x01, 0xDC, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x1D, 0xC0, 0x00,
  0xE7, 0x00, 0xE6, 0x00, 0x07, 0x38, 0x06, 0x30, 0x00, 0x71, 0x80, 0x71,
  0x80, 0x03, 0x9C, 0x03, 0x8C, 0x00, 0x38, 0xE0, 0x1C, 0x70, 0x01, 0xC7,
  0x00, 0xC3, 0x80, 0x1C, 0x38, 0x06, 0x1C, 0x00, 0xC3, 0x80, 0x70, 0xE0,
  0x0E, 0x1C, 0x03, 0x87, 0x00, 0x60, 0xE0, 0x1C, 0x18, 0x07, 0x07, 0x00,
  0xC0, 0xC0, 0x30, 0x30, 0x06, 0x06, 0x03, 0x83, 0x80, 0x70, 0x30, 0x38,
  0x1C, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x1C, 0x0E, 0x1C, 0x07, 0x00, 0xC0,
  0x70, 0xE0, 0x30, 0x0E, 0x03, 0x8E, 0x03, 0x80, 0x70, 0x1C, 0x70, 0x1C,
  0x03, 0x80, 0x67, 0x00, 0xE0, 0x1C, 0x03, 0x38, 0x07, 0x00, 0xC0, 0x1B,
  0x80, 0x70, 0x0E, 0x00, 0xD8, 0x03, 0x80, 0x70, 0x07, 0xC0, 0x1C, 0x03,
  0x80, 0x3C, 0x00, 0xE0, 0x18, 0x01, 0xE0, 0x06, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0F, 0x00,
  0x01, 0xC0, 0x7C, 0x00, 0x06, 0x01, 0xF0, 0x00, 0x18, 0x06, 0xE0, 0x00,
  0xE0, 0x1B, 0x80, 0x03, 0x80, 0xE6, 0x00, 0x0E, 0x03, 0x9C, 0x00, 0x30,
  0x0E, 0x70, 0x01, 0xC0, 0x39, 0xC0, 0x07, 0x00, 0xC3, 0x80, 0x1C, 0x07,
  0x0E, 0x00, 0x70, 0x1C, 0x38, 0x01, 0x80, 0x70, 0x70, 0x0E, 0x01, 0xC1,
  0xC0, 0x38, 0x06, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0C, 0x03, 0x80, 0xE0, 0x70, 0x0C, 0x01, 0x81, 0xC0, 0x30, 0x07, 0x07,
  0x01, 0xC0, 0x1C, 0x18, 0x07, 0x00, 0x30, 0xE0, 0x1C, 0x00, 0xE3, 0x80,
  0x60, 0x03, 0x8E, 0x03, 0x80, 0x06, 0x38, 0x0E, 0x00, 0x1C, 0xC0, 0x38,
  0x00, 0x73, 0x00, 0xE0, 0x00, 0xDC, 0x03, 0x00, 0x03, 0xF0, 0x1C, 0x00,
  0x0F, 0xC0, 0x70, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x78, 0x06, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x03, 0xC0, 0x3C, 0x00, 0x38, 0x07, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x0E, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C,
  0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x1C, 0x00,
  0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x7C, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xC0, 0x3E, 0x01, 0xC0,
  0x0E, 0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80,
  0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x00, 0x07, 0x07, 0x00,
  0x07, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x1C, 0x06, 0x00,
  0x3C, 0x0E, 0x00, 0x78, 0x0E, 0x03, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x03, 0xC0,
  0x3C, 0x00, 0x38, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x70, 0x78, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x3C, 0x00,
  0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x01, 0xC0, 0x3E, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x0F,
  0x01, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07,
  0x03, 0x80, 0x07, 0x03, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x0E,
  0x07, 0x00, 0x0E, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x38, 0x0E, 0x00, 0xF8,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0C, 0x07, 0x00,
  0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x1C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x38, 0x01, 0xC0,
  0x30, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0,
  0x70, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFC,
  0x03, 0xF9, 0xF8, 0x0F, 0x00, 0x30, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x80, 0x07, 0x81, 0xE0, 0x3F, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C,
  0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x60, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x0E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x38, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x70, 0x07, 0x00, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38,
  0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80,
  0x07, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x18, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x70,
  0x03, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x70, 0xE0, 0x00, 0x61, 0xC0, 0x00, 0xC7, 0x00, 0x01,
  0x8E, 0x00, 0x03, 0x38, 0x00, 0x06, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x03, 0xB8,
  0x00, 0x3C, 0x00, 0x1D, 0xC0, 0x01, 0xE0, 0x00, 0xEE, 0x00, 0x1F, 0x00,
  0x0E, 0x70, 0x00, 0xD8, 0x00, 0x73, 0x80, 0x0E, 0xC0, 0x07, 0x1C, 0x00,
  0x76, 0x00, 0x38, 0xE0, 0x03, 0x30, 0x03, 0x87, 0x00, 0x39, 0x80, 0x1C,
  0x38, 0x01, 0x8C, 0x00, 0xC1, 0xC0, 0x1C, 0x60, 0x0E, 0x06, 0x00, 0xC3,
  0x00, 0x70, 0x30, 0x0E, 0x18, 0x07, 0x01, 0x80, 0x70, 0xC0, 0x38, 0x0C,
  0x07, 0x06, 0x03, 0x80, 0x60, 0x38, 0x30, 0x1C, 0x03, 0x01, 0x81, 0x80,
  0xC0, 0x18, 0x1C, 0x0C, 0x0E, 0x00, 0xC0, 0xC0, 0x60, 0x70, 0x06, 0x0E,
  0x03, 0x07, 0x00, 0x30, 0x60, 0x18, 0x38, 0x01, 0x87, 0x00, 0xC3, 0x80,
  0x0C, 0x38, 0x07, 0x1C, 0x00, 0x63, 0x80, 0x38, 0xC0, 0x03, 0x1C, 0x01,
  0xCE, 0x00, 0x18, 0xC0, 0x0E, 0x60, 0x00, 0xCE, 0x00, 0x77, 0x00, 0x06,
  0x60, 0x03, 0xB8, 0x00, 0x37, 0x00, 0x1D, 0x80, 0x01, 0xB0, 0x00, 0xFC,
  0x00, 0x0D, 0x80, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0xE0, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x03, 0x38, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x18, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x1C, 0x70,
  0x00, 0xE0, 0xC0, 0x03, 0x83, 0x80, 0x1C, 0x0E, 0x00, 0xF0, 0x38, 0x03,
  0x80, 0xE0, 0x1C, 0x01, 0x80, 0x70, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00,
  0x70, 0x70, 0x00, 0xC3, 0x80, 0x03, 0x0C, 0x00, 0x0E, 0x70, 0x00, 0x3B,
  0x80, 0x00, 0xEE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xE0, 0xE0, 0xE0,
  0x60, 0x60, 0x60, 0x70, 0x70, 0x70, 0x30, 0x30, 0x30, 0x38, 0x38, 0x38,
  0x18, 0x18, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x0C, 0x0E, 0x0E,
  0x0E, 0x06, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07, 0x03, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x76, 0x00, 0x01, 0x9C, 0x00, 0x0E, 0x30, 0x00, 0x70, 0xC0, 0x01, 0xC3,
  0x80, 0x0E, 0x06, 0x00, 0x30, 0x1C, 0x01, 0xC0, 0x70, 0x06, 0x00, 0xC0,
  0x38, 0x03, 0x81, 0xC0, 0x06, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xC0,
  0x00, 0xC7, 0x00, 0x03, 0x98, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0xE1, 0xC1, 0xC1, 0x83, 0x83, 0x03, 0x00, 0x7E,
  0x0C, 0x07, 0xFC, 0x30, 0x3F, 0x79, 0xC1, 0xE0, 0x36, 0x0F, 0x00, 0xD8,
  0x38, 0x01, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1E, 0x38, 0x00, 0x70, 0xE0,
  0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0x80, 0x03,
  0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x1F, 0x0E, 0x00,
  0xD8, 0x1C, 0x07, 0x60, 0x78, 0x39, 0x80, 0xFF, 0xCE, 0x01, 0xFC, 0x38,
  0x00, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC1, 0xF0,
  0x07, 0x1F, 0xF0, 0x1C, 0xF3, 0xE0, 0x77, 0x03, 0x81, 0xB0, 0x07, 0x07,
  0x80, 0x1C, 0x3E, 0x00, 0x70, 0xF0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00,
  0x1C, 0x78, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C,
  0x60, 0x00, 0x73, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0,
  0x01, 0xC3, 0x80, 0x07, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xE1, 0xA0, 0x07,
  0x06, 0xC0, 0x3C, 0x1B, 0x83, 0xE0, 0xE7, 0xFF, 0x03, 0x0F, 0xF0, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x3F, 0x3C, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x0C, 0x07,
  0xFF, 0x00, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x0F, 0xC1, 0x80, 0x1F, 0xF9, 0xC0, 0x1F,
  0x3E, 0xE0, 0x1E, 0x03, 0x70, 0x1E, 0x00, 0xF0, 0x0E, 0x00, 0x78, 0x0E,
  0x00, 0x3C, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x07, 0x03,
  0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1E,
  0x07, 0x00, 0x0F, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x07,
  0xC0, 0x70, 0x07, 0xE0, 0x1C, 0x07, 0x60, 0x0F, 0x07, 0x30, 0x03, 0xFF,
  0x18, 0x00, 0xFE, 0x1C, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F,
  0xF0, 0x0F, 0x8F, 0x03, 0xC0, 0xF0, 0xF0, 0x0E, 0x1C, 0x01, 0xC7, 0x00,
  0x38, 0xC0, 0x07, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x1E, 0x38, 0x0F,
  0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x08, 0x3C, 0x06, 0x03, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0x08, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x78, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x83, 0x00, 0x7F, 0xE3, 0x00, 0xFC, 0xF3, 0x01, 0xE0, 0x37, 0x03, 0xC0,
  0x1E, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x38, 0x00, 0x78, 0x38, 0x00, 0x78, 0x38, 0x00, 0xF0, 0x38, 0x00,
  0xF0, 0x38, 0x01, 0xF0, 0x38, 0x03, 0xF0, 0x1C, 0x07, 0x60, 0x1E, 0x0E,
  0x60, 0x0F, 0xFC, 0xE0, 0x07, 0xF0, 0xE0, 0x00, 0x80, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0xC0, 0x0E, 0x00, 0xFC, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC1, 0xF8, 0x07, 0x1F, 0xF0, 0x1C, 0xF3, 0xE0, 0x76, 0x03,
  0x81, 0xB0, 0x06, 0x07, 0x80, 0x1C, 0x3C, 0x00, 0x70, 0xF0, 0x01, 0x83,
  0x80, 0x06, 0x0E, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00,
  0x0E, 0x1C, 0x00, 0x30, 0x60, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x38, 0x00, 0x60, 0xE0, 0x03, 0x83, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70,
  0x00, 0xE1, 0xC0, 0x03, 0x07, 0x00, 0x1C, 0x18, 0x00, 0x70, 0xE0, 0x01,
  0xC3, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x3C, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x01, 0xBE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x0F, 0x07, 0x00, 0x78,
  0x1C, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x06, 0x03, 0x80, 0x38,
  0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x0C, 0x38, 0x00, 0x71, 0xC0,
  0x01, 0xCE, 0x00, 0x07, 0x7C, 0x00, 0x1B, 0xF0, 0x00, 0x7D, 0xC0, 0x03,
  0xE3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x70, 0x03, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0x70,
  0x18, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01,
  0xC0, 0x00, 0x03, 0x0F, 0xC0, 0x3F, 0x01, 0xC7, 0xF8, 0x3F, 0xE0, 0x77,
  0x9F, 0x1E, 0x7C, 0x19, 0x81, 0xCE, 0x07, 0x06, 0xC0, 0x36, 0x01, 0xC1,
  0xE0, 0x0F, 0x80, 0x30, 0xF0, 0x03, 0xC0, 0x0C, 0x3C, 0x00, 0xE0, 0x03,
  0x0E, 0x00, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x00,
  0x1C, 0x70, 0x01, 0xC0, 0x07, 0x1C, 0x00, 0x70, 0x01, 0x87, 0x00, 0x18,
  0x00, 0xE1, 0x80, 0x0E, 0x00, 0x38, 0xE0, 0x03, 0x80, 0x0E, 0x38, 0x00,
  0xE0, 0x03, 0x8E, 0x00, 0x38, 0x00, 0xC3, 0x80, 0x0C, 0x00, 0x70, 0xC0,
  0x07, 0x00, 0x1C, 0x70, 0x01, 0xC0, 0x07, 0x1C, 0x00, 0x70, 0x01, 0x87,
  0x00, 0x18, 0x00, 0xE1, 0xC0, 0x0E, 0x00, 0x38, 0x60, 0x03, 0x80, 0x0E,
  0x38, 0x00, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x07, 0xE0,
  0x1C, 0x7F, 0xC0, 0x73, 0xCF, 0x81, 0x98, 0x0E, 0x06, 0xC0, 0x1C, 0x3E,
  0x00, 0x70, 0xF8, 0x01, 0xC3, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x00,
  0xE1, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xC1,
  0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80,
  0x0E, 0x0C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0C,
  0x1C, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xF8, 0xF8, 0x0F, 0x01, 0xC0, 0xF0,
  0x07, 0x07, 0x00, 0x38, 0x70, 0x00, 0xE7, 0x80, 0x07, 0x38, 0x00, 0x39,
  0xC0, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB0, 0x00,
  0x1B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0x38,
  0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x1C, 0x70, 0x00, 0xE1, 0xC0, 0x0E,
  0x0F, 0x00, 0xE0, 0x3C, 0x1E, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00,
  0xC1, 0xF0, 0x01, 0xC7, 0xFC, 0x01, 0xCF, 0x3E, 0x01, 0x9C, 0x0E, 0x01,
  0xB0, 0x07, 0x01, 0xF0, 0x07, 0x03, 0xE0, 0x07, 0x03, 0xC0, 0x07, 0x03,
  0xC0, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x07, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1E,
  0x00, 0x3C, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0x70, 0x1B, 0x00, 0xF0, 0x19,
  0x83, 0xE0, 0x39, 0xFF, 0xC0, 0x38, 0xFF, 0x00, 0x38, 0x10, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x0C, 0x07,
  0xFE, 0x30, 0x3E, 0x7C, 0xC1, 0xE0, 0x37, 0x0F, 0x00, 0x78, 0x38, 0x01,
  0xE1, 0xC0, 0x07, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xC7,
  0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0x80, 0x01, 0xCE, 0x00,
  0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x8E, 0x00, 0x1E,
  0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x1F, 0x0E, 0x00, 0xFC, 0x1C,
  0x07, 0x60, 0x78, 0x39, 0x80, 0xFF, 0xCE, 0x01, 0xFC, 0x38, 0x00, 0x80,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x0F, 0xC1, 0xC7,
  0xE0, 0x73, 0xF8, 0x19, 0xC0, 0x06, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0xF0, 0x7C, 0x7C, 0x3C, 0x01, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xE2, 0x00, 0x78, 0xE0, 0x3C, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x7F, 0xEF,
  0xFF, 0x7F, 0xF8, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x40, 0x00, 0x0E, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0xE0, 0x01, 0x83, 0x80, 0x0E, 0x0C, 0x00, 0x38, 0x70, 0x00,
  0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0C, 0x18, 0x00, 0x70, 0xE0, 0x01, 0xC3,
  0x80, 0x07, 0x0E, 0x00, 0x18, 0x38, 0x00, 0xE0, 0xC0, 0x03, 0x87, 0x00,
  0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x06, 0x00, 0x1C,
  0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x1E, 0x0E, 0x00, 0xD8, 0x38,
  0x06, 0xE0, 0x70, 0x7B, 0x81, 0xFF, 0xCC, 0x03, 0xFC, 0x30, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xF8, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xCE, 0x00,
  0x39, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x03,
  0x81, 0x80, 0x70, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0xE0, 0x1C, 0x1C,
  0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xC0,
  0x07, 0x38, 0x00, 0x6E, 0x00, 0x0D, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x1F, 0x80, 0x1C,
  0x00, 0x6E, 0x00, 0xF0, 0x03, 0xB8, 0x03, 0xC0, 0x0E, 0xE0, 0x0F, 0x00,
  0x73, 0x80, 0x7E, 0x01, 0xCE, 0x01, 0xB8, 0x0E, 0x38, 0x0E, 0xE0, 0x38,
  0xE0, 0x33, 0x80, 0xC3, 0x81, 0xCE, 0x07, 0x0E, 0x06, 0x38, 0x18, 0x38,
  0x38, 0xE0, 0xE0, 0xE0, 0xC3, 0x83, 0x83, 0x87, 0x0E, 0x1C, 0x0E, 0x18,
  0x38, 0x70, 0x38, 0xE0, 0x63, 0x80, 0xE3, 0x81, 0x8E, 0x03, 0x8C, 0x06,
  0x30, 0x0E, 0x70, 0x19, 0xC0, 0x39, 0x80, 0x66, 0x00, 0xEE, 0x01, 0xB8,
  0x03, 0xB0, 0x06, 0xE0, 0x07, 0xC0, 0x1B, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0x78, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x07, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C,
  0x00, 0xC0, 0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xE0, 0x00, 0x61, 0xC0,
  0x00, 0x71, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x37, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xEE, 0x00, 0x01, 0xC6, 0x00, 0x01, 0xC7, 0x00, 0x03, 0x87, 0x00,
  0x07, 0x03, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x1C, 0x01, 0x80,
  0x38, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x00, 0x38,
  0x00, 0x60, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x38,
  0x0C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x1C, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x09, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x00,
  0x3F, 0x80, 0x0B, 0xFF, 0x80, 0xF8, 0x3F, 0x9F, 0x00, 0x7F, 0xE8, 0x00,
  0x7E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 36, 11, 1, -36 },
  { 51, 13, 13, 17, 5, -36 },
  { 73, 27, 36, 27, 1, -36 },
  { 195, 23, 41, 24, 1, -38 },
  { 313, 30, 37, 35, 3, -36 },
  { 452, 26, 37, 28, 1, -36 },
  { 573, 6, 13, 9, 5, -36 },
  { 583, 14, 44, 13, 2, -36 },
  { 660, 15, 44, 13, -4, -36 },
  { 743, 18, 19, 23, 6, -38 },
  { 786, 21, 23, 26, 3, -29 },
  { 847, 8, 12, 10, -2, -6 },
  { 859, 12, 3, 15, 1, -15 },
  { 864, 4, 4, 11, 1, -4 },
  { 866, 22, 36, 16, -2, -36 },
  { 965, 22, 37, 24, 2, -36 },
  { 1067, 12, 36, 24, 7, -36 },
  { 1121, 23, 36, 24, 0, -36 },
  { 1225, 23, 37, 24, 0, -36 },
  { 1332, 23, 36, 24, 0, -36 },
  { 1436, 23, 37, 24, 1, -36 },
  { 1543, 22, 37, 24, 2, -36 },
  { 1645, 21, 36, 24, 4, -36 },
  { 1740, 23, 37, 24, 1, -36 },
  { 1847, 22, 37, 24, 1, -36 },
  { 1949, 9, 27, 11, 1, -27 },
  { 1980, 12, 33, 11, -2, -27 },
  { 2030, 21, 22, 26, 3, -29 },
  { 2088, 21, 13, 26, 3, -24 },
  { 2123, 21, 22, 26, 3, -29 },
  { 2181, 16, 36, 18, 3, -36 },
  { 2253, 34, 40, 37, 2, -36 },
  { 2423, 24, 36, 24, -3, -36 },
  { 2531, 25, 36, 26, 1, -36 },
  { 2644, 25, 37, 25, 3, -36 },
  { 2760, 27, 36, 29, 1, -36 },
  { 2882, 24, 36, 23, 1, -36 },
  { 2990, 24, 36, 21, 1, -36 },
  { 3098, 27, 37, 30, 3, -36 },
  { 3223, 29, 36, 30, 1, -36 },
  { 3354, 17, 36, 13, -1, -36 },
  { 3431, 20, 45, 11, -8, -36 },
  { 3544, 28, 36, 24, 1, -36 },
  { 3670, 17, 36, 21, 1, -36 },
  { 3747, 37, 36, 37, 1, -36 },
  { 3914, 30, 36, 31, 1, -36 },
  { 4049, 27, 37, 31, 3, -36 },
  { 4174, 24, 36, 25, 1, -36 },
  { 4282, 27, 45, 31, 3, -36 },
  { 4434, 24, 36, 25, 1, -36 },
  { 4542, 23, 37, 22, 0, -36 },
  { 4649, 22, 36, 21, 4, -36 },
  { 4748, 28, 37, 30, 3, -36 },
  { 4878, 23, 36, 24, 5, -36 },
  { 4982, 37, 36, 38, 5, -36 },
  { 5149, 29, 36, 22, -3, -36 },
  { 5280, 22, 36, 22, 4, -36 },
  { 5379, 26, 36, 23, -1, -36 },
  { 5496, 19, 44, 15, -1, -36 },
  { 5601, 8, 36, 17, 5, -36 },
  { 5637, 18, 44, 15, -3, -36 },
  { 5736, 22, 21, 25, 2, -36 },
  { 5794, 17, 2, 17, -4, 5 },
  { 5799, 7, 8, 12, 7, -38 },
  { 5806, 22, 28, 25, 2, -27 },
  { 5883, 22, 39, 25, 1, -38 },
  { 5991, 18, 28, 20, 2, -27 },
  { 6054, 25, 39, 26, 2, -38 },
  { 6176, 19, 28, 22, 2, -27 },
  { 6243, 26, 50, 13, -6, -38 },
  { 6406, 24, 39, 26, 0, -27 },
  { 6523, 22, 38, 25, 1, -38 },
  { 6628, 11, 36, 11, 1, -36 },
  { 6678, 19, 48, 11, -7, -36 },
  { 6792, 22, 38, 21, 1, -38 },
  { 6897, 11, 38, 10, 1, -38 },
  { 6950, 34, 27, 38, 1, -27 },
  { 7065, 22, 27, 25, 1, -27 },
  { 7140, 21, 27, 25, 2, -27 },
  { 7211, 24, 39, 25, -1, -27 },
  { 7328, 22, 39, 26, 2, -27 },
  { 7436, 18, 27, 17, 1, -27 },
  { 7497, 18, 28, 19, 0, -27 },
  { 7560, 13, 34, 14, 2, -33 },
  { 7616, 22, 28, 25, 2, -27 },
  { 7693, 19, 27, 19, 3, -27 },
  { 7758, 30, 27, 31, 3, -27 },
  { 7860, 24, 27, 21, -2, -27 },
  { 7941, 27, 39, 20, -5, -27 },
  { 8073, 20, 27, 19, -1, -27 },
  { 8141, 18, 44, 17, 1, -36 },
  { 8240, 3, 50, 24, 11, -38 },
  { 8259, 19, 44, 17, -3, -36 },
  { 8364, 21, 5, 26, 3, -20 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC50PT7B_H_
