#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC39PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C,
  0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0xE0, 0xE0, 0x31, 0xCC, 0x77, 0x19, 0x86, 0x61, 0x98,
  0x66, 0x31, 0x0C, 0xC3, 0x30, 0xC0, 0x00, 0x30, 0x60, 0x03, 0x03, 0x00,
  0x18, 0x30, 0x00, 0xC1, 0x80, 0x04, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x06,
  0x00, 0x10, 0x30, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x60, 0xC0, 0x06,
  0x06, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x08, 0x18, 0x00, 0xC0, 0x80,
  0x06, 0x0C, 0x00, 0x20, 0x60, 0x3F, 0xFF, 0xF0, 0x18, 0x30, 0x00, 0xC1,
  0x80, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x10, 0x30, 0x01,
  0x81, 0x00, 0x0C, 0x18, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x1F, 0xF0, 0x1F, 0xFC, 0x18, 0xC2, 0x18,
  0x60, 0x0C, 0x20, 0x0C, 0x10, 0x06, 0x18, 0x03, 0x8C, 0x00, 0xC4, 0x00,
  0x72, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x5C, 0x00, 0x27,
  0x00, 0x31, 0x80, 0x18, 0x60, 0x0C, 0x30, 0x04, 0x18, 0x02, 0x18, 0x03,
  0x1C, 0x61, 0x9C, 0x3F, 0xFC, 0x07, 0xF8, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0F, 0x80, 0x18, 0x3F, 0x80, 0x60, 0xC3, 0x00,
  0xC1, 0x86, 0x03, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x10, 0x30, 0x60,
  0x60, 0x61, 0x80, 0xC0, 0xC3, 0x01, 0x81, 0x8C, 0x03, 0x02, 0x18, 0x06,
  0x0C, 0x63, 0xCC, 0x19, 0x9F, 0xD8, 0x63, 0x31, 0xB0, 0xCC, 0xC1, 0xFF,
  0x31, 0x83, 0x7C, 0x66, 0x06, 0x01, 0x8C, 0x0C, 0x06, 0x18, 0x30, 0x0C,
  0x60, 0x60, 0x30, 0xC0, 0xC0, 0xC1, 0x81, 0x81, 0x83, 0x02, 0x06, 0x06,
  0x0C, 0x18, 0x0C, 0x18, 0x30, 0x18, 0x60, 0xC0, 0x19, 0x83, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x03, 0x83, 0x00, 0x30, 0x30, 0x03,
  0x03, 0x80, 0x70, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x07, 0x06, 0x00,
  0x30, 0xE0, 0x03, 0x18, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0E, 0xE0, 0x01, 0xC6, 0x03, 0x38, 0x70, 0x67, 0x03, 0x06, 0x60, 0x38,
  0xEC, 0x01, 0x8C, 0xC0, 0x1D, 0x8C, 0x00, 0xF8, 0xC0, 0x07, 0x0C, 0x00,
  0xF0, 0xE0, 0x1F, 0x0E, 0x03, 0xB8, 0x7F, 0xF1, 0x83, 0xFC, 0x1C, 0x33,
  0x76, 0x66, 0x64, 0xCC, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x70, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x80, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x0E, 0x00, 0x00, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x04, 0x18, 0x1E, 0x30, 0x0F, 0x40, 0x83,
  0xFF, 0x03, 0xFE, 0x0F, 0x00, 0x32, 0x00, 0xC6, 0x07, 0x04, 0x04, 0x0C,
  0x00, 0x1C, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x0E, 0x18, 0x70, 0xC3, 0x86,
  0x18, 0x30, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xFC, 0x03, 0xFE, 0x07, 0x06, 0x0E, 0x07, 0x0C, 0x03, 0x1C, 0x03, 0x18,
  0x03, 0x38, 0x03, 0x30, 0x03, 0x30, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x0E, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x38, 0xE0,
  0x70, 0x60, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x00, 0xC0, 0xF0, 0x7C, 0x7E,
  0x39, 0xBC, 0x64, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80,
  0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x70,
  0x38, 0x08, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xF0, 0x00, 0xFE, 0x00,
  0xFF, 0xE0, 0x70, 0x1C, 0x10, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x30, 0x07, 0x0F, 0xFF, 0x81, 0xFF, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0D, 0x80,
  0x06, 0x60, 0x03, 0x98, 0x00, 0xCE, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x1C,
  0x30, 0x06, 0x0C, 0x03, 0x06, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x18,
  0x18, 0x0E, 0x0C, 0x03, 0x06, 0x00, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x6F, 0x80, 0x1F, 0xF8, 0x06, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x20,
  0x1E, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x7E, 0x06, 0xFF, 0xC3, 0x60, 0xE1,
  0xC0, 0x39, 0xC0, 0x0C, 0xE0, 0x06, 0x70, 0x03, 0x30, 0x01, 0x98, 0x00,
  0xCC, 0x00, 0xE6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x30, 0x60, 0x38, 0x38,
  0x38, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xBF, 0xFF, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x70,
  0x38, 0x18, 0x06, 0x0E, 0x01, 0xC3, 0x00, 0x70, 0xC0, 0x1C, 0x30, 0x06,
  0x0C, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x0C, 0x70, 0x01, 0xF8, 0x00,
  0x78, 0x00, 0x7F, 0x00, 0x78, 0x60, 0x38, 0x0C, 0x1C, 0x03, 0x86, 0x00,
  0x63, 0x80, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18,
  0xE0, 0x0C, 0x1C, 0x07, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xFC, 0x01,
  0xFF, 0x01, 0xC1, 0xC1, 0xC0, 0x60, 0xC0, 0x38, 0xC0, 0x0C, 0x60, 0x06,
  0x70, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x73, 0x00,
  0x39, 0xC0, 0x38, 0x60, 0x3C, 0x3E, 0xF6, 0x0F, 0xE3, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x70, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x0C, 0x3C, 0x70,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x87, 0x0E, 0x00, 0x01, 0x80, 0xF0, 0x38, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xE1, 0xFF, 0x8C, 0x0E, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x0F, 0xC0, 0xCC, 0x07, 0xF8, 0x33,
  0x07, 0x06, 0x0D, 0x81, 0x81, 0x83, 0x60, 0xC0, 0xC0, 0xD8, 0x60, 0x30,
  0x3C, 0x18, 0x0C, 0x1B, 0x06, 0x03, 0x06, 0xC3, 0x01, 0x81, 0xB0, 0xC0,
  0x60, 0x6C, 0x30, 0x18, 0x33, 0x0C, 0x0E, 0x0C, 0xC3, 0x07, 0x86, 0x30,
  0x63, 0x63, 0x0C, 0x1F, 0x8F, 0x83, 0x01, 0xC1, 0xC0, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x80, 0x03, 0xC1, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x06,
  0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x60,
  0xC0, 0x0C, 0x18, 0x03, 0x03, 0x00, 0x60, 0x70, 0x18, 0x06, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x18, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x01,
  0x86, 0x00, 0x31, 0x80, 0x06, 0x70, 0x00, 0xCC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x30, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0C, 0x0F, 0x03, 0x80,
  0x70, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x70, 0x03, 0x0C, 0x00,
  0x61, 0x80, 0x18, 0x30, 0x07, 0x06, 0x01, 0xC1, 0xFF, 0xF0, 0x3F, 0xF0,
  0x06, 0x07, 0x80, 0xC0, 0x18, 0x18, 0x03, 0x87, 0x00, 0x30, 0xC0, 0x06,
  0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x1C, 0x00, 0xE3, 0x00, 0x18,
  0x60, 0x07, 0x0C, 0x03, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x0F, 0xFF, 0x01, 0xE0, 0x20, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x20, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0xC1, 0xF0, 0x0E, 0x01, 0xC0, 0x60, 0x07, 0x03, 0x00, 0x38,
  0x18, 0x00, 0xC1, 0xC0, 0x07, 0x0C, 0x00, 0x38, 0x60, 0x01, 0xC3, 0x00,
  0x0E, 0x18, 0x00, 0x71, 0xC0, 0x03, 0x8C, 0x00, 0x18, 0x60, 0x00, 0xC3,
  0x00, 0x06, 0x18, 0x00, 0x71, 0xC0, 0x03, 0x8C, 0x00, 0x18, 0x60, 0x01,
  0xC3, 0x00, 0x0C, 0x38, 0x00, 0xE1, 0xC0, 0x0E, 0x0C, 0x00, 0xE0, 0x60,
  0x0E, 0x03, 0x03, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xE0, 0x7F,
  0xF8, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x78, 0x06,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x3F, 0xCC, 0x03, 0xFC, 0xE0, 0x00,
  0x67, 0x00, 0x03, 0x38, 0x00, 0x39, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30,
  0x00, 0x61, 0x80, 0x03, 0x0E, 0x00, 0x38, 0x38, 0x01, 0x80, 0xE0, 0x0C,
  0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x38, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x81,
  0x80, 0x06, 0x07, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x70, 0x30,
  0x00, 0xC0, 0x60, 0x01, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x06, 0x00,
  0x1C, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x70, 0x00, 0xC0, 0xC0, 0x01,
  0x81, 0x80, 0x07, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x30,
  0x30, 0x00, 0x60, 0x60, 0x01, 0xC0, 0xC0, 0x03, 0x03, 0x80, 0x06, 0x06,
  0x00, 0x0C, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x03, 0xE0, 0x3F, 0xC0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x07, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0x00,
  0x38, 0x18, 0x03, 0x80, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x38, 0x03,
  0x01, 0x80, 0x18, 0x18, 0x01, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0x61, 0xC0,
  0x03, 0x1C, 0x00, 0x19, 0xC0, 0x01, 0xDC, 0x00, 0x0D, 0xE0, 0x00, 0x7B,
  0x80, 0x03, 0x8C, 0x00, 0x18, 0x60, 0x01, 0xC1, 0x80, 0x0C, 0x0C, 0x00,
  0x60, 0x70, 0x03, 0x01, 0x80, 0x38, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0x70, 0x38, 0x01, 0x81, 0x80, 0x0E, 0x00,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0x80,
  0x00, 0x70, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1B,
  0x06, 0xC0, 0x01, 0xE0, 0x6C, 0x00, 0x36, 0x06, 0xC0, 0x03, 0x60, 0xEC,
  0x00, 0x66, 0x0C, 0xC0, 0x06, 0xE0, 0xCC, 0x00, 0xCC, 0x0C, 0xC0, 0x1C,
  0xC0, 0xCC, 0x01, 0x8C, 0x1C, 0xC0, 0x38, 0xC1, 0x86, 0x03, 0x1C, 0x18,
  0x60, 0x71, 0x81, 0x86, 0x06, 0x18, 0x18, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x61, 0x83, 0x83, 0x06, 0x18, 0x30, 0x30, 0x63, 0x03, 0x07,
  0x02, 0x30, 0x30, 0x60, 0x36, 0x07, 0x06, 0x03, 0x60, 0x60, 0x60, 0x3C,
  0x06, 0x06, 0x03, 0xC0, 0x60, 0xE0, 0x38, 0x06, 0x0C, 0x03, 0x80, 0xE0,
  0x03, 0x00, 0x06, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x18, 0x3C, 0x00, 0x70,
  0x6C, 0x00, 0xC0, 0xD8, 0x01, 0x81, 0xB0, 0x03, 0x07, 0x30, 0x06, 0x0C,
  0x60, 0x1C, 0x18, 0xC0, 0x30, 0x31, 0xC0, 0x60, 0x61, 0x80, 0xC1, 0xC3,
  0x01, 0x83, 0x07, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x1C,
  0x30, 0x60, 0x18, 0xE0, 0xC0, 0x31, 0x81, 0x80, 0x73, 0x03, 0x00, 0x66,
  0x0E, 0x00, 0xCC, 0x18, 0x01, 0xF8, 0x30, 0x01, 0xE0, 0x60, 0x03, 0xC0,
  0xC0, 0x07, 0x83, 0x80, 0x07, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0x00, 0xF0, 0x38, 0x0E, 0x00, 0xE0, 0x60, 0x03, 0x86, 0x00,
  0x1C, 0x70, 0x00, 0x63, 0x00, 0x03, 0x38, 0x00, 0x19, 0x80, 0x00, 0xCC,
  0x00, 0x06, 0xE0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00,
  0x6C, 0x00, 0x07, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00, 0x1D, 0xC0,
  0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x71, 0x80, 0x07, 0x0E, 0x00, 0x30,
  0x30, 0x03, 0x81, 0xE0, 0x78, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0xE0, 0x0C, 0x1E, 0x03, 0x80, 0xE0, 0x60, 0x0C, 0x0C,
  0x01, 0x81, 0x80, 0x38, 0x70, 0x07, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30,
  0x03, 0x06, 0x00, 0xE1, 0xC0, 0x38, 0x30, 0x0E, 0x06, 0x0F, 0x80, 0xFF,
  0xC0, 0x1F, 0x80, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00,
  0xF0, 0x38, 0x0E, 0x00, 0xE0, 0x60, 0x03, 0x86, 0x00, 0x1C, 0x70, 0x00,
  0x63, 0x00, 0x03, 0x38, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0xE0,
  0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x07,
  0xE0, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xC6, 0x00,
  0x06, 0x30, 0x00, 0x71, 0x80, 0x07, 0x0E, 0x00, 0x30, 0x30, 0x03, 0x81,
  0xE0, 0x78, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0C, 0x1E, 0x03, 0x80, 0xE0,
  0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x38, 0x70, 0x07, 0x0C, 0x00, 0xC1,
  0x80, 0x18, 0x30, 0x07, 0x06, 0x00, 0xC1, 0xC0, 0x38, 0x30, 0x1E, 0x07,
  0xFF, 0x00, 0xFF, 0x80, 0x18, 0x30, 0x07, 0x06, 0x00, 0xC0, 0xE0, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x00, 0x60, 0x60,
  0x0C, 0x0C, 0x01, 0xC3, 0x80, 0x18, 0x60, 0x03, 0x80, 0x00, 0xFF, 0x80,
  0x7F, 0xF0, 0x38, 0x0C, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x1C, 0x20, 0x0E, 0x0F, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x18, 0xE0, 0x01, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80,
  0x03, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61,
  0x80, 0x03, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00,
  0x61, 0x80, 0x03, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0x86, 0x00, 0x0C, 0x30,
  0x00, 0x61, 0x80, 0x07, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x1C,
  0x18, 0x00, 0xC0, 0xE0, 0x0E, 0x03, 0x80, 0xE0, 0x1F, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x6C, 0x00, 0x3B, 0x00, 0x0C, 0xC0,
  0x07, 0x30, 0x01, 0x8C, 0x00, 0xE3, 0x00, 0x30, 0xC0, 0x1C, 0x30, 0x06,
  0x0E, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x06, 0x06, 0x01,
  0x83, 0x00, 0x60, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x01, 0x8C, 0x00, 0x63,
  0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x3E, 0x00, 0x38, 0x01,
  0xB0, 0x03, 0xC0, 0x1D, 0x80, 0x1E, 0x00, 0xCC, 0x01, 0xB0, 0x06, 0x60,
  0x0D, 0x80, 0x63, 0x00, 0x6C, 0x03, 0x18, 0x06, 0x60, 0x30, 0xC0, 0x33,
  0x01, 0x86, 0x03, 0x18, 0x1C, 0x30, 0x18, 0xC0, 0xC1, 0x81, 0x86, 0x06,
  0x0C, 0x0C, 0x30, 0x60, 0x60, 0xC1, 0x83, 0x03, 0x06, 0x0C, 0x30, 0x18,
  0x70, 0x61, 0x80, 0xC3, 0x03, 0x1C, 0x07, 0x18, 0x18, 0xC0, 0x39, 0x80,
  0xC6, 0x00, 0xCC, 0x06, 0x60, 0x06, 0xC0, 0x33, 0x00, 0x36, 0x01, 0xB0,
  0x01, 0xF0, 0x0D, 0x80, 0x0F, 0x00, 0x6C, 0x00, 0x58, 0x03, 0xC0, 0x03,
  0x80, 0x1E, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x0C, 0x06, 0x00, 0x60, 0x18, 0x03, 0x80, 0x70, 0x0C, 0x00, 0xC0,
  0x60, 0x03, 0x03, 0x80, 0x0C, 0x1C, 0x00, 0x18, 0x60, 0x00, 0x63, 0x00,
  0x01, 0x9C, 0x00, 0x07, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xDC, 0x00, 0x07, 0x30,
  0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00, 0x07, 0x06, 0x00, 0x38, 0x18, 0x00,
  0xC0, 0x60, 0x06, 0x01, 0xC0, 0x38, 0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00,
  0x30, 0x38, 0x00, 0xE0, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0E, 0xC0, 0x0C,
  0xE0, 0x1C, 0x60, 0x18, 0x60, 0x30, 0x60, 0x70, 0x60, 0x60, 0x30, 0xC0,
  0x31, 0xC0, 0x31, 0x80, 0x33, 0x80, 0x3B, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0xC3, 0x0C, 0x10, 0x61, 0x86, 0x18,
  0x61, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x18, 0x61, 0x86, 0x18, 0x61, 0x83,
  0x0C, 0x30, 0xC3, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1B, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x0C, 0x30, 0x0C, 0x18,
  0x06, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x83, 0x00, 0x63, 0x80, 0x31, 0x80,
  0x19, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xF8, 0xC7, 0x18, 0xC3, 0x0C, 0x03,
  0xF1, 0x83, 0xFC, 0xC3, 0x82, 0xC3, 0x81, 0xE3, 0x80, 0x71, 0x80, 0x39,
  0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x70, 0x03, 0x30, 0x03, 0x98, 0x01,
  0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x71, 0x80, 0x38, 0xC0, 0x38, 0x60,
  0x3C, 0x38, 0x36, 0x0F, 0xF3, 0x03, 0xF1, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x3E, 0x03, 0x3F, 0xC1, 0xB0, 0x61, 0xF0, 0x38,
  0xF0, 0x0C, 0x70, 0x06, 0x38, 0x03, 0x18, 0x01, 0x9C, 0x00, 0xCC, 0x00,
  0x66, 0x00, 0x33, 0x00, 0x39, 0x80, 0x19, 0xC0, 0x0C, 0xE0, 0x0E, 0x70,
  0x06, 0x38, 0x07, 0x14, 0x07, 0x1B, 0x07, 0x0C, 0xEF, 0x06, 0x3F, 0x00,
  0x01, 0xF8, 0x1F, 0xF0, 0xE0, 0x47, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x02, 0x1F, 0x78, 0x1F,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x7E,
  0x30, 0x1F, 0xE6, 0x07, 0x07, 0xC1, 0xC0, 0x70, 0x70, 0x0E, 0x0C, 0x01,
  0xC3, 0x80, 0x38, 0x60, 0x06, 0x1C, 0x00, 0xC3, 0x80, 0x18, 0x60, 0x03,
  0x0C, 0x00, 0xE1, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0xE0, 0xC0, 0x1C,
  0x18, 0x07, 0x83, 0x01, 0xE0, 0x70, 0x6C, 0x07, 0xF9, 0x80, 0x7E, 0x30,
  0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xE1, 0xC7, 0x03, 0x38, 0x0C, 0xC0, 0x37,
  0x00, 0xD8, 0x06, 0xE0, 0x7B, 0x0F, 0x8F, 0xF8, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x01, 0x1F, 0xF8,
  0x1F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x06, 0x10, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x60, 0x3F, 0xCC, 0x0E, 0x0D, 0x83,
  0x80, 0xE0, 0xE0, 0x1C, 0x18, 0x03, 0x87, 0x00, 0x70, 0xC0, 0x0C, 0x38,
  0x01, 0x87, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x01, 0xC3, 0x00, 0x30, 0x60,
  0x06, 0x0C, 0x01, 0xC1, 0x80, 0x38, 0x30, 0x0F, 0x06, 0x03, 0xC0, 0xE0,
  0xD8, 0x0F, 0xF3, 0x00, 0xFC, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x40, 0x38, 0x0F, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x3F, 0x03, 0x3F, 0xC1, 0xB0, 0x61, 0xF0, 0x38, 0xF0, 0x1C, 0x70, 0x0E,
  0x30, 0x06, 0x18, 0x03, 0x1C, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0xE3, 0x00,
  0x61, 0x80, 0x31, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x0E, 0x30, 0x06, 0x18,
  0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0xE0, 0x07, 0x07, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x38,
  0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xC0, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x01, 0xC3, 0x01, 0x81, 0x81, 0xC1, 0xC1, 0xC0, 0xC1, 0xC0, 0x61,
  0xC0, 0x31, 0xC0, 0x19, 0xC0, 0x1D, 0xC0, 0x0C, 0xE0, 0x06, 0xF0, 0x03,
  0xD8, 0x01, 0xC6, 0x01, 0xC3, 0x00, 0xC1, 0xC0, 0x60, 0x60, 0x30, 0x30,
  0x18, 0x1C, 0x18, 0x06, 0x0C, 0x03, 0x06, 0x01, 0xC0, 0x03, 0x03, 0x03,
  0x07, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18,
  0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60,
  0xC0, 0xC0, 0xC0, 0x0C, 0x7C, 0x0F, 0x81, 0x9F, 0xC7, 0xF8, 0x36, 0x19,
  0x83, 0x0D, 0x01, 0xE0, 0x71, 0xE0, 0x38, 0x0E, 0x38, 0x07, 0x01, 0xC6,
  0x00, 0xC0, 0x30, 0xC0, 0x38, 0x06, 0x38, 0x06, 0x00, 0xC6, 0x00, 0xC0,
  0x18, 0xC0, 0x18, 0x07, 0x18, 0x03, 0x00, 0xC3, 0x00, 0xC0, 0x18, 0xE0,
  0x18, 0x03, 0x18, 0x03, 0x00, 0x63, 0x00, 0x60, 0x1C, 0x60, 0x1C, 0x03,
  0x0C, 0x03, 0x00, 0x63, 0x00, 0x60, 0x0C, 0x60, 0x0C, 0x01, 0x8C, 0x03,
  0x80, 0x60, 0x0C, 0x7E, 0x06, 0x7F, 0x83, 0x60, 0xC3, 0x60, 0x71, 0xE0,
  0x38, 0xE0, 0x1C, 0x70, 0x0C, 0x30, 0x06, 0x38, 0x03, 0x18, 0x01, 0x8C,
  0x01, 0xC6, 0x00, 0xC3, 0x00, 0x63, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x1C,
  0x60, 0x0C, 0x70, 0x06, 0x38, 0x03, 0x18, 0x03, 0x8C, 0x01, 0xC0, 0x01,
  0xF0, 0x07, 0xFC, 0x0E, 0x0E, 0x1C, 0x06, 0x38, 0x06, 0x30, 0x07, 0x60,
  0x03, 0x60, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xE0, 0x38, 0x60,
  0x70, 0x7F, 0xE0, 0x1F, 0xC0, 0x03, 0x1F, 0x00, 0x67, 0xF8, 0x0D, 0x83,
  0x03, 0x60, 0x70, 0x78, 0x06, 0x0E, 0x00, 0xC1, 0xC0, 0x18, 0x30, 0x03,
  0x0E, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x70, 0xC0, 0x0C,
  0x38, 0x01, 0x87, 0x00, 0x70, 0xE0, 0x0C, 0x1C, 0x03, 0x83, 0x80, 0xE0,
  0xD8, 0x38, 0x19, 0xDE, 0x03, 0x1F, 0x80, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xF1, 0x83, 0xFC, 0xC3, 0x83, 0x63,
  0x80, 0xE3, 0x80, 0x71, 0x80, 0x39, 0xC0, 0x1C, 0xC0, 0x0C, 0x60, 0x06,
  0x70, 0x03, 0x30, 0x01, 0x98, 0x01, 0xCC, 0x00, 0xC6, 0x00, 0x63, 0x00,
  0x71, 0x80, 0x38, 0xC0, 0x3C, 0x60, 0x3C, 0x38, 0x36, 0x0F, 0xF3, 0x03,
  0xF1, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x78, 0x67,
  0xC3, 0x60, 0x36, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0xF1,
  0xC0, 0x46, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0xC8, 0x06, 0x3F, 0xF8, 0x7F, 0x80, 0x04, 0x03, 0x00,
  0xC0, 0x30, 0x18, 0x0F, 0xFF, 0xFC, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xFC, 0x1F, 0x00, 0x18, 0x03, 0x8C, 0x01, 0x8E, 0x00,
  0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x30, 0xC0, 0x18, 0xE0, 0x0C, 0x60,
  0x06, 0x30, 0x07, 0x18, 0x03, 0x0C, 0x01, 0x8E, 0x00, 0xC6, 0x00, 0xE3,
  0x00, 0x71, 0x80, 0x70, 0xC0, 0x38, 0x60, 0x3C, 0x30, 0x36, 0x1F, 0xF2,
  0x07, 0xF3, 0x00, 0xC0, 0x07, 0x80, 0x1B, 0x00, 0x36, 0x00, 0xCE, 0x01,
  0x8C, 0x06, 0x18, 0x0C, 0x30, 0x30, 0x60, 0x60, 0xC1, 0x81, 0x83, 0x03,
  0x0C, 0x06, 0x18, 0x0C, 0x60, 0x18, 0xC0, 0x33, 0x00, 0x66, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0x18, 0x07, 0xC0, 0x38,
  0x06, 0xC0, 0x38, 0x0E, 0xC0, 0x78, 0x0C, 0xC0, 0x78, 0x0C, 0xC0, 0xD8,
  0x18, 0xC0, 0xD8, 0x18, 0xE1, 0x88, 0x30, 0xE1, 0x88, 0x30, 0x61, 0x88,
  0x70, 0x63, 0x0C, 0x60, 0x63, 0x0C, 0x60, 0x66, 0x0C, 0xC0, 0x66, 0x0C,
  0xC0, 0x6C, 0x0D, 0x80, 0x6C, 0x0D, 0x80, 0x78, 0x0F, 0x00, 0x78, 0x0F,
  0x00, 0x70, 0x0F, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x0C, 0x01,
  0xC1, 0x80, 0x60, 0x60, 0x30, 0x1C, 0x1C, 0x03, 0x0E, 0x00, 0xC3, 0x00,
  0x39, 0x80, 0x06, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x07,
  0x80, 0x03, 0x60, 0x01, 0xD8, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x18, 0x30,
  0x0E, 0x06, 0x07, 0x01, 0x81, 0x80, 0x70, 0xC0, 0x0C, 0x00, 0x03, 0x00,
  0x18, 0x1C, 0x01, 0xC0, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x00,
  0xC0, 0x70, 0x06, 0x03, 0x00, 0x30, 0x38, 0x01, 0x81, 0x80, 0x0C, 0x1C,
  0x00, 0x60, 0xC0, 0x03, 0x0E, 0x00, 0x0C, 0x60, 0x00, 0x67, 0x00, 0x03,
  0x30, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00,
  0x1C, 0x01, 0xF0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x07, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x3C, 0x00, 0xF0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xBF,
  0xC0, 0x78, 0x7F, 0xF0, 0x0F, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 28, 9, 1, -28 },
  { 29, 10, 10, 13, 4, -28 },
  { 42, 21, 28, 21, 1, -28 },
  { 116, 17, 32, 19, 1, -30 },
  { 184, 23, 28, 27, 3, -28 },
  { 265, 20, 28, 22, 1, -28 },
  { 335, 4, 10, 7, 4, -28 },
  { 340, 12, 34, 10, 1, -28 },
  { 391, 12, 34, 10, -3, -28 },
  { 442, 15, 16, 18, 4, -30 },
  { 472, 17, 18, 20, 2, -23 },
  { 511, 7, 9, 8, -2, -4 },
  { 519, 9, 2, 11, 1, -12 },
  { 522, 3, 3, 8, 1, -3 },
  { 524, 18, 28, 13, -2, -28 },
  { 587, 16, 28, 19, 2, -28 },
  { 643, 10, 28, 19, 5, -28 },
  { 678, 18, 28, 19, 0, -28 },
  { 741, 18, 28, 19, 0, -28 },
  { 804, 18, 28, 19, 0, -28 },
  { 867, 18, 28, 19, 1, -28 },
  { 930, 17, 28, 19, 2, -28 },
  { 990, 17, 28, 19, 3, -28 },
  { 1050, 18, 28, 19, 1, -28 },
  { 1113, 17, 28, 19, 1, -28 },
  { 1173, 7, 21, 8, 1, -21 },
  { 1192, 10, 26, 8, -2, -21 },
  { 1225, 17, 18, 20, 2, -23 },
  { 1264, 17, 10, 20, 2, -19 },
  { 1286, 17, 18, 20, 2, -23 },
  { 1325, 13, 28, 14, 2, -28 },
  { 1371, 26, 31, 29, 2, -28 },
  { 1472, 19, 28, 19, -2, -28 },
  { 1539, 19, 28, 21, 1, -28 },
  { 1606, 20, 28, 20, 2, -28 },
  { 1676, 21, 28, 23, 1, -28 },
  { 1750, 18, 28, 18, 1, -28 },
  { 1813, 18, 28, 17, 1, -28 },
  { 1876, 21, 28, 24, 2, -28 },
  { 1950, 23, 28, 23, 1, -28 },
  { 2031, 14, 28, 10, -1, -28 },
  { 2080, 15, 35, 9, -6, -28 },
  { 2146, 21, 28, 19, 1, -28 },
  { 2220, 13, 28, 17, 1, -28 },
  { 2266, 28, 28, 29, 1, -28 },
  { 2364, 23, 28, 24, 1, -28 },
  { 2445, 21, 28, 24, 2, -28 },
  { 2519, 19, 28, 19, 1, -28 },
  { 2586, 21, 35, 24, 2, -28 },
  { 2678, 19, 28, 20, 1, -28 },
  { 2745, 18, 28, 18, 0, -28 },
  { 2808, 17, 28, 17, 3, -28 },
  { 2868, 21, 28, 23, 3, -28 },
  { 2942, 18, 28, 19, 4, -28 },
  { 3005, 29, 28, 30, 4, -28 },
  { 3107, 22, 28, 17, -2, -28 },
  { 3184, 16, 28, 17, 4, -28 },
  { 3240, 21, 28, 18, -1, -28 },
  { 3314, 15, 34, 11, -1, -28 },
  { 3378, 6, 28, 13, 4, -28 },
  { 3399, 15, 34, 11, -3, -28 },
  { 3463, 17, 16, 20, 1, -28 },
  { 3497, 13, 1, 14, -3, 4 },
  { 3499, 5, 6, 9, 6, -30 },
  { 3503, 17, 21, 20, 2, -21 },
  { 3548, 17, 30, 20, 1, -30 },
  { 3612, 14, 21, 15, 2, -21 },
  { 3649, 19, 30, 20, 2, -30 },
  { 3721, 14, 21, 17, 2, -21 },
  { 3758, 20, 39, 10, -5, -30 },
  { 3856, 19, 30, 20, 0, -21 },
  { 3928, 17, 30, 19, 1, -30 },
  { 3992, 8, 28, 8, 1, -28 },
  { 4020, 14, 37, 8, -5, -28 },
  { 4085, 17, 30, 16, 1, -30 },
  { 4149, 8, 30, 8, 1, -30 },
  { 4179, 27, 21, 29, 1, -21 },
  { 4250, 17, 21, 19, 1, -21 },
  { 4295, 16, 21, 19, 2, -21 },
  { 4337, 19, 30, 20, -1, -21 },
  { 4409, 17, 30, 20, 2, -21 },
  { 4473, 13, 21, 13, 1, -21 },
  { 4508, 14, 21, 15, 0, -21 },
  { 4545, 10, 26, 11, 2, -26 },
  { 4578, 17, 21, 20, 2, -21 },
  { 4623, 15, 21, 15, 2, -21 },
  { 4663, 24, 21, 24, 2, -21 },
  { 4726, 18, 21, 16, -1, -21 },
  { 4774, 21, 30, 15, -4, -21 },
  { 4853, 16, 21, 15, -1, -21 },
  { 4895, 14, 34, 13, 1, -28 },
  { 4955, 2, 39, 18, 9, -30 },
  { 4965, 14, 34, 13, -2, -28 },
  { 5025, 17, 4, 20, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC39PT7B_H_
